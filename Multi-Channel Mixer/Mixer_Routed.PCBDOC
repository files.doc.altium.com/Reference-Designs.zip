# Altium PCB Mixer_Routed.PCBDOC (part 4 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 16350 x 11350 mil, 2 copper layers (TopLayer, BottomLayer); 554 components, 386 nets, 1551 pads, 25 vias.

## Via types
v1: diameter 50, hole 28, TopLayer to BottomLayer, 25 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetC45_1: C45.1 D4.2 D6.2 U10.1 | length 3775
  TopLayer w20: D4.2@15645,7410 D6.2@15865,7410
  BottomLayer w20: D6.2@15865,7410 16000,7545 16000,8880 C45.1@15900,8980 15800,9080 15800,10600 U10.1@15960,10760
NetC46_2: C46.2 D3.1 D5.1 U11.2 | length 2461.5
  TopLayer w20: D3.1@15645,8570 D5.1@15865,8570
  BottomLayer w20: U11.2@15550,10710 15550,10210 C46.2@15617.16,10142.84 15720,10040 15720,8645 D3.1@15645,8570
NetC50_COUT1_1: C50_COUT1.1 D10_COUT1.2 D10_COUT1.4 D10_COUT1.6 D10_COUT1.8 D10_COUT1.10 D10_COUT1.12 D10_COUT1.14 D10_COUT1.16 D10_COUT1.18 D10_COUT1.20 R69_COUT1.2 | length 1679.2
  TopLayer w10: R69_COUT1.2@16875,3275 17125,3525 D10_COUT1.20@17125,3625 D10_COUT1.18@17225,3625 D10_COUT1.16@17325,3625 D10_COUT1.14@17425,3625 D10_COUT1.12@17525,3625 D10_COUT1.10@17625,3625 D10_COUT1.8@17725,3625 D10_COUT1.6@17825,3625 D10_COUT1.4@17925,3625 D10_COUT1.2@18025,3625
  BottomLayer w10: R69_COUT1.2@16875,3275 16875,3202 17002,3075 C50_COUT1.1@17075,3075
NetC50_COUT2_1: C50_COUT2.1 D10_COUT2.2 D10_COUT2.4 D10_COUT2.6 D10_COUT2.8 D10_COUT2.10 D10_COUT2.12 D10_COUT2.14 D10_COUT2.16 D10_COUT2.18 D10_COUT2.20 R69_COUT2.2 | length 1679.2
  TopLayer w10: R69_COUT2.2@15375,3275 15625,3525 D10_COUT2.20@15625,3625 D10_COUT2.18@15725,3625 D10_COUT2.16@15825,3625 D10_COUT2.14@15925,3625 D10_COUT2.12@16025,3625 D10_COUT2.10@16125,3625 D10_COUT2.8@16225,3625 D10_COUT2.6@16325,3625 D10_COUT2.4@16425,3625 D10_COUT2.2@16525,3625
  BottomLayer w10: R69_COUT2.2@15375,3275 15375,3202 15502,3075 C50_COUT2.1@15575,3075
NetC51_COUT1_1: C51_COUT1.1 R55_COUT1.1 R56_COUT1.2 U5_COUT1.2 | length 1069.2
  BottomLayer w10: R56_COUT1.2@17375,4350 17475,4450 C51_COUT1.1@17475,4500 17475,4575 U5_COUT1.2@17400,4650 17703,4953 17728,4953 R55_COUT1.1@17900,5125
NetC51_COUT2_1: C51_COUT2.1 R55_COUT2.1 R56_COUT2.2 U5_COUT2.2 | length 1211.6
  BottomLayer w10: R56_COUT2.2@15875,4350 15975,4450 C51_COUT2.1@15975,4500 ; U5_COUT2.2@15900,4650 15900,4575 C51_COUT2.1@15975,4500 ; R55_COUT2.1@16400,5125 16280,5005 16280,4740 16040,4500 C51_COUT2.1@15975,4500
NetD1_1: D1.1 Q1.2 R53.1 | length 1098.4
  TopLayer w10: Q1.2@2500,12275 2595,12275 2720,12150 2720,12080 2750,12050 2830,12050 2860,12080 2860,12120 2910,12170 2992,12170 R53.1@3057,12105 ; R53.1@3057.27,12104 3103.27,12058 3278.74,12058 D1.1@3324.76,12104.02 D1.1@3325,12104.02
  BottomLayer w10: R53.1@3057,12105 3057,12104.02 R53.1@3057.25,12104.02
NetD1_2: D1.2 D2.1 U9.6 | length 1172.7
  TopLayer w10: D2.1@3191,12104.02 3286.98,12200 3450.96,12200 U9.6@3515,12264.04
  BottomLayer w10: D2.1@3191,12104.02 3191,12040 3505,11726 3505,11680 3483,11658 3337,11658 3325,11670 3325,11704.02 D1.2@3324.76,11704.02
NetD2_2: D2.2 Q2.2 R54.2 | length 2752.7
  TopLayer w10: Q2.2@2500,12550 2783,12550 2980,12353 3134.72,12353 3171.72,12390 3517.32,12390 3540.32,12367 3709,12367 3756,12320 3756,12227 3680,12151 3680,12080 3550,11950 3169.48,11950 3070,11850.52 3070,11825.02 ; R54.2@2923.49,11704.02 3044.5,11825.02 3070,11825.02 ; D2.2@3192,11704 D2.2@3191,11704.02 3070,11825.02
NetD3_2: D3.2 D4.1 T1.3 | length 2588.6
  TopLayer w20: D4.1@15645,7910 15975,7580 17700,7580 17765,7645 T1.3@17765,7790
  BottomLayer w20: D4.1@15645,7910 D3.2@15645,8070
NetD5_2: D5.2 D6.1 T1.5 | length 1109.7
  TopLayer w20: D6.1@15865,7910 15985,7790 T1.5@16765,7790
  BottomLayer w20: D6.1@15865,7910 D5.2@15865,8070
NetD10_COUT1_1: D10_COUT1.1 U12_COUT1.1 | length 778.8
  BottomLayer w10: D10_COUT1.1@18025,3325 18115,3415 18115,4010 U12_COUT1.1@18075,4050
NetD10_COUT1_3: D10_COUT1.3 U12_COUT1.18 | length 487.1
  BottomLayer w10: D10_COUT1.3@17925,3325 17925,3365 18075,3515 U12_COUT1.18@18075,3750
NetD10_COUT1_5: D10_COUT1.5 U12_COUT1.17 | length 487.1
  BottomLayer w10: D10_COUT1.5@17825,3325 17975,3475 U12_COUT1.17@17975,3750
NetD10_COUT1_7: D10_COUT1.7 U12_COUT1.16 | length 487.1
  BottomLayer w10: D10_COUT1.7@17725,3325 17725,3365 17875,3515 U12_COUT1.16@17875,3750
NetD10_COUT1_9: D10_COUT1.9 U12_COUT1.15 | length 487.1
  BottomLayer w10: D10_COUT1.9@17625,3325 17775,3475 U12_COUT1.15@17775,3750
NetD10_COUT1_11: D10_COUT1.11 U12_COUT1.14 | length 487.1
  BottomLayer w10: D10_COUT1.11@17525,3325 17525,3425 17575,3475 17575,3650 U12_COUT1.14@17675,3750
NetD10_COUT1_13: D10_COUT1.13 U12_COUT1.13 | length 487.1
  BottomLayer w10: D10_COUT1.13@17425,3325 17475,3375 17475,3650 U12_COUT1.13@17575,3750
NetD10_COUT1_15: D10_COUT1.15 U12_COUT1.12 | length 487.1
  BottomLayer w10: D10_COUT1.15@17325,3325 17375,3375 17375,3650 U12_COUT1.12@17475,3750
NetD10_COUT1_17: D10_COUT1.17 U12_COUT1.11 | length 487.1
  BottomLayer w10: D10_COUT1.17@17225,3325 17275,3375 17275,3650 U12_COUT1.11@17375,3750
NetD10_COUT1_19: D10_COUT1.19 U12_COUT1.10 | length 516.4
  BottomLayer w10: D10_COUT1.19@17125,3325 17175,3375 17175,3700 17225,3750 U12_COUT1.10@17275,3750
NetD10_COUT2_1: D10_COUT2.1 U12_COUT2.1 | length 778.8
  BottomLayer w10: D10_COUT2.1@16525,3325 16615,3415 16615,4010 U12_COUT2.1@16575,4050
NetD10_COUT2_3: D10_COUT2.3 U12_COUT2.18 | length 487.1
  BottomLayer w10: D10_COUT2.3@16425,3325 16425,3365 16575,3515 U12_COUT2.18@16575,3750
NetD10_COUT2_5: D10_COUT2.5 U12_COUT2.17 | length 487.1
  BottomLayer w10: D10_COUT2.5@16325,3325 16475,3475 U12_COUT2.17@16475,3750
NetD10_COUT2_7: D10_COUT2.7 U12_COUT2.16 | length 487.1
  BottomLayer w10: D10_COUT2.7@16225,3325 16225,3365 16375,3515 U12_COUT2.16@16375,3750
NetD10_COUT2_9: D10_COUT2.9 U12_COUT2.15 | length 487.1
  BottomLayer w10: D10_COUT2.9@16125,3325 16275,3475 U12_COUT2.15@16275,3750
NetD10_COUT2_11: D10_COUT2.11 U12_COUT2.14 | length 487.1
  BottomLayer w10: D10_COUT2.11@16025,3325 16025,3425 16075,3475 16075,3650 U12_COUT2.14@16175,3750
NetD10_COUT2_13: D10_COUT2.13 U12_COUT2.13 | length 487.1
  BottomLayer w10: D10_COUT2.13@15925,3325 15975,3375 15975,3650 U12_COUT2.13@16075,3750
NetD10_COUT2_15: D10_COUT2.15 U12_COUT2.12 | length 487.1
  BottomLayer w10: D10_COUT2.15@15825,3325 15875,3375 15875,3650 U12_COUT2.12@15975,3750
NetD10_COUT2_17: D10_COUT2.17 U12_COUT2.11 | length 487.1
  BottomLayer w10: D10_COUT2.17@15725,3325 15775,3375 15775,3650 U12_COUT2.11@15875,3750
NetD10_COUT2_19: D10_COUT2.19 U12_COUT2.10 | length 516.4
  BottomLayer w10: D10_COUT2.19@15625,3325 15675,3375 15675,3700 15725,3750 U12_COUT2.10@15775,3750
NetJ4_CIN1_1: J4_CIN1.1 R25_CIN1.1 | length 1399
  BottomLayer w10: J4_CIN1.1@4472,3451 4472,2728 R25_CIN1.1@4950,2250
NetJ4_CIN1_2: J4_CIN1.2 R26_CIN1.1 | length 1401.6
  TopLayer w10: J4_CIN1.2@4199,3178 4277,3100 4277,2859 4641,2495 4732,2495 4877,2350 4975,2350 R26_CIN1.1@5075,2250
NetJ4_CIN2_1: J4_CIN2.1 R25_CIN2.1 | length 1399
  BottomLayer w10: J4_CIN2.1@5897,3451 5897,2728 R25_CIN2.1@6375,2250
NetJ4_CIN2_2: J4_CIN2.2 R26_CIN2.1 | length 1401.6
  TopLayer w10: J4_CIN2.2@5624,3178 5702,3100 5702,2859 6066,2495 6157,2495 6302,2350 6400,2350 R26_CIN2.1@6500,2250
NetJ4_CIN3_1: J4_CIN3.1 R25_CIN3.1 | length 1399
  BottomLayer w10: J4_CIN3.1@7322,3451 7322,2728 R25_CIN3.1@7800,2250
NetJ4_CIN3_2: J4_CIN3.2 R26_CIN3.1 | length 1401.6
  TopLayer w10: J4_CIN3.2@7049,3178 7127,3100 7127,2859 7491,2495 7582,2495 7727,2350 7825,2350 R26_CIN3.1@7925,2250
NetJ4_CIN4_1: J4_CIN4.1 R25_CIN4.1 | length 1399
  BottomLayer w10: J4_CIN4.1@8747,3451 8747,2728 R25_CIN4.1@9225,2250
NetJ4_CIN4_2: J4_CIN4.2 R26_CIN4.1 | length 1401.6
  TopLayer w10: J4_CIN4.2@8474,3178 8552,3100 8552,2859 8916,2495 9007,2495 9152,2350 9250,2350 R26_CIN4.1@9350,2250
NetJ4_CIN5_1: J4_CIN5.1 R25_CIN5.1 | length 1399
  BottomLayer w10: J4_CIN5.1@10172,3451 10172,2728 R25_CIN5.1@10650,2250
NetJ4_CIN5_2: J4_CIN5.2 R26_CIN5.1 | length 1401.6
  TopLayer w10: J4_CIN5.2@9899,3178 9977,3100 9977,2859 10341,2495 10432,2495 10577,2350 10675,2350 R26_CIN5.1@10775,2250
NetJ4_CIN6_1: J4_CIN6.1 R25_CIN6.1 | length 1399
  BottomLayer w10: J4_CIN6.1@11597,3451 11597,2728 R25_CIN6.1@12075,2250
NetJ4_CIN6_2: J4_CIN6.2 R26_CIN6.1 | length 1401.6
  TopLayer w10: J4_CIN6.2@11324,3178 11402,3100 11402,2859 11766,2495 11857,2495 12002,2350 12100,2350 R26_CIN6.1@12200,2250
NetJ4_CIN7_1: J4_CIN7.1 R25_CIN7.1 | length 1399
  BottomLayer w10: J4_CIN7.1@13022,3451 13022,2728 R25_CIN7.1@13500,2250
NetJ4_CIN7_2: J4_CIN7.2 R26_CIN7.1 | length 1401.6
  TopLayer w10: J4_CIN7.2@12749,3178 12827,3100 12827,2859 13191,2495 13282,2495 13427,2350 13525,2350 R26_CIN7.1@13625,2250
NetJ4_CIN8_1: J4_CIN8.1 R25_CIN8.1 | length 1399
  BottomLayer w10: J4_CIN8.1@14447,3451 14447,2728 R25_CIN8.1@14925,2250
NetJ4_CIN8_2: J4_CIN8.2 R26_CIN8.1 | length 1401.6
  TopLayer w10: J4_CIN8.2@14174,3178 14252,3100 14252,2859 14616,2495 14707,2495 14852,2350 14950,2350 R26_CIN8.1@15050,2250
NetJ7_1: J7.1 R68.2 | length 1031.7
  BottomLayer w10: J7.1@2158.23,10966 2402,10966 2522,11086 2522,11704.02 R68.2@2522.23,11704.02
NetQ1_3: Q1.3 R66.2 | length 658.7
  TopLayer w10: Q1.3@2550,12225 2587.54,12187.46 2587.54,11977.46 v1(2683,11882)
  BottomLayer w10: v1(2683,11882) 2748,11882 2790,11840 2790,11704.02 R66.2@2789.74,11704.02
NetQ2_3: Q2.3 R67.1 | length 573.1
  BottomLayer w10: Q2.3@2550,12500 2460,12410 2460,12200 2507,12153 2607,12153 R67.1@2655.99,12104.02
NetR5_CIN1_2: R5_CIN1.2 VR10_CIN1.2 | length 1769.2
  BottomLayer w10: R5_CIN1.2@4925,9850 4925,9390 4904,9369 4904,8296 VR10_CIN1.2@5050,8150
NetR5_CIN2_2: R5_CIN2.2 VR10_CIN2.2 | length 1769.2
  BottomLayer w10: R5_CIN2.2@6350,9850 6350,9390 6329,9369 6329,8296 VR10_CIN2.2@6475,8150
NetR5_CIN3_2: R5_CIN3.2 VR10_CIN3.2 | length 1769.2
  BottomLayer w10: R5_CIN3.2@7775,9850 7775,9390 7754,9369 7754,8296 VR10_CIN3.2@7900,8150
NetR5_CIN4_2: R5_CIN4.2 VR10_CIN4.2 | length 1769.2
  BottomLayer w10: R5_CIN4.2@9200,9850 9200,9390 9179,9369 9179,8296 VR10_CIN4.2@9325,8150
NetR5_CIN5_2: R5_CIN5.2 VR10_CIN5.2 | length 1769.2
  BottomLayer w10: R5_CIN5.2@10625,9850 10625,9390 10604,9369 10604,8296 VR10_CIN5.2@10750,8150
NetR5_CIN6_2: R5_CIN6.2 VR10_CIN6.2 | length 1769.2
  BottomLayer w10: R5_CIN6.2@12050,9850 12050,9390 12029,9369 12029,8296 VR10_CIN6.2@12175,8150
NetR5_CIN7_2: R5_CIN7.2 VR10_CIN7.2 | length 1769.2
  BottomLayer w10: R5_CIN7.2@13475,9850 13475,9390 13454,9369 13454,8296 VR10_CIN7.2@13600,8150
NetR5_CIN8_2: R5_CIN8.2 VR10_CIN8.2 | length 1769.2
  BottomLayer w10: R5_CIN8.2@14900,9850 14900,9390 14879,9369 14879,8296 VR10_CIN8.2@15025,8150
NetR7_2: R7.2 U9.3 | length 987.3
  BottomLayer w10: U9.3@3515,12564.04 3460,12509.04 3460,12210 3400,12150 3400,11896.28 R7.2@3592.26,11704.02
NetR8_COUT1_2: R8_COUT1.2 R15_COUT1.2 U5_COUT1.5 | length 653.3
  TopLayer w10: U5_COUT1.5@17600,4950 17650,5000 17650,5160 17708,5218 17843,5218 R15_COUT1.2@17900,5275 R8_COUT1.2@18025,5275
NetR8_COUT2_2: R8_COUT2.2 R15_COUT2.2 U5_COUT2.5 | length 653.3
  TopLayer w10: U5_COUT2.5@16100,4950 16150,5000 16150,5160 16208,5218 16343,5218 R15_COUT2.2@16400,5275 R8_COUT2.2@16525,5275
NetR9_2: R9.2 U1.3 | length 307.2
  TopLayer w10: U1.3@3389,6580 3551.22,6417.78 R9.2@3551.22,6340
NetR10_2: R10.2 U1.5 | length 1280.4
  BottomLayer w10: R10.2@3425.67,5760 3485,5819.33 3485,6165 3373,6277 3373,6373 3620,6620 3709,6620 3729,6600 3729,6526.72 U1.5@3689,6486.72
NetR11_CIN1_2: R11_CIN1.2 U2_CIN1.3 | length 135.4
  BottomLayer w10: R11_CIN1.2@4525,6600 4550,6625 U2_CIN1.3@4550,6725
NetR11_CIN2_2: R11_CIN2.2 U2_CIN2.3 | length 135.4
  BottomLayer w10: R11_CIN2.2@5950,6600 5975,6625 U2_CIN2.3@5975,6725
NetR11_CIN3_2: R11_CIN3.2 U2_CIN3.3 | length 135.4
  BottomLayer w10: R11_CIN3.2@7375,6600 7400,6625 U2_CIN3.3@7400,6725
NetR11_CIN4_2: R11_CIN4.2 U2_CIN4.3 | length 135.4
  BottomLayer w10: R11_CIN4.2@8800,6600 8825,6625 U2_CIN4.3@8825,6725
NetR11_CIN5_2: R11_CIN5.2 U2_CIN5.3 | length 135.4
  BottomLayer w10: R11_CIN5.2@10225,6600 10250,6625 U2_CIN5.3@10250,6725
NetR11_CIN6_2: R11_CIN6.2 U2_CIN6.3 | length 135.4
  BottomLayer w10: R11_CIN6.2@11650,6600 11675,6625 U2_CIN6.3@11675,6725
NetR11_CIN7_2: R11_CIN7.2 U2_CIN7.3 | length 135.4
  BottomLayer w10: R11_CIN7.2@13075,6600 13100,6625 U2_CIN7.3@13100,6725
NetR11_CIN8_2: R11_CIN8.2 U2_CIN8.3 | length 135.4
  BottomLayer w10: R11_CIN8.2@14500,6600 14525,6625 U2_CIN8.3@14525,6725
NetR12_CIN1_2: R12_CIN1.2 U2_CIN1.5 | length 181.1
  BottomLayer w10: U2_CIN1.5@4650,7025 4725,7100 R12_CIN1.2@4725,7175
NetR12_CIN2_2: R12_CIN2.2 U2_CIN2.5 | length 181.1
  BottomLayer w10: U2_CIN2.5@6075,7025 6150,7100 R12_CIN2.2@6150,7175
NetR12_CIN3_2: R12_CIN3.2 U2_CIN3.5 | length 181.1
  BottomLayer w10: U2_CIN3.5@7500,7025 7575,7100 R12_CIN3.2@7575,7175
NetR12_CIN4_2: R12_CIN4.2 U2_CIN4.5 | length 181.1
  BottomLayer w10: U2_CIN4.5@8925,7025 9000,7100 R12_CIN4.2@9000,7175
NetR12_CIN5_2: R12_CIN5.2 U2_CIN5.5 | length 181.1
  BottomLayer w10: U2_CIN5.5@10350,7025 10425,7100 R12_CIN5.2@10425,7175
NetR12_CIN6_2: R12_CIN6.2 U2_CIN6.5 | length 181.1
  BottomLayer w10: U2_CIN6.5@11775,7025 11850,7100 R12_CIN6.2@11850,7175
NetR12_CIN7_2: R12_CIN7.2 U2_CIN7.5 | length 181.1
  BottomLayer w10: U2_CIN7.5@13200,7025 13275,7100 R12_CIN7.2@13275,7175
NetR12_CIN8_2: R12_CIN8.2 U2_CIN8.5 | length 181.1
  BottomLayer w10: U2_CIN8.5@14625,7025 14700,7100 R12_CIN8.2@14700,7175
NetR13_2: R13.2 R30.2 U8.6 | length 1286.1
  TopLayer w10: R13.2@3360,4520.09 R13.2@3371.93,4532.02 3479.91,4640 3840,4640 3880,4600 3880,4420.09 R30.2@3771.93,4312.02
  BottomLayer w10: U8.6@3761.93,3992.02 3710,4043.95 3710,4250 3771.93,4311.93 R30.2@3771.93,4312.02
NetR14_2: R14.2 R34.2 U3.5 | length 1335.4
  TopLayer w10: R14.2@3371.93,9979 3442.93,10050 3790,10050 3830,10010 3830,9950 3800,9920 3730,9920 3700,9890 3700,9830.93 R34.2@3771.93,9759
  BottomLayer w10: U3.5@3761.93,9339 3810,9387.07 3810,9720.93 R34.2@3771.93,9759
NetR16_2: R16.2 R17.1 VR8.1 | length 989.4
  TopLayer w10: R16.2@3299,5360 3359,5420 3574,5420 3594,5400 3594,5235 R17.1@3559,5200
  BottomLayer w10: VR8.1@3150,4975 3299,5124 R16.2@3299,5360
NetR18_2: R18.2 R19.1 VR8.3 | length 1038.3
  TopLayer w10: VR8.3@3150,5375 3216,5441 3593,5441 3614,5420 3614,5200 ; R19.1@3426.78,5200 3476.78,5150 3589,5150 3614,5175 3614,5200 ; R18.2@3689,5200 3614,5200
NetR20_CIN1_2: R20_CIN1.2 R22_CIN1.1 VR9_CIN1.1 | length 1265.7
  BottomLayer w10: R20_CIN1.2@4775,10725 4997,10947 4997,11097 VR9_CIN1.1@5050,11150 5175,11275 R22_CIN1.1@5175,11825
NetR20_CIN2_2: R20_CIN2.2 R22_CIN2.1 VR9_CIN2.1 | length 1265.7
  BottomLayer w10: R20_CIN2.2@6200,10725 6422,10947 6422,11097 VR9_CIN2.1@6475,11150 6600,11275 R22_CIN2.1@6600,11825
NetR20_CIN3_2: R20_CIN3.2 R22_CIN3.1 VR9_CIN3.1 | length 1265.7
  BottomLayer w10: R20_CIN3.2@7625,10725 7847,10947 7847,11097 VR9_CIN3.1@7900,11150 8025,11275 R22_CIN3.1@8025,11825
NetR20_CIN4_2: R20_CIN4.2 R22_CIN4.1 VR9_CIN4.1 | length 1265.7
  BottomLayer w10: R20_CIN4.2@9050,10725 9272,10947 9272,11097 VR9_CIN4.1@9325,11150 9450,11275 R22_CIN4.1@9450,11825
NetR20_CIN5_2: R20_CIN5.2 R22_CIN5.1 VR9_CIN5.1 | length 1265.7
  BottomLayer w10: R20_CIN5.2@10475,10725 10697,10947 10697,11097 VR9_CIN5.1@10750,11150 10875,11275 R22_CIN5.1@10875,11825
NetR20_CIN6_2: R20_CIN6.2 R22_CIN6.1 VR9_CIN6.1 | length 1265.7
  BottomLayer w10: R20_CIN6.2@11900,10725 12122,10947 12122,11097 VR9_CIN6.1@12175,11150 12300,11275 R22_CIN6.1@12300,11825
NetR20_CIN7_2: R20_CIN7.2 R22_CIN7.1 VR9_CIN7.1 | length 1265.7
  BottomLayer w10: R20_CIN7.2@13325,10725 13547,10947 13547,11097 VR9_CIN7.1@13600,11150 13725,11275 R22_CIN7.1@13725,11825
NetR20_CIN8_2: R20_CIN8.2 R22_CIN8.1 VR9_CIN8.1 | length 1265.7
  BottomLayer w10: R20_CIN8.2@14750,10725 14972,10947 14972,11097 VR9_CIN8.1@15025,11150 15150,11275 R22_CIN8.1@15150,11825
NetR21_CIN1_2: R21_CIN1.2 R23_CIN1.1 VR9_CIN1.3 | length 1265.7
  BottomLayer w10: R21_CIN1.2@4775,10875 4844,10944 4844,11344 VR9_CIN1.3@5050,11550 5105,11605 5105,11905 R23_CIN1.1@5175,11975
NetR21_CIN2_2: R21_CIN2.2 R23_CIN2.1 VR9_CIN2.3 | length 1265.7
  BottomLayer w10: R21_CIN2.2@6200,10875 6269,10944 6269,11344 VR9_CIN2.3@6475,11550 6530,11605 6530,11905 R23_CIN2.1@6600,11975
NetR21_CIN3_2: R21_CIN3.2 R23_CIN3.1 VR9_CIN3.3 | length 1265.7
  BottomLayer w10: R21_CIN3.2@7625,10875 7694,10944 7694,11344 VR9_CIN3.3@7900,11550 7955,11605 7955,11905 R23_CIN3.1@8025,11975
NetR21_CIN4_2: R21_CIN4.2 R23_CIN4.1 VR9_CIN4.3 | length 1265.7
  BottomLayer w10: R21_CIN4.2@9050,10875 9119,10944 9119,11344 VR9_CIN4.3@9325,11550 9380,11605 9380,11905 R23_CIN4.1@9450,11975
NetR21_CIN5_2: R21_CIN5.2 R23_CIN5.1 VR9_CIN5.3 | length 1265.7
  BottomLayer w10: R21_CIN5.2@10475,10875 10544,10944 10544,11344 VR9_CIN5.3@10750,11550 10805,11605 10805,11905 R23_CIN5.1@10875,11975
NetR21_CIN6_2: R21_CIN6.2 R23_CIN6.1 VR9_CIN6.3 | length 1265.7
  BottomLayer w10: R21_CIN6.2@11900,10875 11969,10944 11969,11344 VR9_CIN6.3@12175,11550 12230,11605 12230,11905 R23_CIN6.1@12300,11975
NetR21_CIN7_2: R21_CIN7.2 R23_CIN7.1 VR9_CIN7.3 | length 1265.7
  BottomLayer w10: R21_CIN7.2@13325,10875 13394,10944 13394,11344 VR9_CIN7.3@13600,11550 13655,11605 13655,11905 R23_CIN7.1@13725,11975
NetR21_CIN8_2: R21_CIN8.2 R23_CIN8.1 VR9_CIN8.3 | length 1309.6
  BottomLayer w10: R21_CIN8.2@14750,10875 14819,10944 14819,11344 VR9_CIN8.3@15025,11550 15025,11925 15075,11975 R23_CIN8.1@15150,11975
NetR29_1: R29.1 R50_CIN1.2 R50_CIN2.2 R50_CIN3.2 R50_CIN4.2 R50_CIN5.2 R50_CIN6.2 R50_CIN7.2 R50_CIN8.2 S2.9 | length 18830.2
  TopLayer w10: v1(2990,4810) 2890,4910 2890,7130 3100,7340 3100,7440 3235,7575 R50_CIN1.2@4175,7575 4280,7680 4980,7680 5085,7575 R50_CIN2.2@5600,7575 5705,7680 6405,7680 6510,7575 R50_CIN3.2@7025,7575 7130,7680 7830,7680 7935,7575 R50_CIN4.2@8450,7575 8555,7680 9255,7680 9360,7575 R50_CIN5.2@9875,7575 9980,7680 10680,7680 10785,7575 R50_CIN6.2@11300,7575 11405,7680 12105,7680 12210,7575 R50_CIN7.2@12720,7575 ; R50_CIN7.2@12725,7575 R50_CIN7.2@12720,7575 ; R50_CIN8.2@14145,7575 13630,7575 13525,7680 12825,7680 12722.5,7577.5 R50_CIN7.2@12720,7575
  BottomLayer w10: v1(2990,4810) 2990,4383.95 R29.1@3121.93,4252.02 ; S2.9@3730,11135 4175,10690 R50_CIN1.2@4175,7575
NetR33_1: R33.1 S2.10 VR4_CIN1.2 VR4_CIN2.2 VR4_CIN3.2 VR4_CIN4.2 VR4_CIN5.2 VR4_CIN6.2 VR4_CIN7.2 VR4_CIN8.2 | length 16650.7
  TopLayer w10: R33.1@3121.93,9699 3147,9699 3147,9733 3214,9800 3296,9800 3318,9822 3318,10000 3302,10016 3240,10016 3209,9985 3209,9971 3053,9815 2931,9815 2918,9802 2840,9802 2825,9817 2825,10635 3095,10905 3344,10905 3349,10910 S2.10@3669.71,10910 3900,11140.29 3900,11300 VR4_CIN1.2@5050,12450 5350,12150 6175,12150 VR4_CIN2.2@6475,12450 6775,12150 7600,12150 VR4_CIN3.2@7900,12450 8200,12150 9025,12150 VR4_CIN4.2@9325,12450 9625,12150 10450,12150 VR4_CIN5.2@10750,12450 11050,12150 11875,12150 VR4_CIN6.2@12175,12450 12475,12150 13300,12150 VR4_CIN7.2@13600,12450 13900,12150 14725,12150 VR4_CIN8.2@15025,12450
NetR43_CIN1_1: R43_CIN1.1 R45_CIN1.1 U6_CIN1.8 | length 659.6
  TopLayer w10: R45_CIN1.1@3900,3500 R43_CIN1.1@4025,3500
  BottomLayer w10: R43_CIN1.1@4025,3500 4350,3825 U6_CIN1.8@4350,3900
NetR43_CIN1_2: R43_CIN1.2 S1_CIN1.2 | length 342.1
  BottomLayer w10: S1_CIN1.2@3975,2820 3925,2870 3925,3000 R43_CIN1.2@4025,3100
NetR43_CIN2_1: R43_CIN2.1 R45_CIN2.1 U6_CIN2.8 | length 659.6
  TopLayer w10: R45_CIN2.1@5325,3500 R43_CIN2.1@5450,3500
  BottomLayer w10: R43_CIN2.1@5450,3500 5775,3825 U6_CIN2.8@5775,3900
NetR43_CIN2_2: R43_CIN2.2 S1_CIN2.2 | length 342.1
  BottomLayer w10: S1_CIN2.2@5400,2820 5350,2870 5350,3000 R43_CIN2.2@5450,3100
NetR43_CIN3_1: R43_CIN3.1 R45_CIN3.1 U6_CIN3.8 | length 659.6
  TopLayer w10: R45_CIN3.1@6750,3500 R43_CIN3.1@6875,3500
  BottomLayer w10: R43_CIN3.1@6875,3500 7200,3825 U6_CIN3.8@7200,3900
NetR43_CIN3_2: R43_CIN3.2 S1_CIN3.2 | length 342.1
  BottomLayer w10: S1_CIN3.2@6825,2820 6775,2870 6775,3000 R43_CIN3.2@6875,3100
NetR43_CIN4_1: R43_CIN4.1 R45_CIN4.1 U6_CIN4.8 | length 659.6
  TopLayer w10: R45_CIN4.1@8175,3500 R43_CIN4.1@8300,3500
  BottomLayer w10: R43_CIN4.1@8300,3500 8625,3825 U6_CIN4.8@8625,3900
NetR43_CIN4_2: R43_CIN4.2 S1_CIN4.2 | length 342.1
  BottomLayer w10: S1_CIN4.2@8250,2820 8200,2870 8200,3000 R43_CIN4.2@8300,3100
NetR43_CIN5_1: R43_CIN5.1 R45_CIN5.1 U6_CIN5.8 | length 659.6
  TopLayer w10: R45_CIN5.1@9600,3500 R43_CIN5.1@9725,3500
  BottomLayer w10: R43_CIN5.1@9725,3500 10050,3825 U6_CIN5.8@10050,3900
NetR43_CIN5_2: R43_CIN5.2 S1_CIN5.2 | length 342.1
  BottomLayer w10: S1_CIN5.2@9675,2820 9625,2870 9625,3000 R43_CIN5.2@9725,3100
NetR43_CIN6_1: R43_CIN6.1 R45_CIN6.1 U6_CIN6.8 | length 659.6
  TopLayer w10: R45_CIN6.1@11025,3500 R43_CIN6.1@11150,3500
  BottomLayer w10: R43_CIN6.1@11150,3500 11475,3825 U6_CIN6.8@11475,3900
NetR43_CIN6_2: R43_CIN6.2 S1_CIN6.2 | length 342.1
  BottomLayer w10: S1_CIN6.2@11100,2820 11050,2870 11050,3000 R43_CIN6.2@11150,3100
NetR43_CIN7_1: R43_CIN7.1 R45_CIN7.1 U6_CIN7.8 | length 659.6
  TopLayer w10: R45_CIN7.1@12450,3500 R43_CIN7.1@12575,3500
  BottomLayer w10: R43_CIN7.1@12575,3500 12900,3825 U6_CIN7.8@12900,3900
NetR43_CIN7_2: R43_CIN7.2 S1_CIN7.2 | length 342.1
  BottomLayer w10: S1_CIN7.2@12525,2820 12475,2870 12475,3000 R43_CIN7.2@12575,3100
NetR43_CIN8_1: R43_CIN8.1 R45_CIN8.1 U6_CIN8.8 | length 659.6
  TopLayer w10: R45_CIN8.1@13875,3500 R43_CIN8.1@14000,3500
  BottomLayer w10: R43_CIN8.1@14000,3500 14325,3825 U6_CIN8.8@14325,3900
NetR43_CIN8_2: R43_CIN8.2 S1_CIN8.2 | length 342.1
  BottomLayer w10: S1_CIN8.2@13950,2820 13900,2870 13900,3000 R43_CIN8.2@14000,3100
NetR44_COUT1_1: R44_COUT1.1 R70_COUT1.2 U12_COUT1.8 | length 963.9
  TopLayer w10: R70_COUT1.2@16925,4200 17029,4096 17329,4096 U12_COUT1.8@17375,4050
  BottomLayer w10: R70_COUT1.2@16925,4200 16925,4475 R44_COUT1.1@17050,4600
NetR44_COUT1_2: R44_COUT1.2 U12_COUT1.6 U12_COUT1.7 | length 587.1
  TopLayer w10: R44_COUT1.2@17050,4200 17325,4200 U12_COUT1.7@17475,4050 U12_COUT1.6@17575,4050
NetR44_COUT2_1: R44_COUT2.1 R70_COUT2.2 U12_COUT2.8 | length 963.9
  TopLayer w10: R70_COUT2.2@15425,4200 15529,4096 15829,4096 U12_COUT2.8@15875,4050
  BottomLayer w10: R70_COUT2.2@15425,4200 15425,4475 R44_COUT2.1@15550,4600
NetR44_COUT2_2: R44_COUT2.2 U12_COUT2.6 U12_COUT2.7 | length 587.1
  TopLayer w10: R44_COUT2.2@15550,4200 15825,4200 U12_COUT2.7@15975,4050 U12_COUT2.6@16075,4050
NetR45_CIN1_2: R45_CIN1.2 S1_CIN1.3 | length 441.1
  BottomLayer w10: R45_CIN1.2@3900,3100 3900,2765 S1_CIN1.3@3975,2690
NetR45_CIN2_2: R45_CIN2.2 S1_CIN2.3 | length 441.1
  BottomLayer w10: R45_CIN2.2@5325,3100 5325,2765 S1_CIN2.3@5400,2690
NetR45_CIN3_2: R45_CIN3.2 S1_CIN3.3 | length 441.1
  BottomLayer w10: R45_CIN3.2@6750,3100 6750,2765 S1_CIN3.3@6825,2690
NetR45_CIN4_2: R45_CIN4.2 S1_CIN4.3 | length 441.1
  BottomLayer w10: R45_CIN4.2@8175,3100 8175,2765 S1_CIN4.3@8250,2690
NetR45_CIN5_2: R45_CIN5.2 S1_CIN5.3 | length 441.1
  BottomLayer w10: R45_CIN5.2@9600,3100 9600,2765 S1_CIN5.3@9675,2690
NetR45_CIN6_2: R45_CIN6.2 S1_CIN6.3 | length 441.1
  BottomLayer w10: R45_CIN6.2@11025,3100 11025,2765 S1_CIN6.3@11100,2690
NetR45_CIN7_2: R45_CIN7.2 S1_CIN7.3 | length 441.1
  BottomLayer w10: R45_CIN7.2@12450,3100 12450,2765 S1_CIN7.3@12525,2690
NetR45_CIN8_2: R45_CIN8.2 S1_CIN8.3 | length 441.1
  BottomLayer w10: R45_CIN8.2@13875,3100 13875,2765 S1_CIN8.3@13950,2690
NetR52_1: R52.1 S2.13 | length 984.7
  BottomLayer w10: S2.13@3355,11435 3565,11435 3773,11643 3773,12057.04 R52.1@3726.02,12104.02
NetR61_1: R61.1 U8.7 | length 1804.1
  TopLayer w10: R61.1@2871.93,4522.02 3039.91,4690 3850,4690 3910,4630 3910,4370 3780,4240 3730,4240 3710,4220 3710,4143.95 U8.7@3761.93,4092.02
NetR62_1: R62.1 U3.7 | length 1645.4
  TopLayer w10: R62.1@2871.93,9969 3012.93,10110 3810,10110 3880,10040 3880,9657.07 U3.7@3761.93,9539
NetR63_COUT1_1: R63_COUT1.1 U5_COUT1.7 | length 541.4
  BottomLayer w10: R63_COUT1.1@17300,5450 17363,5387 17363,4987 U5_COUT1.7@17400,4950
NetR63_COUT2_1: R63_COUT2.1 U5_COUT2.7 | length 541.4
  BottomLayer w10: R63_COUT2.1@15800,5450 15863,5387 15863,4987 U5_COUT2.7@15900,4950
NetR64_COUT1_2: R64_COUT1.2 U12_COUT1.5 | length 820
  BottomLayer w10: U12_COUT1.5@17675,4050 18025,4400 R64_COUT1.2@18025,4725
NetR64_COUT2_2: R64_COUT2.2 U12_COUT2.5 | length 820
  BottomLayer w10: U12_COUT2.5@16175,4050 16525,4400 R64_COUT2.2@16525,4725
NetR65_COUT1_1: R65_COUT1.1 U5_COUT1.1 | length 456.1
  BottomLayer w10: U5_COUT1.1@17300,4650 17300,4300 R65_COUT1.1@17375,4225
NetR65_COUT2_1: R65_COUT2.1 U5_COUT2.1 | length 456.1
  BottomLayer w10: U5_COUT2.1@15800,4650 15800,4300 R65_COUT2.1@15875,4225
NetS1_CIN1_1: S1_CIN1.1 U6_CIN1.1 | length 805.3
  BottomLayer w10: S1_CIN1.1@3975,2950 4134,3109 4134,3269 4350,3485 U6_CIN1.1@4350,3600
NetS1_CIN2_1: S1_CIN2.1 U6_CIN2.1 | length 805.3
  BottomLayer w10: S1_CIN2.1@5400,2950 5559,3109 5559,3269 5775,3485 U6_CIN2.1@5775,3600
NetS1_CIN3_1: S1_CIN3.1 U6_CIN3.1 | length 805.3
  BottomLayer w10: S1_CIN3.1@6825,2950 6984,3109 6984,3269 7200,3485 U6_CIN3.1@7200,3600
NetS1_CIN4_1: S1_CIN4.1 U6_CIN4.1 | length 805.3
  BottomLayer w10: S1_CIN4.1@8250,2950 8409,3109 8409,3269 8625,3485 U6_CIN4.1@8625,3600
NetS1_CIN5_1: S1_CIN5.1 U6_CIN5.1 | length 805.3
  BottomLayer w10: S1_CIN5.1@9675,2950 9834,3109 9834,3269 10050,3485 U6_CIN5.1@10050,3600
NetS1_CIN6_1: S1_CIN6.1 U6_CIN6.1 | length 805.3
  BottomLayer w10: S1_CIN6.1@11100,2950 11259,3109 11259,3269 11475,3485 U6_CIN6.1@11475,3600
NetS1_CIN7_1: S1_CIN7.1 U6_CIN7.1 | length 805.3
  BottomLayer w10: S1_CIN7.1@12525,2950 12684,3109 12684,3269 12900,3485 U6_CIN7.1@12900,3600
NetS1_CIN8_1: S1_CIN8.1 U6_CIN8.1 | length 805.3
  BottomLayer w10: S1_CIN8.1@13950,2950 14109,3109 14109,3269 14325,3485 U6_CIN8.1@14325,3600
NEUTRAL: J8.3 T1.2 | length 2740.7
  BottomLayer w100: J8.3@17015,12220 17015,12015 17765,11265 T1.2@17765,9790
pads on no net: J1.0 J1.2 J4_CIN1.0 J4_CIN2.0 J4_CIN3.0 J4_CIN4.0 J4_CIN5.0 J4_CIN6.0 J4_CIN7.0 J4_CIN8.0 J5.0 J5.2 J6.0 J6.2 J7.0 J7.2 J8.2 U4_COUT1.5 U4_COUT1.6 U4_COUT1.7 U4_COUT2.5 U4_COUT2.6 U4_COUT2.7 U7_CIN1.1 U7_CIN1.5 U7_CIN1.8 U7_CIN2.1 U7_CIN2.5 U7_CIN2.8 U7_CIN3.1 U7_CIN3.5 U7_CIN3.8 U7_CIN4.1 U7_CIN4.5 U7_CIN4.8 U7_CIN5.1 U7_CIN5.5 U7_CIN5.8 U7_CIN6.1 U7_CIN6.5 U7_CIN6.8 U7_CIN7.1 U7_CIN7.5 U7_CIN7.8 U7_CIN8.1 U7_CIN8.5 U7_CIN8.8 U9.1 U9.5 U9.8 VR1.MNT VR2_CIN1.MNT VR2_CIN2.MNT VR2_CIN3.MNT VR2_CIN4.MNT VR2_CIN5.MNT VR2_CIN6.MNT VR2_CIN7.MNT VR2_CIN8.MNT VR3_CIN1.MNT VR3_CIN2.MNT VR3_CIN3.MNT VR3_CIN4.MNT VR3_CIN5.MNT VR3_CIN6.MNT VR3_CIN7.MNT VR3_CIN8.MNT VR4_CIN1.MNT VR4_CIN2.MNT VR4_CIN3.MNT VR4_CIN4.MNT VR4_CIN5.MNT VR4_CIN6.MNT VR4_CIN7.MNT VR4_CIN8.MNT VR5.MNT VR6.MNT VR7_COUT1.MNT VR7_COUT2.MNT VR8.MNT VR9_CIN1.MNT VR9_CIN2.MNT VR9_CIN3.MNT VR9_CIN4.MNT VR9_CIN5.MNT VR9_CIN6.MNT VR9_CIN7.MNT VR9_CIN8.MNT VR10_CIN1.MNT VR10_CIN2.MNT VR10_CIN3.MNT VR10_CIN4.MNT VR10_CIN5.MNT VR10_CIN6.MNT VR10_CIN7.MNT VR10_CIN8.MNT VR11_CIN1.MNT VR11_CIN2.MNT VR11_CIN3.MNT VR11_CIN4.MNT VR11_CIN5.MNT VR11_CIN6.MNT VR11_CIN7.MNT VR11_CIN8.MNT

## Keep-outs
KeepOutLayer:
  lines w50: 2000,2500 2000,12850 2500,12850 2500,13350 17850,13350 17850,12850 18350,12850 18350,2500 17850,2500 17850,2000 2500,2000 2500,2500 2000,2500

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Mechanical 16:
  drawing of 1882 lines, arcs and shapes, not listed
  text "1" at 1576.34,15715 h70
  text "2" at 4357,15715 h70
  text "3" at 7136.34,15715 h70
  text "4" at 9933.01,15715 h70
  text "5" at 12716.35,15715 h70
  text "6" at 15507,15715 h70
  text "7" at 18307,15715 h70
  text "8" at 21087,15715 h70
  text "A" at 325,13857 h70
  text "A" at 22325,13857 h70
  text "B" at 325,9927 h70
  text "B" at 22325,9927 h70
  text "C" at 22325,7807 h70
  text "C" at 325,6007 h70
  text "D" at 325,2077 h70
  text "D" at 22325,2077 h70
  text "ENGINEER:" at 17750,1600 h45
  text "TITLE:" at 19250,1600 h45
  text "PCB DESIGNER:" at 17750,1305 h45
  text "DATE:" at 17750,1000 h45
  text "PART NO.:" at 19250,1000 h45
  text "REV:" at 21350,1000 h45
  text "Altium Limited" at 16450,900 h70
  text ".PRINT_DATE" at 17800,880 h70
  text "12a Rodborough Rd" at 16450,800 h70
  text "Frenchs Forest" at 16450,700 h70
  text "FILE NAME:" at 17750,700 h45
  text "DWG NO:" at 19250,700 h45
  text "SCALE:" at 21350,700 h45
  text "NSW 2086" at 16450,600 h70
  text ".PCB_FILE_NAME_NO_PATH" at 17800,580 h70
  text "1" at 1576.34,325 h70
  text "2" at 4357,325 h70
  text "3" at 7136.34,325 h70
  text "4" at 9933.01,325 h70
  text "5" at 12716.35,325 h70
  text "6" at 15507,325 h70
  text "7" at 18307,325 h70
  text "8" at 21087,325 h70