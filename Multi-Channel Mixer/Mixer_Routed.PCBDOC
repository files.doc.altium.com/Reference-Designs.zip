# Altium PCB Mixer_Routed.PCBDOC (part 2 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 16350 x 11350 mil, 2 copper layers (TopLayer, BottomLayer); 554 components, 386 nets, 1551 pads, 25 vias.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad) (continued)
RB.4/.8 [mil]
  round 100 hole 28: 1(0,0) 2(-400,0)
  silkscreen extent -600,-400 350,400
SW-12WAY [mil]
  round 80 hole 40: 1(225,389.71) 2(389.71,225) 3(450,0) 4(389.71,-225) 5(225,-389.71) 6(0,-450) 7(-225,-389.71) 8(-389.71,-225) 9(-450,0) 10(-389.71,225) 11(-225,389.71) 12(0,450) 13(-75,-300)
  silkscreen extent -500,-500 500,500
SW-MAINS [mil]
  rect 120x120 hole 80: 1(50,0)
  round 120 hole 80: 2(750,0)
  silkscreen extent -70,-225 880,225
SW-SPDT [mil]
  rect 50x50 hole 32: 1(0,0)
  round 50 hole 32: 2(130,0) 3(260,0)
  silkscreen extent -70,-75 330,75
TO-92A [mil]
  round 50 hole 30: 1(0,0) 2(50,-50) 3(100,0)
  silkscreen extent -40,-90 140,40
TRANSFORMER [mil]
  rect 150x150 hole 80: 1(0,0) 2(0,1000) 3(2000,1000) 4(2000,500) 5(2000,0)
  silkscreen extent -500,-500 2500,1500
XLR-FEMALE [mm]
  round 2.032 smd: 1(-4.05,0.8) 2(4.05,0.8) 3(0,-4.7)
  silkscreen extent -9,-9 9,9
XLR-MALE [mm]
  round 2.032 smd: 1(4.05,0.8) 2(-4.05,0.8) 3(0,-4.7)
  silkscreen extent -9,-9 9,9

## Part data
C1 C2 C3 C4 C5 C6 C7_CIN1 C7_CIN2 C7_CIN3 C7_CIN4 C7_CIN5 C7_CIN6 C7_CIN7 C7_CIN8 C8_CIN1 C8_CIN2 C8_CIN3 C8_CIN4 C8_CIN5 C8_CIN6 C8_CIN7 C8_CIN8 C9_CIN1 C9_CIN2 C9_CIN3 C9_CIN4 C9_CIN5 C9_CIN6 C9_CIN7 C9_CIN8 C10_CIN1 C10_CIN2 C10_CIN3 C10_CIN4 C10_CIN5 C10_CIN6 C10_CIN7 C10_CIN8 C11 C12 C13_COUT1 C13_COUT2 C14_COUT1 C14_COUT2 C24 C25_CIN1 C25_CIN2 C25_CIN3 C25_CIN4 C25_CIN5 C25_CIN6 C25_CIN7 C25_CIN8 C26_CIN1 C26_CIN2 C26_CIN3 C26_CIN4 C26_CIN5 C26_CIN6 C26_CIN7 C26_CIN8 C27_CIN1 C27_CIN2 C27_CIN3 C27_CIN4 C27_CIN5 C27_CIN6 C27_CIN7 C27_CIN8 C28_COUT1 C28_COUT2 C29_CIN1 C29_CIN2 C29_CIN3 C29_CIN4 C29_CIN5 C29_CIN6 C29_CIN7 C29_CIN8 C30_CIN1 C30_CIN2 C30_CIN3 C30_CIN4 C30_CIN5 C30_CIN6 C30_CIN7 C30_CIN8 C31_CIN1 C31_CIN2 C31_CIN3 C31_CIN4 C31_CIN5 C31_CIN6 C31_CIN7 C31_CIN8 C32_CIN1 C32_CIN2 C32_CIN3 C32_CIN4 C32_CIN5 C32_CIN6 C32_CIN7 C32_CIN8 C33_CIN1 C33_CIN2 C33_CIN3 C33_CIN4 C33_CIN5 C33_CIN6 C33_CIN7 C33_CIN8 C34 C35 C36_COUT1 C36_COUT2 C37 C38 C39_COUT1 C39_COUT2 C40_COUT1 C40_COUT2 C41 C42 C43 C44 C45 C46 C47 C48 C49_COUT1 C49_COUT2 C50_COUT1 C50_COUT2 C51_COUT1 C51_COUT2: "Capacitor"
C15 C16_CIN1 C16_CIN2 C16_CIN3 C16_CIN4 C16_CIN5 C16_CIN6 C16_CIN7 C16_CIN8 C17_CIN1 C17_CIN2 C17_CIN3 C17_CIN4 C17_CIN5 C17_CIN6 C17_CIN7 C17_CIN8 C18_CIN1 C18_CIN2 C18_CIN3 C18_CIN4 C18_CIN5 C18_CIN6 C18_CIN7 C18_CIN8 C19 C20 C21 C22_COUT1 C22_COUT2 C23_COUT1 C23_COUT2: "Bi-Polar Capacitor"
D1 D2 D3 D4 D5 D6: "Diode"
F1: "Fuse"
J2_CIN1 J2_CIN2 J2_CIN3 J2_CIN4 J2_CIN5 J2_CIN6 J2_CIN7 J2_CIN8 J3_COUT1 J3_COUT2: "XLR connector, PCB mounted"
J8: "Connector"
Q1: "NPN BJT"
Q2: "PNP BJT"
R1 R2 R3_CIN1 R3_CIN2 R3_CIN3 R3_CIN4 R3_CIN5 R3_CIN6 R3_CIN7 R3_CIN8 R4_CIN1 R4_CIN2 R4_CIN3 R4_CIN4 R4_CIN5 R4_CIN6 R4_CIN7 R4_CIN8 R5_CIN1 R5_CIN2 R5_CIN3 R5_CIN4 R5_CIN5 R5_CIN6 R5_CIN7 R5_CIN8 R6_CIN1 R6_CIN2 R6_CIN3 R6_CIN4 R6_CIN5 R6_CIN6 R6_CIN7 R6_CIN8 R7 R8_COUT1 R8_COUT2 R9 R10 R11_CIN1 R11_CIN2 R11_CIN3 R11_CIN4 R11_CIN5 R11_CIN6 R11_CIN7 R11_CIN8 R12_CIN1 R12_CIN2 R12_CIN3 R12_CIN4 R12_CIN5 R12_CIN6 R12_CIN7 R12_CIN8 R13 R14 R15_COUT1 R15_COUT2 R16 R17 R18 R19 R20_CIN1 R20_CIN2 R20_CIN3 R20_CIN4 R20_CIN5 R20_CIN6 R20_CIN7 R20_CIN8 R21_CIN1 R21_CIN2 R21_CIN3 R21_CIN4 R21_CIN5 R21_CIN6 R21_CIN7 R21_CIN8 R22_CIN1 R22_CIN2 R22_CIN3 R22_CIN4 R22_CIN5 R22_CIN6 R22_CIN7 R22_CIN8 R23_CIN1 R23_CIN2 R23_CIN3 R23_CIN4 R23_CIN5 R23_CIN6 R23_CIN7 R23_CIN8 R24 R25_CIN1 R25_CIN2 R25_CIN3 R25_CIN4 R25_CIN5 R25_CIN6 R25_CIN7 R25_CIN8 R26_CIN1 R26_CIN2 R26_CIN3 R26_CIN4 R26_CIN5 R26_CIN6 R26_CIN7 R26_CIN8 R27_CIN1 R27_CIN2 R27_CIN3 R27_CIN4 R27_CIN5 R27_CIN6 R27_CIN7 R27_CIN8 R28_CIN1 R28_CIN2 R28_CIN3 R28_CIN4 R28_CIN5 R28_CIN6 R28_CIN7 R28_CIN8 R29 R30 R31 R32 R33 R34 R35 R36 R37_COUT1 R37_COUT2 R38_COUT1 R38_COUT2 R39 R40_CIN1 R40_CIN2 R40_CIN3 R40_CIN4 R40_CIN5 R40_CIN6 R40_CIN7 R40_CIN8 R41_CIN1 R41_CIN2 R41_CIN3 R41_CIN4 R41_CIN5 R41_CIN6 R41_CIN7 R41_CIN8 R42_COUT1 R42_COUT2 R43_CIN1 R43_CIN2 R43_CIN3 R43_CIN4 R43_CIN5 R43_CIN6 R43_CIN7 R43_CIN8 R44_COUT1 R44_COUT2 R45_CIN1 R45_CIN2 R45_CIN3 R45_CIN4 R45_CIN5 R45_CIN6 R45_CIN7 R45_CIN8 R46_CIN1 R46_CIN2 R46_CIN3 R46_CIN4 R46_CIN5 R46_CIN6 R46_CIN7 R46_CIN8 R47_CIN1 R47_CIN2 R47_CIN3 R47_CIN4 R47_CIN5 R47_CIN6 R47_CIN7 R47_CIN8 R48_CIN1 R48_CIN2 R48_CIN3 R48_CIN4 R48_CIN5 R48_CIN6 R48_CIN7 R48_CIN8 R49_CIN1 R49_CIN2 R49_CIN3 R49_CIN4 R49_CIN5 R49_CIN6 R49_CIN7 R49_CIN8 R50_CIN1 R50_CIN2 R50_CIN3 R50_CIN4 R50_CIN5 R50_CIN6 R50_CIN7 R50_CIN8 R51_CIN1 R51_CIN2 R51_CIN3 R51_CIN4 R51_CIN5 R51_CIN6 R51_CIN7 R51_CIN8 R52 R53 R54 R55_COUT1 R55_COUT2 R56_COUT1 R56_COUT2 R57 R58 R59 R60_COUT1 R60_COUT2 R61 R62 R63_COUT1 R63_COUT2 R64_COUT1 R64_COUT2 R65_COUT1 R65_COUT2 R66 R67 R68 R69_COUT1 R69_COUT2 R70_COUT1 R70_COUT2: "Resistor"
T1: "Center-Tapped Transformer"
U1 U2_CIN1 U2_CIN2 U2_CIN3 U2_CIN4 U2_CIN5 U2_CIN6 U2_CIN7 U2_CIN8 U3 U4_COUT1 U4_COUT2 U5_COUT1 U5_COUT2 U8: "Fast Settling Dual Operational Amplifier"
U6_CIN1 U6_CIN2 U6_CIN3 U6_CIN4 U6_CIN5 U6_CIN6 U6_CIN7 U6_CIN8: "Self-Contained Audio Preamplifier"
U7_CIN1 U7_CIN2 U7_CIN3 U7_CIN4 U7_CIN5 U7_CIN6 U7_CIN7 U7_CIN8: "Low Noise, High Speed Precision Operational Amplifier"
U9: "Low-Noise  JFET-Input Operational Amplifiers"
U10 U11: "Very Low Drop Voltage Regulators With Inhibit"
U12_COUT1 U12_COUT2: "Dot/Bar Display Driver"
VR1 VR2_CIN1 VR2_CIN2 VR2_CIN3 VR2_CIN4 VR2_CIN5 VR2_CIN6 VR2_CIN7 VR2_CIN8 VR3_CIN1 VR3_CIN2 VR3_CIN3 VR3_CIN4 VR3_CIN5 VR3_CIN6 VR3_CIN7 VR3_CIN8 VR4_CIN1 VR4_CIN2 VR4_CIN3 VR4_CIN4 VR4_CIN5 VR4_CIN6 VR4_CIN7 VR4_CIN8 VR5 VR6 VR7_COUT1 VR7_COUT2 VR8 VR9_CIN1 VR9_CIN2 VR9_CIN3 VR9_CIN4 VR9_CIN5 VR9_CIN6 VR9_CIN7 VR9_CIN8 VR10_CIN1 VR10_CIN2 VR10_CIN3 VR10_CIN4 VR10_CIN5 VR10_CIN6 VR10_CIN7 VR10_CIN8 VR11_CIN1 VR11_CIN2 VR11_CIN3 VR11_CIN4 VR11_CIN5 VR11_CIN6 VR11_CIN7 VR11_CIN8: "Potentiometer"

## Via types
v1: diameter 50, hole 28, TopLayer to BottomLayer, 25 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
+15V: C15.1 C16_CIN1.1 C16_CIN2.1 C16_CIN3.1 C16_CIN4.1 C16_CIN5.1 C16_CIN6.1 C16_CIN7.1 C16_CIN8.1 C17_CIN1.1 C17_CIN2.1 C17_CIN3.1 C17_CIN4.1 C17_CIN5.1 C17_CIN6.1 C17_CIN7.1 C17_CIN8.1 C18_CIN1.1 C18_CIN2.1 C18_CIN3.1 C18_CIN4.1 C18_CIN5.1 C18_CIN6.1 C18_CIN7.1 C18_CIN8.1 C19.1 C20.1 C21.1 C22_COUT1.1 C22_COUT2.1 C23_COUT1.1 C23_COUT2.1 C47.1 C49_COUT1.1 C49_COUT2.1 Q1.1 R53.2 R69_COUT1.1 R69_COUT2.1 U1.4 U2_CIN1.8 U2_CIN2.8 U2_CIN3.8 U2_CIN4.8 U2_CIN5.8 U2_CIN6.8 U2_CIN7.8 U2_CIN8.8 U3.8 U4_COUT1.8 U4_COUT2.8 U5_COUT1.8 U5_COUT2.8 U6_CIN1.7 U6_CIN2.7 U6_CIN3.7 U6_CIN4.7 U6_CIN5.7 U6_CIN6.7 U6_CIN7.7 U6_CIN8.7 U7_CIN1.7 U7_CIN2.7 U7_CIN3.7 U7_CIN4.7 U7_CIN5.7 U7_CIN6.7 U7_CIN7.7 U7_CIN8.7 U8.8 U9.7 U10.3 U12_COUT1.3 U12_COUT1.9 U12_COUT2.3 U12_COUT2.9 | length 61838.5
  TopLayer w10: C19.1@2231.93,3582.02 2231.93,3448.07 2370,3310 3206.19,3310 3726.19,3830 3820,3830 ; Q1.1@2550,12325 2624,12399 C21.1@2804.06,12399 2885,12399 2984,12300 3110,12300 3180,12370 3509.04,12370 U9.7@3615,12264.04 ; v1(3250,11290) v1(3350,11190) ; v1(3350,7960) 3350,7880 3409.34,7820.66 C15.1@3499,7820.66 ; U1.4@3389,6480 3330,6539 3330,6610 3350,6630 3430,6630 3510,6710 3510,6940 3610,7040 4035,7040 C16_CIN1.1@4100,6975 4150,7025 U2_CIN1.8@4350,7025 4415,6960 4750,6960 4830,7040 5460,7040 C16_CIN2.1@5525,6975 5575,7025 U2_CIN2.8@5775,7025 5840,6960 6175,6960 6255,7040 6885,7040 C16_CIN3.1@6950,6975 7000,7025 U2_CIN3.8@7200,7025 7265,6960 7600,6960 7680,7040 8310,7040 C16_CIN4.1@8375,6975 8425,7025 U2_CIN4.8@8625,7025 8690,6960 9025,6960 9105,7040 9735,7040 C16_CIN5.1@9800,6975 9850,7025 U2_CIN5.8@10050,7025 10115,6960 10450,6960 10530,7040 11160,7040 C16_CIN6.1@11225,6975 11275,7025 U2_CIN6.8@11475,7025 11540,6960 11875,6960 11955,7040 12585,7040 C16_CIN7.1@12650,6975 12700,7025 U2_CIN7.8@12900,7025 12965,6960 13300,6960 13380,7040 14010,7040 C16_CIN8.1@14075,6975 14125,7025 U2_CIN8.8@14325,7025 14400,6950 14760,6950 14910,7100 C22_COUT2.1@15550,7100 15750,7100 U4_COUT2.8@15800,7150 15900,7250 16900,7250 C22_COUT1.1@17050,7100 17250,7100 U4_COUT1.8@17300,7150 ; U8.8@3761.93,4192.02 3820,4133.95 3820,3830 ; U3.8@3761.93,9639 3612.93,9490 3100,9490 2985,9375 2577.93,9375 C20.1@2232,9029.07 ; C17_CIN1.1@4100,10500 4400,10500 U7_CIN1.7@4450,10550 4550,10450 5475,10450 C17_CIN2.1@5525,10500 5825,10500 U7_CIN2.7@5875,10550 5975,10450 6900,10450 C17_CIN3.1@6950,10500 7250,10500 U7_CIN3.7@7300,10550 7400,10450 8325,10450 C17_CIN4.1@8375,10500 8675,10500 U7_CIN4.7@8725,10550 8825,10450 9750,10450 C17_CIN5.1@9800,10500 10100,10500 U7_CIN5.7@10150,10550 10250,10450 11175,10450 C17_CIN6.1@11225,10500 11525,10500 U7_CIN6.7@11575,10550 11675,10450 12600,10450 C17_CIN7.1@12650,10500 12950,10500 U7_CIN7.7@13000,10550 13100,10450 14025,10450 C17_CIN8.1@14075,10500 14375,10500 U7_CIN8.7@14425,10550 14475,10600 14860,10600 15070,10810 15340,10810 15390,10860 16010,10860 16060,10810 ; R69_COUT2.1@15375,3675 15340,3640 14685,3640 U6_CIN8.7@14425,3900 14385,3940 14165,3940 C18_CIN8.1@14075,3850 13985,3940 13040,3940 U6_CIN7.7@13000,3900 12960,3940 12740,3940 C18_CIN7.1@12650,3850 12560,3940 11615,3940 U6_CIN6.7@11575,3900 11535,3940 11315,3940 C18_CIN6.1@11225,3850 11135,3940 10190,3940 U6_CIN5.7@10150,3900 10110,3940 9890,3940 C18_CIN5.1@9800,3850 9710,3940 8765,3940 U6_CIN4.7@8725,3900 8685,3940 8465,3940 C18_CIN4.1@8375,3850 8285,3940 7340,3940 U6_CIN3.7@7300,3900 7260,3940 7040,3940 C18_CIN3.1@6950,3850 6860,3940 5915,3940 U6_CIN2.7@5875,3900 5835,3940 5615,3940 C18_CIN2.1@5525,3850 5435,3940 4490,3940 U6_CIN1.7@4450,3900 4410,3940 4190,3940 C18_CIN1.1@4100,3850 4080,3830 3820,3830 ; C49_COUT2.1@15550,4000 15725,4000 U12_COUT2.9@15775,4050 15816,4009 16200,4009 16225,4034 16225,4060 16255,4090 16335,4090 U12_COUT2.3@16375,4050 16435,4110 16940,4110 C49_COUT1.1@17050,4000 17225,4000 U12_COUT1.9@17275,4050 17316,4009 17700,4009 17725,4034 17725,4060 17755,4090 17835,4090 U12_COUT1.3@17875,4050 ; C23_COUT2.1@15550,4950 U5_COUT2.8@15800,4950 ; U10.3@16060,10760 16060,10810 ; C47.1@16240,11380 16240,10990 16060,10810 ; C23_COUT1.1@17050,4950 U5_COUT1.8@17300,4950 ; C20.1@2232,9029.07 C20.1@2231.93,9029 2232,9029 C20.1@2232,9029.07
  BottomLayer w10: C20.1@2231.93,9029 2231.93,8488.07 2440,8280 3030,8280 v1(3350,7960) ; C21.1@2804.06,12399 2851,12399 3120,12130 3120,11890 3057.25,11827.25 R53.2@3057.25,11704.02 ; R53.2@3057,11704.02 R53.2@3057.25,11704.02 ; v1(3250,11290) 3250,11511.27 R53.2@3057.25,11704.02 ; v1(3350,11190) 3350,11100 3950,10500 C17_CIN1.1@4100,10500 4100,10110 3800,9810 3751.22,9810 3720,9778.78 3720,9680.93 U3.8@3761.93,9639 ; C15.1@3499,7820.66 3609.34,7820.66 4100,7330 C16_CIN1.1@4100,6975 ; R69_COUT2.1@15375,3675 15550,3850 C49_COUT2.1@15550,4000 ; C23_COUT2.1@15550,4950 C22_COUT2.1@15550,7100 ; U12_COUT2.9@15775,4050 15921,4196 15921,4267 15900,4288 15860,4288 15829,4319 15829,4599 15840,4610 15840,4910 U5_COUT2.8@15800,4950 ; R69_COUT1.1@16875,3675 17050,3850 C49_COUT1.1@17050,4000 ; U12_COUT1.9@17275,4050 17421,4196 17421,4267 17400,4288 17360,4288 17329,4319 17329,4599 17340,4610 17340,4910 U5_COUT1.8@17300,4950
-15V: C15.2 C16_CIN1.2 C16_CIN2.2 C16_CIN3.2 C16_CIN4.2 C16_CIN5.2 C16_CIN6.2 C16_CIN7.2 C16_CIN8.2 C17_CIN1.2 C17_CIN2.2 C17_CIN3.2 C17_CIN4.2 C17_CIN5.2 C17_CIN6.2 C17_CIN7.2 C17_CIN8.2 C18_CIN1.2 C18_CIN2.2 C18_CIN3.2 C18_CIN4.2 C18_CIN5.2 C18_CIN6.2 C18_CIN7.2 C18_CIN8.2 C19.2 C20.2 C21.2 C22_COUT1.2 C22_COUT2.2 C23_COUT1.2 C23_COUT2.2 C48.2 Q2.1 R54.1 U1.8 U2_CIN1.4 U2_CIN2.4 U2_CIN3.4 U2_CIN4.4 U2_CIN5.4 U2_CIN6.4 U2_CIN7.4 U2_CIN8.4 U3.4 U4_COUT1.4 U4_COUT2.4 U5_COUT1.4 U5_COUT2.4 U6_CIN1.4 U6_CIN2.4 U6_CIN3.4 U6_CIN4.4 U6_CIN5.4 U6_CIN6.4 U6_CIN7.4 U6_CIN8.4 U7_CIN1.4 U7_CIN2.4 U7_CIN3.4 U7_CIN4.4 U7_CIN5.4 U7_CIN6.4 U7_CIN7.4 U7_CIN8.4 U8.4 U9.4 U11.1 | length 58009
  TopLayer w10: C19.2@2373.35,3441 C19.2@2373.35,3440.6 3150.6,3440.6 3461.93,3751.93 U8.4@3461.93,3892.02 ; C20.2@2373.35,8887.58 2373.35,8888 2920,8888 ; C21.2@3004.06,12399 3045.06,12440 3290.96,12440 U9.4@3415,12564.04 ; v1(3140,11280) v1(3280,11140) ; U3.4@3461.93,9339 U3.4@3462,9339 ; C15.2@3640,7679.24 3640,7780 2920,8500 2920,8888 ; U1.8@3689,6780 3742.58,6833.58 C16_CIN1.2@3958.58,6833.58 3959,6834 4145,6834 4314,6665 4590,6665 U2_CIN1.4@4650,6725 5275,6725 C16_CIN2.2@5383.58,6833.58 5384,6834 5570,6834 5739,6665 6015,6665 U2_CIN2.4@6075,6725 6700,6725 C16_CIN3.2@6808.58,6833.58 6809,6834 6995,6834 7164,6665 7440,6665 U2_CIN3.4@7500,6725 8125,6725 C16_CIN4.2@8233.58,6833.58 8234,6834 8420,6834 8589,6665 8865,6665 U2_CIN4.4@8925,6725 9550,6725 C16_CIN5.2@9658.58,6833.58 9659,6834 9845,6834 10014,6665 10290,6665 U2_CIN5.4@10350,6725 10975,6725 C16_CIN6.2@11083.58,6833.58 11084,6834 11270,6834 11439,6665 11715,6665 U2_CIN6.4@11775,6725 12400,6725 C16_CIN7.2@12508.58,6833.58 12509,6834 12695,6834 12864,6665 13140,6665 U2_CIN7.4@13200,6725 13825,6725 C16_CIN8.2@13933.58,6833.58 13934,6834 14120,6834 14289,6665 14565,6665 U2_CIN8.4@14625,6725 15175,6725 C22_COUT2.2@15408.58,6958.58 15409,6959 15578,6959 15727,6810 15840,6810 15860,6830 15860,6870 15880,6890 16060,6890 U4_COUT2.4@16100,6850 16800,6850 C22_COUT1.2@16908.58,6958.58 16909,6959 17078,6959 17227,6810 17340,6810 17360,6830 17360,6870 17380,6890 17560,6890 U4_COUT1.4@17600,6850 ; C18_CIN1.2@3958.58,3708.58 3959,3709 4541,3709 U6_CIN1.4@4650,3600 5275,3600 C18_CIN2.2@5383.58,3708.58 5384,3709 5966,3709 U6_CIN2.4@6075,3600 6700,3600 C18_CIN3.2@6808.58,3708.58 6809,3709 7391,3709 U6_CIN3.4@7500,3600 8125,3600 C18_CIN4.2@8233.58,3708.58 8234,3709 8816,3709 U6_CIN4.4@8925,3600 9550,3600 C18_CIN5.2@9658.58,3708.58 9659,3709 10241,3709 U6_CIN5.4@10350,3600 10975,3600 C18_CIN6.2@11083.58,3708.58 11084,3709 11666,3709 U6_CIN6.4@11775,3600 12400,3600 C18_CIN7.2@12508.58,3708.58 12509,3709 13091,3709 U6_CIN7.4@13200,3600 13825,3600 C18_CIN8.2@13933.58,3708.58 13934,3709 14516,3709 U6_CIN8.4@14625,3600 14655,3570 v1(15270,3570) ; v1(3958.58,10208.58) 3920,10170 3920,9380 3810,9270 3680,9270 3611,9339 U3.4@3462,9339 ; C17_CIN1.2@3958.58,10358.58 3959,10359 4541.42,10359 ; 4541.42,10358.58 U7_CIN1.4@4650,10250 5275,10250 C17_CIN2.2@5383.58,10358.58 5384,10359 5966.42,10359 ; 5966.42,10358.58 U7_CIN2.4@6075,10250 6700,10250 C17_CIN3.2@6808.58,10358.58 6809,10359 7391.42,10359 ; 7391.42,10358.58 U7_CIN3.4@7500,10250 8125,10250 C17_CIN4.2@8233.58,10358.58 8234,10359 8816.42,10359 ; 8816.42,10358.58 U7_CIN4.4@8925,10250 9550,10250 C17_CIN5.2@9658.58,10358.58 9659,10359 10241.42,10359 ; 10241.42,10358.58 U7_CIN5.4@10350,10250 10975,10250 C17_CIN6.2@11083.58,10358.58 11084,10359 11666.42,10359 ; 11666.42,10358.58 U7_CIN6.4@11775,10250 12400,10250 C17_CIN7.2@12508.58,10358.58 12509,10359 13091.42,10359 ; 13091.42,10358.58 U7_CIN7.4@13200,10250 13825,10250 C17_CIN8.2@13933.58,10358.58 13934,10359 14516.42,10359 ; 14516.42,10358.58 U7_CIN8.4@14625,10250 14990,10250 U11.1@15500,10760 ; C23_COUT2.2@15408.58,4808.58 15379,4779 15379,4569 15420,4528 15592,4528 15633,4569 16019,4569 U5_COUT2.4@16100,4650 16258.58,4808.58 C23_COUT1.2@16908.58,4808.58 16879,4779 16879,4569 16920,4528 17092,4528 17133,4569 17519,4569 U5_COUT1.4@17600,4650 ; 2920,8888 3126,8888 3462,9224 U3.4@3462,9339
  BottomLayer w10: Q2.1@2550,12600 2752,12600 2844,12508 ; C21.2@3004.06,12399 2953,12399 2844,12508 ; v1(3140,11280) 3140,11530 2990,11680 2990,12037.51 R54.1@2923.49,12104.02 2923.5,12168.5 2758,12334 2758,12422 2844,12508 ; v1(3280,11140) 3280,11100 3959,10421 C17_CIN1.2@3959,10359 ; U8.4@3461.93,3892.02 3645.37,3708.58 C18_CIN1.2@3958.58,3708.58 ; C15.2@3640.42,7679.24 3640,7679.24 3640,7535 3697,7478 3697,7173 3689,7165 U1.8@3689,6780 ; v1(3958.58,10208.58) C17_CIN1.2@3958.58,10358.58 ; v1(15270,3570) 15270,4670 C23_COUT2.2@15408.58,4808.58 15330,4887.16 15330,6880 C22_COUT2.2@15408.58,6958.58 ; U11.1@15498.58,10761.42 C48.2@15498.58,11521.42
A_FUSE: C44.2 F1.2 S3.2 | length 934.9
  BottomLayer w50: 16330,12950 F1.2@16490,12950 F1.2@16690,12950
  BottomLayer w100: S3.2@16130,12730 16190,12790 16190,12950 ; C44.2@16190,13140 16190,12950 ; 16330,12950 16190,12950
A_IN: F1.1 J8.1 | length 1064.6
  BottomLayer w50: F1.1@17490,12950 F1.1@17690,12950 17690,12775
  BottomLayer w100: 17690,12775 17690,12695 18015,12370 J8.1@18015,12220
A_SWITCH: C44.1 S3.1 T1.1 | length 4183.1
  BottomLayer w100: C44.1@15390,13140 15390,12910 15430,12870 S3.1@15430,12730 15430,12580 15600,12410 16050,12410 16765,11695 T1.1@16765,9790
GND: C45.2 C46.1 C47.2 C48.1 C49_COUT1.2 C49_COUT2.2 C50_COUT1.2 C50_COUT2.2 J1.3 J2_CIN1.1 J2_CIN2.1 J2_CIN3.1 J2_CIN4.1 J2_CIN5.1 J2_CIN6.1 J2_CIN7.1 J2_CIN8.1 J3_COUT1.1 J3_COUT2.1 J4_CIN1.3 J4_CIN2.3 J4_CIN3.3 J4_CIN4.3 J4_CIN5.3 J4_CIN6.3 J4_CIN7.3 J4_CIN8.3 J5.3 J6.3 J7.3 R1.1 R2.1 R3_CIN1.2 R3_CIN2.2 R3_CIN3.2 R3_CIN4.2 R3_CIN5.2 R3_CIN6.2 R3_CIN7.2 R3_CIN8.2 R7.1 R8_COUT1.1 R8_COUT2.1 R24.2 R27_CIN1.1 R27_CIN2.1 R27_CIN3.1 R27_CIN4.1 R27_CIN5.1 R27_CIN6.1 R27_CIN7.1 R27_CIN8.1 R28_CIN1.1 R28_CIN2.1 R28_CIN3.1 R28_CIN4.1 R28_CIN5.1 R28_CIN6.1 R28_CIN7.1 R28_CIN8.1 R30.1 R31.2 R34.1 R35.2 R38_COUT1.2 R38_COUT2.2 R48_CIN1.1 R48_CIN2.1 R48_CIN3.1 R48_CIN4.1 R48_CIN5.1 R48_CIN6.1 R48_CIN7.1 R48_CIN8.1 R49_CIN1.1 R49_CIN2.1 R49_CIN3.1 R49_CIN4.1 R49_CIN5.1 R49_CIN6.1 R49_CIN7.1 R49_CIN8.1 R70_COUT1.1 R70_COUT2.1 T1.4 U3.3 U4_COUT1.3 U4_COUT2.3 U5_COUT1.3 U5_COUT2.3 U6_CIN1.5 U6_CIN2.5 U6_CIN3.5 U6_CIN4.5 U6_CIN5.5 U6_CIN6.5 U6_CIN7.5 U6_CIN8.5 U7_CIN1.3 U7_CIN2.3 U7_CIN3.3 U7_CIN4.3 U7_CIN5.3 U7_CIN6.3 U7_CIN7.3 U7_CIN8.3 U8.3 U10.2 U11.3 U12_COUT1.2 U12_COUT1.4 U12_COUT2.2 U12_COUT2.4 VR1.3 VR2_CIN1.3 VR2_CIN2.3 VR2_CIN3.3 VR2_CIN4.3 VR2_CIN5.3 VR2_CIN6.3 VR2_CIN7.3 VR2_CIN8.3 VR3_CIN1.3 VR3_CIN2.3 VR3_CIN3.3 VR3_CIN4.3 VR3_CIN5.3 VR3_CIN6.3 VR3_CIN7.3 VR3_CIN8.3 VR4_CIN1.3 VR4_CIN2.3 VR4_CIN3.3 VR4_CIN4.3 VR4_CIN5.3 VR4_CIN6.3 VR4_CIN7.3 VR4_CIN8.3 VR5.3 VR6.3 VR7_COUT1.3 VR7_COUT2.3 VR8.2 VR9_CIN1.2 VR9_CIN2.2 VR9_CIN3.2 VR9_CIN4.2 VR9_CIN5.2 VR9_CIN6.2 VR9_CIN7.2 VR9_CIN8.2 | length 136579.3
  TopLayer w10: J7.3@2593.23,11128 2593.23,11743.23 2670,11820 2710,11820 2880,11990 3478.25,11990 R7.1@3592.26,12104.02 ; VR6.3@3100,9150 3174,9224 3174,9373 3240,9439 U3.3@3461.93,9439 ; VR8.2@3150,5175 3313,5175 3498,5360 R24.2@3547.89,5360 ; VR1.3@3150,6425 3235,6340 R1.1@3419,6340 3468,6291 3634.45,6291 R2.1@3683.45,6340 3684,6340 3724,6380 4370,6380 4400,6350 ; v1(3150,10200) 3250,10300 4500,10300 U7_CIN1.3@4550,10250 4590,10210 5935,10210 U7_CIN2.3@5975,10250 6015,10210 7360,10210 U7_CIN3.3@7400,10250 7440,10210 8785,10210 U7_CIN4.3@8825,10250 8865,10210 10210,10210 U7_CIN5.3@10250,10250 10290,10210 11635,10210 U7_CIN6.3@11675,10250 11715,10210 13060,10210 U7_CIN7.3@13100,10250 13140,10210 14485,10210 U7_CIN8.3@14525,10250 14605,10170 14890,10170 15200,9860 C46.1@15900,9860 ; R27_CIN1.1@4400,6200 4400,6350 ; J2_CIN1.1@4418.5,2265.55 4552.06,2132 v1(4857,2132) ; J4_CIN1.3@4634,3016 4734,3016 R48_CIN1.1@4950,2800 R49_CIN1.1@5075,2800 5120,2800 5654.45,2265.55 J2_CIN2.1@5843.5,2265.55 5977.06,2132 v1(6282,2132) ; VR2_CIN1.3@5050,5800 4955,5895 4955,6560 ; VR4_CIN1.3@5050,12660 5110,12720 6405,12720 VR4_CIN2.3@6475,12650 ; R27_CIN2.1@5825,6200 5825,6350 ; J4_CIN2.3@6059,3016 6159,3016 R48_CIN2.1@6375,2800 R49_CIN2.1@6500,2800 6545,2800 7079.45,2265.55 J2_CIN3.1@7268.5,2265.55 7402.06,2132 v1(7707,2132) ; VR2_CIN2.3@6475,5800 6380,5895 6380,6560 ; VR4_CIN2.3@6475,12660 6535,12720 7830,12720 VR4_CIN3.3@7900,12650 ; R27_CIN3.1@7250,6200 7250,6350 ; J4_CIN3.3@7484,3016 7584,3016 R48_CIN3.1@7800,2800 R49_CIN3.1@7925,2800 7970,2800 8504.45,2265.55 J2_CIN4.1@8693.5,2265.55 8827.06,2132 v1(9132,2132) ; VR2_CIN3.3@7900,5800 7805,5895 7805,6560 ; VR4_CIN3.3@7900,12660 7960,12720 9255,12720 VR4_CIN4.3@9325,12650 ; R27_CIN4.1@8675,6200 8675,6350 ; J4_CIN4.3@8909,3016 9009,3016 R48_CIN4.1@9225,2800 R49_CIN4.1@9350,2800 9395,2800 9929.45,2265.55 J2_CIN5.1@10118.5,2265.55 10252.06,2132 v1(10557,2132) ; VR2_CIN4.3@9325,5800 9230,5895 9230,6560 ; VR4_CIN4.3@9325,12660 9385,12720 10680,12720 VR4_CIN5.3@10750,12650 ; R27_CIN5.1@10100,6200 10100,6350 ; J4_CIN5.3@10334,3016 10434,3016 R48_CIN5.1@10650,2800 R49_CIN5.1@10775,2800 10820,2800 11354.45,2265.55 J2_CIN6.1@11543.5,2265.55 11677.06,2132 v1(11982,2132) ; VR2_CIN5.3@10750,5800 10655,5895 10655,6560 ; VR4_CIN5.3@10750,12660 10810,12720 12105,12720 VR4_CIN6.3@12175,12650 ; R27_CIN6.1@11525,6200 11525,6350 ; J4_CIN6.3@11759,3016 11859,3016 R48_CIN6.1@12075,2800 R49_CIN6.1@12200,2800 12245,2800 12779.45,2265.55 J2_CIN7.1@12968.5,2265.55 13102.06,2132 v1(13407,2132) ; VR2_CIN6.3@12175,5800 12080,5895 12080,6560 ; VR4_CIN6.3@12175,12660 12235,12720 13530,12720 VR4_CIN7.3@13600,12650 ; R27_CIN7.1@12950,6200 12950,6350 ; J4_CIN7.3@13184,3016 13284,3016 R48_CIN7.1@13500,2800 R49_CIN7.1@13625,2800 13670,2800 14204.45,2265.55 J2_CIN8.1@14393.5,2265.55 14527.06,2132 v1(14832,2132) ; VR2_CIN7.3@13600,5800 13505,5895 13505,6560 ; VR4_CIN7.3@13600,12660 13660,12720 14955,12720 VR4_CIN8.3@15025,12650 ; R27_CIN8.1@14375,6200 14375,6350 ; J4_CIN8.3@14609,3016 14709,3016 R48_CIN8.1@14925,2800 R49_CIN8.1@15050,2800 15090,2800 ; U6_CIN8.5@14625,3900 14665,3940 15327.16,3940 C49_COUT2.2@15408.58,3858.58 15500,3950 15711,3950 15735,3974 16199,3974 U12_COUT2.4@16275,4050 16315,4010 16435,4010 U12_COUT2.2@16475,4050 16666.42,3858.58 C49_COUT1.2@16908.58,3858.58 17000,3950 17211,3950 17235,3974 17699,3974 U12_COUT1.4@17775,4050 17815,4010 17935,4010 U12_COUT1.2@17975,4050 ; VR2_CIN8.3@15025,5800 14930,5895 14930,6560 ; VR9_CIN8.2@15025,11350 15055,11380 C48.1@15640,11380 15957.16,11380 C47.2@16098.58,11521.42 ; R70_COUT2.1@15425,4600 15525,4700 15950,4700 U5_COUT2.3@16000,4650 16225,4875 R38_COUT2.2@16225,5050 16790,5050 17025,4815 17025,4700 ; C50_COUT2.2@15434,2934 15433.58,2934 C50_COUT2.2@15433.58,2933.58 15223.58,2933.58 15090,2800 ; U11.3@15600,10760 15670,10830 15990,10830 16010,10810 U10.2@16010,10710 ; 15754.45,2265.55 15629.45,2265.55 15095,2800 15090,2800 ; 15755,2265 15931.5,2265 16613,2265 16934,2586 ; U4_COUT2.3@16000,6850 16030,6850 16120,6760 16120,6590 15920,6390 15350,6390 15140,6600 14970,6600 14930,6560 ; VR7_COUT2.3@16500,6225 17255,6225 17620,6590 17620,6760 17530,6850 U4_COUT1.3@17500,6850 ; R70_COUT1.1@16925,4600 17025,4700 ; C50_COUT1.2@16933.58,2933.58 16933.58,2934 16934,2934 16934,2933.58 16934,2586 ; J3_COUT1.1@17431.5,2265.55 17431.5,2265 17255,2265 16934,2586 ; R38_COUT1.2@17725,5050 17725,4875 U5_COUT1.3@17500,4650 17450,4700 17025,4700 ; R7.1@3592.26,12104.02 3592,12104.28 3592,12104.02 R7.1@3592.26,12104.02 ; 4400,6350 R3_CIN1.2@4650,6600 4915,6600 4955,6560 ; 4955,6560 5005,6610 5270,6610 5480,6400 5775,6400 5825,6350 ; 5825,6350 R3_CIN2.2@6075,6600 6340,6600 6380,6560 ; 6380,6560 6430,6610 6695,6610 6905,6400 7200,6400 7250,6350 ; 7250,6350 R3_CIN3.2@7500,6600 7765,6600 7805,6560 ; 7805,6560 7855,6610 8120,6610 8330,6400 8625,6400 8675,6350 ; 8675,6350 R3_CIN4.2@8925,6600 9190,6600 9230,6560 ; 9230,6560 9280,6610 9545,6610 9755,6400 10050,6400 10100,6350 ; 10100,6350 R3_CIN5.2@10350,6600 10615,6600 10655,6560 ; 10655,6560 10705,6610 10970,6610 11180,6400 11475,6400 11525,6350 ; 11525,6350 R3_CIN6.2@11775,6600 12040,6600 12080,6560 ; 12080,6560 12130,6610 12395,6610 12605,6400 12900,6400 12950,6350 ; 12950,6350 R3_CIN7.2@13200,6600 13465,6600 13505,6560 ; 13505,6560 13555,6610 13820,6610 14030,6400 14325,6400 14375,6350 ; 14375,6350 R3_CIN8.2@14625,6600 14890,6600 14930,6560
  TopLayer w20: C45.2@15617.16,9262.84 15900,9545.69 C46.1@15900,9860
  BottomLayer w10: J5.3@2555.93,2723.02 3100,3267.09 VR5.3@3100,3700 3169.91,3700 U8.3@3461.93,3992.02 ; J6.3@2555.93,8170 2543,8157.07 J1.3@2543,7456 2543,7032 VR1.3@3150,6425 ; J7.3@2593.23,11128 2780,10941.23 2780,10570 v1(3150,10200) 3320,10030 3320,9910.93 R35.2@3371.93,9859 3372,9859 3372,9759 R34.1@3371.93,9759 3371,9759 3371,9480 3412,9439 U3.3@3461.93,9439 ; VR8.2@3150,5175 3080,5105 3080,4860 3320,4620 3320,4463.95 R31.2@3371.93,4412.02 3371.93,4409 3372,4409 R30.1@3372,4312.02 ; R30.1@3371.93,4312.02 R30.1@3372,4312.02 ; R1.1@3419,6340 3598,6161 3598,5645 3548,5595 3548,5360 R24.2@3547.89,5360 ; U8.3@3462,3987 U8.3@3462,3991.95 ; U7_CIN1.3@4550,10250 4690,10390 4690,10760 4720,10790 4790,10790 4920,10920 4920,11220 VR9_CIN1.2@5050,11350 ; R28_CIN1.1@4600,7175 4600,6650 R3_CIN1.2@4650,6600 ; J4_CIN1.3@4634,3016 4634,3314 4690,3370 4690,3860 U6_CIN1.5@4650,3900 ; v1(4857,2132) 4924,2132 4996,2204 4996,2358 4904,2450 4904,2754 R48_CIN1.1@4950,2800 ; VR3_CIN1.3@5050,4700 5096,4654 5096,4480 5070,4454 5000,4454 4650,4104 U6_CIN1.5@4650,3900 ; U7_CIN2.3@5975,10250 6115,10390 6115,10760 6145,10790 6215,10790 6345,10920 6345,11220 VR9_CIN2.2@6475,11350 ; R28_CIN2.1@6025,7175 6025,6650 R3_CIN2.2@6075,6600 ; J4_CIN2.3@6059,3016 6059,3314 6115,3370 6115,3860 U6_CIN2.5@6075,3900 6075,4104 6425,4454 6495,4454 6521,4480 6521,4654 VR3_CIN2.3@6475,4700 ; v1(6282,2132) 6349,2132 6421,2204 6421,2358 6329,2450 6329,2754 R48_CIN2.1@6375,2800 ; U7_CIN3.3@7400,10250 7540,10390 7540,10760 7570,10790 7640,10790 7770,10920 7770,11220 VR9_CIN3.2@7900,11350 ; R28_CIN3.1@7450,7175 7450,6650 R3_CIN3.2@7500,6600 ; J4_CIN3.3@7484,3016 7484,3314 7540,3370 7540,3860 U6_CIN3.5@7500,3900 7500,4104 7850,4454 7920,4454 7946,4480 7946,4654 VR3_CIN3.3@7900,4700 ; v1(7707,2132) 7774,2132 7846,2204 7846,2358 7754,2450 7754,2754 R48_CIN3.1@7800,2800 ; U7_CIN4.3@8825,10250 8965,10390 8965,10760 8995,10790 9065,10790 9195,10920 9195,11220 VR9_CIN4.2@9325,11350 ; R28_CIN4.1@8875,7175 8875,6650 R3_CIN4.2@8925,6600 ; J4_CIN4.3@8909,3016 8909,3314 8965,3370 8965,3860 U6_CIN4.5@8925,3900 8925,4104 9275,4454 9345,4454 9371,4480 9371,4654 VR3_CIN4.3@9325,4700 ; v1(9132,2132) 9199,2132 9271,2204 9271,2358 9179,2450 9179,2754 R48_CIN4.1@9225,2800 ; U7_CIN5.3@10250,10250 10390,10390 10390,10760 10420,10790 10490,10790 10620,10920 10620,11220 VR9_CIN5.2@10750,11350 ; R28_CIN5.1@10300,7175 10300,6650 R3_CIN5.2@10350,6600 ; J4_CIN5.3@10334,3016 10334,3314 10390,3370 10390,3860 U6_CIN5.5@10350,3900 10350,4104 10700,4454 10770,4454 10796,4480 10796,4654 VR3_CIN5.3@10750,4700 ; v1(10557,2132) 10624,2132 10696,2204 10696,2358 10604,2450 10604,2754 R48_CIN5.1@10650,2800 ; U7_CIN6.3@11675,10250 11815,10390 11815,10760 11845,10790 11915,10790 12045,10920 12045,11220 VR9_CIN6.2@12175,11350 ; R28_CIN6.1@11725,7175 11725,6650 R3_CIN6.2@11775,6600 ; J4_CIN6.3@11759,3016 11759,3314 11815,3370 11815,3860 U6_CIN6.5@11775,3900 11775,4104 12125,4454 12195,4454 12221,4480 12221,4654 VR3_CIN6.3@12175,4700 ; v1(11982,2132) 12049,2132 12121,2204 12121,2358 12029,2450 12029,2754 R48_CIN6.1@12075,2800 ; U7_CIN7.3@13100,10250 13240,10390 13240,10760 13270,10790 13340,10790 13470,10920 13470,11220 VR9_CIN7.2@13600,11350 ; R28_CIN7.1@13150,7175 13150,6650 R3_CIN7.2@13200,6600 ; J4_CIN7.3@13184,3016 13184,3314 13240,3370 13240,3860 U6_CIN7.5@13200,3900 13200,4104 13550,4454 13620,4454 13646,4480 13646,4654 VR3_CIN7.3@13600,4700 ; v1(13407,2132) 13474,2132 13546,2204 13546,2358 13454,2450 13454,2754 R48_CIN7.1@13500,2800 ; U7_CIN8.3@14525,10250 14680,10405 14680,10750 14740,10810 14770,10810 14930,10970 14930,11255 VR9_CIN8.2@15025,11350 15080,11405 15080,11850 15140,11910 15180,11910 15210,11940 15210,12030 15110,12130 15030,12130 14960,12200 14960,12300 15100,12440 15100,12575 VR4_CIN8.3@15025,12650 ; R28_CIN8.1@14575,7175 14575,6650 R3_CIN8.2@14625,6600 ; J4_CIN8.3@14609,3016 14609,3314 14665,3370 14665,3860 U6_CIN8.5@14625,3900 14625,4104 14975,4454 15045,4454 15071,4480 15071,4654 VR3_CIN8.3@15025,4700 ; v1(14832,2132) 14899,2132 14971,2204 14971,2358 14879,2450 14879,2754 R48_CIN8.1@14925,2800 ; U4_COUT2.3@16000,6850 16030,6850 16100,6780 16260,6780 16500,6540 VR7_COUT2.3@16500,6225 16454,6179 16454,5746 R8_COUT2.1@16525,5675 16296,5446 16296,5080 16266,5050 R38_COUT2.2@16225,5050 ; T1.4@17265,7790 17450,7605 17450,6900 U4_COUT1.3@17500,6850 ; R38_COUT1.2@17725,5050 17766,5050 17796,5080 17796,5446 R8_COUT1.1@18025,5675 17954,5746 17954,6179 VR7_COUT1.3@18000,6225 ; R30.1@3372,4312.02 3447.98,4312.02 3520,4240 3520,4050.09 U8.3@3461.93,3992.02 ; U8.3@3461.93,3992.02 3462,3992.02 U8.3@3462,3991.95 ; U8.3@3461.93,3992.02 U8.3@3462,3991.95 ; U8.3@3462,3991.95 3663.95,3790 3810,3790 4010,3990 4560,3990 U6_CIN1.5@4650,3900
  BottomLayer w20: U10.2@16010,10710 15900,10600 C46.1@15900,9860 15900,9400 16220,9080 16220,8835 T1.4@17265,7790
HEADPHONE1: R51_CIN1.2 S2.8 | length 2052.3
  BottomLayer w10: S2.8@3669.71,11360 3720,11360 4775,12415 R51_CIN1.2@4775,12925
HEADPHONE2: R51_CIN2.2 S2.7 | length 3670.6
  TopLayer w10: S2.7@3505,11524.71 3505,11845 3560,11900 4366,11900 4747,12281 4747,12636 4921,12810 5613,12810 5728,12925 R51_CIN2.2@6200,12925
HEADPHONE3: R51_CIN3.2 S2.6 | length 5182.5
  TopLayer w10: S2.6@3280,11585 3375,11490 3430,11490 3478,11442 3638,11442 3732,11536 4056,11536 4888,12368 4888,12648 5026,12786 6749,12786 6888,12925 R51_CIN3.2@7625,12925
HEADPHONE4: R51_CIN4.2 S2.5 | length 6908.4
  TopLayer w10: S2.5@3055,11524.71 3082.71,11524.71 3278,11720 3278,11821 3320,11863 3489,11863 3551,11925 3665,11925 4053,12313 4053,12680 4120,12747 4195,12747 4221,12773 4673,12773 4779,12879 4821,12879 4913,12971 9040,12971 9050,12961 R51_CIN4.2@9050,12925
HEADPHONE5: R51_CIN5.2 S2.4 | length 8386.4
  TopLayer w10: S2.4@2890.29,11360 3565,11360 3622,11417 3987,11417 4940,12370 4940,12632 5061,12753 6770,12753 6862,12845 9874,12845 9954,12925 R51_CIN5.2@10475,12925
HEADPHONE6: R51_CIN6.2 S2.3 | length 10331.5
  TopLayer w10: v1(4161,12793) 4362,12793 4563,12994 9472,12994 9490,12976 11849,12976 R51_CIN6.2@11900,12925
  BottomLayer w10: S2.3@2830,11135 3213,11135 3493,11415 3573.28,11415 3793,11634.72 3793,12425 v1(4161,12793)
HEADPHONE7: R51_CIN7.2 S2.2 | length 13106.8
  TopLayer w10: v1(2402,12625) 2601,12824 3320,12824 3440,12944 4345,12944 4436,13035 13215,13035 R51_CIN7.2@13325,12925
  BottomLayer w10: v1(2402,12625) 2402,11840 2473,11769 2560,11769 2602,11727 2602,11276 2890,10988 2890,10910 S2.2@2890.29,10910
HEADPHONE8: R51_CIN8.2 S2.1 | length 13471.6
  TopLayer w10: v1(6933,11572) 6557,11196 6429,11196 6004,10771 5129,10771 4993,10635 4652,10635 4597,10690 3710,10690 3600,10580 3220.29,10580 S2.1@3055.29,10745 ; v1(6967,12785) 12263,12785 12264,12786 14611,12786 R51_CIN8.2@14750,12925 ; S2.1@3055.29,10745 3055,10745 S2.1@3055,10745.29 S2.1@3055.29,10745
  BottomLayer w10: v1(6933,11572) 6933,11751 6967,11785 v1(6967,12785)
MB1: R17.2 R22_CIN1.2 R22_CIN2.2 R22_CIN3.2 R22_CIN4.2 R22_CIN5.2 R22_CIN6.2 R22_CIN7.2 R22_CIN8.2 R37_COUT1.1 S2.11 | length 25682
  TopLayer w10: S2.11@3505,10745.29 3905.29,10745.29 3970,10810 v1@3980,10820 ; v1(3971,10809) 4393,10809 4775,11191 R22_CIN1.2@4775,11825 4840,11890 6135,11890 R22_CIN2.2@6200,11825 6265,11890 7560,11890 R22_CIN3.2@7625,11825 7690,11890 8985,11890 R22_CIN4.2@9050,11825 9115,11890 10410,11890 R22_CIN5.2@10475,11825 10540,11890 11835,11890 R22_CIN6.2@11900,11825 11965,11890 13260,11890 R22_CIN7.2@13325,11825 13390,11890 14685,11890 R22_CIN8.2@14750,11825 14835,11740 15280,11740 v1(15390,11630)
  BottomLayer w10: R17.2@3559,4800 3805,5046 3805,6160 4054,6409 4054,6546 4147,6639 4147,7075 4125,7097 4125,7530 4071,7584 4071,10018 4147,10094 4147,10633 v1(3971,10809) ; v1(15390,11630) 15390,7770 15840,7320 16710,7320 17150,6880 R37_COUT1.1@17150,6750
MB2: R19.2 R23_CIN1.2 R23_CIN2.2 R23_CIN3.2 R23_CIN4.2 R23_CIN5.2 R23_CIN6.2 R23_CIN7.2 R23_CIN8.2 R37_COUT2.1 S2.12 | length 24931.3
  TopLayer w10: S2.12@3280,10685 3415,10820 3770,10820 4040,11090 4040,11360 4655,11975 R23_CIN1.2@4775,11975 4809,11975 4864,12030 6145,12030 R23_CIN2.2@6200,11975 6255,12030 7570,12030 R23_CIN3.2@7625,11975 7680,12030 8995,12030 R23_CIN4.2@9050,11975 9105,12030 10420,12030 R23_CIN5.2@10475,11975 10530,12030 11845,12030 R23_CIN6.2@11900,11975 11955,12030 13270,12030 R23_CIN7.2@13325,11975 13380,12030 14695,12030 R23_CIN8.2@14750,11975 14805,12030 v1(15320,12030)
  BottomLayer w10: S2.12@3280,10685 3280,10474 3534,10220 3534,9759 3546,9747 3546,7961 3452,7867 3452,7688 3657,7483 3657,7306 3677,7286 3677,7210 3660,7193 3660,7133 3593,7066 3593,6894 3649,6838 3649,6760 3669,6740 3720,6740 3777,6683 3777,5155 3513,4891 3513,4840 3473,4800 R19.2@3426.78,4800 ; v1(15320,12030) 15350,12000 15350,7470 15650,7170 R37_COUT2.1@15650,6750
NetC1_1: C1.1 J1.1 | length 829.7
  TopLayer w10: J1.1@2381,7891 2891,7381 2999,7381 C1.1@2999,7380.53
NetC1_2: C1.2 R1.2 R9.1 | length 1547.1
  TopLayer w10: R1.2@3419,5940 R9.1@3551.22,5940
  BottomLayer w10: C1.2@3140,7239.11 C1.2@3140.42,7239.11 3272,7107.53 3272,6087 R1.2@3419,5940
NetC2_1: C2.1 VR1.2 | length 871.2
  BottomLayer w10: C2.1@2999,6940.4 2999,6941 3091,6941 3196,6836 3196,6271 VR1.2@3150,6225
NetC2_2: C2.2 R2.2 R10.1 | length 2121.5
  TopLayer w10: C2.2@3140.42,6798.98 3104,6762.55 3104,6389 3260,6233 3390.45,6233 R2.2@3683.45,5940
  BottomLayer w10: R10.1@3425.67,5360 3510.67,5275 3575,5275 3625,5325 3625,5581 3727,5683 3727,5896.44 R2.2@3683.45,5940 R2.2@3683,5940
NetC3_1: C3.1 VR5.2 | length 987.1
  TopLayer w10: C3.1@2701.93,4202.15 2701.93,4073.07 2836,3939 3241,3939 3300,3880 VR5.2@3300,3700
NetC3_2: C3.2 R13.1 | length 1271.4
  TopLayer w10: C3.2@2843.35,4060.73 2854.08,4050 3525,4050 3650,4175 3650,4410.09 R13.1@3771.93,4532.02 3772,4532.02 R13.1@3772,4533
NetC4_1: C4.1 VR6.2 | length 904.5
  BottomLayer w10: C4.1@2701.93,9649.13 2741,9649.13 2760,9630.13 2760,9630 2800,9590 2891,9590 3110,9371 3249,9371 3300,9320 VR6.2@3300,9150
NetC4_2: C4.2 R14.1 | length 1153.1
  TopLayer w10: C4.2@2843.35,9507.71 2985.64,9650 3150,9650 3175,9675 3175,9725 3200,9750 3275,9750 3335,9810 3470,9810 3639,9979 R14.1@3771.93,9979
NetC5_1: C5.1 U1.1 U1.2 | length 1392
  BottomLayer w10: C5.1@2999,7820.66 3152.34,7820.66 3373,7600 3373,6894 3389,6878 U1.1@3389,6780 U1.2@3389,6680
NetC5_2: C5.2 VR1.1 | length 1767.1
  BottomLayer w10: C5.2@3140.42,7679.24 3075,7613.82 3075,6992 3216,6851 3216,6091 VR1.1@3150,6025
NetC6_1: C6.1 C24.2 R39.1 U1.7 | length 2263.5
  BottomLayer w10: R39.1@3680.11,5360 3681,5360 3681,5510 3747,5576 3747,6518 3749,6520 3749,6620 U1.7@3689,6680 3589,6780 3480,6780 3467,6793 3467,6932 C24.2@3439,6960 3489,7010 C6.1@3489,7380.53 ; C6.1@3489,7380.53 3489,7381 C6.1@3489,7380.53
NetC6_2: C6.2 R16.1 R18.1 | length 3580.1
  BottomLayer w10: C6.2@3630.42,7239.11 3631,7239.11 3631,7360 3564,7427 3460,7427 3439,7406 3439,7040 3393,6994 3393,6935 3414,6914 3414,6835 3429,6820 3429,6559 3400,6530 3379,6530 3349,6500 3349,6233 3465,6117 3465,5910 3400,5845 3384,5845 R16.1@3299,5760 3350,5709 3350,4780 3386.43,4743.57 3632.57,4743.57 R18.1@3689,4800
NetC7_CIN1_1: C7_CIN1.1 VR2_CIN1.2 | length 888.1
  BottomLayer w10: VR2_CIN1.2@5050,5600 5096,5646 5096,6404 C7_CIN1.1@5050,6450
NetC7_CIN1_2: C7_CIN1.2 R3_CIN1.1 R11_CIN1.1 | length 429.1
  TopLayer w10: R11_CIN1.1@4525,6200 R3_CIN1.1@4650,6200 4759,6309 4908.58,6309 C7_CIN1.2@4908.58,6308.58
NetC7_CIN2_1: C7_CIN2.1 VR2_CIN2.2 | length 888.1
  BottomLayer w10: VR2_CIN2.2@6475,5600 6521,5646 6521,6404 C7_CIN2.1@6475,6450
NetC7_CIN2_2: C7_CIN2.2 R3_CIN2.1 R11_CIN2.1 | length 429.1
  TopLayer w10: R11_CIN2.1@5950,6200 R3_CIN2.1@6075,6200 6184,6309 6333.58,6309 C7_CIN2.2@6333.58,6308.58
NetC7_CIN3_1: C7_CIN3.1 VR2_CIN3.2 | length 888.1
  BottomLayer w10: VR2_CIN3.2@7900,5600 7946,5646 7946,6404 C7_CIN3.1@7900,6450
NetC7_CIN3_2: C7_CIN3.2 R3_CIN3.1 R11_CIN3.1 | length 429.1
  TopLayer w10: R11_CIN3.1@7375,6200 R3_CIN3.1@7500,6200 7609,6309 7758.58,6309 C7_CIN3.2@7758.58,6308.58
NetC7_CIN4_1: C7_CIN4.1 VR2_CIN4.2 | length 888.1
  BottomLayer w10: VR2_CIN4.2@9325,5600 9371,5646 9371,6404 C7_CIN4.1@9325,6450
NetC7_CIN4_2: C7_CIN4.2 R3_CIN4.1 R11_CIN4.1 | length 429.1
  TopLayer w10: R11_CIN4.1@8800,6200 R3_CIN4.1@8925,6200 9034,6309 9183.58,6309 C7_CIN4.2@9183.58,6308.58
NetC7_CIN5_1: C7_CIN5.1 VR2_CIN5.2 | length 888.1
  BottomLayer w10: VR2_CIN5.2@10750,5600 10796,5646 10796,6404 C7_CIN5.1@10750,6450
NetC7_CIN5_2: C7_CIN5.2 R3_CIN5.1 R11_CIN5.1 | length 429.1
  TopLayer w10: R11_CIN5.1@10225,6200 R3_CIN5.1@10350,6200 10459,6309 10608.58,6309 C7_CIN5.2@10608.58,6308.58
NetC7_CIN6_1: C7_CIN6.1 VR2_CIN6.2 | length 888.1
  BottomLayer w10: VR2_CIN6.2@12175,5600 12221,5646 12221,6404 C7_CIN6.1@12175,6450
NetC7_CIN6_2: C7_CIN6.2 R3_CIN6.1 R11_CIN6.1 | length 429.1
  TopLayer w10: R11_CIN6.1@11650,6200 R3_CIN6.1@11775,6200 11884,6309 12033.58,6309 C7_CIN6.2@12033.58,6308.58
NetC7_CIN7_1: C7_CIN7.1 VR2_CIN7.2 | length 888.1
  BottomLayer w10: VR2_CIN7.2@13600,5600 13646,5646 13646,6404 C7_CIN7.1@13600,6450
NetC7_CIN7_2: C7_CIN7.2 R3_CIN7.1 R11_CIN7.1 | length 429.1
  TopLayer w10: R11_CIN7.1@13075,6200 R3_CIN7.1@13200,6200 13309,6309 13458.58,6309 C7_CIN7.2@13458.58,6308.58
NetC7_CIN8_1: C7_CIN8.1 VR2_CIN8.2 | length 888.1
  BottomLayer w10: VR2_CIN8.2@15025,5600 15071,5646 15071,6404 C7_CIN8.1@15025,6450
NetC7_CIN8_2: C7_CIN8.2 R3_CIN8.1 R11_CIN8.1 | length 429.1
  TopLayer w10: R11_CIN8.1@14500,6200 R3_CIN8.1@14625,6200 14734,6309 14883.58,6309 C7_CIN8.2@14883.58,6308.58
NetC8_CIN1_1: C8_CIN1.1 C26_CIN1.2 R40_CIN1.2 U2_CIN1.1 | length 1176
  TopLayer w10: C26_CIN1.2@4100,6500 4200,6600 R40_CIN1.2@4275,6600 ; U2_CIN1.1@4350,6725 4465,6840 4710,6840 4845,6975 C8_CIN1.1@5050,6975
  BottomLayer w10: R40_CIN1.2@4275,6600 4350,6675 U2_CIN1.1@4350,6725
NetC8_CIN1_2: C8_CIN1.2 R4_CIN1.1 R46_CIN1.2 | length 1953.5
  BottomLayer w10: C8_CIN1.2@4908.58,6833.58 4908.58,7108.58 5022.5,7222.5 ; R4_CIN1.1@5100,7300 5022.5,7222.5 ; R46_CIN1.2@5100,8500 5100,8090 4904,7894 4904,7341 5022.5,7222.5
NetC8_CIN2_1: C8_CIN2.1 C26_CIN2.2 R40_CIN2.2 U2_CIN2.1 | length 1176
  TopLayer w10: C26_CIN2.2@5525,6500 5625,6600 R40_CIN2.2@5700,6600 ; U2_CIN2.1@5775,6725 5890,6840 6135,6840 6270,6975 C8_CIN2.1@6475,6975
  BottomLayer w10: R40_CIN2.2@5700,6600 5775,6675 U2_CIN2.1@5775,6725
NetC8_CIN2_2: C8_CIN2.2 R4_CIN2.1 R46_CIN2.2 | length 1953.5
  BottomLayer w10: C8_CIN2.2@6333.58,6833.58 6333.58,7108.58 6447.5,7222.5 ; R4_CIN2.1@6525,7300 6447.5,7222.5 ; R46_CIN2.2@6525,8500 6525,8090 6329,7894 6329,7341 6447.5,7222.5
NetC8_CIN3_1: C8_CIN3.1 C26_CIN3.2 R40_CIN3.2 U2_CIN3.1 | length 1176
  TopLayer w10: C26_CIN3.2@6950,6500 7050,6600 R40_CIN3.2@7125,6600 ; U2_CIN3.1@7200,6725 7315,6840 7560,6840 7695,6975 C8_CIN3.1@7900,6975
  BottomLayer w10: R40_CIN3.2@7125,6600 7200,6675 U2_CIN3.1@7200,6725
NetC8_CIN3_2: C8_CIN3.2 R4_CIN3.1 R46_CIN3.2 | length 1953.5
  BottomLayer w10: C8_CIN3.2@7758.58,6833.58 7758.58,7108.58 7872.5,7222.5 ; R4_CIN3.1@7950,7300 7872.5,7222.5 ; R46_CIN3.2@7950,8500 7950,8090 7754,7894 7754,7341 7872.5,7222.5
NetC8_CIN4_1: C8_CIN4.1 C26_CIN4.2 R40_CIN4.2 U2_CIN4.1 | length 1176
  TopLayer w10: C26_CIN4.2@8375,6500 8475,6600 R40_CIN4.2@8550,6600 ; U2_CIN4.1@8625,6725 8740,6840 8985,6840 9120,6975 C8_CIN4.1@9325,6975
  BottomLayer w10: R40_CIN4.2@8550,6600 8625,6675 U2_CIN4.1@8625,6725
NetC8_CIN4_2: C8_CIN4.2 R4_CIN4.1 R46_CIN4.2 | length 1953.5
  BottomLayer w10: C8_CIN4.2@9183.58,6833.58 9183.58,7108.58 9297.5,7222.5 ; R4_CIN4.1@9375,7300 9297.5,7222.5 ; R46_CIN4.2@9375,8500 9375,8090 9179,7894 9179,7341 9297.5,7222.5
NetC8_CIN5_1: C8_CIN5.1 C26_CIN5.2 R40_CIN5.2 U2_CIN5.1 | length 1176
  TopLayer w10: C26_CIN5.2@9800,6500 9900,6600 R40_CIN5.2@9975,6600 ; U2_CIN5.1@10050,6725 10165,6840 10410,6840 10545,6975 C8_CIN5.1@10750,6975
  BottomLayer w10: R40_CIN5.2@9975,6600 10050,6675 U2_CIN5.1@10050,6725
NetC8_CIN5_2: C8_CIN5.2 R4_CIN5.1 R46_CIN5.2 | length 1953.5
  BottomLayer w10: C8_CIN5.2@10608.58,6833.58 10608.58,7108.58 10722.5,7222.5 ; R4_CIN5.1@10800,7300 10722.5,7222.5 ; R46_CIN5.2@10800,8500 10800,8090 10604,7894 10604,7341 10722.5,7222.5
NetC8_CIN6_1: C8_CIN6.1 C26_CIN6.2 R40_CIN6.2 U2_CIN6.1 | length 1176
  TopLayer w10: C26_CIN6.2@11225,6500 11325,6600 R40_CIN6.2@11400,6600 ; U2_CIN6.1@11475,6725 11590,6840 11835,6840 11970,6975 C8_CIN6.1@12175,6975
  BottomLayer w10: R40_CIN6.2@11400,6600 11475,6675 U2_CIN6.1@11475,6725
NetC8_CIN6_2: C8_CIN6.2 R4_CIN6.1 R46_CIN6.2 | length 1953.5
  BottomLayer w10: C8_CIN6.2@12033.58,6833.58 12033.58,7108.58 12147.5,7222.5 ; R4_CIN6.1@12225,7300 12147.5,7222.5 ; R46_CIN6.2@12225,8500 12225,8090 12029,7894 12029,7341 12147.5,7222.5
NetC8_CIN7_1: C8_CIN7.1 C26_CIN7.2 R40_CIN7.2 U2_CIN7.1 | length 1176
  TopLayer w10: C26_CIN7.2@12650,6500 12750,6600 R40_CIN7.2@12825,6600 ; U2_CIN7.1@12900,6725 13015,6840 13260,6840 13395,6975 C8_CIN7.1@13600,6975
  BottomLayer w10: R40_CIN7.2@12825,6600 12900,6675 U2_CIN7.1@12900,6725
NetC8_CIN7_2: C8_CIN7.2 R4_CIN7.1 R46_CIN7.2 | length 1953.5
  BottomLayer w10: C8_CIN7.2@13458.58,6833.58 13458.58,7108.58 13572.5,7222.5 ; R4_CIN7.1@13650,7300 13572.5,7222.5 ; R46_CIN7.2@13650,8500 13650,8090 13454,7894 13454,7341 13572.5,7222.5
NetC8_CIN8_1: C8_CIN8.1 C26_CIN8.2 R40_CIN8.2 U2_CIN8.1 | length 1176
  TopLayer w10: C26_CIN8.2@14075,6500 14175,6600 R40_CIN8.2@14250,6600 ; U2_CIN8.1@14325,6725 14470,6870 14765,6870 14870,6975 C8_CIN8.1@15025,6975
  BottomLayer w10: R40_CIN8.2@14250,6600 14325,6675 U2_CIN8.1@14325,6725
NetC8_CIN8_2: C8_CIN8.2 R4_CIN8.1 R46_CIN8.2 | length 1953.5
  BottomLayer w10: C8_CIN8.2@14883.58,6833.58 14883.58,7108.58 14997.5,7222.5 ; R4_CIN8.1@15075,7300 14997.5,7222.5 ; R46_CIN8.2@15075,8500 15075,8090 14879,7894 14879,7341 14997.5,7222.5