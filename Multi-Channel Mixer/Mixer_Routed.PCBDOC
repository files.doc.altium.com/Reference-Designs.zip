# Altium PCB Mixer_Routed.PCBDOC (part 3 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 16350 x 11350 mil, 2 copper layers (TopLayer, BottomLayer); 554 components, 386 nets, 1551 pads, 25 vias.

## Via types
v1: diameter 50, hole 28, TopLayer to BottomLayer, 25 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetC9_CIN1_1: C9_CIN1.1 C33_CIN1.2 R6_CIN1.2 R47_CIN1.2 U7_CIN1.6 | length 2077.4
  TopLayer w10: R47_CIN1.2@3975,9850 4262,10137 4388,10137 C33_CIN1.2@4475,10050 ; U7_CIN1.6@4550,10550 4600,10500 C9_CIN1.1@5050,10500
  BottomLayer w10: C33_CIN1.2@4475,10050 4510,10085 4510,10290 4550,10330 U7_CIN1.6@4550,10550 ; C9_CIN1.1@5050,10500 5050,10200 R6_CIN1.2@5100,10150
NetC9_CIN1_2: C9_CIN1.2 R20_CIN1.1 R21_CIN1.1 R51_CIN1.1 VR4_CIN1.1 | length 2859
  BottomLayer w10: C9_CIN1.2@4908.58,10358.58 4997,10447 4997,10547 R20_CIN1.1@5175,10725 R21_CIN1.1@5175,10875 5270,10970 5270,12030 VR4_CIN1.1@5050,12250 5175,12375 R51_CIN1.1@5175,12925
NetC9_CIN2_1: C9_CIN2.1 C33_CIN2.2 R6_CIN2.2 R47_CIN2.2 U7_CIN2.6 | length 2077.4
  TopLayer w10: R47_CIN2.2@5400,9850 5687,10137 5813,10137 C33_CIN2.2@5900,10050 ; U7_CIN2.6@5975,10550 6025,10500 C9_CIN2.1@6475,10500
  BottomLayer w10: C33_CIN2.2@5900,10050 5935,10085 5935,10290 5975,10330 U7_CIN2.6@5975,10550 ; C9_CIN2.1@6475,10500 6475,10200 R6_CIN2.2@6525,10150
NetC9_CIN2_2: C9_CIN2.2 R20_CIN2.1 R21_CIN2.1 R51_CIN2.1 VR4_CIN2.1 | length 2859
  BottomLayer w10: C9_CIN2.2@6333.58,10358.58 6422,10447 6422,10547 R20_CIN2.1@6600,10725 R21_CIN2.1@6600,10875 6695,10970 6695,12030 VR4_CIN2.1@6475,12250 6600,12375 R51_CIN2.1@6600,12925
NetC9_CIN3_1: C9_CIN3.1 C33_CIN3.2 R6_CIN3.2 R47_CIN3.2 U7_CIN3.6 | length 2077.4
  TopLayer w10: R47_CIN3.2@6825,9850 7112,10137 7238,10137 C33_CIN3.2@7325,10050 ; U7_CIN3.6@7400,10550 7450,10500 C9_CIN3.1@7900,10500
  BottomLayer w10: C33_CIN3.2@7325,10050 7360,10085 7360,10290 7400,10330 U7_CIN3.6@7400,10550 ; C9_CIN3.1@7900,10500 7900,10200 R6_CIN3.2@7950,10150
NetC9_CIN3_2: C9_CIN3.2 R20_CIN3.1 R21_CIN3.1 R51_CIN3.1 VR4_CIN3.1 | length 2859
  BottomLayer w10: C9_CIN3.2@7758.58,10358.58 7847,10447 7847,10547 R20_CIN3.1@8025,10725 R21_CIN3.1@8025,10875 8120,10970 8120,12030 VR4_CIN3.1@7900,12250 8025,12375 R51_CIN3.1@8025,12925
NetC9_CIN4_1: C9_CIN4.1 C33_CIN4.2 R6_CIN4.2 R47_CIN4.2 U7_CIN4.6 | length 2077.4
  TopLayer w10: R47_CIN4.2@8250,9850 8537,10137 8663,10137 C33_CIN4.2@8750,10050 ; U7_CIN4.6@8825,10550 8875,10500 C9_CIN4.1@9325,10500
  BottomLayer w10: C33_CIN4.2@8750,10050 8785,10085 8785,10290 8825,10330 U7_CIN4.6@8825,10550 ; C9_CIN4.1@9325,10500 9325,10200 R6_CIN4.2@9375,10150
NetC9_CIN4_2: C9_CIN4.2 R20_CIN4.1 R21_CIN4.1 R51_CIN4.1 VR4_CIN4.1 | length 2859
  BottomLayer w10: C9_CIN4.2@9183.58,10358.58 9272,10447 9272,10547 R20_CIN4.1@9450,10725 R21_CIN4.1@9450,10875 9545,10970 9545,12030 VR4_CIN4.1@9325,12250 9450,12375 R51_CIN4.1@9450,12925
NetC9_CIN5_1: C9_CIN5.1 C33_CIN5.2 R6_CIN5.2 R47_CIN5.2 U7_CIN5.6 | length 2077.4
  TopLayer w10: R47_CIN5.2@9675,9850 9962,10137 10088,10137 C33_CIN5.2@10175,10050 ; U7_CIN5.6@10250,10550 10300,10500 C9_CIN5.1@10750,10500
  BottomLayer w10: C33_CIN5.2@10175,10050 10210,10085 10210,10290 10250,10330 U7_CIN5.6@10250,10550 ; C9_CIN5.1@10750,10500 10750,10200 R6_CIN5.2@10800,10150
NetC9_CIN5_2: C9_CIN5.2 R20_CIN5.1 R21_CIN5.1 R51_CIN5.1 VR4_CIN5.1 | length 2859
  BottomLayer w10: C9_CIN5.2@10608.58,10358.58 10697,10447 10697,10547 R20_CIN5.1@10875,10725 R21_CIN5.1@10875,10875 10970,10970 10970,12030 VR4_CIN5.1@10750,12250 10875,12375 R51_CIN5.1@10875,12925
NetC9_CIN6_1: C9_CIN6.1 C33_CIN6.2 R6_CIN6.2 R47_CIN6.2 U7_CIN6.6 | length 2077.4
  TopLayer w10: R47_CIN6.2@11100,9850 11387,10137 11513,10137 C33_CIN6.2@11600,10050 ; U7_CIN6.6@11675,10550 11725,10500 C9_CIN6.1@12175,10500
  BottomLayer w10: C33_CIN6.2@11600,10050 11635,10085 11635,10290 11675,10330 U7_CIN6.6@11675,10550 ; C9_CIN6.1@12175,10500 12175,10200 R6_CIN6.2@12225,10150
NetC9_CIN6_2: C9_CIN6.2 R20_CIN6.1 R21_CIN6.1 R51_CIN6.1 VR4_CIN6.1 | length 2859
  BottomLayer w10: C9_CIN6.2@12033.58,10358.58 12122,10447 12122,10547 R20_CIN6.1@12300,10725 R21_CIN6.1@12300,10875 12395,10970 12395,12030 VR4_CIN6.1@12175,12250 12300,12375 R51_CIN6.1@12300,12925
NetC9_CIN7_1: C9_CIN7.1 C33_CIN7.2 R6_CIN7.2 R47_CIN7.2 U7_CIN7.6 | length 2077.4
  TopLayer w10: R47_CIN7.2@12525,9850 12812,10137 12938,10137 C33_CIN7.2@13025,10050 ; U7_CIN7.6@13100,10550 13150,10500 C9_CIN7.1@13600,10500
  BottomLayer w10: C33_CIN7.2@13025,10050 13060,10085 13060,10290 13100,10330 U7_CIN7.6@13100,10550 ; C9_CIN7.1@13600,10500 13600,10200 R6_CIN7.2@13650,10150
NetC9_CIN7_2: C9_CIN7.2 R20_CIN7.1 R21_CIN7.1 R51_CIN7.1 VR4_CIN7.1 | length 2859
  BottomLayer w10: C9_CIN7.2@13458.58,10358.58 13547,10447 13547,10547 R20_CIN7.1@13725,10725 R21_CIN7.1@13725,10875 13820,10970 13820,12030 VR4_CIN7.1@13600,12250 13725,12375 R51_CIN7.1@13725,12925
NetC9_CIN8_1: C9_CIN8.1 C33_CIN8.2 R6_CIN8.2 R47_CIN8.2 U7_CIN8.6 | length 2077.4
  TopLayer w10: R47_CIN8.2@13950,9850 14237,10137 14363,10137 C33_CIN8.2@14450,10050 ; U7_CIN8.6@14525,10550 14575,10500 C9_CIN8.1@15025,10500
  BottomLayer w10: C33_CIN8.2@14450,10050 14485,10085 14485,10290 14525,10330 U7_CIN8.6@14525,10550 ; C9_CIN8.1@15025,10500 15025,10200 R6_CIN8.2@15075,10150
NetC9_CIN8_2: C9_CIN8.2 R20_CIN8.1 R21_CIN8.1 R51_CIN8.1 VR4_CIN8.1 | length 2854.9
  BottomLayer w10: C9_CIN8.2@14883.58,10358.58 14972,10447 14972,10547 R20_CIN8.1@15150,10725 R21_CIN8.1@15150,10875 15240,10965 15240,12035 VR4_CIN8.1@15025,12250 15150,12375 R51_CIN8.1@15150,12925
NetC10_CIN1_1: C10_CIN1.1 VR3_CIN1.2 | length 638.1
  BottomLayer w10: VR3_CIN1.2@5050,4500 5004,4546 5004,5054 C10_CIN1.1@5050,5100
NetC10_CIN1_2: C10_CIN1.2 R12_CIN1.1 | length 2716.5
  BottomLayer w10: R12_CIN1.1@4725,7575 4765,7575 4779,7561 4779,5361 4908.58,5231.42 C10_CIN1.2@4908.58,4958.58 C10_CIN1.2@4909,4959
NetC10_CIN2_1: C10_CIN2.1 VR3_CIN2.2 | length 638.1
  BottomLayer w10: VR3_CIN2.2@6475,4500 6429,4546 6429,5054 C10_CIN2.1@6475,5100
NetC10_CIN2_2: C10_CIN2.2 R12_CIN2.1 | length 2716.5
  BottomLayer w10: R12_CIN2.1@6150,7575 6190,7575 6204,7561 6204,5361 6333.58,5231.42 C10_CIN2.2@6333.58,4958.58 C10_CIN2.2@6334,4959
NetC10_CIN3_1: C10_CIN3.1 VR3_CIN3.2 | length 638.1
  BottomLayer w10: VR3_CIN3.2@7900,4500 7854,4546 7854,5054 C10_CIN3.1@7900,5100
NetC10_CIN3_2: C10_CIN3.2 R12_CIN3.1 | length 2716.5
  BottomLayer w10: R12_CIN3.1@7575,7575 7615,7575 7629,7561 7629,5361 7758.58,5231.42 C10_CIN3.2@7758.58,4958.58 C10_CIN3.2@7759,4959
NetC10_CIN4_1: C10_CIN4.1 VR3_CIN4.2 | length 638.1
  BottomLayer w10: VR3_CIN4.2@9325,4500 9279,4546 9279,5054 C10_CIN4.1@9325,5100
NetC10_CIN4_2: C10_CIN4.2 R12_CIN4.1 | length 2716.5
  BottomLayer w10: R12_CIN4.1@9000,7575 9040,7575 9054,7561 9054,5361 9183.58,5231.42 C10_CIN4.2@9183.58,4958.58 C10_CIN4.2@9184,4959
NetC10_CIN5_1: C10_CIN5.1 VR3_CIN5.2 | length 638.1
  BottomLayer w10: VR3_CIN5.2@10750,4500 10704,4546 10704,5054 C10_CIN5.1@10750,5100
NetC10_CIN5_2: C10_CIN5.2 R12_CIN5.1 | length 2716.5
  BottomLayer w10: R12_CIN5.1@10425,7575 10465,7575 10479,7561 10479,5361 10608.58,5231.42 C10_CIN5.2@10608.58,4958.58 C10_CIN5.2@10609,4959
NetC10_CIN6_1: C10_CIN6.1 VR3_CIN6.2 | length 638.1
  BottomLayer w10: VR3_CIN6.2@12175,4500 12129,4546 12129,5054 C10_CIN6.1@12175,5100
NetC10_CIN6_2: C10_CIN6.2 R12_CIN6.1 | length 2716.5
  BottomLayer w10: R12_CIN6.1@11850,7575 11890,7575 11904,7561 11904,5361 12033.58,5231.42 C10_CIN6.2@12033.58,4958.58 C10_CIN6.2@12034,4959
NetC10_CIN7_1: C10_CIN7.1 VR3_CIN7.2 | length 638.1
  BottomLayer w10: VR3_CIN7.2@13600,4500 13554,4546 13554,5054 C10_CIN7.1@13600,5100
NetC10_CIN7_2: C10_CIN7.2 R12_CIN7.1 | length 2716.5
  BottomLayer w10: R12_CIN7.1@13275,7575 13315,7575 13329,7561 13329,5361 13458.58,5231.42 C10_CIN7.2@13458.58,4958.58 C10_CIN7.2@13459,4959
NetC10_CIN8_1: C10_CIN8.1 VR3_CIN8.2 | length 638.1
  BottomLayer w10: VR3_CIN8.2@15025,4500 14979,4546 14979,5054 C10_CIN8.1@15025,5100
NetC10_CIN8_2: C10_CIN8.2 R12_CIN8.1 | length 2716.5
  BottomLayer w10: R12_CIN8.1@14700,7575 14740,7575 14754,7561 14754,5361 14883.58,5231.42 C10_CIN8.2@14883.58,4958.58 C10_CIN8.2@14884,4959
NetC11_1: C11.1 C34.2 R57.2 U8.1 | length 1849.7
  BottomLayer w10: C11.1@2231.93,4022.15 2231.93,3843.07 2375,3700 2693.95,3700 C34.2@2821.93,3572.02 ; R57.2@3242,3853 R57.2@3242,3852.09 ; U8.1@3462,4192.02 U8.1@3461.93,4192.02 3400,4130.09 3400,4010.09 R57.2@3242,3852.09 ; C34.2@2821.93,3572.02 C34.2@2822,3572.09 ; C34.2@2821.93,3572.02 2822,3572.02 C34.2@2822,3572.09 ; C34.2@2822,3572.09 3024.91,3775 3164.91,3775 R57.2@3241.93,3852.02 ; R57.2@3241.93,3852.02 3242,3852.02 R57.2@3242,3852.09 ; R57.2@3241.93,3852.02 R57.2@3242,3852.09
NetC11_2: C11.2 VR5.1 | length 1830.2
  TopLayer w10: 2325,3832.38 2327,3834.38 ; C11.2@2373.35,3880.73 2327,3834.38 ; VR5.1@3500,3700 3165,3365 2360,3365 2327,3398 2327,3834.38
NetC12_1: C12.1 C35.2 R58.2 U3.1 | length 2785.6
  TopLayer w10: C12.1@2231.93,9469.13 2231.93,9469 2232,9469 2232,9196 2185,9149 2185,8996 2220,8961 2682,8961 2740,9019 C35.2@2821.93,9019 3081,9019 3242,9180 3242,9299 R58.2@3241.93,9299
  BottomLayer w10: R58.2@3241.93,9299 3241,9299 3241,9080 3283,9038 3296,9038 3502,9244 3502,9627 3490,9639 U3.1@3461.93,9639
NetC12_2: C12.2 VR6.1 | length 1320.7
  BottomLayer w10: C12.2@2373.35,9327.71 2601.06,9100 3170,9100 3265.4,9004.6 3354.6,9004.6 VR6.1@3500,9150
NetC13_COUT1_1: C13_COUT1.1 C36_COUT1.2 R60_COUT1.2 U4_COUT1.1 | length 1346.8
  TopLayer w10: C36_COUT1.2@16925,6700 17075,6700 R60_COUT1.2@17150,6625 ; U4_COUT1.1@17300,6850 17550,7100 C13_COUT1.1@18000,7100
  BottomLayer w10: R60_COUT1.2@17150,6625 17300,6775 U4_COUT1.1@17300,6850
NetC13_COUT1_2: C13_COUT1.2 VR7_COUT1.1 | length 1271.1
  BottomLayer w10: C13_COUT1.2@17858.58,6958.58 17859,6959 18066,6752 18066,5851 18040,5825 VR7_COUT1.1@18000,5825
NetC13_COUT2_1: C13_COUT2.1 C36_COUT2.2 R60_COUT2.2 U4_COUT2.1 | length 1346.8
  TopLayer w10: C36_COUT2.2@15425,6700 15575,6700 R60_COUT2.2@15650,6625 ; U4_COUT2.1@15800,6850 16050,7100 C13_COUT2.1@16500,7100
  BottomLayer w10: R60_COUT2.2@15650,6625 15800,6775 U4_COUT2.1@15800,6850
NetC13_COUT2_2: C13_COUT2.2 VR7_COUT2.1 | length 1271.1
  BottomLayer w10: C13_COUT2.2@16358.58,6958.58 16359,6959 16566,6752 16566,5851 16540,5825 VR7_COUT2.1@16500,5825
NetC14_COUT1_1: C14_COUT1.1 VR7_COUT1.2 | length 663.1
  BottomLayer w10: VR7_COUT1.2@18000,6025 18046,6071 18046,6604 C14_COUT1.1@18000,6650
NetC14_COUT1_2: C14_COUT1.2 R15_COUT1.1 | length 851.2
  BottomLayer w10: C14_COUT1.2@17858.58,6508.58 17858,6508 17858,6170 17900,6128 R15_COUT1.1@17900,5675
NetC14_COUT2_1: C14_COUT2.1 VR7_COUT2.2 | length 663.1
  BottomLayer w10: VR7_COUT2.2@16500,6025 16546,6071 16546,6604 C14_COUT2.1@16500,6650
NetC14_COUT2_2: C14_COUT2.2 R15_COUT2.1 | length 851.2
  BottomLayer w10: C14_COUT2.2@16358.58,6508.58 16358,6508 16358,6170 16400,6128 R15_COUT2.1@16400,5675
NetC24_1: C24.1 R24.1 R39.2 U1.6 | length 1392.3
  TopLayer w10: R24.1@3547.89,5760 R39.2@3680.11,5760 ; C24.1@3639,6960 3639,6630 U1.6@3689,6580
  BottomLayer w10: R39.2@3680.11,5760 3637,5803.11 3637,6528 U1.6@3689,6580
NetC25_CIN1_1: C25_CIN1.1 J2_CIN1.2 R25_CIN1.2 R48_CIN1.2 U6_CIN1.2 | length 3131.9
  TopLayer w10: J2_CIN1.2@4418.5,2584.45 4419,2584.45 4419,2345 4592,2172 5113,2172 5141,2200 5141,2680 5114,2707 4965,2707 4950,2692 R25_CIN1.2@4950,2650 ; U6_CIN1.2@4450,3600 4625,3425 C25_CIN1.1@4900,3425
  BottomLayer w10: C25_CIN1.1@4900,3425 4900,3250 R48_CIN1.2@4950,3200 4996,3154 4996,2696 R25_CIN1.2@4950,2650
NetC25_CIN1_2: C25_CIN1.2 J2_CIN1.3 R26_CIN1.2 R49_CIN1.2 U6_CIN1.3 | length 2489.1
  TopLayer w10: U6_CIN1.3@4550,3600 4620,3530 4995,3530 C25_CIN1.2@5100,3425 ; J2_CIN1.3@4635.04,2425 4868.04,2192 5093,2192 5121,2220 5121,2325 5075,2371 R26_CIN1.2@5075,2650
  BottomLayer w10: R26_CIN1.2@5075,2650 5121,2696 5121,3154 R49_CIN1.2@5075,3200 5100,3225 C25_CIN1.2@5100,3425
NetC25_CIN2_1: C25_CIN2.1 J2_CIN2.2 R25_CIN2.2 R48_CIN2.2 U6_CIN2.2 | length 3131.9
  TopLayer w10: J2_CIN2.2@5843.5,2584.45 5844,2584.45 5844,2345 6017,2172 6538,2172 6566,2200 6566,2680 6539,2707 6390,2707 6375,2692 R25_CIN2.2@6375,2650 ; U6_CIN2.2@5875,3600 6050,3425 C25_CIN2.1@6325,3425
  BottomLayer w10: C25_CIN2.1@6325,3425 6325,3250 R48_CIN2.2@6375,3200 6421,3154 6421,2696 R25_CIN2.2@6375,2650
NetC25_CIN2_2: C25_CIN2.2 J2_CIN2.3 R26_CIN2.2 R49_CIN2.2 U6_CIN2.3 | length 2489.1
  TopLayer w10: U6_CIN2.3@5975,3600 6045,3530 6420,3530 C25_CIN2.2@6525,3425 ; J2_CIN2.3@6060.04,2425 6293.04,2192 6518,2192 6546,2220 6546,2325 6500,2371 R26_CIN2.2@6500,2650
  BottomLayer w10: R26_CIN2.2@6500,2650 6546,2696 6546,3154 R49_CIN2.2@6500,3200 6525,3225 C25_CIN2.2@6525,3425
NetC25_CIN3_1: C25_CIN3.1 J2_CIN3.2 R25_CIN3.2 R48_CIN3.2 U6_CIN3.2 | length 3131.9
  TopLayer w10: J2_CIN3.2@7268.5,2584.45 7269,2584.45 7269,2345 7442,2172 7963,2172 7991,2200 7991,2680 7964,2707 7815,2707 7800,2692 R25_CIN3.2@7800,2650 ; U6_CIN3.2@7300,3600 7475,3425 C25_CIN3.1@7750,3425
  BottomLayer w10: C25_CIN3.1@7750,3425 7750,3250 R48_CIN3.2@7800,3200 7846,3154 7846,2696 R25_CIN3.2@7800,2650
NetC25_CIN3_2: C25_CIN3.2 J2_CIN3.3 R26_CIN3.2 R49_CIN3.2 U6_CIN3.3 | length 2489.1
  TopLayer w10: U6_CIN3.3@7400,3600 7470,3530 7845,3530 C25_CIN3.2@7950,3425 ; J2_CIN3.3@7485.04,2425 7718.04,2192 7943,2192 7971,2220 7971,2325 7925,2371 R26_CIN3.2@7925,2650
  BottomLayer w10: R26_CIN3.2@7925,2650 7971,2696 7971,3154 R49_CIN3.2@7925,3200 7950,3225 C25_CIN3.2@7950,3425
NetC25_CIN4_1: C25_CIN4.1 J2_CIN4.2 R25_CIN4.2 R48_CIN4.2 U6_CIN4.2 | length 3131.9
  TopLayer w10: J2_CIN4.2@8693.5,2584.45 8694,2584.45 8694,2345 8867,2172 9388,2172 9416,2200 9416,2680 9389,2707 9240,2707 9225,2692 R25_CIN4.2@9225,2650 ; U6_CIN4.2@8725,3600 8900,3425 C25_CIN4.1@9175,3425
  BottomLayer w10: C25_CIN4.1@9175,3425 9175,3250 R48_CIN4.2@9225,3200 9271,3154 9271,2696 R25_CIN4.2@9225,2650
NetC25_CIN4_2: C25_CIN4.2 J2_CIN4.3 R26_CIN4.2 R49_CIN4.2 U6_CIN4.3 | length 2489.1
  TopLayer w10: U6_CIN4.3@8825,3600 8895,3530 9270,3530 C25_CIN4.2@9375,3425 ; J2_CIN4.3@8910.04,2425 9143.04,2192 9368,2192 9396,2220 9396,2325 9350,2371 R26_CIN4.2@9350,2650
  BottomLayer w10: R26_CIN4.2@9350,2650 9396,2696 9396,3154 R49_CIN4.2@9350,3200 9375,3225 C25_CIN4.2@9375,3425
NetC25_CIN5_1: C25_CIN5.1 J2_CIN5.2 R25_CIN5.2 R48_CIN5.2 U6_CIN5.2 | length 3131.9
  TopLayer w10: J2_CIN5.2@10118.5,2584.45 10119,2584.45 10119,2345 10292,2172 10813,2172 10841,2200 10841,2680 10814,2707 10665,2707 10650,2692 R25_CIN5.2@10650,2650 ; U6_CIN5.2@10150,3600 10325,3425 C25_CIN5.1@10600,3425
  BottomLayer w10: C25_CIN5.1@10600,3425 10600,3250 R48_CIN5.2@10650,3200 10696,3154 10696,2696 R25_CIN5.2@10650,2650
NetC25_CIN5_2: C25_CIN5.2 J2_CIN5.3 R26_CIN5.2 R49_CIN5.2 U6_CIN5.3 | length 2489.1
  TopLayer w10: U6_CIN5.3@10250,3600 10320,3530 10695,3530 C25_CIN5.2@10800,3425 ; J2_CIN5.3@10335.04,2425 10568.04,2192 10793,2192 10821,2220 10821,2325 10775,2371 R26_CIN5.2@10775,2650
  BottomLayer w10: R26_CIN5.2@10775,2650 10821,2696 10821,3154 R49_CIN5.2@10775,3200 10800,3225 C25_CIN5.2@10800,3425
NetC25_CIN6_1: C25_CIN6.1 J2_CIN6.2 R25_CIN6.2 R48_CIN6.2 U6_CIN6.2 | length 3131.9
  TopLayer w10: J2_CIN6.2@11543.5,2584.45 11544,2584.45 11544,2345 11717,2172 12238,2172 12266,2200 12266,2680 12239,2707 12090,2707 12075,2692 R25_CIN6.2@12075,2650 ; U6_CIN6.2@11575,3600 11750,3425 C25_CIN6.1@12025,3425
  BottomLayer w10: C25_CIN6.1@12025,3425 12025,3250 R48_CIN6.2@12075,3200 12121,3154 12121,2696 R25_CIN6.2@12075,2650
NetC25_CIN6_2: C25_CIN6.2 J2_CIN6.3 R26_CIN6.2 R49_CIN6.2 U6_CIN6.3 | length 2489.1
  TopLayer w10: U6_CIN6.3@11675,3600 11745,3530 12120,3530 C25_CIN6.2@12225,3425 ; J2_CIN6.3@11760.04,2425 11993.04,2192 12218,2192 12246,2220 12246,2325 12200,2371 R26_CIN6.2@12200,2650
  BottomLayer w10: R26_CIN6.2@12200,2650 12246,2696 12246,3154 R49_CIN6.2@12200,3200 12225,3225 C25_CIN6.2@12225,3425
NetC25_CIN7_1: C25_CIN7.1 J2_CIN7.2 R25_CIN7.2 R48_CIN7.2 U6_CIN7.2 | length 3131.9
  TopLayer w10: J2_CIN7.2@12968.5,2584.45 12969,2584.45 12969,2345 13142,2172 13663,2172 13691,2200 13691,2680 13664,2707 13515,2707 13500,2692 R25_CIN7.2@13500,2650 ; U6_CIN7.2@13000,3600 13175,3425 C25_CIN7.1@13450,3425
  BottomLayer w10: C25_CIN7.1@13450,3425 13450,3250 R48_CIN7.2@13500,3200 13546,3154 13546,2696 R25_CIN7.2@13500,2650
NetC25_CIN7_2: C25_CIN7.2 J2_CIN7.3 R26_CIN7.2 R49_CIN7.2 U6_CIN7.3 | length 2489.1
  TopLayer w10: U6_CIN7.3@13100,3600 13170,3530 13545,3530 C25_CIN7.2@13650,3425 ; J2_CIN7.3@13185.04,2425 13418.04,2192 13643,2192 13671,2220 13671,2325 13625,2371 R26_CIN7.2@13625,2650
  BottomLayer w10: R26_CIN7.2@13625,2650 13671,2696 13671,3154 R49_CIN7.2@13625,3200 13650,3225 C25_CIN7.2@13650,3425
NetC25_CIN8_1: C25_CIN8.1 J2_CIN8.2 R25_CIN8.2 R48_CIN8.2 U6_CIN8.2 | length 3131.9
  TopLayer w10: J2_CIN8.2@14393.5,2584.45 14394,2584.45 14394,2345 14567,2172 15088,2172 15116,2200 15116,2680 15089,2707 14940,2707 14925,2692 R25_CIN8.2@14925,2650 ; U6_CIN8.2@14425,3600 14600,3425 C25_CIN8.1@14875,3425
  BottomLayer w10: C25_CIN8.1@14875,3425 14875,3250 R48_CIN8.2@14925,3200 14971,3154 14971,2696 R25_CIN8.2@14925,2650
NetC25_CIN8_2: C25_CIN8.2 J2_CIN8.3 R26_CIN8.2 R49_CIN8.2 U6_CIN8.3 | length 2489.1
  TopLayer w10: U6_CIN8.3@14525,3600 14595,3530 14970,3530 C25_CIN8.2@15075,3425 ; J2_CIN8.3@14610.04,2425 14843.04,2192 15068,2192 15096,2220 15096,2325 15050,2371 R26_CIN8.2@15050,2650
  BottomLayer w10: R26_CIN8.2@15050,2650 15096,2696 15096,3154 R49_CIN8.2@15050,3200 15075,3225 C25_CIN8.2@15075,3425
NetC26_CIN1_1: C26_CIN1.1 R27_CIN1.2 R40_CIN1.1 U2_CIN1.2 | length 813.9
  TopLayer w10: C26_CIN1.1@4100,6300 4175,6300 R40_CIN1.1@4275,6200
  BottomLayer w10: R40_CIN1.1@4275,6200 4275,6475 R27_CIN1.2@4400,6600 4450,6650 U2_CIN1.2@4450,6725
NetC26_CIN2_1: C26_CIN2.1 R27_CIN2.2 R40_CIN2.1 U2_CIN2.2 | length 813.9
  TopLayer w10: C26_CIN2.1@5525,6300 5600,6300 R40_CIN2.1@5700,6200
  BottomLayer w10: R40_CIN2.1@5700,6200 5700,6475 R27_CIN2.2@5825,6600 5875,6650 U2_CIN2.2@5875,6725
NetC26_CIN3_1: C26_CIN3.1 R27_CIN3.2 R40_CIN3.1 U2_CIN3.2 | length 813.9
  TopLayer w10: C26_CIN3.1@6950,6300 7025,6300 R40_CIN3.1@7125,6200
  BottomLayer w10: R40_CIN3.1@7125,6200 7125,6475 R27_CIN3.2@7250,6600 7300,6650 U2_CIN3.2@7300,6725
NetC26_CIN4_1: C26_CIN4.1 R27_CIN4.2 R40_CIN4.1 U2_CIN4.2 | length 813.9
  TopLayer w10: C26_CIN4.1@8375,6300 8450,6300 R40_CIN4.1@8550,6200
  BottomLayer w10: R40_CIN4.1@8550,6200 8550,6475 R27_CIN4.2@8675,6600 8725,6650 U2_CIN4.2@8725,6725
NetC26_CIN5_1: C26_CIN5.1 R27_CIN5.2 R40_CIN5.1 U2_CIN5.2 | length 813.9
  TopLayer w10: C26_CIN5.1@9800,6300 9875,6300 R40_CIN5.1@9975,6200
  BottomLayer w10: R40_CIN5.1@9975,6200 9975,6475 R27_CIN5.2@10100,6600 10150,6650 U2_CIN5.2@10150,6725
NetC26_CIN6_1: C26_CIN6.1 R27_CIN6.2 R40_CIN6.1 U2_CIN6.2 | length 813.9
  TopLayer w10: C26_CIN6.1@11225,6300 11300,6300 R40_CIN6.1@11400,6200
  BottomLayer w10: R40_CIN6.1@11400,6200 11400,6475 R27_CIN6.2@11525,6600 11575,6650 U2_CIN6.2@11575,6725
NetC26_CIN7_1: C26_CIN7.1 R27_CIN7.2 R40_CIN7.1 U2_CIN7.2 | length 813.9
  TopLayer w10: C26_CIN7.1@12650,6300 12725,6300 R40_CIN7.1@12825,6200
  BottomLayer w10: R40_CIN7.1@12825,6200 12825,6475 R27_CIN7.2@12950,6600 13000,6650 U2_CIN7.2@13000,6725
NetC26_CIN8_1: C26_CIN8.1 R27_CIN8.2 R40_CIN8.1 U2_CIN8.2 | length 813.9
  TopLayer w10: C26_CIN8.1@14075,6300 14150,6300 R40_CIN8.1@14250,6200
  BottomLayer w10: R40_CIN8.1@14250,6200 14250,6475 R27_CIN8.2@14375,6600 14425,6650 U2_CIN8.2@14425,6725
NetC27_CIN1_1: C27_CIN1.1 R28_CIN1.2 R41_CIN1.1 U2_CIN1.6 | length 874.3
  TopLayer w10: R41_CIN1.1@4300,7575 4350,7575 C27_CIN1.1@4450,7475 4550,7575 R28_CIN1.2@4600,7575
  BottomLayer w10: C27_CIN1.1@4450,7475 4550,7375 U2_CIN1.6@4550,7025
NetC27_CIN1_2: C27_CIN1.2 R41_CIN1.2 R50_CIN1.1 U2_CIN1.7 | length 566.4
  TopLayer w10: R50_CIN1.1@4175,7175 R41_CIN1.2@4300,7175 4400,7275 C27_CIN1.2@4450,7275
  BottomLayer w10: U2_CIN1.7@4450,7025 C27_CIN1.2@4450,7275
NetC27_CIN2_1: C27_CIN2.1 R28_CIN2.2 R41_CIN2.1 U2_CIN2.6 | length 874.3
  TopLayer w10: R41_CIN2.1@5725,7575 5775,7575 C27_CIN2.1@5875,7475 5975,7575 R28_CIN2.2@6025,7575
  BottomLayer w10: C27_CIN2.1@5875,7475 5975,7375 U2_CIN2.6@5975,7025
NetC27_CIN2_2: C27_CIN2.2 R41_CIN2.2 R50_CIN2.1 U2_CIN2.7 | length 566.4
  TopLayer w10: R50_CIN2.1@5600,7175 R41_CIN2.2@5725,7175 5825,7275 C27_CIN2.2@5875,7275
  BottomLayer w10: U2_CIN2.7@5875,7025 C27_CIN2.2@5875,7275
NetC27_CIN3_1: C27_CIN3.1 R28_CIN3.2 R41_CIN3.1 U2_CIN3.6 | length 874.3
  TopLayer w10: R41_CIN3.1@7150,7575 7200,7575 C27_CIN3.1@7300,7475 7400,7575 R28_CIN3.2@7450,7575
  BottomLayer w10: C27_CIN3.1@7300,7475 7400,7375 U2_CIN3.6@7400,7025
NetC27_CIN3_2: C27_CIN3.2 R41_CIN3.2 R50_CIN3.1 U2_CIN3.7 | length 566.4
  TopLayer w10: R50_CIN3.1@7025,7175 R41_CIN3.2@7150,7175 7250,7275 C27_CIN3.2@7300,7275
  BottomLayer w10: U2_CIN3.7@7300,7025 C27_CIN3.2@7300,7275
NetC27_CIN4_1: C27_CIN4.1 R28_CIN4.2 R41_CIN4.1 U2_CIN4.6 | length 874.3
  TopLayer w10: R41_CIN4.1@8575,7575 8625,7575 C27_CIN4.1@8725,7475 8825,7575 R28_CIN4.2@8875,7575
  BottomLayer w10: C27_CIN4.1@8725,7475 8825,7375 U2_CIN4.6@8825,7025
NetC27_CIN4_2: C27_CIN4.2 R41_CIN4.2 R50_CIN4.1 U2_CIN4.7 | length 566.4
  TopLayer w10: R50_CIN4.1@8450,7175 R41_CIN4.2@8575,7175 8675,7275 C27_CIN4.2@8725,7275
  BottomLayer w10: U2_CIN4.7@8725,7025 C27_CIN4.2@8725,7275
NetC27_CIN5_1: C27_CIN5.1 R28_CIN5.2 R41_CIN5.1 U2_CIN5.6 | length 874.3
  TopLayer w10: R41_CIN5.1@10000,7575 10050,7575 C27_CIN5.1@10150,7475 10250,7575 R28_CIN5.2@10300,7575
  BottomLayer w10: C27_CIN5.1@10150,7475 10250,7375 U2_CIN5.6@10250,7025
NetC27_CIN5_2: C27_CIN5.2 R41_CIN5.2 R50_CIN5.1 U2_CIN5.7 | length 566.4
  TopLayer w10: R50_CIN5.1@9875,7175 R41_CIN5.2@10000,7175 10100,7275 C27_CIN5.2@10150,7275
  BottomLayer w10: U2_CIN5.7@10150,7025 C27_CIN5.2@10150,7275
NetC27_CIN6_1: C27_CIN6.1 R28_CIN6.2 R41_CIN6.1 U2_CIN6.6 | length 874.3
  TopLayer w10: R41_CIN6.1@11425,7575 11475,7575 C27_CIN6.1@11575,7475 11675,7575 R28_CIN6.2@11725,7575
  BottomLayer w10: C27_CIN6.1@11575,7475 11675,7375 U2_CIN6.6@11675,7025
NetC27_CIN6_2: C27_CIN6.2 R41_CIN6.2 R50_CIN6.1 U2_CIN6.7 | length 566.4
  TopLayer w10: R50_CIN6.1@11300,7175 R41_CIN6.2@11425,7175 11525,7275 C27_CIN6.2@11575,7275
  BottomLayer w10: U2_CIN6.7@11575,7025 C27_CIN6.2@11575,7275
NetC27_CIN7_1: C27_CIN7.1 R28_CIN7.2 R41_CIN7.1 U2_CIN7.6 | length 874.3
  TopLayer w10: R41_CIN7.1@12850,7575 12900,7575 C27_CIN7.1@13000,7475 13100,7575 R28_CIN7.2@13150,7575
  BottomLayer w10: C27_CIN7.1@13000,7475 13100,7375 U2_CIN7.6@13100,7025
NetC27_CIN7_2: C27_CIN7.2 R41_CIN7.2 R50_CIN7.1 U2_CIN7.7 | length 566.4
  TopLayer w10: R50_CIN7.1@12725,7175 R41_CIN7.2@12850,7175 12950,7275 C27_CIN7.2@13000,7275
  BottomLayer w10: U2_CIN7.7@13000,7025 C27_CIN7.2@13000,7275
NetC27_CIN8_1: C27_CIN8.1 R28_CIN8.2 R41_CIN8.1 U2_CIN8.6 | length 874.3
  TopLayer w10: R41_CIN8.1@14275,7575 14325,7575 C27_CIN8.1@14425,7475 14525,7575 R28_CIN8.2@14575,7575
  BottomLayer w10: C27_CIN8.1@14425,7475 14525,7375 U2_CIN8.6@14525,7025
NetC27_CIN8_2: C27_CIN8.2 R41_CIN8.2 R50_CIN8.1 U2_CIN8.7 | length 566.4
  TopLayer w10: R50_CIN8.1@14150,7175 R41_CIN8.2@14275,7175 14375,7275 C27_CIN8.2@14425,7275
  BottomLayer w10: U2_CIN8.7@14425,7025 C27_CIN8.2@14425,7275
NetC28_COUT1_1: C28_COUT1.1 R38_COUT1.1 R42_COUT1.2 U5_COUT1.6 | length 813.9
  TopLayer w10: R42_COUT1.2@17425,5450 17525,5350 C28_COUT1.1@17575,5350 17675,5450 R38_COUT1.1@17725,5450
  BottomLayer w10: U5_COUT1.6@17500,4950 17500,5275 C28_COUT1.1@17575,5350
NetC28_COUT1_2: C28_COUT1.2 C39_COUT1.1 R42_COUT1.1 R55_COUT1.2 R63_COUT1.2 R64_COUT1.1 | length 3456.1
  TopLayer w10: R63_COUT1.2@17300,5050 R42_COUT1.1@17425,5050 17525,5150 C28_COUT1.2@17575,5150 17746,5321 18050,5321 18071,5300 18071,5171 R64_COUT1.1@18025,5125
  BottomLayer w10: R55_COUT1.2@17900,4725 17900,4771 ; R64_COUT1.1@18025,5125 17900,5000 17900,4771 ; C39_COUT1.1@18075,3075 18135,3135 18135,4707 18071,4771 17900,4771
NetC28_COUT2_1: C28_COUT2.1 R38_COUT2.1 R42_COUT2.2 U5_COUT2.6 | length 813.9
  TopLayer w10: R42_COUT2.2@15925,5450 16025,5350 C28_COUT2.1@16075,5350 16175,5450 R38_COUT2.1@16225,5450
  BottomLayer w10: U5_COUT2.6@16000,4950 16000,5275 C28_COUT2.1@16075,5350
NetC28_COUT2_2: C28_COUT2.2 C39_COUT2.1 R42_COUT2.1 R55_COUT2.2 R63_COUT2.2 R64_COUT2.1 | length 3456.1
  TopLayer w10: R63_COUT2.2@15800,5050 R42_COUT2.1@15925,5050 16025,5150 C28_COUT2.2@16075,5150 16246,5321 16550,5321 16571,5300 16571,5171 R64_COUT2.1@16525,5125
  BottomLayer w10: R55_COUT2.2@16400,4725 16400,4771 ; R64_COUT2.1@16525,5125 16400,5000 16400,4771 ; C39_COUT2.1@16575,3075 16635,3135 16635,4707 16571,4771 16400,4771
NetC29_CIN1_1: C29_CIN1.1 R4_CIN1.2 VR10_CIN1.3 | length 1032.8
  TopLayer w10: VR10_CIN1.3@5050,8350 5100,8300 R4_CIN1.2@5100,7700
  BottomLayer w10: C29_CIN1.1@4950,7400 5100,7550 R4_CIN1.2@5100,7700
NetC29_CIN1_2: C29_CIN1.2 R6_CIN1.1 VR10_CIN1.1 | length 2250.2
  BottomLayer w10: C29_CIN1.2@4950,7600 5050,7700 VR10_CIN1.1@5050,7950 5146,8046 5146,9704 R6_CIN1.1@5100,9750
NetC29_CIN2_1: C29_CIN2.1 R4_CIN2.2 VR10_CIN2.3 | length 1032.8
  TopLayer w10: VR10_CIN2.3@6475,8350 6525,8300 R4_CIN2.2@6525,7700
  BottomLayer w10: C29_CIN2.1@6375,7400 6525,7550 R4_CIN2.2@6525,7700
NetC29_CIN2_2: C29_CIN2.2 R6_CIN2.1 VR10_CIN2.1 | length 2250.2
  BottomLayer w10: C29_CIN2.2@6375,7600 6475,7700 VR10_CIN2.1@6475,7950 6571,8046 6571,9704 R6_CIN2.1@6525,9750
NetC29_CIN3_1: C29_CIN3.1 R4_CIN3.2 VR10_CIN3.3 | length 1032.8
  TopLayer w10: VR10_CIN3.3@7900,8350 7950,8300 R4_CIN3.2@7950,7700
  BottomLayer w10: C29_CIN3.1@7800,7400 7950,7550 R4_CIN3.2@7950,7700
NetC29_CIN3_2: C29_CIN3.2 R6_CIN3.1 VR10_CIN3.1 | length 2250.2
  BottomLayer w10: C29_CIN3.2@7800,7600 7900,7700 VR10_CIN3.1@7900,7950 7996,8046 7996,9704 R6_CIN3.1@7950,9750
NetC29_CIN4_1: C29_CIN4.1 R4_CIN4.2 VR10_CIN4.3 | length 1032.8
  TopLayer w10: VR10_CIN4.3@9325,8350 9375,8300 R4_CIN4.2@9375,7700
  BottomLayer w10: C29_CIN4.1@9225,7400 9375,7550 R4_CIN4.2@9375,7700
NetC29_CIN4_2: C29_CIN4.2 R6_CIN4.1 VR10_CIN4.1 | length 2250.2
  BottomLayer w10: C29_CIN4.2@9225,7600 9325,7700 VR10_CIN4.1@9325,7950 9421,8046 9421,9704 R6_CIN4.1@9375,9750
NetC29_CIN5_1: C29_CIN5.1 R4_CIN5.2 VR10_CIN5.3 | length 1032.8
  TopLayer w10: VR10_CIN5.3@10750,8350 10800,8300 R4_CIN5.2@10800,7700
  BottomLayer w10: C29_CIN5.1@10650,7400 10800,7550 R4_CIN5.2@10800,7700
NetC29_CIN5_2: C29_CIN5.2 R6_CIN5.1 VR10_CIN5.1 | length 2250.2
  BottomLayer w10: C29_CIN5.2@10650,7600 10750,7700 VR10_CIN5.1@10750,7950 10846,8046 10846,9704 R6_CIN5.1@10800,9750
NetC29_CIN6_1: C29_CIN6.1 R4_CIN6.2 VR10_CIN6.3 | length 1032.8
  TopLayer w10: VR10_CIN6.3@12175,8350 12225,8300 R4_CIN6.2@12225,7700
  BottomLayer w10: C29_CIN6.1@12075,7400 12225,7550 R4_CIN6.2@12225,7700
NetC29_CIN6_2: C29_CIN6.2 R6_CIN6.1 VR10_CIN6.1 | length 2250.2
  BottomLayer w10: C29_CIN6.2@12075,7600 12175,7700 VR10_CIN6.1@12175,7950 12271,8046 12271,9704 R6_CIN6.1@12225,9750
NetC29_CIN7_1: C29_CIN7.1 R4_CIN7.2 VR10_CIN7.3 | length 1032.8
  TopLayer w10: VR10_CIN7.3@13600,8350 13650,8300 R4_CIN7.2@13650,7700
  BottomLayer w10: C29_CIN7.1@13500,7400 13650,7550 R4_CIN7.2@13650,7700
NetC29_CIN7_2: C29_CIN7.2 R6_CIN7.1 VR10_CIN7.1 | length 2250.2
  BottomLayer w10: C29_CIN7.2@13500,7600 13600,7700 VR10_CIN7.1@13600,7950 13696,8046 13696,9704 R6_CIN7.1@13650,9750
NetC29_CIN8_1: C29_CIN8.1 R4_CIN8.2 VR10_CIN8.3 | length 1032.8
  TopLayer w10: VR10_CIN8.3@15025,8350 15075,8300 R4_CIN8.2@15075,7700
  BottomLayer w10: C29_CIN8.1@14925,7400 15075,7550 R4_CIN8.2@15075,7700
NetC29_CIN8_2: C29_CIN8.2 R6_CIN8.1 VR10_CIN8.1 | length 2250.2
  BottomLayer w10: C29_CIN8.2@14925,7600 15025,7700 VR10_CIN8.1@15025,7950 15121,8046 15121,9704 R6_CIN8.1@15075,9750
NetC30_CIN1_1: C30_CIN1.1 U6_CIN1.6 | length 520.7
  TopLayer w10: U6_CIN1.6@4550,3900 4600,3850 C30_CIN1.1@5050,3850
NetC30_CIN1_2: C30_CIN1.2 VR2_CIN1.1 VR3_CIN1.1 | length 1805.3
  BottomLayer w10: C30_CIN1.2@4909,3709 C30_CIN1.2@4908.58,3708.58 4908.58,4158.58 VR3_CIN1.1@5050,4300 5116,4366 5116,5126 5050,5192 VR2_CIN1.1@5050,5400
NetC30_CIN2_1: C30_CIN2.1 U6_CIN2.6 | length 520.7
  TopLayer w10: U6_CIN2.6@5975,3900 6025,3850 C30_CIN2.1@6475,3850
NetC30_CIN2_2: C30_CIN2.2 VR2_CIN2.1 VR3_CIN2.1 | length 1805.3
  BottomLayer w10: C30_CIN2.2@6334,3709 C30_CIN2.2@6333.58,3708.58 6333.58,4158.58 VR3_CIN2.1@6475,4300 6541,4366 6541,5126 6475,5192 VR2_CIN2.1@6475,5400
NetC30_CIN3_1: C30_CIN3.1 U6_CIN3.6 | length 520.7
  TopLayer w10: U6_CIN3.6@7400,3900 7450,3850 C30_CIN3.1@7900,3850
NetC30_CIN3_2: C30_CIN3.2 VR2_CIN3.1 VR3_CIN3.1 | length 1805.3
  BottomLayer w10: C30_CIN3.2@7759,3709 C30_CIN3.2@7758.58,3708.58 7758.58,4158.58 VR3_CIN3.1@7900,4300 7966,4366 7966,5126 7900,5192 VR2_CIN3.1@7900,5400
NetC30_CIN4_1: C30_CIN4.1 U6_CIN4.6 | length 520.7
  TopLayer w10: U6_CIN4.6@8825,3900 8875,3850 C30_CIN4.1@9325,3850
NetC30_CIN4_2: C30_CIN4.2 VR2_CIN4.1 VR3_CIN4.1 | length 1805.3
  BottomLayer w10: C30_CIN4.2@9184,3709 C30_CIN4.2@9183.58,3708.58 9183.58,4158.58 VR3_CIN4.1@9325,4300 9391,4366 9391,5126 9325,5192 VR2_CIN4.1@9325,5400
NetC30_CIN5_1: C30_CIN5.1 U6_CIN5.6 | length 520.7
  TopLayer w10: U6_CIN5.6@10250,3900 10300,3850 C30_CIN5.1@10750,3850
NetC30_CIN5_2: C30_CIN5.2 VR2_CIN5.1 VR3_CIN5.1 | length 1805.3
  BottomLayer w10: C30_CIN5.2@10609,3709 C30_CIN5.2@10608.58,3708.58 10608.58,4158.58 VR3_CIN5.1@10750,4300 10816,4366 10816,5126 10750,5192 VR2_CIN5.1@10750,5400
NetC30_CIN6_1: C30_CIN6.1 U6_CIN6.6 | length 520.7
  TopLayer w10: U6_CIN6.6@11675,3900 11725,3850 C30_CIN6.1@12175,3850
NetC30_CIN6_2: C30_CIN6.2 VR2_CIN6.1 VR3_CIN6.1 | length 1805.3
  BottomLayer w10: C30_CIN6.2@12034,3709 C30_CIN6.2@12033.58,3708.58 12033.58,4158.58 VR3_CIN6.1@12175,4300 12241,4366 12241,5126 12175,5192 VR2_CIN6.1@12175,5400
NetC30_CIN7_1: C30_CIN7.1 U6_CIN7.6 | length 520.7
  TopLayer w10: U6_CIN7.6@13100,3900 13150,3850 C30_CIN7.1@13600,3850
NetC30_CIN7_2: C30_CIN7.2 VR2_CIN7.1 VR3_CIN7.1 | length 1805.3
  BottomLayer w10: C30_CIN7.2@13459,3709 C30_CIN7.2@13458.58,3708.58 13458.58,4158.58 VR3_CIN7.1@13600,4300 13666,4366 13666,5126 13600,5192 VR2_CIN7.1@13600,5400
NetC30_CIN8_1: C30_CIN8.1 U6_CIN8.6 | length 520.7
  TopLayer w10: U6_CIN8.6@14525,3900 14575,3850 C30_CIN8.1@15025,3850
NetC30_CIN8_2: C30_CIN8.2 VR2_CIN8.1 VR3_CIN8.1 | length 1805.3
  BottomLayer w10: C30_CIN8.2@14884,3709 C30_CIN8.2@14883.58,3708.58 14883.58,4158.58 VR3_CIN8.1@15025,4300 15091,4366 15091,5126 15025,5192 VR2_CIN8.1@15025,5400
NetC31_CIN1_1: C31_CIN1.1 R46_CIN1.1 | length 362.1
  BottomLayer w10: C31_CIN1.1@4950,8600 5100,8750 R46_CIN1.1@5100,8900
NetC31_CIN1_2: C31_CIN1.2 VR11_CIN1.1 | length 291.4
  TopLayer w10: C31_CIN1.2@4950,8800 5050,8900 VR11_CIN1.1@5050,9050
NetC31_CIN2_1: C31_CIN2.1 R46_CIN2.1 | length 362.1
  BottomLayer w10: C31_CIN2.1@6375,8600 6525,8750 R46_CIN2.1@6525,8900
NetC31_CIN2_2: C31_CIN2.2 VR11_CIN2.1 | length 291.4
  TopLayer w10: C31_CIN2.2@6375,8800 6475,8900 VR11_CIN2.1@6475,9050
NetC31_CIN3_1: C31_CIN3.1 R46_CIN3.1 | length 362.1
  BottomLayer w10: C31_CIN3.1@7800,8600 7950,8750 R46_CIN3.1@7950,8900
NetC31_CIN3_2: C31_CIN3.2 VR11_CIN3.1 | length 291.4
  TopLayer w10: C31_CIN3.2@7800,8800 7900,8900 VR11_CIN3.1@7900,9050
NetC31_CIN4_1: C31_CIN4.1 R46_CIN4.1 | length 362.1
  BottomLayer w10: C31_CIN4.1@9225,8600 9375,8750 R46_CIN4.1@9375,8900
NetC31_CIN4_2: C31_CIN4.2 VR11_CIN4.1 | length 291.4
  TopLayer w10: C31_CIN4.2@9225,8800 9325,8900 VR11_CIN4.1@9325,9050
NetC31_CIN5_1: C31_CIN5.1 R46_CIN5.1 | length 362.1
  BottomLayer w10: C31_CIN5.1@10650,8600 10800,8750 R46_CIN5.1@10800,8900
NetC31_CIN5_2: C31_CIN5.2 VR11_CIN5.1 | length 291.4
  TopLayer w10: C31_CIN5.2@10650,8800 10750,8900 VR11_CIN5.1@10750,9050
NetC31_CIN6_1: C31_CIN6.1 R46_CIN6.1 | length 362.1
  BottomLayer w10: C31_CIN6.1@12075,8600 12225,8750 R46_CIN6.1@12225,8900
NetC31_CIN6_2: C31_CIN6.2 VR11_CIN6.1 | length 291.4
  TopLayer w10: C31_CIN6.2@12075,8800 12175,8900 VR11_CIN6.1@12175,9050
NetC31_CIN7_1: C31_CIN7.1 R46_CIN7.1 | length 362.1
  BottomLayer w10: C31_CIN7.1@13500,8600 13650,8750 R46_CIN7.1@13650,8900
NetC31_CIN7_2: C31_CIN7.2 VR11_CIN7.1 | length 291.4
  TopLayer w10: C31_CIN7.2@13500,8800 13600,8900 VR11_CIN7.1@13600,9050
NetC31_CIN8_1: C31_CIN8.1 R46_CIN8.1 | length 362.1
  BottomLayer w10: C31_CIN8.1@14925,8600 15075,8750 R46_CIN8.1@15075,8900
NetC31_CIN8_2: C31_CIN8.2 VR11_CIN8.1 | length 291.4
  TopLayer w10: C31_CIN8.2@14925,8800 15025,8900 VR11_CIN8.1@15025,9050
NetC32_CIN1_1: C32_CIN1.1 VR11_CIN1.3 | length 672.5
  BottomLayer w10: C32_CIN1.1@4875,10050 5050,9875 VR11_CIN1.3@5050,9450
NetC32_CIN1_2: C32_CIN1.2 R47_CIN1.1 | length 382.8
  BottomLayer w10: R47_CIN1.1@4375,9850 4439,9914 4539,9914 C32_CIN1.2@4675,10050
NetC32_CIN2_1: C32_CIN2.1 VR11_CIN2.3 | length 672.5
  BottomLayer w10: C32_CIN2.1@6300,10050 6475,9875 VR11_CIN2.3@6475,9450
NetC32_CIN2_2: C32_CIN2.2 R47_CIN2.1 | length 382.8
  BottomLayer w10: R47_CIN2.1@5800,9850 5864,9914 5964,9914 C32_CIN2.2@6100,10050
NetC32_CIN3_1: C32_CIN3.1 VR11_CIN3.3 | length 672.5
  BottomLayer w10: C32_CIN3.1@7725,10050 7900,9875 VR11_CIN3.3@7900,9450
NetC32_CIN3_2: C32_CIN3.2 R47_CIN3.1 | length 382.8
  BottomLayer w10: R47_CIN3.1@7225,9850 7289,9914 7389,9914 C32_CIN3.2@7525,10050
NetC32_CIN4_1: C32_CIN4.1 VR11_CIN4.3 | length 672.5
  BottomLayer w10: C32_CIN4.1@9150,10050 9325,9875 VR11_CIN4.3@9325,9450
NetC32_CIN4_2: C32_CIN4.2 R47_CIN4.1 | length 382.8
  BottomLayer w10: R47_CIN4.1@8650,9850 8714,9914 8814,9914 C32_CIN4.2@8950,10050
NetC32_CIN5_1: C32_CIN5.1 VR11_CIN5.3 | length 672.5
  BottomLayer w10: C32_CIN5.1@10575,10050 10750,9875 VR11_CIN5.3@10750,9450
NetC32_CIN5_2: C32_CIN5.2 R47_CIN5.1 | length 382.8
  BottomLayer w10: R47_CIN5.1@10075,9850 10139,9914 10239,9914 C32_CIN5.2@10375,10050
NetC32_CIN6_1: C32_CIN6.1 VR11_CIN6.3 | length 672.5
  BottomLayer w10: C32_CIN6.1@12000,10050 12175,9875 VR11_CIN6.3@12175,9450
NetC32_CIN6_2: C32_CIN6.2 R47_CIN6.1 | length 382.8
  BottomLayer w10: R47_CIN6.1@11500,9850 11564,9914 11664,9914 C32_CIN6.2@11800,10050
NetC32_CIN7_1: C32_CIN7.1 VR11_CIN7.3 | length 672.5
  BottomLayer w10: C32_CIN7.1@13425,10050 13600,9875 VR11_CIN7.3@13600,9450
NetC32_CIN7_2: C32_CIN7.2 R47_CIN7.1 | length 382.8
  BottomLayer w10: R47_CIN7.1@12925,9850 12989,9914 13089,9914 C32_CIN7.2@13225,10050
NetC32_CIN8_1: C32_CIN8.1 VR11_CIN8.3 | length 672.5
  BottomLayer w10: C32_CIN8.1@14850,10050 15025,9875 VR11_CIN8.3@15025,9450
NetC32_CIN8_2: C32_CIN8.2 R47_CIN8.1 | length 382.8
  BottomLayer w10: R47_CIN8.1@14350,9850 14414,9914 14514,9914 C32_CIN8.2@14650,10050
NetC33_CIN1_1: C33_CIN1.1 R5_CIN1.1 U7_CIN1.2 VR11_CIN1.2 | length 1449.2
  TopLayer w10: C33_CIN1.1@4275,10050 4375,9950 4425,9950 R5_CIN1.1@4525,9850 4525,9775 VR11_CIN1.2@5050,9250
  BottomLayer w10: C33_CIN1.1@4275,10050 4275,10120 4323,10168 4368,10168 U7_CIN1.2@4450,10250
NetC33_CIN2_1: C33_CIN2.1 R5_CIN2.1 U7_CIN2.2 VR11_CIN2.2 | length 1449.2
  TopLayer w10: C33_CIN2.1@5700,10050 5800,9950 5850,9950 R5_CIN2.1@5950,9850 5950,9775 VR11_CIN2.2@6475,9250
  BottomLayer w10: C33_CIN2.1@5700,10050 5700,10120 5748,10168 5793,10168 U7_CIN2.2@5875,10250
NetC33_CIN3_1: C33_CIN3.1 R5_CIN3.1 U7_CIN3.2 VR11_CIN3.2 | length 1449.2
  TopLayer w10: C33_CIN3.1@7125,10050 7225,9950 7275,9950 R5_CIN3.1@7375,9850 7375,9775 VR11_CIN3.2@7900,9250
  BottomLayer w10: C33_CIN3.1@7125,10050 7125,10120 7173,10168 7218,10168 U7_CIN3.2@7300,10250
NetC33_CIN4_1: C33_CIN4.1 R5_CIN4.1 U7_CIN4.2 VR11_CIN4.2 | length 1449.2
  TopLayer w10: C33_CIN4.1@8550,10050 8650,9950 8700,9950 R5_CIN4.1@8800,9850 8800,9775 VR11_CIN4.2@9325,9250
  BottomLayer w10: C33_CIN4.1@8550,10050 8550,10120 8598,10168 8643,10168 U7_CIN4.2@8725,10250
NetC33_CIN5_1: C33_CIN5.1 R5_CIN5.1 U7_CIN5.2 VR11_CIN5.2 | length 1449.2
  TopLayer w10: C33_CIN5.1@9975,10050 10075,9950 10125,9950 R5_CIN5.1@10225,9850 10225,9775 VR11_CIN5.2@10750,9250
  BottomLayer w10: C33_CIN5.1@9975,10050 9975,10120 10023,10168 10068,10168 U7_CIN5.2@10150,10250
NetC33_CIN6_1: C33_CIN6.1 R5_CIN6.1 U7_CIN6.2 VR11_CIN6.2 | length 1449.2
  TopLayer w10: C33_CIN6.1@11400,10050 11500,9950 11550,9950 R5_CIN6.1@11650,9850 11650,9775 VR11_CIN6.2@12175,9250
  BottomLayer w10: C33_CIN6.1@11400,10050 11400,10120 11448,10168 11493,10168 U7_CIN6.2@11575,10250
NetC33_CIN7_1: C33_CIN7.1 R5_CIN7.1 U7_CIN7.2 VR11_CIN7.2 | length 1449.2
  TopLayer w10: C33_CIN7.1@12825,10050 12925,9950 12975,9950 R5_CIN7.1@13075,9850 13075,9775 VR11_CIN7.2@13600,9250
  BottomLayer w10: C33_CIN7.1@12825,10050 12825,10120 12873,10168 12918,10168 U7_CIN7.2@13000,10250
NetC33_CIN8_1: C33_CIN8.1 R5_CIN8.1 U7_CIN8.2 VR11_CIN8.2 | length 1449.2
  TopLayer w10: C33_CIN8.1@14250,10050 14350,9950 14400,9950 R5_CIN8.1@14500,9850 14500,9775 VR11_CIN8.2@15025,9250
  BottomLayer w10: C33_CIN8.1@14250,10050 14250,10120 14298,10168 14343,10168 U7_CIN8.2@14425,10250
NetC34_1: C34.1 R29.2 R57.1 U8.2 | length 1070.2
  TopLayer w10: C34.1@2821.93,3772.02 2901.93,3852.02 R29.2@3121.93,3852.02 3122,3852.02 R29.2@3122,3853 ; R57.1@3241.93,4252.02 3401.93,4092.02 U8.2@3461.93,4092.02
  BottomLayer w10: R29.2@3121.93,3852.02 3241.93,3972.02 R57.1@3241.93,4252.02 R57.1@3242,4252.02
NetC35_1: C35.1 R33.2 R58.1 U3.2 | length 2064.5
  TopLayer w10: C35.1@2821.93,9219 2961,9219 3041,9299 R33.2@3121.93,9299 ; R58.1@3241.93,9699 3401.93,9539 U3.2@3461.93,9539
  BottomLayer w10: R33.2@3121.93,9299 3032,9299 2990,9341 2714,9341 2655,9400 2655,9696 2721,9762 3134,9762 3197,9699 R58.1@3241.93,9699
NetC36_COUT1_1: C36_COUT1.1 R37_COUT1.2 R60_COUT1.1 U4_COUT1.2 | length 993.2
  TopLayer w10: C36_COUT1.1@16925,6500 17382,6500 17507,6625 R60_COUT1.1@17550,6625 ; U4_COUT1.2@17400,6850 17500,6750 R37_COUT1.2@17550,6750
  BottomLayer w10: R60_COUT1.1@17550,6625 R37_COUT1.2@17550,6750
NetC36_COUT2_1: C36_COUT2.1 R37_COUT2.2 R60_COUT2.1 U4_COUT2.2 | length 993.2
  TopLayer w10: C36_COUT2.1@15425,6500 15882,6500 16007,6625 R60_COUT2.1@16050,6625 ; U4_COUT2.2@15900,6850 16000,6750 R37_COUT2.2@16050,6750
  BottomLayer w10: R60_COUT2.1@16050,6625 R37_COUT2.2@16050,6750
NetC37_1: C37.1 C41.2 R32.1 R61.2 | length 2381.6
  TopLayer w10: C37.1@2231.93,4462.28 2231.93,4467 3272,4467 ; R32.1@3271.93,4402.02 3272,4402.02 3272,4467 ; R61.2@3271.93,4522.02 3272,4522.02 3272,4467
  BottomLayer w10: C37.1@2231.93,4462.28 2231.93,4462 2232,4462 2232,4160 2185,4113 2185,3797 2407,3575 2621.93,3575 C41.2@2621.93,3572.02
NetC37_2: C37.2 J5.1 | length 1831.1
  BottomLayer w10: C37.2@2373.35,4320.86 2373.35,4482 2320.35,4535 2220,4535 2165,4480 2165,3386.95 J5.1@2393.93,3158.02 J5.1@2394,3158.02
NetC38_1: C38.1 C42.2 R36.1 R62.2 | length 2412.2
  TopLayer w10: C38.1@2231.93,9910 C38.1@2231.93,9909.26 2440.74,9909.26 2575,9775 3077.93,9775 R62.2@3271.93,9969
  BottomLayer w10: C38.1@2231.93,9909.26 2231.93,9909 2232,9909 2232,9763 2300,9695 ; 2300,9700 2300,9695 ; C42.2@2621.93,9019 2522,9019 2300,9241 2300,9695 ; R36.1@3271.93,9849 3272,9849 3272,9969 R62.2@3271.93,9969
NetC38_2: C38.2 J6.1 | length 1502.4
  BottomLayer w10: C38.2@2373.35,9767.84 2327,9721.49 2327,9279 2540,9066 2642,9066 2675,9033 2675,8886.07 J6.1@2393.93,8605
NetC39_COUT1_2: C39_COUT1.2 J3_COUT1.2 | length 646.7
  TopLayer w10: J3_COUT1.2@17431.5,2584.45 17584.45,2584.45 C39_COUT1.2@17933.58,2933.58
NetC39_COUT2_2: C39_COUT2.2 J3_COUT2.2 | length 646.7
  TopLayer w10: J3_COUT2.2@15931.5,2584.45 16084.45,2584.45 C39_COUT2.2@16433.58,2933.58
NetC40_COUT1_1: C40_COUT1.1 C51_COUT1.2 R56_COUT1.1 R65_COUT1.2 | length 1628
  BottomLayer w10: C40_COUT1.1@17625,3075 17585,3115 17585,3365 17685,3465 17685,3665 17715,3695 17715,3848 17635,3928 17635,4085 R65_COUT1.2@17775,4225 R56_COUT1.1@17775,4350 17675,4450 C51_COUT1.2@17675,4500
NetC40_COUT1_2: C40_COUT1.2 J3_COUT1.3 | length 619.8
  TopLayer w10: J3_COUT1.3@17214.96,2425 17214.96,2664.96 C40_COUT1.2@17483.58,2933.58
NetC40_COUT2_1: C40_COUT2.1 C51_COUT2.2 R56_COUT2.1 R65_COUT2.2 | length 1628
  BottomLayer w10: C40_COUT2.1@16125,3075 16085,3115 16085,3365 16185,3465 16185,3665 16215,3695 16215,3848 16135,3928 16135,4085 R65_COUT2.2@16275,4225 R56_COUT2.1@16275,4350 16175,4450 C51_COUT2.2@16175,4500
NetC40_COUT2_2: C40_COUT2.2 J3_COUT2.3 | length 619.8
  TopLayer w10: J3_COUT2.3@15714.96,2425 15714.96,2664.96 C40_COUT2.2@15983.58,2933.58
NetC41_1: C41.1 R31.1 R32.2 U8.5 | length 2630.1
  TopLayer w10: R32.2@2872,4402.02 2924.02,4350 3320,4350 3330,4360 3510,4360 3760,4610 3820,4610 3840,4590 3840,4480.09 R31.1@3771.93,4412.02
  BottomLayer w10: C41.1@2621.93,3772.02 2773,3923.09 2773,4303.09 R32.2@2871.93,4402.02 R32.2@2872,4402.02 ; U8.5@3761.93,3892.02 3690,3963.95 3690,4330.09 R31.1@3771.93,4412.02 3772,4412.02 R31.1@3772,4413
NetC42_1: C42.1 R35.1 R36.2 U3.6 | length 2614.2
  TopLayer w10: R36.2@2875,9850 2975,9850 3200,10075 3805,10075 3860,10020 3860,9947.07 R35.1@3771.93,9859
  BottomLayer w10: C42.1@2621.93,9219 2621.93,9745.93 2725,9849 R36.2@2871.93,9849 ; U3.6@3761.93,9439 3675,9525.93 3675,9762.07 R35.1@3771.93,9859
NetC43_1: C43.1 R52.2 R59.1 U9.2 | length 1537.1
  TopLayer w10: C43.1@3241,12520.04 3334.96,12614 3565.04,12614 U9.2@3615,12564.04
  BottomLayer w10: R59.1@3458.51,12104.02 3463,12104 3575,12216 ; U9.2@3615,12564.04 3615,12507 3575,12467 3575,12216 ; R52.2@3726.02,11704.02 3727,11704 3727,11951 3659,12019 3659,12132 3575,12216
NetC43_2: C43.2 R59.2 R66.1 R67.2 R68.1 | length 2575.4
  TopLayer w10: R67.2@2655.99,11704.02 2900.02,11460 3110,11460 3170,11520 3170,11580 3240,11650 3404.49,11650 R59.2@3458.51,11704.02 ; R66.1@2789.74,12104.02 2935.72,12250 3170.96,12250 C43.2@3241,12320.04
  BottomLayer w10: R67.2@2656,11680 R67.2@2655.99,11704.02 2656,11819 2522,11953 2522,12104.02 R68.1@2522.23,12104.02 2533,12104.02 2533,12000 2580,11953 2743,11953 2790,12000 2790,12104.02 R66.1@2789.74,12104.02