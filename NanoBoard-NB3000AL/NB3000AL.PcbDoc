# Altium PCB NB3000AL.PcbDoc (part 66 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
PBIO.D5: EXTHDR1.12 U8.AH7 | length 4338.8
  Top Layer w4: EXTHDR1.12@1968.19,2910.03 ccw(c1954.53,2923.68) 1973.84,2923.68 ccw(c1993.16,2923.68) EXTHDR1.12@1979.5,2910.03 ; EXTHDR1.12@1973.84,2859.25 1973.84,2941.69 1990.52,2958.37 2204.52,2958.37 v1(2279.52,3033.37) ; v1@2270.02,3033.37 cw(c2247.09,3033.37) 2263.31,3017.16 cw(c2279.52,3000.94) v1@2279.52,3023.87 ; v1@2274.02,3033.37 cw(c2260.75,3033.37) 2270.14,3023.99 cw(c2279.52,3014.6) v1@2279.52,3027.87 ; v1@5047.36,3383.37 ccw(c5024.42,3383.37) 5040.64,3399.59 ccw(c5056.86,3415.81) v1@5056.86,3392.87 ; v1@5051.36,3383.37 ccw(c5038.08,3383.37) 5047.47,3392.76 ccw(c5056.86,3402.15) v1@5056.86,3388.87 ; v1(5056.86,3383.37) 5040.19,3400.04 5040.19,3491.71 5065.19,3516.71 5073.52,3516.71 5090.19,3533.37 5090.19,3573.71 5110.23,3593.75 5110.23,3604.77 5094.72,3620.28 5094.72,3630.82 5094.72,3638.82 ; 5094.72,3638.82 U8.AH7@5094.72,3658.5 5094.72,3638.82 ; 5094.72,3640.78 ccw(c5077,3640.78) 5089.53,3653.31 cw(c5077,3640.78) 5094.72,3640.78 ; 5094.72,3640.78 cw(c5112.45,3640.78) 5099.92,3653.31 ccw(c5112.45,3640.78) 5094.72,3640.78
  MidLayer2 w4: 3463.52,2983.37 v1(3446.86,3000.04) 3472.19,2974.71 4435.54,2974.71 4442.75,2967.5 4495.35,2967.5 4567.85,3040 4675.84,3040 4778.69,3040 4966.5,3227.81 4966.5,3335 ; 4966.5,3344.87 4966.5,3335 ; v1@5050.14,3376.66 ccw(c5033.92,3360.44) 5033.92,3383.37 ccw(c5033.92,3406.31) v1@5050.14,3390.09 ; v1@5052.97,3379.49 ccw(c5043.58,3370.1) 5043.58,3383.37 ccw(c5043.58,3396.65) v1@5052.97,3387.26 ; v1(5056.86,3383.37) 5003.86,3383.37 4966.5,3346.02 4966.5,3335 ; 3456.25,2990.65 cw(c3465.64,3000.04) 3452.36,3000.04 ccw(c3465.64,3000.04) 3456.25,2990.65 ; 3456.25,2990.65 ccw(c3446.86,2981.26) 3446.86,2994.54 cw(c3446.86,2981.26) 3456.25,2990.65 ; 3463.08,2983.82 cw(c3479.29,3000.04) 3456.36,3000.04 ccw(c3479.29,3000.04) 3463.07,2983.82 ; 3463.08,2983.82 ccw(c3446.86,2967.61) 3446.86,2990.54 cw(c3446.86,2967.61) 3463.07,2983.82
  Bottom Layer w4: v1(2279.52,3033.37) 2825,3033.37 2885.71,3033.37 2927.37,2991.71 3370,2991.71 3378.33,3000.04 v1(3446.86,3000.04) ; v1@2283.41,3029.49 cw(c2292.8,3020.1) 2292.8,3033.37 cw(c2292.8,3046.65) v1@2283.41,3037.26 ; v1@2286.24,3026.66 cw(c2302.46,3010.44) 2302.46,3033.37 cw(c2302.46,3056.31) v1@2286.24,3040.09 ; v1@3440.14,2993.32 ccw(c3423.92,2977.11) 3423.92,3000.04 ccw(c3423.92,3022.98) v1@3440.14,3006.76 ; v1@3442.97,2996.15 ccw(c3433.58,2986.76) 3433.58,3000.04 ccw(c3433.58,3013.32) v1@3442.97,3003.93
PBIO.D6: EXTHDR1.14 U8.AG7 | length 5255.6
  Top Layer w4: EXTHDR1.14@1936.69,2910.03 ccw(c1928.24,2918.48) 1940.19,2918.48 ; EXTHDR1.14@1940.19,2883.37 1940.19,2925.04 v1(1948.52,2933.37) ; EXTHDR1.14@1940.19,2890.32 cw(c1991.58,2890.32) v1@1955.24,2926.66 ; EXTHDR1.14@1940.19,2899.98 cw(c1981.92,2899.98) v1@1952.41,2929.49 ; EXTHDR1.14@1940.19,2909.63 cw(c1972.27,2909.63) v1@1949.58,2932.31 ; 1940.19,2916.9 ccw(c1952.02,2916.9) EXTHDR1.14@1944.79,2907.53 ; 1940.19,2919.29 cw(c1962.61,2919.29) v1@1946.76,2935.14 ; v1@4925,3490.5 cw(c4925,3467.56) 4941.22,3483.78 cw(c4957.43,3500) v1@4934.5,3500 ; v1@4925,3494.5 cw(c4925,3481.22) 4934.39,3490.61 cw(c4943.78,3500) v1@4930.5,3500 ; v1(4925,3500) 4949.5,3475.5 4970.25,3475.5 ; 4955.75,3475.5 4970.25,3475.5 ; 5000,3498.37 4993.12,3498.37 ; 4970.25,3475.5 4985,3490.25 4993.12,3498.37 ; 4993.12,3498.37 5015,3498.37 ; 4993.12,3498.37 5015,3498.37 ; 5015,3498.37 5028.37,3498.37 5070,3540 5070,3605 5079.22,3614.22 5079.22,3630.82 5079.22,3638.82 ; 5079.22,3638.82 5079.22,3678.16 ; 5079.22,3638.82 5079.22,3678.16 ; 5079.22,3678.16 cw(c5089.37,3678.16) 5082.19,3685.34 ; 5079.22,3678.16 cw(c5089.37,3678.16) 5082.19,3685.34 ; 5082.19,3685.34 cw(c5094.72,3672.8) 5094.72,3690.53 ccw(c5094.72,3672.8) 5082.19,3685.34 ; 5082.19,3685.34 ccw(c5069.66,3697.87) 5087.38,3697.87 cw(c5069.66,3697.87) 5082.19,3685.34
  MidLayer2 w4: v1@1939.02,2933.37 cw(c1916.09,2933.37) 1932.31,2917.16 cw(c1948.52,2900.94) v1@1948.52,2923.87 ; v1@1943.02,2933.37 cw(c1929.75,2933.37) 1939.14,2923.99 cw(c1948.52,2914.6) v1@1948.52,2927.87 ; v1(1948.52,2933.37) 1909.15,2894 1461,2894 1448.52,2906.48 1448.52,3050.04 1515.19,3116.71 2200.9,3116.71 2217.56,3133.37 2623.52,3133.37 2631.86,3125.04 3145.54,3125.04 3203.88,3183.37 4169.82,3183.37 4237.2,3250.76 ; v1@4915.5,3500 cw(c4892.56,3500) 4908.78,3483.78 cw(c4925,3467.56) v1@4925,3490.5 ; v1@4919.5,3500 cw(c4906.22,3500) 4915.61,3490.61 cw(c4925,3481.22) v1@4925,3494.5 ; v1(4925,3500) 4907.52,3482.52 4907.52,3475.71 4907.52,3433.37 4873.19,3399.04 4748.52,3399.04 4732.86,3383.37 4685,3383.37 ; v1@4925.23,3500 4928.52,3496.71 v1@4928.41,3496.59 ; 4237.2,3250.76 4249.44,3263 ; 4237.2,3250.76 4249.44,3263 ; 4249.44,3263 4323.21,3263 4326.84,3259.37 4404.37,3259.37 4427.31,3282.31 4432,3287 4583.06,3287 4619.26,3323.2 4619.39,3323.2 4652,3355.81 4652,3370.37 4665,3383.37 ; 4665,3383.37 4685,3383.37 ; 4665,3383.37 4685,3383.37
PBIO.D7: EXTHDR1.16 U8.AF8 | length 8339.4
  Top Layer w4: EXTHDR1.16@1905.19,2808.48 cw(c1891.54,2794.82) 1910.85,2794.82 cw(c1930.16,2794.82) EXTHDR1.16@1916.51,2808.48 ; EXTHDR1.16@1910.85,2859.25 1910.85,2635.15 2054.4,2491.6 2054.4,2418.22 2300.63,2172 3123.38,2172 3165.3,2130.08 3165.3,2069.45 3165,2069.15 3165,1337.23 3165.19,1337.04 ; 3165.19,1990 3165.19,1337.04 ; 5064.22,3504.42 5067.68,3507.88 ; U8.AF8@5126.75,3737.24 cw(c5109.03,3737.24) 5121.56,3724.71 ; U8.AF8@5134.09,3729.9 ccw(c5134.09,3712.18) 5121.56,3724.71 ; 3165.19,1337.04 3585.86,916.37 4864.86,916.37 5098.52,1150.04 5098.52,1444.69 5112.5,1458.66 5112.5,1747.5 5081.02,1778.98 5081.02,1793.96 5114.7,1827.63 5120.5,1833.43 5120.5,2025.6 5171.75,2076.85 5171.75,2254.19 5082.02,2343.91 5082.02,2487.02 5123.69,2528.69 5123.69,2648.95 5102.5,2670.14 5102.5,2753.48 5088.77,2767.21 5088.67,2767.21 4971.5,2884.38 4971.5,2983.88 4975,2987.38 4975,3168.18 5031.19,3224.37 ; 5031.19,3224.37 5045.52,3238.71 ; 5031.19,3224.37 5045.52,3238.71 ; 5045.52,3238.71 5059.21,3238.71 5102.86,3282.35 5102.86,3387.37 5048.52,3441.71 5048.52,3488.73 5067.68,3507.88 ; 5067.68,3507.88 5076.01,3507.88 5099.02,3530.89 5099.02,3535.86 5098.52,3536.35 5098.52,3570.73 5119.06,3591.26 5119.06,3607.25 5110.23,3616.08 5110.23,3630.82 5110.23,3638.82 5110.23,3697.36 cw(c5148.91,3697.36) 5121.56,3724.71
PBIO.D8: EXTHDR1.18 U8.AB12 | length 4539.2
  Top Layer w4: EXTHDR1.18@1873.7,2910.03 ccw(c1860.04,2923.68) 1879.35,2923.68 ccw(c1898.67,2923.68) EXTHDR1.18@1885.01,2910.03 ; EXTHDR1.18@1879.35,2859.25 1879.35,2958.37 1896.02,2975.04 v1(1983.52,2975.04) ; v1@1976.81,2968.32 ccw(c1960.59,2952.11) 1960.59,2975.04 ccw(c1960.59,2997.98) v1@1976.81,2981.76 ; v1@1979.64,2971.15 ccw(c1970.25,2961.76) 1970.25,2975.04 ccw(c1970.25,2988.32) v1@1979.64,2978.93 ; v3(5271.89,3875.04) U8.AB12@5291.57,3894.72 ; U8.AB12@5284.23,3894.72 cw(c5266.51,3894.72) 5279.04,3882.19 cw(c5291.57,3869.66) U8.AB12@5291.57,3887.38 ; 5284.69,3887.84 cw(c5271.89,3900.65) 5271.89,3882.54 ccw(c5271.89,3900.65) 5284.69,3887.84 ; 5284.69,3887.84 ccw(c5297.5,3875.04) 5279.39,3875.04 cw(c5297.5,3875.04) 5284.69,3887.84
  MidLayer2 w4: v1@1983.52,2965.54 cw(c1983.52,2942.61) 1999.74,2958.82 cw(c2015.96,2975.04) v1@1993.02,2975.04 ; v1@1983.52,2969.54 cw(c1983.52,2956.26) 1992.91,2965.65 cw(c2002.3,2975.04) v1@1989.02,2975.04 ; v1(1983.52,2975.04) 2000.19,2958.37 2057.86,2958.37 2074.52,2975.04 2630.04,2975.04 2665,3010 2735.73,3010 2763.02,2982.71 3274.33,2982.71 3391.83,3100.2 3470.99,3100.2 3471.15,3100.04 4626.23,3100.04 4651.19,3125 4719.13,3125 4719.17,3125.04 4736.17,3108.04 4812.79,3108.04 4940.86,3236.11 4942.5,3237.75 4942.5,3296.64 4942.5,3317.25 4942.5,3374.75 5004.5,3436.75 5004.5,3482.81 5117.69,3596 5184,3596 5201.46,3578.54 5243.54,3578.54 5256.38,3591.38 5256.38,3630.82 5256.38,3638.82 5256.38,3699.73 ; 5256.38,3641.47 5256.38,3699.73 ; 5256.38,3837.6 5256.38,3851.53 ; 5260.5,3861.46 ccw(c5270.43,3851.53) 5256.38,3851.53 ; v3@5264.42,3874.39 cw(c5246.38,3872.81) 5260.25,3861.17 cw(c5274.12,3849.53) v3@5272.54,3867.57 ; 5256.38,3699.73 5256.38,3757.99 5256.38,3851.53
PBIO.D9: EXTHDR1.20 U8.AF7 | length 4657.5
  Top Layer w4: v1@1841.14,2781.76 ccw(c1824.92,2797.98) 1847.86,2797.98 ccw(c1870.79,2797.98) v1@1854.57,2781.76 ; EXTHDR1.20@1842.2,2808.48 cw(c1828.55,2794.82) 1847.86,2794.82 cw(c1867.17,2794.82) EXTHDR1.20@1853.51,2808.48 ; v1@1843.97,2778.93 ccw(c1834.58,2788.32) 1847.86,2788.32 ccw(c1861.14,2788.32) v1@1851.75,2778.93 ; v1(1847.86,2775.04) 1847.86,2814.13 EXTHDR1.20@1847.86,2859.25 ; v1(4963,3493) 4967.45,3493 4980.83,3506.37 ; v1@4964.39,3498.32 ccw(c4967.42,3509.91) 4975.89,3501.44 ; v1@4965.4,3502.19 ccw(c4969.47,3517.73) 4980.83,3506.37 ; v1@4972.5,3493 cw(c4984.68,3493) 4976.07,3501.62 ; 4980.83,3506.37 5025.06,3506.37 5062,3543.31 5062,3608.31 5070.86,3617.18 5070.86,3630.82 5070.86,3638.82 ; 5070.86,3638.82 5070.86,3697.36 ; 5070.86,3638.82 5070.86,3697.36 ; 5070.86,3697.36 cw(c5109.54,3697.36) 5082.19,3724.71 ; 5070.86,3697.36 cw(c5109.54,3697.36) 5082.19,3724.71 ; 5082.19,3724.71 ccw(c5069.66,3737.24) 5087.38,3737.24 cw(c5069.66,3737.24) 5082.19,3724.71 ; 5082.19,3724.71 cw(c5094.72,3712.18) 5094.72,3729.9 ccw(c5094.72,3712.18) 5082.19,3724.71
  MidLayer1 w4: v1(2673.52,2866.71) 2916.95,2866.71 3056.86,3006.61 v1(3056.86,3241.71) ; v1@2677.41,2862.82 cw(c2686.8,2853.43) 2686.8,2866.71 cw(c2686.8,2879.99) v1@2677.41,2870.6 ; v1@2680.24,2859.99 cw(c2696.46,2843.77) 2696.46,2866.71 cw(c2696.46,2889.64) v1@2680.24,2873.43 ; v1@3050.14,3234.99 cw(c3033.92,3218.77) 3056.86,3218.77 cw(c3079.79,3218.77) v1@3063.57,3234.99 ; v1@3052.97,3237.82 cw(c3043.58,3228.43) 3056.86,3228.43 cw(c3070.14,3228.43) v1@3060.75,3237.82
  MidLayer2 w4: v1@3056.86,3232.21 cw(c3056.86,3209.27) 3073.07,3225.49 cw(c3089.29,3241.71) v1@3066.36,3241.71 ; v1@3056.86,3236.21 cw(c3056.86,3222.93) 3066.25,3232.32 cw(c3075.64,3241.71) v1@3062.36,3241.71 ; v1(3056.86,3241.71) 3081.52,3217.04 3292.84,3217.04 3334.17,3258.37 4206.86,3258.37 4306.86,3358.37 4540.19,3358.37 4565.19,3383.37 4623.52,3383.37 4631.86,3391.71 4729.88,3391.71 4745.21,3407.04 4869.88,3407.04 4899.52,3436.69 4899.52,3475 ; v1@4953.5,3493 ccw(c4930.56,3493) 4946.78,3509.22 ccw(c4963,3525.43) v1@4963,3502.5 ; v1@4957.5,3493 ccw(c4944.22,3493) 4953.61,3502.39 ccw(c4963,3511.78) v1@4963,3498.5 ; v1(4963,3493) 4938.33,3517.67 4938.16,3517.5 4932.25,3517.5 ; 4899.52,3475 4899.52,3483.37 ; 4899.52,3475 4899.52,3483.37 ; 4899.52,3483.37 4899.52,3501.04 4906.86,3508.37 4915.98,3517.5 ; 4915.98,3517.5 4932.25,3517.5 ; 4915.98,3517.5 4932.25,3517.5
  Bottom Layer w4: v1(1847.86,2775.04) 2500.19,2775.04 2591.86,2866.71 v1(2673.52,2866.71) ; v1@1851.75,2771.15 cw(c1861.14,2761.76) 1861.14,2775.04 cw(c1861.14,2788.32) v1@1851.75,2778.93 ; v1@1854.57,2768.32 cw(c1870.79,2752.11) 1870.79,2775.04 cw(c1870.79,2797.98) v1@1854.57,2781.76 ; v1@2666.81,2859.99 ccw(c2650.59,2843.77) 2650.59,2866.71 ccw(c2650.59,2889.64) v1@2666.81,2873.43 ; v1@2669.64,2862.82 ccw(c2660.25,2853.43) 2660.25,2866.71 ccw(c2660.25,2879.99) v1@2669.64,2870.6
PBIO.D10: EXTHDR1.22 U8.AF2 | length 5161.3
  Top Layer w4: EXTHDR1.22@1810.7,2808.48 cw(c1797.05,2794.82) 1816.36,2794.82 cw(c1835.67,2794.82) EXTHDR1.22@1822.02,2808.48 ; EXTHDR1.22@1816.36,2859.25 1816.36,2682.2 v1(2006.86,2491.71) ; v1@1997.36,2491.71 ccw(c1974.42,2491.71) 1990.64,2507.93 ccw(c2006.86,2524.14) v1@2006.86,2501.21 ; v1@2001.36,2491.71 ccw(c1988.08,2491.71) 1997.47,2501.1 ccw(c2006.86,2510.49) v1@2006.86,2497.21 ; v1(4755,3680) 4777.62,3680 ; v1@4758.93,3676.15 cw(c4768.1,3667.16) 4768.1,3680 cw(c4768.1,3692.84) v1@4758.93,3683.85 ; v1@4761.78,3673.35 cw(c4777.62,3657.81) 4777.62,3680 ; v1@4761.78,3686.65 ccw(c4777.62,3702.19) 4777.62,3680 ; 4777.62,3680 4782.62,3685 ; 4782.62,3685 4789.81,3692.19 ; 4782.62,3685 4789.81,3692.19 ; 4789.81,3692.19 4797.38,3692.19 4807.81,3702.62 4807.81,3710.19 4819.36,3721.74 4830.82,3721.74 4838.82,3721.74 ; 4838.82,3721.74 4878.16,3721.74 ; 4838.82,3721.74 4878.16,3721.74 ; 4878.16,3721.74 ccw(c4878.16,3731.89) 4885.34,3724.71 ; 4878.16,3721.74 ccw(c4878.16,3731.89) 4885.34,3724.71 ; 4885.34,3724.71 ccw(c4872.81,3737.24) 4890.53,3737.24 cw(c4872.81,3737.24) 4885.34,3724.71 ; 4885.34,3724.71 cw(c4897.87,3712.18) 4897.87,3729.9 ccw(c4897.87,3712.18) 4885.34,3724.71
  MidLayer1 w4: v1(3359.19,2335.71) 3381.21,2335.71 ; v1@3363.19,2331.93 cw(c3371.94,2323.68) 3371.94,2335.71 cw(c3371.94,2347.73) v1@3363.19,2339.48 ; v1@3366.1,2329.19 cw(c3381.21,2314.94) 3381.21,2335.71 ; v1@3366.1,2342.23 ccw(c3381.21,2356.48) 3381.21,2335.71 ; v1@4068.47,3478.32 ccw(c4052.26,3462.11) 4052.26,3485.04 ccw(c4052.26,3507.98) v1@4068.47,3491.76 ; v1@4071.3,3481.15 ccw(c4061.91,3471.76) 4061.91,3485.04 ccw(c4061.91,3498.32) v1@4071.3,3488.93 ; v1@4073.52,3483.37 v1(4075.19,3485.04) 4011.5,3485.04 3714.86,3188.39 3714.86,2691.37 3714.86,2669.35 3381.21,2335.71
  MidLayer2 w4: v1(4075.19,3485.04) 4090.52,3500.37 4130.37,3500.37 4135,3505 4135,3520 4135,3597.15 4097.69,3634.46 4097.69,3648.96 4131.52,3682.79 4131.52,3776.52 4146.71,3791.71 4155.19,3791.71 4256.86,3791.71 4388.66,3659.91 4690,3659.91 ; v1@4748.28,3673.28 ccw(c4732.06,3657.06) 4732.06,3680 ccw(c4732.06,3702.93) v1@4748.28,3686.72 ; v1@4751.11,3676.11 ccw(c4741.72,3666.72) 4741.72,3680 ccw(c4741.72,3693.28) v1@4751.11,3683.89 ; v1(4755,3680) 4720,3680 4715.04,3675.04 4699.91,3659.91 4696.74,3659.91 ; 4690,3659.91 4696.74,3659.91 ; 4690,3659.91 4696.74,3659.91
  Bottom Layer w4: v1(2006.86,2491.71) 2075,2491.71 2121.71,2445 2973.37,2445 2994.43,2423.95 3078.87,2339.5 3288.65,2339.5 3317.65,2310.5 3358,2310.5 3359.19,2311.69 v1(3359.19,2335.71) v1@3353.08,2335.71 ; v1@2010.75,2487.82 cw(c2020.14,2478.43) 2020.14,2491.71 cw(c2020.14,2504.99) v1@2010.75,2495.6 ; v1@2013.57,2484.99 cw(c2029.79,2468.77) 2029.79,2491.71 cw(c2029.79,2514.64) v1@2013.57,2498.43 ; v1@3352.47,2328.99 cw(c3336.26,2312.77) 3359.19,2312.77 cw(c3382.13,2312.77) v1@3365.91,2328.99 ; v1@3355.3,2331.82 cw(c3345.91,2322.43) 3359.19,2322.43 cw(c3372.47,2322.43) v1@3363.08,2331.82
PBIO.D11: EXTHDR1.24 U8.AF6 | length 4275.7
  Top Layer w4: EXTHDR1.24@1780.06,2910.77 ccw(c1772.84,2920.38) 1784.87,2920.38 ; EXTHDR1.24@1784.87,2859.25 1784.87,2920.38 ; EXTHDR1.24@1789.67,2910.76 cw(c1796.89,2920.38) 1784.87,2920.38 ; v1(1798.52,2934.04) 1784.87,2920.38 ; v1@4921.29,3543 4968.41,3543 4973,3543 4977.02,3547.02 5031.49,3601.49 5031.49,3638.82 ; v1@4923.89,3539.11 cw(c4933.28,3529.72) 4933.28,3543 cw(c4933.28,3556.28) v1@4923.89,3546.89 ; v1@4926.72,3536.28 cw(c4942.93,3520.06) 4942.93,3543 cw(c4942.93,3565.93) v1@4926.72,3549.72 ; 5031.49,3638.82 5031.49,3697.36 ; 5031.49,3638.82 5031.49,3697.36 ; 5031.49,3697.36 cw(c5070.17,3697.36) 5042.82,3724.71 ; 5031.49,3697.36 cw(c5070.17,3697.36) 5042.82,3724.71 ; 5042.82,3724.71 ccw(c5030.29,3737.24) 5048.01,3737.24 cw(c5030.29,3737.24) 5042.82,3724.71 ; 5042.82,3724.71 cw(c5055.35,3712.18) 5055.35,3729.9 ccw(c5055.35,3712.18) 5042.82,3724.71
  MidLayer2 w4: v1(2390.86,3175.04) 2433.19,3217.37 2763.02,3217.37 2771.69,3208.71 2976.84,3208.71 3035.17,3267.04 3086.88,3267.04 3128.88,3225.04 3289.52,3225.04 3331.19,3266.71 4090.19,3266.71 4248.52,3425.04 4412.19,3425.04 4453.86,3383.37 4482.52,3383.37 4504.19,3405.04 4565.19,3405.04 4570.19,3400.04 4612.21,3400.04 4670.54,3458.37 4790.52,3458.37 4873.86,3541.71 4875.15,3543 v1(4920,3543) ; v1@2390.86,3180.54 ccw(c2390.86,3193.82) 2400.25,3184.43 ccw(c2409.64,3175.04) v1@2396.36,3175.04 ; v1@2390.86,3184.54 ccw(c2390.86,3207.48) 2407.07,3191.26 ccw(c2423.29,3175.04) v1@2400.36,3175.04 ; v1@4913.28,3536.28 ccw(c4897.06,3520.06) 4897.06,3543 ccw(c4897.06,3565.93) v1@4913.28,3549.72 ; v1@4916.11,3539.11 ccw(c4906.72,3529.72) 4906.72,3543 ccw(c4906.72,3556.28) v1@4916.11,3546.89
  Bottom Layer w4: v1(1798.52,2934.04) 1840.19,2975.71 1840.19,3025.04 1856.86,3041.71 2257.52,3041.71 v1(2390.86,3175.04) ; v1@1798.52,2939.54 ccw(c1798.52,2952.82) 1807.91,2943.43 ccw(c1817.3,2934.04) v1@1804.02,2934.04 ; v1@1798.52,2943.54 ccw(c1798.52,2966.48) 1814.74,2950.26 ccw(c1830.96,2934.04) v1@1808.02,2934.04 ; v1@2381.36,3175.04 cw(c2358.42,3175.04) 2374.64,3158.82 cw(c2390.86,3142.61) v1@2390.86,3165.54 ; v1@2385.36,3175.04 cw(c2372.08,3175.04) 2381.47,3165.65 cw(c2390.86,3156.26) v1@2390.86,3169.54
PBIO.D12: EXTHDR1.26 U8.AG6 | length 4779.6
  Top Layer w4: EXTHDR1.26@1747.71,2910.03 ccw(c1734.06,2923.68) 1753.37,2923.68 ccw(c1772.68,2923.68) EXTHDR1.26@1759.03,2910.03 ; v1@1750.14,2984.99 cw(c1733.92,2968.77) 1756.86,2968.77 cw(c1779.79,2968.77) v1@1763.57,2984.99 ; v1@1752.97,2987.82 cw(c1743.58,2978.43) 1756.86,2978.43 cw(c1770.14,2978.43) v1@1760.75,2987.82 ; EXTHDR1.26@1753.37,2859.25 1753.37,2951.51 1756.86,2955 v1(1756.86,2991.71) ; v1@4989.47,3540.48 ccw(c4983.89,3549.47) 4994.47,3549.47 ; v1(4994.47,3532.4) 4994.47,3549.47 ; v1@4999.48,3540.48 cw(c5005.06,3549.47) 4994.47,3549.47 ; 4994.47,3549.47 5039.85,3594.85 5039.85,3630.82 5039.85,3638.82 ; 5039.85,3638.82 5039.85,3678.16 ; 5039.85,3638.82 5039.85,3678.16 ; 5039.85,3678.16 cw(c5050,3678.16) 5042.82,3685.34 ; 5039.85,3678.16 cw(c5050,3678.16) 5042.82,3685.34 ; 5042.82,3685.34 cw(c5055.35,3672.8) 5055.35,3690.53 ccw(c5055.35,3672.8) 5042.82,3685.34 ; 5042.82,3685.34 ccw(c5030.29,3697.87) 5048.01,3697.87 cw(c5030.29,3697.87) 5042.82,3685.34
  MidLayer2 w4: v1@1747.36,2991.71 ccw(c1724.42,2991.71) 1740.64,3007.93 ccw(c1756.86,3024.14) v1@1756.86,3001.21 ; v1@1751.36,2991.71 ccw(c1738.08,2991.71) 1747.47,3001.1 ccw(c1756.86,3010.49) v1@1756.86,2997.21 ; v1(1756.86,2991.71) 1715,3033.56 1676.7,3033.56 1568.17,2925.04 1555.21,2925.04 1515.4,2964.85 1515.4,3085.4 1530.37,3100.37 2207.19,3100.37 2223.52,3116.71 2617.56,3116.71 2625.9,3108.37 3151.51,3108.37 3209.84,3166.71 4265.19,3166.71 4341.86,3243.37 4411,3243.37 4438.63,3271 4589.69,3271 4625.89,3307.2 4626.02,3307.2 4656.86,3338.04 4742.86,3338.04 4756.86,3324.04 4819.54,3324.04 4923.52,3428.02 4923.52,3436.59 4962.44,3475.5 4970.25,3475.5 4976.69,3481.95 4976.69,3482.11 4994.47,3499.88 v1(4994.47,3532.4) ; v1@4987.76,3525.69 cw(c4971.54,3509.47) 4994.47,3509.47 cw(c5017.41,3509.47) v1@5001.19,3525.69 ; v1@4990.59,3528.51 cw(c4981.2,3519.13) 4994.47,3519.13 cw(c5007.75,3519.13) v1@4998.36,3528.51
PBIO.D13: EXTHDR1.28 U8.AH4 | length 5141.4
  Top Layer w4: EXTHDR1.28@1716.22,2808.48 cw(c1702.56,2794.82) 1721.87,2794.82 cw(c1741.19,2794.82) EXTHDR1.28@1727.53,2808.48 ; EXTHDR1.28@1721.87,2859.25 1721.87,2750.36 v1(2013.86,2458.37) ; v1@2004.36,2458.37 ccw(c1981.42,2458.37) 1997.64,2474.59 ccw(c2013.86,2490.81) v1@2013.86,2467.87 ; v1@2008.36,2458.37 ccw(c1995.08,2458.37) 2004.47,2467.76 ccw(c2013.86,2477.15) v1@2013.86,2463.87 ; v1@4875.26,3530.5 ccw(c4869.95,3539.26) 4880.19,3539.26 ; v1(4880.19,3522.38) 4880.19,3539.26 ; v1@4885.13,3530.5 cw(c4890.44,3539.26) 4880.19,3539.26 ; U8.AH4@4971.42,3653.31 cw(c4958.89,3640.78) 4976.61,3640.78 cw(c4994.34,3640.78) U8.AH4@4981.81,3653.31 ; U8.AH4@4976.61,3658.5 4976.61,3638.82 4976.61,3630.61 4976.61,3622.93 4968.5,3614.81 4966.31,3614.81 4945.48,3593.98 4934.92,3593.98 4880.19,3539.26
  MidLayer1 w4: v1@4876.14,2465.09 ccw(c4859.92,2481.31) 4882.86,2481.31 ccw(c4905.79,2481.31) v1@4889.57,2465.09 ; v1@4878.97,2462.26 ccw(c4869.58,2471.65) 4882.86,2471.65 ccw(c4896.14,2471.65) v1@4886.75,2462.26 ; v1@4880.19,3512.88 cw(c4880.19,3485.93) 4899.25,3504.98 ; v1@4880.19,3516.88 cw(c4880.19,3499.58) 4892.42,3511.81 ; v1(4880.19,3522.38) 4881.86,3522.38 4899.52,3504.71 4899.52,3432.37 4907.5,3424.4 4907.5,3291.19 4948.52,3250.16 4948.52,3231 4915,3197.48 4915,3175 ; v1(4882.86,2458.37) 4882.86,2693.75 4915.19,2726.08 4915.19,3175 ; v1@4889.69,3522.38 ccw(c4908.62,3522.38) 4895.24,3508.99
  MidLayer2 w4: v1@2013.86,2448.87 cw(c2013.86,2425.94) 2030.07,2442.16 cw(c2046.29,2458.37) v1@2023.36,2458.37 ; v1@2013.86,2452.87 cw(c2013.86,2439.6) 2023.25,2448.99 cw(c2032.64,2458.37) v1@2019.36,2458.37 ; v1(2013.86,2458.37) 2080.86,2391.37 2417.32,2391.37 2450.65,2358.04 2734.35,2358.04 2742.81,2366.5 2777.19,2366.5 2785.65,2358.04 3093.04,2358.04 3126.37,2391.37 4688,2391.37 4755,2458.37 v1(4882.86,2458.37) ; v1@4876.14,2451.66 ccw(c4859.92,2435.44) 4859.92,2458.37 ccw(c4859.92,2481.31) v1@4876.14,2465.09 ; v1@4878.97,2454.49 ccw(c4869.58,2445.1) 4869.58,2458.37 ccw(c4869.58,2471.65) v1@4878.97,2462.26
PBIO.D14: EXTHDR1.30 U8.AE1 | length 5616.4
  Top Layer w4: EXTHDR1.30@1690.38,2859.25 1690.38,2813.15 1698.52,2805 v1(1698.52,2788.04) ; EXTHDR1.30@1693.08,2806.6 cw(c1694.68,2802.14) 1698.03,2805.49 cw(c1700.85,2808.31) EXTHDR1.30@1697.37,2810.24 ; v1@1693.56,2796.14 ccw(c1688.14,2805) 1698.52,2805 ccw(c1708.91,2805) v1@1703.49,2796.14 ; v1(2931.86,3039.37) 3099.37,3039.37 3181.86,3121.86 v1(3181.86,3283.37) ; v1@2935.75,3035.49 cw(c2945.14,3026.1) 2945.14,3039.37 cw(c2945.14,3052.65) v1@2935.75,3043.26 ; v1@2938.57,3032.66 cw(c2954.79,3016.44) 2954.79,3039.37 cw(c2954.79,3062.31) v1@2938.57,3046.09 ; v1@3175.14,3276.66 cw(c3158.92,3260.44) 3181.86,3260.44 cw(c3204.79,3260.44) v1@3188.57,3276.66 ; v1@3177.97,3279.49 cw(c3168.58,3270.1) 3181.86,3270.1 cw(c3195.14,3270.1) v1@3185.75,3279.49 ; v1@4709.47,3652.42 ccw(c4693.25,3668.64) 4716.18,3668.64 ccw(c4739.12,3668.64) v1@4722.9,3652.42 ; v1@4712.29,3649.6 ccw(c4702.91,3658.99) 4716.18,3658.99 ccw(c4729.46,3658.99) v1@4720.07,3649.6 ; v1(4716.18,3645.71) 4716.18,3676.18 4729.34,3689.34 4729.34,3729.84 4760,3760.5 4785.5,3760.5 4801.62,3776.61 U8.AE1@4858.5,3776.61 ; U8.AE1@4853.31,3771.42 ccw(c4840.78,3758.89) 4840.78,3776.61 ccw(c4840.78,3794.34) U8.AE1@4853.31,3781.81
  MidLayer2 w4: v1@3940.19,3498.87 cw(c3940.19,3475.94) 3956.41,3492.16 cw(c3972.63,3508.37) v1@3949.69,3508.37 ; v1@3940.19,3502.87 cw(c3940.19,3489.6) 3949.58,3498.99 cw(c3958.97,3508.37) v1@3945.69,3508.37 ; v1(3940.19,3508.37) 4006.86,3441.71 4015.19,3441.71 4048.52,3408.37 4073.52,3408.37 4080.96,3415.81 4114.49,3415.81 4215.19,3516.5 4215.19,3575.04 4215.19,3585 4215.19,3708.37 4205.51,3718.06 4175,3748.56 4175,3765 4175,3775 4183.37,3783.37 4198.52,3783.37 4251.52,3783.37 4382.99,3651.91 4665,3651.91 4671.2,3645.71 v1(4716.18,3645.71) ; v1@4709.47,3638.99 ccw(c4693.25,3622.77) 4693.25,3645.71 ccw(c4693.25,3668.64) v1@4709.47,3652.42 ; v1@4712.29,3641.82 ccw(c4702.91,3632.43) 4702.91,3645.71 ccw(c4702.91,3658.99) v1@4712.29,3649.6
  Bottom Layer w4: v1(1698.52,2788.04) 1735,2824.52 1735,3020.04 1765,3050.04 2085,3050.04 2244,3209.04 2721.35,3209.04 2930.69,2999.71 3106.52,2999.71 3123.52,3016.71 3123.52,3048.37 3121.86,3050.04 3030,3050.04 3020.41,3040.45 2932.93,3040.45 v1(2931.86,3039.37) ; v1@1698.52,2793.54 ccw(c1698.52,2806.82) 1707.91,2797.43 ccw(c1717.3,2788.04) v1@1704.02,2788.04 ; v1@1698.52,2797.54 ccw(c1698.52,2820.48) 1714.74,2804.26 ccw(c1730.96,2788.04) v1@1708.02,2788.04 ; v1@2935.75,3035.49 cw(c2947.73,3023.5) 2947.73,3040.45 ; v1@2938.57,3032.66 cw(c2957.38,3013.85) 2957.38,3040.45 ; v1@2938.57,3046.09 ccw(c2952.2,3059.72) 2952.2,3040.45 ; v1(3181.86,3283.37) 3198.86,3300.37 3935.86,3300.37 3956.86,3321.37 3969.86,3321.37 3990.19,3341.71 3990.19,3458.37 v1(3940.19,3508.37) ; v1@3181.86,3288.87 ccw(c3181.86,3302.15) 3191.25,3292.76 ccw(c3200.64,3283.37) v1@3187.36,3283.37 ; v1@3181.86,3292.87 ccw(c3181.86,3315.81) 3198.07,3299.59 ccw(c3214.29,3283.37) v1@3191.36,3283.37 ; v1@3940.19,3498.87 cw(c3940.19,3475.94) 3956.41,3492.16 cw(c3972.63,3508.37) v1@3949.69,3508.37 ; v1@3940.19,3502.87 cw(c3940.19,3489.6) 3949.58,3498.99 cw(c3958.97,3508.37) v1@3945.69,3508.37
PBIO.D15: EXTHDR1.32 U8.AD7 | length 4542.4
  Top Layer w4: EXTHDR1.32@1653.92,2910.65 ccw(c1649.13,2916.71) 1656.86,2916.71 ; EXTHDR1.32@1656.86,2883.37 1656.86,2916.71 ; EXTHDR1.32@1660.52,2912.2 cw(c1661.46,2916.71) 1656.86,2916.71 ; v1@1672.36,2941.71 cw(c1649.42,2941.71) 1665.64,2925.49 cw(c1681.86,2909.27) v1@1681.86,2932.21 ; v1@1676.36,2941.71 cw(c1663.08,2941.71) 1672.47,2932.32 cw(c1681.86,2922.93) v1@1681.86,2936.21 ; v1(1681.86,2941.71) 1656.86,2916.71 ; v3(5075.04,3796.3) U8.AD7@5094.72,3815.98 ; U8.AD7@5087.38,3815.98 cw(c5069.66,3815.98) 5082.19,3803.45 cw(c5094.72,3790.92) U8.AD7@5094.72,3808.64 ; 5087.84,3809.1 cw(c5075.04,3821.91) 5075.04,3803.8 ccw(c5075.04,3821.91) 5087.84,3809.1 ; 5087.84,3809.1 ccw(c5100.65,3796.3) 5082.54,3796.3 cw(c5100.65,3796.3) 5087.84,3809.1
  MidLayer1 w4: v1(4956.86,3166.71) 4972.86,3182.71 ; v1@4956.91,3172.21 ccw(c4957.03,3185.06) 4966.12,3175.97 ccw(c4975.21,3166.88) v1@4962.36,3166.76 ; v1@4956.95,3176.21 ccw(c4957.16,3198.4) 4972.86,3182.71 ; v1@4966.36,3166.8 cw(c4988.55,3167.01) 4972.86,3182.71 ; 5063.65,3782.72 ccw(c5073.58,3772.79) 5059.53,3772.79 5059.53,3679.25 5059.53,3638.82 5059.53,3630.82 5059.53,3617.16 5051.18,3608.8 5051.18,3555.49 5040.19,3544.5 5040.19,3445.31 4972.86,3377.98 4972.86,3205 4972.86,3191.04 4972.86,3182.71 ; v3@5067.57,3795.65 cw(c5049.53,3794.07) 5063.4,3782.43 cw(c5077.27,3770.79) v3@5075.69,3788.83
  MidLayer2 w4: v1(1681.86,2941.71) 1743.29,2941.71 1768.63,2916.37 1881.37,2916.37 1919.41,2954.41 1952.49,2954.41 1998.52,2908.37 2031.86,2908.37 2081.86,2958.37 3290.19,2958.37 3298.52,2966.71 3353.88,2966.71 3354.37,2966.21 3359.34,2966.21 3359.5,2966.37 4432.56,2966.37 4439.44,2959.5 4498.67,2959.5 4571.17,3032 4672.53,3032 4822.15,3032 v1(4956.86,3166.71) ; v1@1685.75,2937.82 cw(c1695.14,2928.43) 1695.14,2941.71 cw(c1695.14,2954.99) v1@1685.75,2945.6 ; v1@1688.57,2934.99 cw(c1704.79,2918.77) 1704.79,2941.71 cw(c1704.79,2964.64) v1@1688.57,2948.43 ; v1@4947.36,3166.71 cw(c4924.42,3166.71) 4940.64,3150.49 cw(c4956.86,3134.27) v1@4956.86,3157.21 ; v1@4951.36,3166.71 cw(c4938.08,3166.71) 4947.47,3157.32 cw(c4956.86,3147.93) v1@4956.86,3161.21
PBIO.D16: EXTHDR1.34 U8.AB5 | length 5407.6
  Top Layer w4: EXTHDR1.34@1621.73,2808.48 cw(c1608.07,2794.82) 1627.39,2794.82 cw(c1646.7,2794.82) EXTHDR1.34@1633.04,2808.48 ; EXTHDR1.34@1627.39,2859.25 1627.39,2721.18 v1(1756.86,2591.71) ; v1@1747.36,2591.71 ccw(c1724.42,2591.71) 1740.64,2607.93 ccw(c1756.86,2624.14) v1@1756.86,2601.21 ; v1@1751.36,2591.71 ccw(c1738.08,2591.71) 1747.47,2601.1 ccw(c1756.86,2610.49) v1@1756.86,2597.21 ; v3(4996.3,3875.04) U8.AB5@5015.98,3894.72 ; U8.AB5@5008.64,3894.72 cw(c4990.92,3894.72) 5003.45,3882.19 cw(c5015.98,3869.66) U8.AB5@5015.98,3887.38 ; 5009.1,3887.84 cw(c4996.3,3900.65) 4996.3,3882.54 ccw(c4996.3,3900.65) 5009.1,3887.84 ; 5009.1,3887.84 ccw(c5021.91,3875.04) 5003.8,3875.04 cw(c5021.91,3875.04) 5009.1,3887.84
  MidLayer1 w4: v1@3891.81,2873.43 ccw(c3875.59,2889.64) 3898.52,2889.64 ccw(c3921.46,2889.64) v1@3905.24,2873.43 ; v1@3894.64,2870.6 ccw(c3885.25,2879.99) 3898.52,2879.99 ccw(c3911.8,2879.99) v1@3902.41,2870.6 ; v1(3898.52,2866.71) 3898.52,2944.08 4272.52,3318.08 4272.52,3955.83 4319.13,4002.44 4319.13,4034.13 4341.21,4056.21 4410,4056.21 4431.46,4056.21 4432.75,4057.5 4438.06,4062.81 4473.49,4062.81 4526.94,4062.81 4543.36,4046.39 4543.36,3991.52 4551.5,3983.38 4577.38,3957.5 4615,3957.5 4654.18,3957.5 4657.18,3954.5 4685.73,3954.5 4710,3930.23 4710,3910 4710,3899.5 4710,3875 4725.47,3859.53 4749.97,3859.53 4755,3859.53 4830.82,3859.53 4838.82,3859.53 4879.25,3859.53 4898.67,3859.53 4958.86,3859.53 4972.79,3859.53 ccw(c4972.79,3873.58) 4982.72,3863.65 ; v3@4988.83,3875.69 cw(c4970.79,3877.27) 4982.43,3863.4 cw(c4994.07,3849.53) v3@4995.65,3867.57
  Bottom Layer w4: v1@1750.14,2598.43 ccw(c1733.92,2614.64) 1756.86,2614.64 ccw(c1779.79,2614.64) v1@1763.57,2598.43 ; v1@1752.97,2595.6 ccw(c1743.58,2604.99) 1756.86,2604.99 ccw(c1770.14,2604.99) v1@1760.75,2595.6 ; v1(1756.86,2591.71) 1756.86,2646.86 1785.71,2675.71 2164.69,2675.71 2206.69,2633.71 2991.29,2633.71 3008.29,2616.71 3023.52,2616.71 3031.86,2625.04 3198.52,2625.04 3206.86,2616.71 3248.29,2616.71 3255.19,2623.61 3255.19,2635.04 3248.52,2641.71 3248.52,2677.04 3256.86,2685.37 3288.52,2685.37 3294.19,2679.71 3319.86,2679.71 3327.68,2687.53 3355,2714.85 3355,2855 3426.37,2926.37 3838.86,2926.37 v1(3898.52,2866.71) ; v1@3889.02,2866.71 ccw(c3866.09,2866.71) 3882.31,2882.93 ccw(c3898.52,2899.14) v1@3898.52,2876.21 ; v1@3893.02,2866.71 ccw(c3879.75,2866.71) 3889.14,2876.1 ccw(c3898.52,2885.49) v1@3898.52,2872.21
PBIO.D17: EXTHDR1.36 U8.AF5 | length 4595
  Top Layer w4: v1@1565.19,2940.54 cw(c1565.19,2917.61) 1581.41,2933.82 cw(c1597.63,2950.04) v1@1574.69,2950.04 ; v1@1565.19,2944.54 cw(c1565.19,2931.26) 1574.58,2940.65 cw(c1583.97,2950.04) v1@1570.69,2950.04 ; v1(1565.19,2950.04) 1581.86,2933.37 1587.89,2933.37 1595.89,2925.37 EXTHDR1.36@1595.89,2859.25 ; EXTHDR1.36@1590.23,2910.03 ccw(c1576.57,2923.68) 1595.89,2923.68 ccw(c1615.2,2923.68) EXTHDR1.36@1601.55,2910.03 ; 4940.79,3585.98 4948.79,3585.98 ; v1(4957,3434) 4972.25,3434 4979.75,3426.5 4994.25,3426.5 5004.5,3436.75 5004.5,3451.25 4994.25,3461.5 4978.88,3461.5 4976.88,3459.5 4929.44,3459.5 4899.5,3489.44 4899.5,3547.25 4912.75,3560.5 4938.23,3585.98 4948.79,3585.98 ; 4948.79,3585.98 4969.62,3606.81 4971.81,3606.81 4992.12,3627.12 4992.12,3630.82 4992.12,3638.82 ; 4992.12,3638.82 4992.12,3697.36 ; 4992.12,3638.82 4992.12,3697.36 ; 4992.12,3697.36 cw(c5030.8,3697.36) 5003.45,3724.71 ; 4992.12,3697.36 cw(c5030.8,3697.36) 5003.45,3724.71 ; 5003.45,3724.71 ccw(c4990.92,3737.24) 5008.64,3737.24 cw(c4990.92,3737.24) 5003.45,3724.71 ; 5003.45,3724.71 cw(c5015.98,3712.18) 5015.98,3729.9 ccw(c5015.98,3712.18) 5003.45,3724.71
  MidLayer2 w4: v1(1565.19,2950.04) 1581.86,2966.71 1598.52,2966.71 1673.52,3041.71 2256.86,3041.71 2323.86,3108.71 2614.25,3108.71 2622.58,3100.37 3154.82,3100.37 3213.15,3158.71 4348.96,3158.71 4445.25,3255 4600,3255 4635.37,3290.37 4723.52,3290.37 4747.19,3266.71 ; v1@1565.19,2955.54 ccw(c1565.19,2968.82) 1574.58,2959.43 ccw(c1583.97,2950.04) v1@1570.69,2950.04 ; v1@1565.19,2959.54 ccw(c1565.19,2982.48) 1581.41,2966.26 ccw(c1597.63,2950.04) v1@1574.69,2950.04 ; v1@4947.5,3434 cw(c4924.56,3434) 4940.78,3417.78 cw(c4957,3401.56) v1@4957,3424.5 ; v1@4951.5,3434 cw(c4938.22,3434) 4947.61,3424.61 cw(c4957,3415.22) v1@4957,3428.5 ; v1(4957,3434) 4789.71,3266.71 4786.86,3266.71 ; 4747.19,3266.71 4786.86,3266.71 ; 4747.19,3266.71 4786.86,3266.71
PBIO.D18: EXTHDR1.38 U8.AH3 | length 8734.8
  Top Layer w4: EXTHDR1.38@1558.74,2808.48 cw(c1545.08,2794.82) 1564.39,2794.82 cw(c1583.71,2794.82) EXTHDR1.38@1570.05,2808.48 ; EXTHDR1.38@1564.39,2859.25 1564.39,2692.51 1909.9,2347 2114.31,2347 2297.31,2164 3120.06,2164 3157.3,2126.76 3157.3,2072.77 ; 3156.86,2072.32 3156.86,1333.37 3581.86,908.37 4870.58,908.37 5120,1157.8 v1@5120,1191.57 ; v1@4750.14,3431.76 ccw(c4733.92,3447.98) 4756.86,3447.98 ccw(c4779.79,3447.98) v1@4763.57,3431.76 ; v1@4752.97,3428.93 ccw(c4743.58,3438.32) 4756.86,3438.32 ccw(c4770.14,3438.32) v1@4760.75,3428.93 ; v1(4756.86,3425.04) 4756.86,3520 4773.71,3536.86 4826.86,3536.86 4856.5,3566.5 4856.5,3581.25 4866.75,3591.5 4898.5,3591.5 4924.98,3617.98 4935.54,3617.98 4937.5,3619.94 4937.5,3630.5 4937.24,3638.82 U8.AH3@4937.24,3658.5 ; U8.AH3@4932.05,3653.31 cw(c4919.52,3640.78) 4937.24,3640.78 cw(c4954.97,3640.78) U8.AH3@4942.44,3653.31 ; v1@4937.28,2433.28 ccw(c4921.06,2417.06) 4921.06,2440 ccw(c4921.06,2462.93) v1@4937.28,2446.72 ; v1@4940.11,2436.11 ccw(c4930.72,2426.72) 4930.72,2440 ccw(c4930.72,2453.28) v1@4940.11,2443.89 ; v1(4944,2440) 4905,2440 4870,2405 4870,1480.19 5006.86,1343.33 v1(5006.86,1191.71) ; v1@5000.14,1198.43 ccw(c4983.92,1214.64) 5006.86,1214.64 ccw(c5029.79,1214.64) v1@5013.57,1198.43 ; v1@5002.97,1195.6 ccw(c4993.58,1204.99) 5006.86,1204.99 ccw(c5020.14,1204.99) v1@5010.75,1195.6 ; v1@5112.81,1184.99 cw(c5095.45,1167.63) 5120,1167.63 ; v1@5115.64,1187.82 cw(c5105.1,1177.29) 5120,1177.29 ; 5120,1169.92 cw(c5141.32,1169.92) v1@5126.24,1184.99 ; 5120,1179.57 cw(c5131.66,1179.57) v1@5123.42,1187.82
  MidLayer1 w4: 4906.86,3200 4906.86,2729.06 4865.19,2687.39 4865.19,2450.04 4875.23,2440 v1(4944,2440) ; 4906.86,3200.65 4920,3213.79 v1(4920,3240) ; v1@4913.28,3233.28 cw(c4897.06,3217.06) 4920,3217.06 cw(c4942.93,3217.06) v1@4926.72,3233.28 ; v1@4916.11,3236.11 cw(c4906.72,3226.72) 4920,3226.72 cw(c4933.28,3226.72) v1@4923.89,3236.11 ; v1@4937.28,2433.28 ccw(c4921.06,2417.06) 4921.06,2440 ccw(c4921.06,2462.93) v1@4937.28,2446.72 ; v1@4940.11,2436.11 ccw(c4930.72,2426.72) 4930.72,2440 ccw(c4930.72,2453.28) v1@4940.11,2443.89 ; v1(5006.86,1191.71) v1(5119.53,1191.71) ; v1@5010.75,1187.82 cw(c5020.14,1178.43) 5020.14,1191.71 cw(c5020.14,1204.99) v1@5010.75,1195.6 ; v1@5013.57,1184.99 cw(c5029.79,1168.77) 5029.79,1191.71 cw(c5029.79,1214.64) v1@5013.57,1198.43 ; v1@5112.81,1184.99 ccw(c5096.59,1168.77) 5096.59,1191.71 ccw(c5096.59,1214.64) v1@5112.81,1198.43 ; v1@5115.64,1187.82 ccw(c5106.25,1178.43) 5106.25,1191.71 ccw(c5106.25,1204.99) v1@5115.64,1195.6
  Bottom Layer w4: v1@4756.86,3415.54 cw(c4756.86,3392.61) 4773.07,3408.82 cw(c4789.29,3425.04) v1@4766.36,3425.04 ; v1@4756.86,3419.54 cw(c4756.86,3406.26) 4766.25,3415.65 cw(c4775.64,3425.04) v1@4762.36,3425.04 ; v1(4756.86,3425.04) 4795.36,3386.54 4795.36,3331.15 4795.36,3262.32 4819.67,3238 4854,3238 4856,3240 v1(4920,3240) ; v1@4913.28,3233.28 ccw(c4897.06,3217.06) 4897.06,3240 ccw(c4897.06,3262.93) v1@4913.28,3246.72 ; v1@4916.11,3236.11 ccw(c4906.72,3226.72) 4906.72,3240 ccw(c4906.72,3253.28) v1@4916.11,3243.89
PBIO.D19: EXTHDR1.40 U8.AG3 | length 4769.1
  Top Layer w4: v1@1516.81,2923.66 cw(c1477.96,2884.81) EXTHDR1.40@1532.9,2884.81 ; v1@1519.64,2926.49 cw(c1487.62,2894.47) EXTHDR1.40@1532.9,2894.47 ; v1@1522.46,2929.31 cw(c1497.27,2904.13) EXTHDR1.40@1532.9,2904.13 ; v1(1523.52,2930.37) 1532.9,2921 EXTHDR1.40@1532.9,2859.25 ; v1@1525.29,2932.14 cw(c1506.93,2913.78) EXTHDR1.40@1532.9,2913.78 ; v1@4831.97,3568.03 4860,3596.06 4863.44,3599.5 4889.62,3599.5 4893.98,3599.5 4894.98,3600.5 4921.74,3627.26 4921.74,3638.82 ; 4921.74,3638.82 4921.74,3678.16 ; 4921.74,3638.82 4921.74,3678.16 ; 4921.74,3678.16 cw(c4931.89,3678.16) 4924.71,3685.34 ; 4921.74,3678.16 cw(c4931.89,3678.16) 4924.71,3685.34 ; 4924.71,3685.34 cw(c4937.24,3672.8) 4937.24,3690.53 ccw(c4937.24,3672.8) 4924.71,3685.34 ; 4924.71,3685.34 ccw(c4912.18,3697.87) 4929.9,3697.87 cw(c4912.18,3697.87) 4924.71,3685.34
  MidLayer1 w4: v1(4769.86,3341.71) 4786.52,3341.71 ; v1@4778.03,3336.87 cw(c4786.52,3331.84) 4786.52,3341.71 ; v1@4778.03,3346.55 ccw(c4786.52,3351.58) 4786.52,3341.71 ; v1@4823.28,3563.28 cw(c4807.06,3547.06) 4830,3547.06 cw(c4852.93,3547.06) v1@4836.72,3563.28 ; v1@4826.11,3566.11 cw(c4816.72,3556.72) 4830,3556.72 cw(c4843.28,3556.72) v1@4833.89,3566.11 ; v1(4830,3570) 4830,3491.19 4841.19,3480 4841.19,3365.71 4881.86,3325.04 4881.86,3300.04 4865.19,3283.37 4844.86,3283.37 4786.52,3341.71
  MidLayer2 w4: v1@1514.02,2930.37 ccw(c1491.09,2930.37) 1507.31,2946.59 ccw(c1523.52,2962.81) v1@1523.52,2939.87 ; v1@1518.02,2930.37 ccw(c1504.75,2930.37) 1514.14,2939.76 ccw(c1523.52,2949.15) v1@1523.52,2935.87 ; v1(1523.52,2930.37) 1470,2983.9 1470,3060.2 1518.17,3108.37 2203.88,3108.37 2220.54,3125.04 2620.54,3125.04 2628.88,3116.71 3148.52,3116.71 3206.86,3175.04 4155,3175.04 ; v1@4760.36,3341.71 ccw(c4737.42,3341.71) 4753.64,3357.93 ccw(c4769.86,3374.14) v1@4769.86,3351.21 ; v1@4764.36,3341.71 ccw(c4751.08,3341.71) 4760.47,3351.1 ccw(c4769.86,3360.49) v1@4769.86,3347.21 ; v1(4769.86,3341.71) 4736.52,3375.04 4670,3375.04 4660,3365.04 4660,3352.5 4622.7,3315.2 4622.58,3315.2 4586.37,3279 4435.31,3279 4407.69,3251.37 4323.52,3251.37 4319.9,3255 ; 4155,3175.04 4172.8,3175.04 ; 4155,3175.04 4172.8,3175.04 ; 4172.8,3175.04 4252.76,3255 4285.82,3255 ; 4285.82,3255 4319.9,3255 ; 4285.82,3255 4319.9,3255
PBIO.D20: EXTHDR1.42 U8.AF3 | length 6258.1
  Top Layer w4: EXTHDR1.42@1495.74,2808.48 cw(c1482.09,2794.82) 1501.4,2794.82 cw(c1520.71,2794.82) EXTHDR1.42@1507.06,2808.48 ; EXTHDR1.42@1501.4,2859.25 1501.4,2773.6 1525,2750 v1(1525,2285) ; v1@1518.28,2291.72 ccw(c1502.06,2307.93) 1525,2307.93 ccw(c1547.93,2307.93) v1@1531.72,2291.72 ; v1@1521.11,2288.89 ccw(c1511.72,2298.28) 1525,2298.28 ccw(c1538.28,2298.28) v1@1528.89,2288.89 ; v1(4750,3590) 4755,3590 4780.34,3615.34 4780.34,3671.41 4793.13,3684.19 4800.69,3684.19 4815.81,3699.31 4815.81,3706.87 4822.32,3713.38 4830.82,3713.38 4838.82,3713.38 4897.36,3713.38 ; v1@4750,3591.5 ccw(c4750,3607.19) 4761.1,3596.1 ; v1@4750,3595.5 ccw(c4750,3620.85) 4767.92,3602.92 ; v1@4750,3599.5 ccw(c4750,3634.51) 4774.75,3609.75 ; v1@4759.5,3590 cw(c4770.36,3590) 4762.68,3597.68 ; U8.AF3@4929.9,3737.24 cw(c4912.18,3737.24) 4924.71,3724.71 ; U8.AF3@4937.24,3729.9 ccw(c4937.24,3712.18) 4924.71,3724.71 ; 4897.36,3713.38 ccw(c4897.36,3752.06) 4924.71,3724.71 ; 4897.36,3713.38 ccw(c4897.36,3752.06) 4924.71,3724.71
  MidLayer1 w4: v1@4341.81,2240.09 ccw(c4328.06,2253.84) 4347.5,2253.84 ; 4347.5,2249.13 ccw(c4364.27,2249.13) v1@4352.41,2237.26 ; 4347.5,2258.78 ccw(c4373.93,2258.78) v1@4355.24,2240.09 ; v1(4348.52,2233.37) 4347.5,2234.4 4347.5,2397.75 4352.25,2402.5 4367.25,2402.5 4377.5,2412.75 4377.5,2432.75 4342.5,2467.75 4342.5,2593.41 4352.5,2603.41 4352.5,2607.25 4362.75,2617.5 4376.19,2617.5 4431.19,2672.5 4431.19,2805 4431.19,2818.34 4431.19,3107.75 4423.52,3115.42 4423.52,3258.37 4556.86,3391.71 4556.86,3536.04 4515.19,3577.71 4515.19,3635.19 4530,3650 4590.23,3650 v1(4606.86,3633.37) ; v1@4597.36,3633.37 ccw(c4574.42,3633.37) 4590.64,3649.59 ccw(c4606.86,3665.81) v1@4606.86,3642.87 ; v1@4601.36,3633.37 ccw(c4588.08,3633.37) 4597.47,3642.76 ccw(c4606.86,3652.15) v1@4606.86,3638.87
  Bottom Layer w4: v1@1528.89,2281.11 cw(c1538.28,2271.72) 1538.28,2285 cw(c1538.28,2298.28) 1528.89,2288.89 ccw(c1542.2,2302.2) 1542.2,2283.37 ; 1544.01,2283.37 ccw(c1544.01,2265.99) 1531.72,2278.28 cw(c1547.93,2262.06) 1547.93,2285 cw(c1547.93,2307.93) 1531.72,2291.72 ccw(c1551.86,2311.86) 1551.86,2283.37 ; v1@4339.02,2233.37 ccw(c4316.09,2233.37) 4332.31,2249.59 ccw(c4348.52,2265.81) v1@4348.52,2242.87 ; v1@4342.65,2227.5 v1(4348.52,2233.37) 4307.02,2274.87 3372.5,2274.87 3368.88,2278.5 3304.39,2278.5 3275.39,2307.5 2752.75,2307.5 2742.75,2317.5 2232.75,2317.5 2211.27,2296.02 1567.65,2296.02 1556.63,2285 ; v1@4343.02,2233.37 ccw(c4329.75,2233.37) 4339.14,2242.76 ccw(c4348.52,2252.15) v1@4348.52,2238.87 ; v1@4600.14,3626.66 cw(c4583.92,3610.44) 4606.86,3610.44 cw(c4629.79,3610.44) v1@4613.57,3626.66 ; v1@4602.97,3629.49 cw(c4593.58,3620.1) 4606.86,3620.1 cw(c4620.14,3620.1) v1@4610.75,3629.49 ; v1(4606.86,3633.37) 4606.86,3603.14 4626.96,3583.04 4663.46,3583.04 4703.71,3542.79 4721.76,3542.79 4732.19,3553.23 4732.19,3572.19 v1(4750,3590) v1@4754.81,3590 ; v1@4740.5,3590 cw(c4717.56,3590) 4733.78,3573.78 cw(c4750,3557.56) v1@4750,3580.5 ; v1@4744.5,3590 cw(c4731.22,3590) 4740.61,3580.61 cw(c4750,3571.22) v1@4750,3584.5 ; 1556.63,2285 v1(1525,2285) 1526.63,2283.37 1555,2283.37 1556.63,2285
PBIO.D21: EXTHDR1.44 U8.AE4 | length 6045.7
  Top Layer w4: EXTHDR1.44@1464.25,2808.48 cw(c1450.59,2794.82) 1469.9,2794.82 cw(c1489.22,2794.82) EXTHDR1.44@1475.56,2808.48 ; EXTHDR1.44@1469.9,2859.25 1469.9,2750 1515.19,2704.71 1515.19,2463.73 1498.52,2447.06 v1(1498.52,2241.71) ; v1@1491.81,2248.43 ccw(c1475.59,2264.64) 1498.52,2264.64 ccw(c1521.46,2264.64) v1@1505.24,2248.43 ; v1@1494.64,2245.6 ccw(c1485.25,2254.99) 1498.52,2254.99 ccw(c1511.8,2254.99) v1@1502.41,2245.6 ; v1(4756.86,2216.71) 4814.86,2274.71 4814.86,3196.33 4839.5,3220.98 4839.5,3269.25 4829.25,3279.5 4810.5,3279.5 4775,3315 4765.79,3324.21 4758.69,3324.21 4740.19,3342.71 4740.19,3369.69 4739.36,3370.52 4739.36,3484.17 4741.52,3486.33 4741.52,3523.45 4810.57,3592.5 4837.25,3592.5 4837.37,3592.37 4845,3592.37 4860.12,3607.5 4886.31,3607.5 4889.81,3607.5 4890.81,3608.5 4913,3630.69 4913,3631 4913.38,3638.82 4913.38,3697.36 cw(c4923.53,3697.36) 4916.36,3704.54 4916.36,3704.76 4924.27,3712.68 cw(c4937.24,3697.87) 4937.24,3717.56 ccw(c4937.24,3737.25) 4956.93,3737.24 4956.93,3748.69 cw(c4976.61,3748.69) 4962.69,3762.6 4962.69,3762.69 4964.08,3764.08 ; v1@4756.86,2222.21 ccw(c4756.86,2235.49) 4766.25,2226.1 ccw(c4775.64,2216.71) v1@4762.36,2216.71 ; v1@4756.86,2226.21 ccw(c4756.86,2249.14) 4773.07,2232.93 ccw(c4789.29,2216.71) v1@4766.36,2216.71 ; 4964.08,3764.08 ccw(c4951.55,3776.61) 4969.27,3776.61 cw(c4951.55,3776.61) 4964.08,3764.08 ; 4964.08,3764.08 cw(c4976.61,3751.55) 4976.61,3769.27 ccw(c4976.61,3751.55) 4964.08,3764.08
  MidLayer2 w4: v1(1498.52,2241.71) 1546.31,2241.71 1588.61,2284 1633.6,2284 1634.39,2283.21 1645.99,2283.21 1646.78,2284 2219.94,2284 2229.44,2274.5 2250.56,2274.5 2262.56,2286.5 3372.19,2286.5 3399.98,2258.71 4714.86,2258.71 v1(4756.86,2216.71) ; v1@1502.41,2237.82 cw(c1511.8,2228.43) 1511.8,2241.71 cw(c1511.8,2254.99) v1@1502.41,2245.6 ; v1@1505.24,2234.99 cw(c1521.46,2218.77) 1521.46,2241.71 cw(c1521.46,2264.64) v1@1505.24,2248.43 ; v1@4747.36,2216.71 ccw(c4724.42,2216.71) 4740.64,2232.93 ccw(c4756.86,2249.14) v1@4756.86,2226.21 ; v1@4751.36,2216.71 ccw(c4738.08,2216.71) 4747.47,2226.1 ccw(c4756.86,2235.49) v1@4756.86,2222.21
PBIO.D22: EXTHDR1.46 U8.AC2 | length 5110.6
  Top Layer w4: v1@1427.03,2791.56 ccw(c1422.06,2800) 1431.86,2800 ccw(c1441.65,2800) v1@1436.68,2791.56 ; v1(1431.86,2783.37) 1431.86,2800 1438.41,2806.55 EXTHDR1.46@1438.41,2859.25 ; v1(4733.86,2877.04) 4798.52,2941.71 4798.52,3150 ; v1@4733.86,2882.54 ccw(c4733.86,2895.82) 4743.25,2886.43 ccw(c4752.64,2877.04) v1@4739.36,2877.04 ; v1@4733.86,2886.54 ccw(c4733.86,2909.48) 4750.07,2893.26 ccw(c4766.29,2877.04) v1@4743.36,2877.04 ; 4666.27,3794.3 4666.27,3668.61 4673.52,3661.35 4673.52,3403.02 4684.84,3391.71 4706.86,3391.71 4731.86,3366.71 4731.86,3336.36 4739.19,3329.02 4739.19,3290 4798.52,3230.67 4798.52,3166.71 ; 4666.27,3794.3 4704.16,3832.19 ; 4666.27,3794.3 4704.16,3832.19 ; 4704.16,3832.19 4721.05,3832.19 4768.95,3832.19 4772.63,3832.19 4778.63,3838.19 ; 4778.63,3838.19 4779.94,3839.49 ; 4778.63,3838.19 4779.94,3839.49 ; 4779.94,3839.49 4830.83,3839.49 4838.82,3839.85 ; 4798.52,3150 4798.52,3166.71 ; 4798.52,3150 4798.52,3166.71 ; 4838.82,3839.85 4878.16,3839.85 ; 4838.82,3839.85 4878.16,3839.85 ; 4878.16,3839.85 ccw(c4878.16,3850) 4885.34,3842.82 ; 4878.16,3839.85 ccw(c4878.16,3850) 4885.34,3842.82 ; 4885.34,3842.82 ccw(c4872.81,3855.35) 4890.53,3855.35 cw(c4872.81,3855.35) 4885.34,3842.82 ; 4885.34,3842.82 cw(c4897.87,3830.29) 4897.87,3848.01 ccw(c4897.87,3830.29) 4885.34,3842.82
  MidLayer2 w4: v1@1431.86,2773.87 cw(c1431.86,2750.94) 1448.07,2767.16 cw(c1464.29,2783.37) v1@1441.36,2783.37 ; v1@1431.86,2777.87 cw(c1431.86,2764.6) 1441.25,2773.99 cw(c1450.64,2783.37) v1@1437.36,2783.37 ; v1(1431.86,2783.37) 1465.19,2750.04 1953.35,2750.04 1978.69,2775.37 2976.33,2775.37 3001.67,2750.04 3239.52,2750.04 3322.86,2833.37 4273.37,2833.37 4323.5,2883.5 4381.25,2883.5 4660,2883.5 4669.29,2874.21 4691.28,2874.21 ; v1@4727.14,2870.32 ccw(c4710.92,2854.11) 4710.92,2877.04 ccw(c4710.92,2899.98) v1@4727.14,2883.76 ; v1@4729.97,2873.15 ccw(c4720.58,2863.76) 4720.58,2877.04 ccw(c4720.58,2890.32) v1@4729.97,2880.93 ; v1(4733.86,2877.04) 4708.61,2877.04 ; 4691.28,2874.21 4705.77,2874.21 ; 4691.28,2874.21 4705.77,2874.21 ; 4705.77,2874.21 4708.61,2877.04 ; 4705.77,2874.21 4708.61,2877.04
PBIO.D23: EXTHDR1.48 U8.AE3 | length 6128.5
  Top Layer w4: EXTHDR1.48@1401.26,2808.48 cw(c1387.73,2794.95) 1406.86,2794.95 ; 1406.86,2794.69 cw(c1426.36,2794.69) EXTHDR1.48@1412.57,2808.48 ; EXTHDR1.48@1406.86,2859.25 1406.86,2780 1506.86,2680 1506.86,2466.71 1473.52,2433.37 v1(1473.52,2383.37) ; v1@1466.81,2390.09 ccw(c1450.59,2406.31) 1473.52,2406.31 ccw(c1496.46,2406.31) v1@1480.24,2390.09 ; v1@1469.64,2387.26 ccw(c1460.25,2396.65) 1473.52,2396.65 ccw(c1486.8,2396.65) v1@1477.41,2387.26 ; v1@4684.69,3438.14 ccw(c4665.88,3456.95) 4692.49,3456.95 ; v1@4687.52,3435.31 ccw(c4675.53,3447.3) 4692.49,3447.3 ; v1@4692.49,3431.6 4692.49,3577.34 ; 4692.49,3451.75 ccw(c4711.75,3451.75) v1@4698.13,3438.14 ; 4692.49,3575 4692.49,3577.34 ; 4693.2,3578.05 4692.49,3577.34 ; v1(4756.86,2400.04) 4806.86,2450.04 4806.86,3246.86 v1(4822,3262) ; v1@4756.86,2405.54 ccw(c4756.86,2418.82) 4766.25,2409.43 ccw(c4775.64,2400.04) v1@4762.36,2400.04 ; v1@4756.86,2409.54 ccw(c4756.86,2432.48) 4773.07,2416.26 ccw(c4789.29,2400.04) v1@4766.36,2400.04 ; 4692.49,3577.34 4698.52,3583.37 4742.22,3627.07 4742.22,3668.03 4737.5,3672.75 4737.5,3692.69 4767.31,3722.5 4772.25,3722.5 4782.5,3732.75 4782.5,3737.69 4789.31,3744.5 4792.13,3744.5 4800.38,3752.75 4830.82,3752.75 4838.82,3752.75 ; 4838.82,3752.75 4897.36,3752.75 ; 4838.82,3752.75 4897.36,3752.75 ; 4897.36,3752.75 ccw(c4897.36,3791.43) 4924.71,3764.08 ; 4897.36,3752.75 ccw(c4897.36,3791.43) 4924.71,3764.08 ; 4924.71,3764.08 cw(c4937.24,3751.55) 4937.24,3769.27 ccw(c4937.24,3751.55) 4924.71,3764.08 ; 4924.71,3764.08 ccw(c4912.18,3776.61) 4929.9,3776.61 cw(c4912.18,3776.61) 4924.71,3764.08
  MidLayer2 w4: v1(1473.52,2383.37) 2414,2383.37 2447.34,2350.04 2737.66,2350.04 2746.12,2358.5 2773.88,2358.5 2782.34,2350.04 3211.19,2350.04 3215.19,2346.04 3267.67,2346.04 3305,2383.37 4740.19,2383.37 v1(4756.86,2400.04) ; v1@1477.41,2379.49 cw(c1486.8,2370.1) 1486.8,2383.37 cw(c1486.8,2396.65) v1@1477.41,2387.26 ; v1@1480.24,2376.66 cw(c1496.46,2360.44) 1496.46,2383.37 cw(c1496.46,2406.31) v1@1480.24,2390.09 ; v1@4747.36,2400.04 cw(c4724.42,2400.04) 4740.64,2383.82 cw(c4756.86,2367.61) v1@4756.86,2390.54 ; v1@4751.36,2400.04 cw(c4738.08,2400.04) 4747.47,2390.65 cw(c4756.86,2381.26) v1@4756.86,2394.54
  Bottom Layer w4: v1(4691.41,3431.42) 4716.42,3431.42 4729.37,3444.37 ; v1@4695.3,3427.53 cw(c4704.69,3418.14) 4704.69,3431.42 cw(c4704.69,3444.7) v1@4695.3,3435.31 ; v1@4698.13,3424.7 cw(c4714.35,3408.48) 4714.35,3431.42 cw(c4714.35,3454.35) v1@4698.13,3438.14 ; v1@4815.28,3268.72 ccw(c4799.06,3284.93) 4822,3284.93 ccw(c4844.93,3284.93) v1@4828.72,3268.72 ; v1@4818.11,3265.89 ccw(c4808.72,3275.28) 4822,3275.28 ccw(c4835.28,3275.28) v1@4825.89,3265.89 ; v1(4822,3262) 4822,3295.86 4805.52,3312.33 ; 4729.37,3444.37 4740,3444.37 ; 4729.37,3444.37 4740,3444.37 ; 4740,3444.37 4767.52,3444.37 4805.52,3406.37 4805.52,3325 ; 4805.52,3312.33 4805.52,3325 ; 4805.52,3312.33 4805.52,3325