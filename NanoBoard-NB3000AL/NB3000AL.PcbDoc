# Altium PCB NB3000AL.PcbDoc (part 74 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
USER_LEDS.LED4.GREEN: R300.2 U8.AD26 U34.5 | length 2263.1
  Top Layer w4: v1@6030.49,3711.09 ccw(c6015.76,3697.49) 6015.76,3717.53 ; v1@6030.49,3723.98 cw(c6015.76,3737.57) 6015.76,3717.53 ; v1@6033.43,3713.8 ccw(c6024.9,3705.93) 6024.9,3717.53 ccw(c6024.9,3729.13) v1@6033.43,3721.26 ; v1(6037.47,3717.53) 6015.76,3717.53 ; U34.5@6815.19,3067.64 U34.5@6820,3067.64 6871.47,3067.64 6881.86,3078.02 6881.86,3291.71 v1(6848.52,3325.04) ; v1@6848.52,3315.54 cw(c6848.52,3292.61) 6864.74,3308.82 cw(c6880.96,3325.04) v1@6858.02,3325.04 ; v1@6848.52,3319.54 cw(c6848.52,3306.26) 6857.91,3315.65 cw(c6867.3,3325.04) v1@6854.02,3325.04 ; U34.5@6849.31,3064.81 cw(c6856.14,3057.98) 6856.14,3067.64 cw(c6856.14,3077.29) U34.5@6849.31,3070.47 ; 5855.29,3803.45 ccw(c5842.76,3790.92) 5842.76,3808.64 cw(c5842.76,3790.92) 5855.29,3803.45 ; 5855.29,3803.45 cw(c5867.82,3815.98) 5850.1,3815.98 ccw(c5867.82,3815.98) 5855.29,3803.45 ; 5855.29,3803.45 ccw(c5882.64,3830.8) 5882.64,3792.12 ; 5855.29,3803.45 ccw(c5882.64,3830.8) 5882.64,3792.12 ; 5882.64,3792.12 5941.18,3792.12 5949.18,3792.12 5971.72,3792.12 5986.19,3777.66 5986.19,3765.06 5993,3758.25 5993,3740.3 6015.76,3717.53
  MidLayer2 w4: v1@6037.47,3708.03 cw(c6037.47,3685.1) 6053.69,3701.31 cw(c6069.9,3717.53) v1@6046.97,3717.53 ; v1@6037.47,3712.03 cw(c6037.47,3698.75) 6046.86,3708.14 cw(c6056.25,3717.53) v1@6042.97,3717.53 ; v1@6039.22,3715.78 6060.69,3694.31 6060.69,3637.87 6072.69,3625.87 6120,3625.87 6129.13,3635 6221.69,3635 6250.81,3605.87 6255.96,3605.87 6277.09,3605.87 6281.21,3610 6326.64,3610 6476.93,3459.71 6647.78,3459.71 6655.61,3467.54 6676.96,3467.54 6698.63,3445.88 6827.81,3445.88 6848.52,3425.16 v1(6848.52,3325.04) ; v1@6841.81,3331.76 ccw(c6825.59,3347.98) 6848.52,3347.98 ccw(c6871.46,3347.98) v1@6855.24,3331.76 ; v1@6844.64,3328.93 ccw(c6835.25,3338.32) 6848.52,3338.32 ccw(c6861.8,3338.32) v1@6852.41,3328.93
  Bottom Layer w4: v1(6848.52,3325.04) 6870.48,3347 6914.88,3347 6942.88,3375 R300.2@7063.82,3375 ; v1@6848.52,3330.54 ccw(c6848.52,3343.82) 6857.91,3334.43 ccw(c6867.3,3325.04) v1@6854.02,3325.04 ; v1@6848.52,3334.54 ccw(c6848.52,3357.48) 6864.74,3341.26 ccw(c6880.96,3325.04) v1@6858.02,3325.04
USER_LEDS.LED4.RED: R301.2 U8.AB24 U34.1 | length 2250.7
  Top Layer w4: U8.AB24@5764.02,3887.38 cw(c5764.02,3869.66) 5776.55,3882.19 cw(c5789.08,3894.72) U8.AB24@5771.36,3894.72 ; U8.AB24@5764.02,3894.72 v3(5783.7,3875.04) ; v1@6808.28,3278.28 cw(c6791.61,3261.61) 6815.19,3261.61 ; v1@6811.11,3281.11 cw(c6801.26,3271.26) 6815.19,3271.26 ; v1(6815,3285) 6815.19,3284.81 6815.19,3183.37 6823.52,3175.04 6823.52,3170 U34.1@6820,3170 ccw(c6806.51,3172.62) 6816.23,3182.34 ; 6815.19,3262.52 cw(c6837.48,3262.52) v1@6821.72,3278.28 ; 6815.19,3272.18 cw(c6827.82,3272.18) v1@6818.89,3281.11 ; 6821.55,3177.02 cw(c6815.42,3170.89) U34.1@6823.93,3169.24 ; 5770.9,3887.84 cw(c5758.09,3875.04) 5776.2,3875.04 ccw(c5758.09,3875.04) 5770.9,3887.84 ; 5770.9,3887.84 ccw(c5783.7,3900.65) 5783.7,3882.54 cw(c5783.7,3900.65) 5770.9,3887.84
  MidLayer1 w4: v3@5784.35,3867.57 cw(c5785.93,3849.53) 5797.57,3863.4 cw(c5809.21,3877.27) v3@5791.17,3875.69 ; 5797.28,3863.65 ccw(c5807.21,3873.58) 5807.21,3859.53 5900.75,3859.53 5941.18,3859.53 5949.18,3859.53 5963.1,3859.53 6072.35,3750.27 6072.35,3698.23 6086.19,3684.39 ; v1@6079.67,3669.29 ccw(c6065.42,3684.39) 6086.19,3684.39 ; v1@6082.42,3666.38 ccw(c6074.17,3675.12) 6086.19,3675.12 ccw(c6098.21,3675.12) v1@6089.96,3666.38 ; v1(6086.19,3662.37) 6086.19,3684.39 ; v1@6092.71,3669.29 cw(c6106.96,3684.39) 6086.19,3684.39
  MidLayer2 w4: v1(6086.19,3662.37) 6093.67,3669.85 6198.15,3669.85 6254.13,3613.87 6273.77,3613.87 6277.9,3618 6329.96,3618 6480.25,3467.71 6644.46,3467.71 6652.29,3475.54 6680.77,3475.54 6681.02,3475.29 6681.02,3474.79 6701.94,3453.88 6831.12,3453.88 6869,3416 6869,3299 6853.37,3283.37 6815.19,3283.37 6815,3283.56 v1(6815,3285) ; v1@6818.89,3288.89 ccw(c6832.2,3302.2) 6832.2,3283.37 ; v1@6821.72,3278.28 cw(c6834.01,3265.99) 6834.01,3283.37 ; v1@6821.72,3291.72 ccw(c6841.86,3311.86) 6841.86,3283.37
  Bottom Layer w4: v1(6815,3285) 6935,3285 6943.75,3276.25 R301.2@7063.82,3276.25 ; v1@6818.89,3281.11 cw(c6828.28,3271.72) 6828.28,3285 cw(c6828.28,3298.28) v1@6818.89,3288.89 ; v1@6821.72,3278.28 cw(c6837.93,3262.06) 6837.93,3285 cw(c6837.93,3307.93) v1@6821.72,3291.72
USER_LEDS.LED5.BLUE: R296.2 U8.AB20 U34.11 | length 3032.6
  Top Layer w4: U8.AB20@5606.54,3887.38 cw(c5606.54,3869.66) 5619.07,3882.19 cw(c5631.6,3894.72) U8.AB20@5613.88,3894.72 ; U8.AB20@5606.54,3894.72 v3(5626.22,3875.04) ; v1(6990.19,3075.04) 6990.19,3090.19 6993.23,3093.23 U34.11@7038.5,3093.23 ; U34.11@7009.2,3090.4 ccw(c7002.37,3083.57) 7002.37,3093.23 ccw(c7002.37,3102.89) U34.11@7009.2,3096.06 ; 5613.42,3887.84 cw(c5600.61,3875.04) 5618.72,3875.04 ccw(c5600.61,3875.04) 5613.42,3887.84 ; 5613.42,3887.84 ccw(c5626.22,3900.65) 5626.22,3882.54 cw(c5626.22,3900.65) 5613.42,3887.84
  MidLayer2 w4: v3@5625.57,3867.57 cw(c5623.99,3849.53) 5637.86,3861.17 cw(c5651.73,3872.81) v3@5633.69,3874.39 ; 5637.61,3861.46 cw(c5627.68,3851.53) 5641.73,3851.53 ; 5641.73,3837.6 5641.73,3851.53 ; v1@6980.69,3075.04 ccw(c6957.76,3075.04) 6973.97,3091.26 ccw(c6990.19,3107.48) v1@6990.19,3084.54 ; v1@6984.69,3075.04 ccw(c6971.41,3075.04) 6980.8,3084.43 ccw(c6990.19,3093.82) v1@6990.19,3080.54 ; v1(6990.19,3075.04) 6973.19,3092.04 6973.19,3207.94 7017.5,3252.25 7031.86,3266.61 7031.86,3635.52 6900.66,3766.71 6797.13,3766.71 6774.02,3789.81 6774.02,3803.25 6754.27,3823 6411.69,3823 6396,3807.31 6269,3807.31 6245.81,3830.5 6114,3830.5 6101.5,3818 6101.5,3786.75 6049.78,3735.03 6030.22,3735.03 6001.12,3705.93 6001.12,3616.3 5976.71,3591.9 5930.73,3591.9 5922.09,3600.54 5900.96,3600.54 5873.42,3573 5840.31,3573 5817.5,3595.81 5817.5,3613.5 5805,3626 5787,3626 5766,3605 5650,3605 5641.73,3613.27 5641.73,3630.82 5641.73,3638.82 5641.73,3757.99 5641.73,3851.53
  Bottom Layer w4: v1@6983.47,3081.76 ccw(c6967.26,3097.98) 6990.19,3097.98 ccw(c7013.13,3097.98) v1@6996.91,3081.76 ; v1@6986.3,3078.93 ccw(c6976.91,3088.32) 6990.19,3088.32 ccw(c7003.47,3088.32) v1@6994.08,3078.93 ; v1(6990.19,3075.04) 6990.19,3120.19 6998.12,3128.12 R296.2@7063.82,3128.12
USER_LEDS.LED5.GREEN: R297.2 U8.AA24 U34.13 | length 2566.3
  Top Layer w4: U8.AA24@5764.02,3926.75 cw(c5764.02,3909.03) 5776.55,3921.56 cw(c5789.08,3934.09) U8.AA24@5771.36,3934.09 ; U8.AA24@5764.02,3934.09 v3(5783.7,3914.41) ; v1(6930,3070) 6927.82,3070 7005.82,3148 7036.6,3148 7038.5,3146.1 U34.13@7038.5,3144.41 ; v1@6930,3079.5 ccw(c6930,3097.16) 6942.49,3084.67 ; v1@6935.5,3070 cw(c6954.05,3070) 6940.93,3083.12 ; v1@6939.5,3070 cw(c6967.71,3070) 6947.76,3089.95 ; 6988.47,3130.65 cw(c7012.02,3107.1) U34.13@7012.02,3140.41 ; 6995.3,3137.48 cw(c7012.02,3120.76) U34.13@7012.02,3144.41 ; 7002.13,3144.31 cw(c7012.02,3134.41) U34.13@7012.02,3148.41 ; 5770.9,3927.21 cw(c5758.09,3914.41) 5776.2,3914.41 ccw(c5758.09,3914.41) 5770.9,3927.21 ; 5770.9,3927.21 ccw(c5783.7,3940.02) 5783.7,3921.91 cw(c5783.7,3940.02) 5770.9,3927.21
  MidLayer1 w4: v3@5784.35,3906.94 cw(c5785.93,3888.9) 5797.57,3902.77 cw(c5809.21,3916.64) v3@5791.17,3915.06 ; 5797.28,3903.02 ccw(c5807.21,3912.95) 5807.21,3898.9 5900.75,3898.9 5941.18,3898.9 5949.18,3898.9 5968.34,3898.9 5979.04,3909.6 6009.15,3909.6 6058.94,3859.81 6081.38,3859.81 6084.69,3856.5 6119.87,3856.5 6173.52,3802.85 6173.52,3675.04 6198.52,3650.04 v1(6246.86,3650.04) ; v1@6240.14,3643.32 ccw(c6223.92,3627.11) 6223.92,3650.04 ccw(c6223.92,3672.98) v1@6240.14,3656.76 ; v1@6242.97,3646.15 ccw(c6233.58,3636.76) 6233.58,3650.04 ccw(c6233.58,3663.32) v1@6242.97,3653.93
  MidLayer2 w4: v1(6246.86,3650.04) 6300.83,3650.04 6322.68,3628.19 6331.08,3628.19 6483.56,3475.71 6641.15,3475.71 6665.48,3500.04 6826.34,3500.04 6864.69,3461.69 6864.69,3447.81 6877,3435.5 6877,3114.23 6924.52,3066.71 6927.82,3070 v1(6930,3070) ; v1@6250.75,3646.15 cw(c6260.14,3636.76) 6260.14,3650.04 cw(c6260.14,3663.32) v1@6250.75,3653.93 ; v1@6253.57,3643.32 cw(c6269.79,3627.11) 6269.79,3650.04 cw(c6269.79,3672.98) v1@6253.57,3656.76 ; 6898.81,3092.42 ccw(c6930,3123.6) v1@6930,3079.5 ; 6905.64,3085.59 ccw(c6930,3109.95) v1@6930,3075.5 ; 6912.47,3078.76 ccw(c6930,3096.29) v1@6930,3071.5
  Bottom Layer w4: v1(6930,3070) 6950,3070 ; v1@6934.26,3066.53 cw(c6941.58,3060.56) 6941.58,3070 cw(c6941.58,3079.44) v1@6934.26,3073.47 ; v1@6937.36,3064 cw(c6950,3053.7) 6950,3070 ; v1@6937.36,3076 ccw(c6950,3086.3) 6950,3070 ; R297.2@7063.82,3029.38 6999.79,3029.38 6969.17,3060 6960,3060 6950,3070
USER_LEDS.LED5.RED: R298.2 U8.AB25 U34.9 | length 2862.5
  Top Layer w4: U8.AB25@5803.39,3887.38 cw(c5803.39,3869.66) 5815.92,3882.19 cw(c5828.45,3894.72) U8.AB25@5810.73,3894.72 ; U8.AB25@5803.39,3894.72 v3(5823.07,3875.04) ; v1(6912.52,3011.04) 6915.19,3008.37 6970,3008.37 7003.67,3042.05 ; v1@6916.41,3014.93 ccw(c6932.24,3030.76) 6932.24,3008.37 ; v1@6919.24,3004.32 cw(c6929.02,2994.54) 6929.02,3008.37 ; v1@6919.24,3017.76 ccw(c6941.9,3040.41) 6941.9,3008.37 ; U34.9@7008.91,3039.54 ccw(c7003.67,3035.33) 7003.67,3042.05 ; U34.9@7008.91,3044.55 cw(c7003.67,3048.76) 7003.67,3042.05 ; U34.9@7038.5,3042.05 7003.67,3042.05 ; 5810.27,3887.84 cw(c5797.46,3875.04) 5815.57,3875.04 ccw(c5797.46,3875.04) 5810.27,3887.84 ; 5810.27,3887.84 ccw(c5823.07,3900.65) 5823.07,3882.54 cw(c5823.07,3900.65) 5810.27,3887.84
  MidLayer1 w4: v3(5823.07,3875.04) 5900.75,3875.04 5941.18,3875.04 5949.18,3875.04 5958.9,3875.04 6080.35,3753.59 6080.35,3708.62 6114.94,3674.04 6115.71,3674.04 6131.31,3658.44 6131.31,3643.68 6099.37,3611.74 6099.37,3590.86 6105.23,3585 6135,3585 6148.52,3571.48 6148.52,3406.46 6106.86,3364.79 6106.86,3332.37 v1(6140.19,3299.04) ; v3@5828.26,3869.85 cw(c5840.8,3857.31) 5840.8,3875.04 cw(c5840.8,3892.77) v3@5828.26,3880.23 ; 5841.18,3875.04 cw(c5841.18,3893.15) 5828.37,3880.34 ccw(c5841.18,3893.15) 5841.18,3875.04 ; 5841.18,3875.04 ccw(c5841.18,3856.93) 5828.37,3869.74 cw(c5841.18,3856.93) 5841.18,3875.04 ; 6123.97,3315.26 cw(c6107.76,3299.04) 6130.69,3299.04 ccw(c6107.76,3299.04) 6123.97,3315.26 ; 6123.97,3315.26 ccw(c6140.19,3331.48) 6140.19,3308.54 cw(c6140.19,3331.48) 6123.97,3315.26 ; 6130.8,3308.43 cw(c6121.41,3299.04) 6134.69,3299.04 ccw(c6121.41,3299.04) 6130.8,3308.43 ; 6130.8,3308.43 ccw(c6140.19,3317.82) 6140.19,3304.54 cw(c6140.19,3317.82) 6130.8,3308.43
  Bottom Layer w4: v1(6140.19,3299.04) 6167.02,3325.87 6261.02,3325.87 6269.19,3317.71 6446.79,3317.71 6471.46,3342.37 6509.94,3342.37 6539,3313.31 6539,3283.25 6581.04,3241.21 6729.63,3241.21 6737.96,3232.87 6759.09,3232.87 6784.92,3258.71 6859.5,3258.71 6897.02,3221.19 6897.02,3062.6 6912.52,3047.1 v1(6912.52,3011.04) 6943.56,2980 R298.2@7063.82,2980 ; v1@6905.81,3017.76 ccw(c6889.59,3033.98) 6912.52,3033.98 ccw(c6935.46,3033.98) v1@6919.24,3017.76 ; v1@6908.64,3014.93 ccw(c6899.25,3024.32) 6912.52,3024.32 ccw(c6925.8,3024.32) v1@6916.41,3014.93 ; v1@6912.52,3001.54 cw(c6912.52,2978.61) 6928.74,2994.82 cw(c6944.96,3011.04) v1@6922.02,3011.04 ; v1@6912.52,3005.54 cw(c6912.52,2992.26) 6921.91,3001.65 cw(c6931.3,3011.04) v1@6918.02,3011.04 ; 6149.58,3308.43 cw(c6140.19,3317.82) 6140.19,3304.54 ccw(c6140.19,3317.82) 6149.58,3308.43 ; 6149.58,3308.43 ccw(c6158.97,3299.04) 6145.69,3299.04 cw(c6158.97,3299.04) 6149.58,3308.43 ; 6156.41,3315.26 cw(c6140.19,3331.48) 6140.19,3308.54 ccw(c6140.19,3331.48) 6156.41,3315.26 ; 6156.41,3315.26 ccw(c6172.63,3299.04) 6149.69,3299.04 cw(c6172.63,3299.04) 6156.41,3315.26
USER_LEDS.LED6.BLUE: R293.2 U8.AA25 U35.3 | length 2858.9
  Top Layer w4: U8.AA25@5803.39,3926.75 cw(c5803.39,3909.03) 5815.92,3921.56 cw(c5828.45,3934.09) U8.AA25@5810.73,3934.09 ; U8.AA25@5803.39,3934.09 v3(5823.07,3914.41) ; v1(6922.52,3133.37) 6948.52,3133.37 6965.19,3150.04 6965.19,3205.39 6999.8,3240 7015.25,3240 7027.75,3227.5 7042.25,3227.5 7054.75,3240 7147.25,3240 7173.52,3213.73 7173.52,3128.52 ; v1@6926.41,3129.49 cw(c6935.8,3120.1) 6935.8,3133.37 cw(c6935.8,3146.65) v1@6926.41,3137.26 ; v1@6929.24,3126.66 cw(c6945.46,3110.44) 6945.46,3133.37 cw(c6945.46,3156.31) v1@6929.24,3140.09 ; U35.3@7130,3118.82 7163.82,3118.82 ; U35.3@7156.48,3118.82 ccw(c7158.1,3132.31) 7167.7,3122.7 ; U35.3@7156.96,3122.79 ccw(c7159.34,3142.71) 7173.52,3128.52 ; U35.3@7159.84,3116.65 cw(c7163.82,3114.09) 7163.82,3118.82 ; U35.3@7159.84,3120.99 ccw(c7163.82,3123.55) 7163.82,3118.82 ; 5810.27,3927.21 cw(c5797.46,3914.41) 5815.57,3914.41 ccw(c5797.46,3914.41) 5810.27,3927.21 ; 5810.27,3927.21 ccw(c5823.07,3940.02) 5823.07,3921.91 cw(c5823.07,3940.02) 5810.27,3927.21 ; 7163.82,3118.82 7173.52,3128.52
  MidLayer1 w4: v3(5823.07,3914.41) 5900.75,3914.41 5941.18,3914.41 5949.18,3914.41 5972.53,3914.41 5975.72,3917.6 6012.46,3917.6 6062.25,3867.81 6084.69,3867.81 6088,3864.5 6123.19,3864.5 6181.86,3805.83 6181.86,3699.04 6190.44,3690.46 v1(6233.52,3690.46) ; v3@5828.26,3909.22 cw(c5840.8,3896.68) 5840.8,3914.41 cw(c5840.8,3932.14) v3@5828.26,3919.6 ; v3@5828.37,3909.11 cw(c5841.18,3896.3) 5841.18,3914.41 cw(c5841.18,3932.52) v3@5828.37,3919.71 ; v1@6226.8,3683.74 ccw(c6210.58,3667.52) 6210.58,3690.46 ccw(c6210.58,3713.39) v1@6226.8,3697.17 ; v1@6229.63,3686.57 ccw(c6220.24,3677.18) 6220.24,3690.46 ccw(c6220.24,3703.73) v1@6229.63,3694.35
  MidLayer2 w4: v1(6233.52,3690.46) 6271.73,3690.46 6326,3636.19 6334.4,3636.19 6474.77,3495.81 6486.88,3483.71 6637.83,3483.71 6662.5,3508.37 6829.32,3508.37 6872.69,3465 6872.69,3451.13 6885,3438.82 6885,3170.9 v1(6922.52,3133.37) ; v1@6237.41,3686.57 cw(c6246.8,3677.18) 6246.8,3690.46 cw(c6246.8,3703.73) v1@6237.41,3694.35 ; v1@6240.24,3683.74 cw(c6256.45,3667.52) 6256.45,3690.46 cw(c6256.45,3713.39) v1@6240.24,3697.17 ; v1@6913.02,3133.37 ccw(c6890.09,3133.37) 6906.31,3149.59 ccw(c6922.52,3165.81) v1@6922.52,3142.87 ; v1@6917.02,3133.37 ccw(c6903.75,3133.37) 6913.14,3142.76 ccw(c6922.52,3152.15) v1@6922.52,3138.87
  Bottom Layer w4: v1(6922.52,3133.37) 6956.63,3133.37 6972.69,3117.31 6972.69,3067.79 6982.94,3057.54 6997.44,3057.54 7018.65,3078.75 R293.2@7063.82,3078.75 ; v1@6926.41,3129.49 cw(c6935.8,3120.1) 6935.8,3133.37 cw(c6935.8,3146.65) v1@6926.41,3137.26 ; v1@6929.24,3126.66 cw(c6945.46,3110.44) 6945.46,3133.37 cw(c6945.46,3156.31) v1@6929.24,3140.09
USER_LEDS.LED6.GREEN: R294.2 U8.AA23 U35.5 | length 3617.7
  Top Layer w4: U8.AA23@5724.65,3926.75 cw(c5724.65,3909.03) 5737.18,3921.56 cw(c5749.71,3934.09) U8.AA23@5731.99,3934.09 ; U8.AA23@5724.65,3934.09 v3(5744.33,3914.41) ; U35.5@7130,3067.64 v1@7180.93,3067.64 ; U35.5@7156.68,3067.64 cw(c7156.68,3041.53) v1@7175.14,3059.99 ; U35.5@7159.31,3064.81 cw(c7166.14,3057.98) 7166.14,3067.64 cw(c7166.14,3077.29) U35.5@7159.31,3070.47 ; U35.5@7161.17,3067.64 ccw(c7161.17,3087.4) v1@7175.14,3073.43 ; 7166.33,3067.64 cw(c7166.33,3051.18) v1@7177.97,3062.82 ; 5731.53,3927.21 cw(c5718.72,3914.41) 5736.83,3914.41 ccw(c5718.72,3914.41) 5731.53,3927.21 ; 5731.53,3927.21 ccw(c5744.33,3940.02) 5744.33,3921.91 cw(c5744.33,3940.02) 5731.53,3927.21
  MidLayer1 w4: v3@5744.98,3906.94 cw(c5746.56,3888.9) 5758.2,3902.77 ; v3@5751.8,3915.06 ccw(c5769.84,3916.64) 5758.2,3902.77 ; 5821.14,3890.55 5807.21,3890.55 ; 6108,3692.29 6118.25,3682.04 ; v1(6176,2752) 6176,2839.23 6156.86,2858.37 6156.86,2900.04 6131.86,2925.04 6131.86,2941.71 6165.5,2975.35 6165.5,3108.37 6176.5,3119.37 6176.5,3268.77 6174.19,3271.08 6174.19,3365.43 6165.19,3374.43 6165.19,3635.88 6119.03,3682.04 6118.25,3682.04 ; 5758.2,3902.77 ccw(c5787.71,3932.28) 5787.71,3890.55 5807.21,3890.55 ; 5807.21,3890.55 5881.33,3890.55 5900.75,3890.55 5941.18,3890.55 5949.18,3890.55 5971.3,3890.55 5982.35,3901.6 6005.83,3901.6 6020,3887.43 6020,3825.25 6088.35,3756.9 6088.35,3711.94 6118.25,3682.04 ; 6176,2765.28 cw(c6162.72,2765.28) 6172.11,2755.89 ccw(c6162.72,2765.28) 6176,2765.28 ; 6176,2765.28 ccw(c6189.28,2765.28) 6179.89,2755.89 cw(c6189.28,2765.28) 6176,2765.28 ; 6176,2774.93 cw(c6153.06,2774.93) 6169.28,2758.72 ccw(c6153.06,2774.93) 6176,2774.93 ; 6176,2774.93 ccw(c6198.93,2774.93) 6182.72,2758.72 cw(c6198.93,2774.93) 6176,2774.93
  Bottom Layer w4: v1(6176,2752) 6176,2800.52 6181.86,2806.37 6195.52,2820.04 6305.9,2820.04 6330.4,2795.54 6420.6,2795.54 6458.44,2833.37 6598.52,2833.37 6623.86,2808.04 6831.52,2808.04 6906.52,2883.04 6979.58,2883.04 6986.12,2876.5 7143.46,2876.5 7173.02,2906.06 7173.02,2994.34 7181.86,3003.17 v1(7181.86,3066.71) 7210.15,3095 R294.2@7348.82,3095 ; v1@7175.14,3059.99 cw(c7158.92,3043.77) 7181.86,3043.77 cw(c7204.79,3043.77) v1@7188.57,3059.99 ; v1@7177.97,3062.82 cw(c7168.58,3053.43) 7181.86,3053.43 cw(c7195.14,3053.43) v1@7185.75,3062.82 ; v1@7181.86,3072.21 ccw(c7181.86,3085.49) 7191.25,3076.1 ccw(c7200.64,3066.71) v1@7187.36,3066.71 ; v1@7181.86,3076.21 ccw(c7181.86,3099.14) 7198.07,3082.93 ccw(c7214.29,3066.71) v1@7191.36,3066.71 ; 6176,2765.28 cw(c6162.72,2765.28) 6172.11,2755.89 ccw(c6162.72,2765.28) 6176,2765.28 ; 6176,2765.28 ccw(c6189.28,2765.28) 6179.89,2755.89 cw(c6189.28,2765.28) 6176,2765.28 ; 6176,2774.93 cw(c6153.06,2774.93) 6169.28,2758.72 ccw(c6153.06,2774.93) 6176,2774.93 ; 6176,2774.93 ccw(c6198.93,2774.93) 6182.72,2758.72 cw(c6198.93,2774.93) 6176,2774.93
USER_LEDS.LED6.RED: R295.2 U8.W26 U35.1 | length 2336.1
  Top Layer w4: v1@6081.28,3926.72 ccw(c6065.06,3942.93) 6088,3942.93 ccw(c6110.93,3942.93) v1@6094.72,3926.72 ; v1@6084.11,3923.89 ccw(c6074.72,3933.28) 6088,3933.28 ccw(c6101.28,3933.28) v1@6091.89,3923.89 ; v1(6088,3920) 6088,3962 6082.29,3967.71 6058.52,3967.71 6056.61,3965.8 6005.99,3965.8 5982.82,3988.97 5949.18,3988.97 5941.18,3988.97 5882.64,3988.97 ; v1@6088.15,3919.85 v1@6091.71,3923.41 ; v1@7082.68,3203.18 ccw(c7094.79,3198.38) 7085.58,3189.17 ; v1@7083.97,3201.73 7083.97,3190.78 7104.75,3170 U35.1@7130,3170 ; v1@7084,3201.76 v1@7085,3201.76 ; v1@7086.39,3201.7 ccw(c7100.96,3195.94) 7089.88,3184.87 ; v1@7090.11,3200.23 ccw(c7107.13,3193.5) 7094.19,3180.56 ; v1@7093.83,3198.76 ccw(c7113.3,3191.06) 7098.49,3176.25 ; 7096.24,3178.51 cw(c7088.31,3170.57) U35.1@7099.52,3170.15 ; 7098.79,3175.96 ccw(c7103.52,3180.69) U35.1@7103.52,3174 ; 5855.29,4000.3 ccw(c5882.64,4027.65) 5882.64,3988.97 ; 5855.29,4000.3 ccw(c5882.64,4027.65) 5882.64,3988.97 ; 5855.29,4000.3 cw(c5867.82,4012.83) 5850.1,4012.83 ccw(c5867.82,4012.83) 5855.29,4000.3 ; 5855.29,4000.3 ccw(c5842.76,3987.77) 5842.76,4005.49 cw(c5842.76,3987.77) 5855.29,4000.3
  MidLayer2 w4: v1@6088.15,3919.85 6101.67,3933.37 6123.11,3933.37 6243.37,3933.37 6260.5,3950.5 6310.69,3950.5 6344.48,3916.71 6375.19,3916.71 6408.52,3883.37 6448.52,3883.37 6473.52,3908.37 6581.86,3908.37 6590.19,3900.04 6814.19,3900.04 6897.52,3816.71 6897.52,3792.48 7047.86,3642.14 7047.86,3296.5 7074.36,3270 7085,3259.36 v1(7085,3202.26) ; v1@7078.28,3208.97 ccw(c7062.06,3225.19) 7085,3225.19 ccw(c7107.94,3225.19) v1@7091.72,3208.97 ; v1@7081.11,3206.14 ccw(c7071.72,3215.53) 7085,3215.53 ccw(c7098.28,3215.53) v1@7088.89,3206.14
  Bottom Layer w4: R295.2@7063.82,3177.5 7063.82,3181.07 v1(7085,3202.26) ; v1@7075.5,3202.26 cw(c7052.56,3202.26) 7068.78,3186.04 cw(c7085,3169.82) v1@7085,3192.76 ; v1@7079.5,3202.26 cw(c7066.22,3202.26) 7075.61,3192.87 cw(c7085,3183.48) v1@7085,3196.76
USER_LEDS.LED7.BLUE: R290.2 U8.AD27 U35.11 | length 2992.4
  Top Layer w4: v1@6031.38,3660.4 6031.38,3656.4 6032.34,3655.43 6032.53,3655.43 v1(6037.5,3660.4) 6037.5,3677.5 6054.97,3694.97 6054.97,3746.4 6010.87,3790.5 6000.89,3800.48 5901.84,3800.48 ; v1@6032.48,3668.47 ccw(c6026.86,3677.5) 6037.5,3677.5 ccw(c6048.14,3677.5) v1@6042.52,3668.47 ; v1@7014.02,3808.37 cw(c6991.09,3808.37) 7007.31,3792.16 cw(c7023.52,3775.94) v1@7023.52,3798.87 ; v1@7018.02,3808.37 cw(c7004.75,3808.37) 7014.14,3798.99 cw(c7023.52,3789.6) v1@7023.52,3802.87 ; v1(7023.52,3808.37) 7006.52,3791.37 7006.52,3296.52 7023.05,3280 7135.23,3280 7189.52,3225.71 ; 7139.99,3275.24 7140.19,3275.04 ; U35.11@7318.54,3091.27 ccw(c7315.19,3089.39) 7315.19,3093.23 ; U35.11@7318.54,3095.19 cw(c7315.19,3097.06) 7315.19,3093.23 ; U35.11@7319.2,3090.4 ccw(c7312.37,3083.57) 7312.37,3093.23 ccw(c7312.37,3102.88) U35.11@7319.2,3096.06 ; 5894.66,3803.45 cw(c5907.19,3815.98) 5889.47,3815.98 ccw(c5907.19,3815.98) 5894.66,3803.45 ; 5894.66,3803.45 ccw(c5882.13,3790.92) 5882.13,3808.64 cw(c5882.13,3790.92) 5894.66,3803.45 ; 5894.66,3803.45 ccw(c5901.84,3810.63) 5901.84,3800.48 ; 5894.66,3803.45 ccw(c5901.84,3810.63) 5901.84,3800.48 ; 7140.19,3275.04 7189.52,3225.71 ; 7140.19,3275.04 7189.52,3225.71 ; 7189.52,3225.71 7189.52,3187.02 7283.32,3093.23 7315.19,3093.23
  Bottom Layer w4: v1@6037.5,3655.43 v1(6037.5,3660.4) 6022.69,3645.59 6022.69,3640.62 6022.69,3630 6022.69,3612.5 6027.81,3607.38 6027.81,3592.19 6045.29,3574.71 6128.54,3574.71 6148.52,3594.69 ; 6141.19,3587.36 6148.52,3594.69 ; v1@7016.81,3801.66 cw(c7000.59,3785.44) 7023.52,3785.44 cw(c7046.46,3785.44) v1@7030.24,3801.66 ; v1@7019.64,3804.49 cw(c7010.25,3795.1) 7023.52,3795.1 cw(c7036.8,3795.1) v1@7027.41,3804.49 ; v1@7023.52,3813.87 ccw(c7023.52,3836.01) 7039.18,3820.36 ; v1@7023.52,3817.87 ccw(c7023.52,3849.67) 7046.01,3827.19 ; v1@7033.02,3808.37 cw(c7047.1,3808.37) 7037.15,3818.33 ; R290.2@7063.82,3845 7027.19,3808.37 v1(7023.52,3808.37) 7023.52,3780 7002.23,3758.71 6757.19,3758.71 6740.19,3741.71 6722.52,3724.04 6524.19,3724.04 6481.86,3681.71 6458.52,3681.71 6423.52,3716.71 6348.52,3716.71 6323.52,3691.71 6257.02,3691.71 6240.77,3707.96 6226.27,3707.96 6210.02,3691.71 6165.19,3691.71 6148.52,3675.04 6148.52,3605 6148.52,3594.69
USER_LEDS.LED7.GREEN: R291.2 U8.AC28 U35.13 | length 4640.1
  Top Layer w4: U8.AC28@5926.25,3850.6 U8.AC28@5921.5,3855.35 5970.97,3855.35 5975.72,3850.6 5996.02,3850.6 6024.12,3822.5 6052.63,3794 v1(6084,3794) ; U8.AC28@5926.69,3850.16 cw(c5939.22,3837.63) 5939.22,3855.35 cw(c5939.22,3873.08) U8.AC28@5926.69,3860.55 ; U35.13@7348.5,3141.71 7415.19,3141.71 7427.33,3153.85 ; U35.13@7374.98,3144.41 ccw(c7381.51,3150.93) 7381.51,3141.71 ; U35.13@7377.81,3147.24 ccw(c7391.16,3160.59) 7391.16,3141.71 ; 7436.64,3153.85 cw(c7436.64,3134.04) v1@7451.01,3147.67 ; 7437.83,3153.85 ccw(c7437.83,3168.62) v1@7448.28,3158.18 ; v1@7448.11,3144.92 ccw(c7427.33,3125.21) 7427.33,3153.85 ; v1(7455,3151.46) 7452.61,3153.85 7427.33,3153.85 ; 6061.06,3794 cw(c6061.06,3771.06) 6077.28,3787.28 ccw(c6061.06,3771.06) 6061.06,3794 ; 6061.06,3794 ccw(c6061.06,3816.93) 6077.28,3800.72 cw(c6061.06,3816.93) 6061.06,3794 ; 6070.72,3794 cw(c6070.72,3780.72) 6080.11,3790.11 ccw(c6070.72,3780.72) 6070.72,3794 ; 6070.72,3794 ccw(c6070.72,3807.28) 6080.11,3797.89 cw(c6070.72,3807.28) 6070.72,3794
  Bottom Layer w4: v1(6084,3794) 6084,3739.82 6099.61,3724.21 6114.11,3724.21 6148.27,3758.37 6265.19,3758.37 6306.86,3800.04 6331.86,3800.04 6390.19,3741.71 6440,3741.71 6449.67,3732.04 6680.52,3732.04 6715.19,3766.71 6983.19,3766.71 6998.52,3782.04 6998.52,3855.39 7089.7,3946.57 7089.7,4019.7 7111.21,4041.21 7249.11,4041.21 7305.77,4097.87 7524.87,4097.87 7525,4098 7797,4098 7825,4070 7825,3706.69 7836.69,3695 7941.86,3695 7956.86,3680 7956.86,3660 7957.19,3659.67 7957.19,3572.56 7967.5,3562.25 7967.5,3547.75 7957.19,3537.44 7957.19,3395.46 7978.69,3373.96 7978.69,3108.19 7936.72,3066.21 7797.51,3066.21 7738.73,3125 7633.69,3125 7607.23,3151.46 v1(7455,3151.46) 7455,3190 7440,3205 R291.2@7391.18,3205 ; v1@7448.28,3158.18 ccw(c7432.06,3174.39) 7455,3174.39 ccw(c7477.94,3174.39) 7461.72,3158.18 ccw(c7477.94,3174.39) 7477.94,3151.46 ccw(c7477.94,3128.52) v1@7461.72,3144.74 ; v1@7451.11,3155.35 ccw(c7441.72,3164.74) 7455,3164.74 ccw(c7468.28,3164.74) 7458.89,3155.35 ccw(c7468.28,3164.74) 7468.28,3151.46 ccw(c7468.28,3138.18) v1@7458.89,3147.57 ; 6084,3771.06 cw(c6106.93,3771.06) 6090.72,3787.28 ccw(c6106.93,3771.06) 6084,3771.06 ; 6084,3771.06 ccw(c6061.06,3771.06) 6077.28,3787.28 cw(c6061.06,3771.06) 6084,3771.06 ; 6084,3780.72 cw(c6097.28,3780.72) 6087.89,3790.11 ccw(c6097.28,3780.72) 6084,3780.72 ; 6084,3780.72 ccw(c6070.72,3780.72) 6080.11,3790.11 cw(c6070.72,3780.72) 6084,3780.72
USER_LEDS.LED7.RED: R292.2 U8.Y22 U35.9 | length 2573.6
  Top Layer w4: U8.Y22@5685.28,3966.12 cw(c5685.28,3948.4) 5697.81,3960.93 cw(c5710.34,3973.46) U8.Y22@5692.62,3973.46 ; U8.Y22@5685.28,3973.46 v3(5704.96,3953.78) ; v1(7035,3245) 7040,3250 7048.48,3250 7056.86,3258.37 7140.19,3258.37 7181.52,3217.04 7181.52,3183.71 7323.52,3041.71 7348.5,3041.71 U35.9@7348.5,3042.05 ; 7314.37,3050.86 cw(c7305.56,3042.05) U35.9@7318.02,3042.05 ; 7317.18,3048.06 ccw(c7322.02,3052.9) U35.9@7322.02,3046.05 ; 5692.16,3966.58 cw(c5679.35,3953.78) 5697.46,3953.78 ccw(c5679.35,3953.78) 5692.16,3966.58 ; 5692.16,3966.58 ccw(c5704.96,3979.39) 5704.96,3961.28 cw(c5704.96,3979.39) 5692.16,3966.58
  MidLayer2 w4: v3@5705.61,3946.31 cw(c5707.19,3928.27) 5718.83,3942.14 cw(c5730.47,3956.01) v3@5712.43,3954.43 ; 5718.54,3942.39 ccw(c5728.47,3952.32) 5728.47,3938.27 5822.01,3938.27 5995.73,3938.27 6000,3934 6000,3917 6043.5,3873.5 6045.25,3873.5 6055.5,3863.25 6055.5,3835.31 6066.62,3824.19 6096.38,3824.19 6110.69,3838.5 6249.13,3838.5 6272.31,3815.31 6392.69,3815.31 6408.37,3831 6757.59,3831 6782.02,3806.56 6782.02,3793.13 6800.11,3775.04 6903.65,3775.04 7039.86,3638.83 7039.86,3263.29 7035,3258.43 v1(7035,3245)
  Bottom Layer w4: v1(7035,3245) 7055,3245 ; v1@7039.26,3241.53 cw(c7046.58,3235.56) 7046.58,3245 cw(c7046.58,3254.44) v1@7039.26,3248.47 ; v1@7042.36,3239 cw(c7055,3228.7) 7055,3245 ; v1@7042.36,3251 ccw(c7055,3261.3) 7055,3245 ; R292.2@7063.82,3226.88 7063.82,3236.18 7055,3245
VBATT: BT1.1 D8.2 TP12.1 | length 3690.2
  Top Layer w4: TP12.1@3564.05,3433.5 ccw(c3554.92,3452.64) 3576.12,3452.64 ; TP12.1@3565.78,3429.89 ccw(c3557.95,3446.29) 3576.12,3446.29 ccw(c3594.3,3446.29) TP12.1@3586.46,3429.89 ; TP12.1@3567.5,3426.28 ccw(c3560.97,3439.95) 3576.12,3439.95 ccw(c3591.27,3439.95) TP12.1@3584.74,3426.28 ; TP12.1@3576.12,3408.23 3576.12,3452.64 ; TP12.1@3588.19,3433.5 cw(c3597.33,3452.64) 3576.12,3452.64 ; BT1.1@3721.44,4669.07 cw(c3717.53,4655.42) 3731.73,4655.42 ; BT1.1@3722.54,4672.92 cw(c3719.05,4660.73) 3731.73,4660.73 cw(c3744.41,4660.73) BT1.1@3740.92,4672.92 ; BT1.1@3731.73,4705 3731.73,4655.42 ; BT1.1@3742.02,4669.07 ccw(c3745.93,4655.42) 3731.73,4655.42 ; v1@4315,4350.5 cw(c4315,4325.15) 4332.92,4343.08 ; v1@4315,4354.5 cw(c4315,4338.81) 4326.1,4349.9 ; v1(4315,4360) 4316,4360 4378.5,4297.5 4551.06,4297.5 4604,4244.57 D8.2@4615.59,4244.57 ; v1@4320.5,4360 ccw(c4331.36,4360) 4323.68,4352.32 ; v1@4324.5,4360 ccw(c4345.02,4360) 4330.51,4345.49 ; 4568.97,4279.59 ccw(c4615.59,4326.21) D8.2@4615.59,4260.28 ; 4575.8,4272.77 ccw(c4615.59,4312.56) D8.2@4615.59,4256.28 ; 4582.63,4265.94 ccw(c4615.59,4298.9) D8.2@4615.59,4252.28 ; 4589.46,4259.11 ccw(c4615.59,4285.24) D8.2@4615.59,4248.28 ; 4596.28,4252.28 ccw(c4615.59,4271.59) D8.2@4615.59,4244.28 ; 4603.11,4245.45 ccw(c4615.59,4257.93) D8.2@4615.59,4240.28 ; D8.2@4608.11,4241.73 ccw(c4604,4240.17) 4604,4244.57 ccw(c4604,4248.97) D8.2@4608.11,4247.4 ; 3576.12,3452.64 3565.19,3463.57 3565.19,3803.02 3705.04,3942.87 3757.19,3995.02 3757.19,4089.37 3673.52,4173.04 3673.52,4189.71 3723.52,4239.71 3723.52,4647.21 3731.73,4655.42
  MidLayer1 w4: BT1.1@3731.73,4705 3998.69,4705 4298.75,4404.94 ; BT1.1@3744.01,4692.72 cw(c3773.67,4663.07) 3773.67,4705 cw(c3773.67,4746.94) BT1.1@3744.01,4717.28 ; BT1.1@3746.84,4689.89 cw(c3783.32,4653.41) 3783.32,4705 cw(c3783.32,4756.59) BT1.1@3746.84,4720.11 ; BT1.1@3749.67,4687.06 cw(c3792.98,4643.75) 3792.98,4705 cw(c3792.98,4766.25) BT1.1@3749.67,4722.94 ; BT1.1@3752.5,4684.23 cw(c3802.64,4634.09) 3802.64,4705 cw(c3802.64,4775.91) BT1.1@3752.5,4725.77 ; BT1.1@3755.33,4681.4 cw(c3812.29,4624.44) 3812.29,4705 cw(c3812.3,4785.56) BT1.1@3755.33,4728.6 ; BT1.1@3758.16,4678.58 cw(c3821.95,4614.78) 3821.95,4705 cw(c3821.95,4795.22) BT1.1@3758.16,4731.42 ; v1@4308.28,4366.72 ccw(c4292.06,4382.93) 4315,4382.93 ccw(c4337.93,4382.93) v1@4321.72,4366.72 ; v1@4311.11,4363.89 ccw(c4301.72,4373.28) 4315,4373.28 ccw(c4328.28,4373.28) v1@4318.89,4363.89 ; v1(4315,4360) 4315,4388.69 ; 4298.75,4404.94 4315,4388.69 ; 4298.75,4404.94 4315,4388.69
VCCA_PLL1: C343.1 C344.1 C345.1 C346.1 L4.2 U8.Y8 | length 881
  Top Layer w4: v3(5114.41,3953.78) U8.Y8@5134.09,3973.46 ; U8.Y8@5126.75,3973.46 cw(c5109.03,3973.46) 5121.56,3960.93 cw(c5134.09,3948.4) U8.Y8@5134.09,3966.12 ; 5127.21,3966.58 cw(c5114.41,3979.39) 5114.41,3961.28 ccw(c5114.41,3979.39) 5127.21,3966.58 ; 5127.21,3966.58 ccw(c5140.02,3953.78) 5121.91,3953.78 cw(c5140.02,3953.78) 5127.21,3966.58
  Bottom Layer w9: C343.1@4955.94,4190 4976.94,4211 5055.02,4211 C344.1@5076.02,4190 ; C343.1@4955.94,4197.31 ccw(c4955.94,4214.96) 4968.43,4202.48 ccw(c4980.91,4190) C343.1@4963.26,4190 ; C344.1@5068.71,4190 ccw(c5051.06,4190) 5063.54,4202.48 ccw(c5076.02,4214.96) C344.1@5076.02,4197.31
  Bottom Layer w10: L4.2@4918.54,4190 C343.1@4955.94,4190 ; L4.2@4923.36,4185.18 cw(c4934.99,4173.56) 4934.99,4190 cw(c4934.99,4206.44) L4.2@4923.36,4194.82 ; C343.1@4951.13,4185.18 ccw(c4939.5,4173.56) 4939.5,4190 ccw(c4939.5,4206.44) C343.1@4951.13,4194.82 ; C344.1@5076.02,4190 C345.1@5113.43,4190 ; C344.1@5080.84,4185.18 cw(c5092.47,4173.56) 5092.47,4190 cw(c5092.47,4206.44) C344.1@5080.84,4194.82 ; 5094.72,4189.72 5094.72,4151.73 ccw(c5114.41,4151.73) 5114.41,4132.04 5193.15,4132.04 cw(c5193.15,4112.36) 5212.84,4112.36 5212.84,4031.42 cw(c5193.15,4031.42) 5193.15,4011.73 ccw(c5193.15,3992.05) 5173.46,3992.05 ; C345.1@5108.61,4185.18 ccw(c5096.98,4173.56) 5096.98,4190 ccw(c5096.98,4206.44) C345.1@5108.61,4194.82 ; C346.1@5119.88,3954.88 cw(c5139.56,3954.88) 5139.56,3974.56 5153.78,3974.56 ccw(c5153.78,3994.25) 5173.46,3994.25
VCCA_PLL2: C347.1 C348.1 C349.1 C350.1 L5.2 U8.J21 | length 895
  Top Layer w4: U8.J21@5645.91,4406.54 v3(5665.59,4426.22) ; U8.J21@5645.91,4413.88 ccw(c5645.91,4431.6) 5658.44,4419.07 ccw(c5670.97,4406.54) U8.J21@5653.25,4406.54 ; 5652.79,4413.42 cw(c5665.59,4400.61) 5665.59,4418.72 ccw(c5665.59,4400.61) 5652.79,4413.42 ; 5652.79,4413.42 ccw(c5639.98,4426.22) 5658.09,4426.22 cw(c5639.98,4426.22) 5652.79,4413.42
  Bottom Layer w4: 5649.73,4244.88 5663.66,4244.88
  Bottom Layer w9: C348.1@5703.98,4182.69 cw(c5703.98,4165.04) 5716.46,4177.52 cw(c5728.94,4190) C348.1@5711.29,4190 ; C348.1@5703.98,4190 5724.98,4169 5803.06,4169 C347.1@5824.06,4190 ; C347.1@5816.74,4190 cw(c5799.09,4190) 5811.57,4177.52 cw(c5824.06,4165.04) C347.1@5824.06,4182.69
  Bottom Layer w10: 5606.54,4385.75 cw(c5626.22,4385.75) 5626.22,4405.44 5640.44,4405.44 ccw(c5640.44,4425.12) C350.1@5660.12,4425.12 ; 5606.54,4387.95 cw(c5586.85,4387.95) 5586.85,4368.26 ccw(c5586.85,4348.58) 5567.16,4348.58 5567.16,4267.64 ccw(c5586.85,4267.64) 5586.85,4247.95 5665.59,4247.95 cw(c5665.59,4228.27) 5685.28,4228.27 5685.28,4190.28 ; C349.1@5666.57,4190 C348.1@5703.98,4190 ; C349.1@5671.39,4185.18 cw(c5683.02,4173.56) 5683.02,4190 cw(c5683.02,4206.44) C349.1@5671.39,4194.82 ; C348.1@5699.16,4185.18 ccw(c5687.53,4173.56) 5687.53,4190 ccw(c5687.53,4206.44) C348.1@5699.16,4194.82 ; C347.1@5824.06,4190 L5.2@5861.46,4190 ; C347.1@5828.87,4185.18 cw(c5840.5,4173.56) 5840.5,4190 cw(c5840.5,4206.44) C347.1@5828.87,4194.82 ; L5.2@5856.64,4185.18 ccw(c5845.01,4173.56) 5845.01,4190 ccw(c5845.01,4206.44) L5.2@5856.64,4194.82
VCCA_PLL3: C351.1 C352.1 C353.1 C354.1 L6.2 U8.J8 | length 884.4
  Top Layer w4: v3(5114.41,4426.22) U8.J8@5134.09,4406.54 ; U8.J8@5126.75,4406.54 ccw(c5109.03,4406.54) 5121.56,4419.07 ccw(c5134.09,4431.6) U8.J8@5134.09,4413.88 ; 5127.21,4413.42 cw(c5140.02,4426.22) 5121.91,4426.22 ccw(c5140.02,4426.22) 5127.21,4413.42 ; 5127.21,4413.42 ccw(c5114.41,4400.61) 5114.41,4418.72 cw(c5114.41,4400.61) 5127.21,4413.42
  Bottom Layer w9: C352.1@5390,4503.98 5411,4524.98 5411,4603.06 C351.1@5390,4624.06 ; C352.1@5390,4511.29 ccw(c5390,4528.94) 5402.48,4516.46 ccw(c5414.96,4503.98) C352.1@5397.31,4503.98 ; C351.1@5390,4616.74 cw(c5390,4599.09) 5402.48,4611.57 cw(c5414.96,4624.06) C351.1@5397.31,4624.06
  Bottom Layer w10: C354.1@5121.25,4426.22 ccw(c5140.94,4426.22) 5140.94,4406.54 5154.88,4406.54 cw(c5154.88,4386.85) 5174.56,4386.85 ccw(c5194.25,4386.85) 5194.25,4367.17 5311.26,4367.16 ccw(c5311.26,4386.85) 5330.95,4386.85 5330.95,4465.59 cw(c5350.63,4465.59) 5350.63,4485.28 5387.09,4485.28 ; C353.1@5385.18,4471.39 ccw(c5373.56,4483.02) 5390,4483.02 ccw(c5406.44,4483.02) C353.1@5394.82,4471.39 ; C352.1@5385.18,4499.16 cw(c5373.56,4487.53) 5390,4487.53 cw(c5406.44,4487.53) C352.1@5394.82,4499.16 ; C351.1@5385.18,4628.87 ccw(c5373.56,4640.5) 5390,4640.5 ccw(c5406.44,4640.5) C351.1@5394.82,4628.87 ; L6.2@5385.18,4656.64 cw(c5373.56,4645.01) 5390,4645.01 cw(c5406.44,4645.01) L6.2@5394.82,4656.64 ; C353.1@5390,4466.57 C352.1@5390,4503.98 ; C351.1@5390,4624.06 L6.2@5390,4661.46
VCCA_PLL4: C355.1 C356.1 C357.1 C358.1 L7.2 U8.Y21 | length 884.4
  Top Layer w4: U8.Y21@5645.91,3966.12 cw(c5645.91,3948.4) 5658.44,3960.93 cw(c5670.97,3973.46) U8.Y21@5653.25,3973.46 ; U8.Y21@5645.91,3973.46 v3(5665.59,3953.78) ; 5652.79,3966.58 cw(c5639.98,3953.78) 5658.09,3953.78 ccw(c5639.98,3953.78) 5652.79,3966.58 ; 5652.79,3966.58 ccw(c5665.59,3979.39) 5665.59,3961.28 cw(c5665.59,3979.39) 5652.79,3966.58
  Bottom Layer w9: C355.1@5382.69,3755.94 ccw(c5365.04,3755.94) 5377.52,3768.43 ccw(c5390,3780.91) C355.1@5390,3763.26 ; C356.1@5382.69,3876.02 cw(c5365.04,3876.02) 5377.52,3863.54 cw(c5390,3851.06) C356.1@5390,3868.71 ; C355.1@5390,3755.94 5369,3776.94 5369,3855.02 C356.1@5390,3876.02
  Bottom Layer w10: L7.2@5385.18,3723.36 ccw(c5373.56,3734.99) 5390,3734.99 ccw(c5406.44,3734.99) L7.2@5394.82,3723.36 ; C355.1@5385.18,3751.13 cw(c5373.56,3739.5) 5390,3739.5 cw(c5406.44,3739.5) C355.1@5394.82,3751.13 ; C356.1@5385.18,3880.84 ccw(c5373.56,3892.47) 5390,3892.47 ccw(c5406.44,3892.47) C356.1@5394.82,3880.84 ; C357.1@5385.18,3908.61 cw(c5373.56,3896.98) 5390,3896.98 cw(c5406.44,3896.98) C357.1@5394.82,3908.61 ; L7.2@5390,3718.54 C355.1@5390,3755.94 ; C356.1@5390,3876.02 C357.1@5390,3913.43 ; 5392.91,3894.72 5410,3894.72 5429.37,3894.72 ccw(c5429.37,3914.41) 5449.06,3914.41 5449.05,3993.15 cw(c5468.74,3993.15) 5468.74,4012.83 5586.85,4012.83 cw(c5586.85,3993.15) 5606.54,3993.15 ccw(c5626.22,3993.15) 5626.22,3973.46 5639.06,3973.46 cw(c5639.06,3953.78) C358.1@5658.75,3953.78
VCCA_PLL5: C359.1 C360.1 C361.1 C362.1 L8.2 U30.L5 | length 3633.4
  Top Layer w4: v3(6852.52,1746.89) U30.L5@6872.2,1766.57 ; U30.L5@6864.86,1766.57 cw(c6847.14,1766.57) 6859.67,1754.04 cw(c6872.2,1741.51) U30.L5@6872.2,1759.23 ; 6865.32,1759.69 cw(c6852.52,1772.5) 6852.52,1754.39 ccw(c6852.52,1772.5) 6865.32,1759.69 ; 6865.32,1759.69 ccw(c6878.13,1746.89) 6860.02,1746.89 cw(c6878.13,1746.89) 6865.32,1759.69
  Top Layer w8: v2(6602,1516) 6630.98,1516 6701.5,1445.48 6701.5,1317.83 6701.81,1317.52 6701.81,1310.59 6708.9,1303.5 6709.39,1303.5 6740.19,1272.7 6740.19,1241.79 6751.79,1230.19 6808.21,1230.19 v2(6838,1260) ; v2@6607.52,1510.48 cw(c6620.86,1497.14) 6620.86,1516 cw(c6620.86,1534.86) v2@6607.52,1521.52 ; 6824.65,1246.64 ccw(c6811.29,1260) v2@6830.19,1260 ; 6824.69,1246.68 cw(c6838,1233.37) v2@6838,1252.19
  MidLayer1 w8: v2@6496.48,1724.48 cw(c6483.14,1711.14) 6502,1711.14 cw(c6520.86,1711.14) v2@6507.52,1724.48 ; v2(6502,1730) 6502,1710 6520.19,1691.81 6526.21,1691.81 6542,1676.02 6542,1641.02 6590.81,1592.21 6590.81,1527.19 v2(6602,1516) ; v2@6832.48,1254.48 cw(c6819.14,1241.14) 6838,1241.14 cw(c6856.86,1241.14) v2@6843.52,1254.48 ; v2(6838,1260) 6838,1230.34 6846.35,1221.99 6846.35,1219.76 6852.5,1213.61 6865.6,1200.51 6965.92,1100.19 7116.19,1100.19 v2(7194,1178) ; v2@7186.19,1178 cw(c7167.33,1178) 7180.67,1164.67 cw(c7194,1151.33) v2@7194,1170.19
  MidLayer2 w4: v2(6502,1730) 6504,1730 6561.5,1672.5 6608.5,1672.5 6667.14,1731.14 6828.72,1731.14 ccw(c6828.72,1745.18) 6838.65,1735.25 ; v3@6845.05,1747.54 cw(c6827.01,1749.12) 6838.65,1735.25 ; v3@6851.87,1739.42 ccw(c6850.29,1721.38) 6838.65,1735.25
  MidLayer2 w8: v1(7424,1750) 7440.67,1750 ; v1@7429.61,1745.03 cw(c7440.67,1735.23) 7440.67,1750 ; v1@7429.61,1754.97 ccw(c7440.67,1764.77) 7440.67,1750 ; v1@7809.61,1745.89 ccw(c7796.81,1733.09) 7796.81,1751.19 ccw(c7796.81,1769.3) v1@7809.61,1756.5 ; v1(7814.91,1751.19) 7774.62,1751.19 7770.47,1755.34 7769.53,1755.34 7735,1755.34 7650,1755.34 7586.07,1755.34 7503.92,1755.34 7496.77,1748.19 7442.48,1748.19 7440.67,1750
  Bottom Layer w8: v2@7188.48,1183.52 ccw(c7175.14,1196.86) 7194,1196.86 ccw(c7212.86,1196.86) v2@7199.52,1183.52 ; v2(7194,1178) 7194,1241.98 7180,1255.98 7180,1297.11 7170.5,1306.61 7170.5,1375.94 7199.06,1404.5 7214.3,1404.5 7364,1554.2 7364,1692 7381.81,1709.81 7405.81,1709.81 7424,1728 v1(7424,1750) ; v1@7418.7,1744.7 cw(c7405.89,1731.89) 7424,1731.89 cw(c7442.11,1731.89) v1@7429.3,1744.7 ; 7670.33,1734 7728,1734 7748,1714 7780,1714 7814.91,1748.91 v1(7814.91,1751.19) ; 7800.5,1734.5 ccw(c7783.8,1751.19) v1@7807.41,1751.19 ; 7806,1740 cw(c7814.91,1731.09) v1@7814.91,1743.69
  Bottom Layer w12: L8.2@7666.22,1717.11 ccw(c7656.3,1727.03) 7670.33,1727.03 ccw(c7684.36,1727.03) L8.2@7674.44,1717.11 ; C360.1@7666.22,1751.64 cw(c7656.3,1741.72) 7670.33,1741.72 cw(c7684.36,1741.72) C360.1@7674.44,1751.64 ; C360.1@7666.22,1759.86 ccw(c7656.3,1769.78) 7670.33,1769.78 ccw(c7684.36,1769.78) C360.1@7674.44,1759.86 ; C361.1@7666.22,1794.39 cw(c7656.3,1784.47) 7670.33,1784.47 cw(c7684.36,1784.47) C361.1@7674.44,1794.39 ; C361.1@7666.22,1802.61 ccw(c7656.3,1812.53) 7670.33,1812.53 ccw(c7684.36,1812.53) C361.1@7674.44,1802.61 ; C362.1@7666.22,1837.14 cw(c7656.3,1827.22) 7670.33,1827.22 cw(c7684.36,1827.22) C362.1@7674.44,1837.14 ; C362.1@7666.22,1845.36 ccw(c7656.3,1855.28) 7670.33,1855.28 ccw(c7684.36,1855.28) C362.1@7674.44,1845.36 ; C359.1@7666.22,1879.89 cw(c7656.3,1869.97) 7670.33,1869.97 cw(c7684.36,1869.97) C359.1@7674.44,1879.89 ; L8.2@7670.33,1713 7670.33,1734 C360.1@7670.33,1755.75 ; C360.1@7670.33,1756 C359.1@7670.33,1884
VCCA_PLL6: C363.1 C364.1 C365.1 C366.1 L9.2 U30.F12 | length 1296.8
  Top Layer w4: U30.F12@7147.8,1963.43 v3(7167.48,1983.11) ; U30.F12@7147.8,1970.77 ccw(c7147.8,1988.49) 7160.33,1975.96 ccw(c7172.86,1963.42) U30.F12@7155.14,1963.42 ; 7154.68,1970.31 cw(c7167.48,1957.5) 7167.48,1975.61 ccw(c7167.48,1957.5) 7154.68,1970.31 ; 7154.68,1970.31 ccw(c7141.87,1983.11) 7159.98,1983.11 cw(c7141.87,1983.11) 7154.68,1970.31
  MidLayer2 w4: v3@7168.13,1990.58 ccw(c7169.71,2008.62) 7181.35,1994.75 ccw(c7192.99,1980.88) v3@7174.95,1982.46 ; 7181.06,1994.5 cw(c7190.99,1984.57) 7190.99,1998.62 7284.53,1998.62 7357.38,1998.62 7370.19,1985.81 7406.19,1985.81 7451,1941 v2@7482,1941 ; 7468.36,1941 ccw(c7468.36,1966.33) v2@7486.27,1948.42 ; 7470.68,1941 cw(c7470.68,1918.95) v2@7486.27,1934.54 ; 7478.02,1941 ccw(c7478.02,1956.67) v2@7489.1,1945.59 ; 7480.34,1941 cw(c7480.34,1928.61) v2@7489.1,1937.37
  Bottom Layer w4: v2(7493.21,1941.48) 7493.21,1942.94 7506.64,1929.51 7509.64,1926.51 7557.43,1926.51 7567.44,1916.5 7573.07,1916.5 7605.57,1884 C366.1@7612.67,1884 ; 7583.79,1905.77 ccw(c7612.67,1934.65) C366.1@7612.67,1893.81 ; 7590.62,1898.94 ccw(c7612.67,1920.99) C366.1@7612.67,1889.81 ; 7597.45,1892.11 ccw(c7612.67,1907.33) C366.1@7612.67,1885.81 ; C366.1@7600.94,1888.62 cw(c7596.32,1884) C366.1@7602.86,1884
  Bottom Layer w10: v2(7493.21,1941.48) 7505.17,1929.51 7506.64,1929.51 7558.67,1929.51 7569.21,1918.97 7577.7,1918.97 C366.1@7612.67,1884 C364.1@7612.67,1798.5 L9.2@7612.67,1713 ; C366.1@7605.86,1884 ccw(c7589.41,1884) 7601.04,1895.63 ccw(c7612.67,1907.25) C366.1@7612.67,1890.81 ; L9.2@7607.85,1717.82 ccw(c7596.23,1729.44) 7612.67,1729.44 ccw(c7629.11,1729.44) L9.2@7617.49,1717.82 ; C363.1@7607.85,1750.93 cw(c7596.23,1739.31) 7612.67,1739.31 cw(c7629.11,1739.31) C363.1@7617.49,1750.93 ; C363.1@7607.85,1760.57 ccw(c7596.23,1772.19) 7612.67,1772.19 ccw(c7629.11,1772.19) C363.1@7617.49,1760.57 ; C364.1@7607.85,1793.68 cw(c7596.23,1782.06) 7612.67,1782.06 cw(c7629.11,1782.06) C364.1@7617.49,1793.68 ; C364.1@7607.85,1803.32 ccw(c7596.23,1814.94) 7612.67,1814.94 ccw(c7629.11,1814.94) C364.1@7617.49,1803.32 ; C365.1@7607.85,1836.43 cw(c7596.23,1824.81) 7612.67,1824.81 cw(c7629.11,1824.81) C365.1@7617.49,1836.43 ; C365.1@7607.85,1846.07 ccw(c7596.23,1857.69) 7612.67,1857.69 ccw(c7629.11,1857.69) C365.1@7617.49,1846.07 ; C366.1@7607.85,1879.18 cw(c7596.23,1867.56) 7612.67,1867.56 cw(c7629.11,1867.56) C366.1@7617.49,1879.18
VGA.BLUE0: U8.H12 U21.8 | length 1616.6
  Top Layer w4: v3(5271.89,4465.59) U8.H12@5291.57,4445.91 ; U8.H12@5284.23,4445.91 ccw(c5266.51,4445.91) 5279.04,4458.44 ccw(c5291.57,4470.97) U8.H12@5291.57,4453.25 ; 5284.69,4452.79 cw(c5297.5,4465.59) 5279.39,4465.59 ccw(c5297.5,4465.59) 5284.69,4452.79 ; 5284.69,4452.79 ccw(c5271.89,4439.98) 5271.89,4458.09 cw(c5271.89,4439.98) 5284.69,4452.79
  MidLayer1 w4: v1@5205.69,4937.37 ccw(c5182.76,4937.37) 5198.97,4953.59 ccw(c5215.19,4969.81) v1@5215.19,4946.87 ; v1@5209.69,4937.37 ccw(c5196.41,4937.37) 5205.8,4946.76 ccw(c5215.19,4956.15) v1@5215.19,4942.87 ; v1@5351.5,5528 cw(c5328.56,5528) 5344.78,5511.78 cw(c5361,5495.56) v1@5361,5518.5 ; v1@5355.5,5528 cw(c5342.22,5528) 5351.61,5518.61 cw(c5361,5509.22) v1@5361,5522.5 ; v1(5361,5528) 5248.52,5415.52 5248.52,5216.74 5214.36,5182.57 5198.19,5166.4 5198.19,4954.37 v1@5214.36,4938.21 ; v1@5214.36,4938.21 v1(5215.19,4937.37) v1@5214.36,4938.21
  MidLayer2 w4: v1@5215.19,4927.87 cw(c5215.19,4904.94) 5231.41,4921.16 cw(c5247.63,4937.37) v1@5224.69,4937.37 ; v1@5215.19,4931.87 cw(c5215.19,4918.6) 5224.58,4927.99 cw(c5233.97,4937.37) v1@5220.69,4937.37 ; v1(5215.19,4937.37) 5240,4912.56 5240,4895 ; 5248.03,4738.53 5248.03,4680.27 ; v3@5264.42,4466.24 ccw(c5246.38,4467.82) 5260.25,4479.46 ; v3@5272.54,4473.06 cw(c5274.12,4491.1) 5260.25,4479.46 ; 5225,4880 5240,4895 ; 5225,4880 5225,4785 5237.29,4772.71 5242.29,4772.71 5248.03,4766.97 5248.03,4760.66 5248.03,4749.18 5248.03,4741.18 5248.03,4680.27 ; 5225,4880 5240,4895 ; 5248.03,4680.27 5248.03,4622.01 5248.03,4602.59 5248.03,4528.47 5248.03,4508.97 ccw(c5289.76,4508.97) 5260.25,4479.46
  Bottom Layer w4: U21.8@5312.32,5540.47 5346.09,5540.47 5358.56,5528 v1(5361,5528) ; U21.8@5338.68,5537.64 cw(c5345.51,5530.82) 5345.51,5540.47 cw(c5345.51,5550.13) U21.8@5338.68,5543.3
VGA.BLUE1: U8.F11 U21.7 | length 1657.1
  Top Layer w4: v3(5232.52,4544.33) U8.F11@5252.2,4524.65 ; U8.F11@5244.86,4524.65 ccw(c5227.14,4524.65) 5239.67,4537.18 ccw(c5252.2,4549.71) U8.F11@5252.2,4531.99 ; v1@5383.28,5558.28 cw(c5366.61,5541.61) 5390.19,5541.61 ; v1@5386.11,5561.11 cw(c5376.26,5551.26) 5390.19,5551.26 ; v1@5387.48,5565 v1(5390,5565) ; 5390.19,5542.52 cw(c5412.48,5542.52) v1@5396.72,5558.28 ; 5390.19,5552.18 cw(c5402.82,5552.18) v1@5393.89,5561.11 ; v1@5390.19,5565 5390.19,5370.04 5385.52,5365.37 5385.52,5281.37 5406.86,5260.04 5407.35,5259.55 5407.35,5176.29 5402.81,5171.75 5402.81,5137.42 v1(5423.52,5116.71) ; v1@5414.02,5116.71 ccw(c5391.09,5116.71) 5407.31,5132.93 ccw(c5423.52,5149.14) v1@5423.52,5126.21 ; v1@5418.02,5116.71 ccw(c5404.75,5116.71) 5414.14,5126.1 ccw(c5423.52,5135.49) v1@5423.52,5122.21 ; 5245.32,4531.53 cw(c5258.13,4544.33) 5240.02,4544.33 ccw(c5258.13,4544.33) 5245.32,4531.53 ; 5245.32,4531.53 ccw(c5232.52,4518.72) 5232.52,4536.83 cw(c5232.52,4518.72) 5245.32,4531.53
  MidLayer1 w4: 5208.66,4621.14 5208.66,4607.21 ; v3@5225.05,4544.98 ccw(c5207.01,4546.56) 5220.88,4558.2 ; v3@5233.17,4551.8 cw(c5234.75,4569.84) 5220.88,4558.2 ; v1@5416.54,5110.27 ccw(c5401.86,5096.75) 5401.86,5116.71 ; v1@5416.54,5123.14 cw(c5401.86,5136.66) 5401.86,5116.71 ; v1@5419.48,5112.98 ccw(c5410.98,5105.15) 5410.98,5116.71 ccw(c5410.98,5128.26) v1@5419.48,5120.43 ; v1(5423.52,5116.71) 5401.86,5116.71 ; 5208.66,4607.21 5208.66,4681.33 5208.66,4700.75 5208.66,4741.18 5208.66,4749.18 5208.66,4794.16 5209.5,4795 5209.5,4808.19 5211.31,4810 5260,4810 5305.52,4855.52 5305.52,5020.37 5401.86,5116.71 ; 5208.66,4607.21 5208.66,4587.71 ccw(c5250.39,4587.71) 5220.88,4558.2
  Bottom Layer w4: U21.7@5312.32,5560.16 5348.52,5560.16 5349.31,5559.37 5384.37,5559.37 v1(5390,5565) ; U21.7@5338.68,5557.33 cw(c5345.51,5550.5) 5345.51,5560.16 cw(c5345.51,5569.82) U21.7@5338.68,5562.99 ; 5353.48,5559.37 ccw(c5353.48,5601.52) v1@5383.28,5571.72 ; 5363.14,5559.37 ccw(c5363.14,5591.86) v1@5386.11,5568.89 ; 5372.8,5559.37 ccw(c5372.8,5582.2) v1@5388.94,5566.06
VGA.BLUE2: U8.J12 U21.6 | length 1847.3
  Top Layer w4: v3(5271.89,4426.22) U8.J12@5291.57,4406.54 ; U8.J12@5284.23,4406.54 ccw(c5266.51,4406.53) 5279.04,4419.07 ccw(c5291.57,4431.6) U8.J12@5291.57,4413.88 ; 5284.69,4413.42 cw(c5297.5,4426.22) 5279.39,4426.22 ccw(c5297.5,4426.22) 5284.69,4413.42 ; 5284.69,4413.42 ccw(c5271.89,4400.61) 5271.89,4418.72 cw(c5271.89,4400.61) 5284.69,4413.42
  MidLayer1 w4: v1@5116.19,5125.04 v1@5116.23,5125 ; v1@5120,5115.5 cw(c5120,5101.66) 5129.78,5111.45 ; v1(5120,5125) v1@5116.23,5125 ; v1@5125.5,5125 ccw(c5147.88,5125) 5132.05,5109.18 ; v1@5129.5,5125 ccw(c5161.53,5125) 5138.88,5102.35 ; v1@5153.28,4941.72 ccw(c5144.65,4950.35) 5156.86,4950.35 ; 5156.86,4946.21 ccw(c5171.21,4946.21) v1@5161.06,4936.06 ; 5156.86,4955.87 ccw(c5180.87,4955.87) v1@5163.89,4938.89 ; 5156.86,4965.52 ccw(c5190.52,4965.52) v1@5166.72,4941.72 ; v1(5160,4935) 5158.9,4935 5156.86,4937.04 5156.86,5084.37 5118.12,5123.12 v1@5116.23,5125
  Bottom Layer w4: v1@5123.89,5121.11 cw(c5133.38,5111.62) 5133.38,5125.04 ; v1@5123.89,5128.89 ccw(c5133.18,5138.18) 5133.18,5125.04 ; v1@5126.72,5118.28 cw(c5143.03,5101.97) 5143.03,5125.04 ; v1@5126.72,5131.72 ccw(c5142.84,5147.84) 5142.84,5125.04 ; v1@5159.45,4934.45 5158.9,4935 v1(5160,4935) 5187.82,4962.82 5232.18,4962.82 5244.02,4950.98 5244.02,4920.87 5262.02,4902.87 5262.02,4898.62 5262.02,4895 5262.02,4855.98 5266.02,4851.98 5266.02,4786.28 5256.38,4776.63 5256.38,4751.18 5256.38,4741.18 5256.38,4718.05 5256.38,4543.27 5256.38,4449.73 ccw(c5270.43,4449.73) 5260.5,4439.8 ; v1@5160,4940.5 ccw(c5160,4953.78) 5169.39,4944.39 ccw(c5178.78,4935) v1@5165.5,4935 ; v1@5160,4944.5 ccw(c5160,4967.43) 5176.22,4951.22 ccw(c5192.43,4935) v1@5169.5,4935 ; v3@5264.42,4426.87 ccw(c5246.38,4428.45) 5260.25,4440.09 ccw(c5274.12,4451.73) v3@5272.54,4433.69 ; U21.6@5285.97,5577.01 ccw(c5279.14,5570.19) 5279.14,5579.84 ccw(c5279.14,5589.5) U21.6@5285.97,5582.67 ; U21.6@5312.32,5579.84 5274.84,5579.84 5273.52,5578.52 5273.52,5341.71 5315.19,5300.04 5315.19,5275.29 5164.94,5125.04 v1@5120.04,5125.04 ; v1(5120,5125) v1@5120.04,5125.04