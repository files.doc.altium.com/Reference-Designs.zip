# Altium PCB NB3000AL.PcbDoc (part 16 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.UIO.IO6: J33.A18 PROTOTYPE1.H5 U8.L7 UH1.8 | length 9991.4
  Top Layer w4: J33.A18@-785.98,3519 -712,3519 -695,3502 -631.69,3502 -625.31,3508.37 v1(-601.48,3508.37) ; J33.A18@-716.6,3515.25 cw(c-714.64,3500.26) J33.A18@-703.95,3510.95 ; J33.A18@-716.08,3511.29 cw(c-713.32,3490.09) -698.21,3505.21 ; J33.A18@-705.3,3519 ccw(c-689.13,3519) -700.57,3507.57 ; v1@-608.19,3501.66 ccw(c-624.41,3485.44) -624.41,3508.37 ccw(c-624.41,3531.31) v1@-608.19,3515.09 ; v1@-605.36,3504.49 ccw(c-614.75,3495.1) -614.75,3508.37 ccw(c-614.75,3521.65) v1@-605.36,3512.26 ; PROTOTYPE1.H5@655.62,4228.74 ccw(c606.11,4278.25) 676.12,4278.25 ccw(c746.13,4278.25) PROTOTYPE1.H5@696.63,4228.74 ; PROTOTYPE1.H5@658.44,4225.91 ccw(c615.77,4268.59) 676.12,4268.59 ccw(c736.48,4268.59) PROTOTYPE1.H5@693.8,4225.91 ; PROTOTYPE1.H5@661.27,4223.08 ccw(c625.42,4258.93) 676.12,4258.93 ccw(c726.82,4258.93) PROTOTYPE1.H5@690.97,4223.08 ; PROTOTYPE1.H5@664.1,4220.26 ccw(c635.08,4249.28) 676.12,4249.28 ccw(c717.16,4249.28) PROTOTYPE1.H5@688.14,4220.26 ; PROTOTYPE1.H5@666.93,4217.43 ccw(c644.74,4239.62) 676.12,4239.62 ccw(c707.51,4239.62) PROTOTYPE1.H5@685.31,4217.43 ; PROTOTYPE1.H5@676.12,4208.23 676.12,4301.12 890,4515 1113.48,4515 1155.45,4556.96 1215.19,4616.71 1215.19,4752.3 UH1.8@1276.12,4813.23 ; UH1.8@1248.59,4813.23 cw(c1182.14,4813.23) 1229.13,4766.24 cw(c1276.12,4719.25) UH1.8@1276.12,4785.71 ; UH1.8@1252.59,4813.23 cw(c1195.79,4813.23) 1235.96,4773.07 cw(c1276.12,4732.91) UH1.8@1276.12,4789.71 ; UH1.8@1256.59,4813.23 cw(c1209.45,4813.23) 1242.79,4779.9 cw(c1276.12,4746.56) UH1.8@1276.12,4793.71 ; UH1.8@1260.59,4813.23 cw(c1223.11,4813.23) 1249.61,4786.73 cw(c1276.12,4760.22) UH1.8@1276.12,4797.71 ; v3(5075.04,4347.48) U8.L7@5094.72,4327.8 ; U8.L7@5087.38,4327.8 ccw(c5069.66,4327.8) 5082.19,4340.33 ccw(c5094.72,4352.86) U8.L7@5094.72,4335.14 ; 5087.84,4334.68 cw(c5100.65,4347.48) 5082.54,4347.48 ccw(c5100.65,4347.48) 5087.84,4334.68 ; 5087.84,4334.68 ccw(c5075.04,4321.87) 5075.04,4339.98 cw(c5075.04,4321.87) 5087.84,4334.68
  MidLayer1 w4: PROTOTYPE1.H5@676.12,4208.23 723.86,4160.5 723.86,3300.37 v1(698.52,3275.04) ; PROTOTYPE1.H5@676.57,4191.24 cw(c677.55,4153.69) 704.1,4180.25 cw(c730.66,4206.81) PROTOTYPE1.H5@693.12,4207.79 ; PROTOTYPE1.H5@676.67,4187.24 cw(c677.88,4140.86) 710.69,4173.67 cw(c743.49,4206.48) PROTOTYPE1.H5@697.11,4207.69 ; PROTOTYPE1.H5@676.77,4183.24 cw(c678.22,4128.03) 717.27,4167.08 cw(c756.33,4206.14) PROTOTYPE1.H5@701.11,4207.58 ; PROTOTYPE1.H5@676.88,4179.24 cw(c678.55,4115.2) 723.86,4160.5 cw(c769.16,4205.8) PROTOTYPE1.H5@705.11,4207.48 ; v1@698.52,3280.54 ccw(c698.52,3293.82) 707.91,3284.43 ccw(c717.3,3275.04) v1@704.02,3275.04 ; v1@698.52,3284.54 ccw(c698.52,3307.48) 714.74,3291.26 ccw(c730.96,3275.04) v1@708.02,3275.04 ; v1(1548.52,4850.04) 1568.48,4870 2715,4870 2731.86,4853.14 2731.86,4783.37 2748.52,4766.71 2905,4766.71 2925,4786.71 2925,4835 2967,4877 3741.39,4877 3851.69,4766.71 3948.29,4766.71 4364.96,4350.04 v1(4416.19,4350.04) ; v1@1548.52,4855.54 ccw(c1548.52,4868.82) 1557.91,4859.43 ccw(c1567.3,4850.04) v1@1554.02,4850.04 ; v1@1548.52,4859.54 ccw(c1548.52,4882.48) 1564.74,4866.26 ccw(c1580.96,4850.04) v1@1558.02,4850.04 ; v1@4409.47,4343.32 ccw(c4393.26,4327.11) 4393.26,4350.04 ccw(c4393.26,4372.98) v1@4409.47,4356.76 ; v1@4412.3,4346.15 ccw(c4402.91,4336.76) 4402.91,4350.04 ccw(c4402.91,4363.32) v1@4412.3,4353.93
  MidLayer2 w4: v1@-608.19,3501.66 cw(c-624.41,3485.44) -601.48,3485.44 cw(c-578.54,3485.44) v1@-594.76,3501.66 ; v1@-605.36,3504.49 cw(c-614.75,3495.1) -601.48,3495.1 cw(c-588.2,3495.1) v1@-597.59,3504.49 ; v1(-601.48,3508.37) -601.48,3473.33 -568.14,3440 -568.14,3211.04 -577.81,3201.37 -601.48,3201.37 -618.14,3184.71 -618.14,3108.37 -601.48,3091.71 -573.29,3091.71 -531.96,3133.04 -436.96,3133.04 -352,3218 -37,3218 -21.63,3233.37 440,3233.37 491.63,3285 575,3285 584.96,3275.04 v1(698.52,3275.04) ; v1@691.81,3268.32 ccw(c675.59,3252.11) 675.59,3275.04 ccw(c675.59,3297.98) v1@691.81,3281.76 ; v1@694.64,3271.15 ccw(c685.25,3261.76) 685.25,3275.04 ccw(c685.25,3288.32) v1@694.64,3278.93 ; UH1.8@1276.12,4813.23 1301.56,4838.67 1312.16,4838.67 1323.52,4850.04 v1(1548.52,4850.04) ; v1@1541.81,4843.32 ccw(c1525.59,4827.11) 1525.59,4850.04 ccw(c1525.59,4872.98) v1@1541.81,4856.76 ; v1@1544.64,4846.15 ccw(c1535.25,4836.76) 1535.25,4850.04 ccw(c1535.25,4863.32) v1@1544.64,4853.93 ; v1(4416.19,4350.04) 4442.17,4350.04 4475.57,4316.64 4524.02,4316.64 4561.92,4316.64 4609.06,4269.5 4664.25,4269.5 4674.5,4279.75 4674.5,4293.56 4689.44,4308.5 4711.75,4308.5 4729.97,4326.72 4741.34,4326.72 4755.56,4312.5 4772.25,4312.5 4782.5,4322.75 4782.5,4354.5 4790.99,4362.99 4838.82,4362.99 4841.47,4362.99 4899.73,4362.99 4957.99,4362.99 4977.41,4362.99 5037.6,4362.99 5051.53,4362.99 cw(c5051.53,4348.94) 5061.46,4358.87 ; v1@4420.08,4346.15 cw(c4429.47,4336.76) 4429.47,4350.04 cw(c4429.47,4363.32) v1@4420.08,4353.93 ; v1@4422.91,4343.32 cw(c4439.13,4327.11) 4439.13,4350.04 cw(c4439.13,4372.98) v1@4422.91,4356.76 ; v3@5067.57,4346.83 ccw(c5049.53,4345.25) 5061.17,4359.12 ccw(c5072.81,4372.99) v3@5074.39,4354.95
ATE.UIO.IO7: J33.B19 PROTOTYPE1.H6 U8.R5 UH1.9 | length 9858.3
  Top Layer w4: PROTOTYPE1.H6@776.12,4208.23 959.59,4391.71 1215.19,4391.71 1376.12,4552.64 UH1.9@1376.12,4713.23 ; PROTOTYPE1.H6@776.12,4221.23 ccw(c776.12,4252.62) 798.31,4230.43 ccw(c820.51,4208.23) PROTOTYPE1.H6@789.12,4208.23 ; PROTOTYPE1.H6@776.12,4225.23 ccw(c776.12,4266.28) 805.14,4237.26 ccw(c834.16,4208.23) PROTOTYPE1.H6@793.12,4208.23 ; PROTOTYPE1.H6@776.12,4229.23 ccw(c776.12,4279.93) 811.97,4244.08 ccw(c847.82,4208.23) PROTOTYPE1.H6@797.12,4208.23 ; PROTOTYPE1.H6@776.12,4233.23 ccw(c776.12,4293.59) 818.8,4250.91 ccw(c861.48,4208.23) PROTOTYPE1.H6@801.12,4208.23 ; PROTOTYPE1.H6@776.12,4237.23 ccw(c776.12,4307.25) 825.63,4257.74 ccw(c875.13,4208.23) PROTOTYPE1.H6@805.12,4208.23 ; UH1.9@1356.66,4693.77 cw(c1309.66,4646.78) 1376.12,4646.78 cw(c1442.58,4646.78) UH1.9@1395.59,4693.77 ; UH1.9@1359.48,4696.6 cw(c1319.32,4656.43) 1376.12,4656.43 cw(c1432.92,4656.43) UH1.9@1392.76,4696.6 ; UH1.9@1362.31,4699.43 cw(c1328.98,4666.09) 1376.12,4666.09 cw(c1423.26,4666.09) UH1.9@1389.93,4699.43 ; UH1.9@1365.14,4702.26 cw(c1338.63,4675.75) 1376.12,4675.75 cw(c1413.61,4675.75) UH1.9@1387.1,4702.26 ; v3(4996.3,4150.63) U8.R5@5015.98,4170.31 ; U8.R5@5008.64,4170.31 cw(c4990.92,4170.31) 5003.45,4157.78 cw(c5015.98,4145.25) U8.R5@5015.98,4162.97 ; 5009.1,4163.43 cw(c4996.3,4176.24) 4996.3,4158.13 ccw(c4996.3,4176.24) 5009.1,4163.43 ; 5009.1,4163.43 ccw(c5021.91,4150.63) 5003.8,4150.63 cw(c5021.91,4150.63) 5009.1,4163.43
  MidLayer1 w4: v1(145,3415) 190,3460 190,3846.87 206.19,3863.06 206.19,4285.08 446.15,4525.04 v1(542.86,4525.04) ; v1@145,3420.5 ccw(c145,3433.78) 154.39,3424.39 ccw(c163.78,3415) v1@150.5,3415 ; v1@145,3424.5 ccw(c145,3447.43) 161.22,3431.22 ccw(c177.43,3415) v1@154.5,3415 ; v1@536.14,4518.32 ccw(c519.92,4502.11) 519.92,4525.04 ccw(c519.92,4547.98) v1@536.14,4531.76 ; v1@538.97,4521.15 ccw(c529.58,4511.76) 529.58,4525.04 ccw(c529.58,4538.32) v1@538.97,4528.93 ; v1@750.86,4515.54 cw(c750.86,4478.92) 776.75,4504.82 ; v1@750.86,4519.54 cw(c750.86,4492.58) 769.92,4511.64 ; v1@750.86,4523.54 cw(c750.86,4506.24) 763.09,4518.47 cw(c769.61,4525.04) v1@760.36,4525.04 ; v1@756.52,4525.04 815.37,4466.19 815.37,4289.87 776.12,4250.62 ; PROTOTYPE1.H6@765.62,4235.27 ccw(c759.65,4250.62) 776.12,4250.62 ; PROTOTYPE1.H6@767.07,4231.54 ccw(c761.92,4244.77) 776.12,4244.77 ccw(c790.32,4244.77) PROTOTYPE1.H6@785.18,4231.54 ; PROTOTYPE1.H6@776.12,4208.23 776.12,4250.62 ; PROTOTYPE1.H6@786.63,4235.27 cw(c792.59,4250.62) 776.12,4250.62 ; UH1.9@1376.12,4713.23 1421.26,4758.37 ; UH1.9@1376.57,4728.76 ccw(c1377.55,4762.73) 1401.58,4738.7 ccw(c1425.61,4714.66) UH1.9@1391.64,4713.68 ; UH1.9@1376.69,4732.75 ccw(c1377.92,4775.48) 1408.14,4745.25 ccw(c1438.36,4715.03) UH1.9@1395.64,4713.8 ; UH1.9@1376.8,4736.75 ccw(c1378.29,4788.22) 1414.7,4751.81 ccw(c1451.11,4715.4) UH1.9@1399.64,4713.91 ; UH1.9@1376.92,4740.75 ccw(c1378.66,4800.97) 1421.26,4758.37 ; UH1.9@1403.64,4714.03 cw(c1463.86,4715.77) 1421.26,4758.37 ; v1@4499.79,4280 ccw(c4476.85,4280) 4493.07,4296.22 ccw(c4509.29,4312.43) v1@4509.29,4289.5 ; v1@4503.79,4280 ccw(c4490.51,4280) 4499.9,4289.39 ccw(c4509.29,4298.78) v1@4509.29,4285.5 ; v1(4509.29,4280) 4456.75,4332.54 4450,4332.54 4445,4332.54 4354.91,4332.54 4346.58,4324.21 4318.31,4324.21 4297.5,4345.02 4297.5,4367.25 4297.5,4394.87 4126.33,4566.04 1781.59,4566.04 1720,4627.63 1720,4745 1706.63,4758.37 1643.23,4758.37 1642.57,4759.03 1641.64,4759.03 1641.47,4759.2 1636.5,4759.2 1636.32,4759.03 1635.4,4759.03 1634.74,4758.37 1533.51,4758.37 1533.18,4758.05 1526.01,4758.05 1525.69,4758.37 1421.26,4758.37 ; v1@4762.69,4212 cw(c4762.69,4189.07) 4778.91,4205.28 cw(c4795.12,4221.5) v1@4772.19,4221.5 ; v1@4762.69,4216 cw(c4762.69,4202.72) 4772.08,4212.11 cw(c4781.47,4221.5) v1@4768.19,4221.5 ; v1(4762.69,4221.5) 4808,4176.19 4808,4138.31 4811.19,4135.12 4830.82,4135.12 4838.82,4135.12 4879.25,4135.12 4898.67,4135.12 4958.86,4135.12 4972.79,4135.12 ccw(c4972.79,4149.17) 4982.72,4139.24 ; v3@4988.83,4151.28 cw(c4970.79,4152.86) 4982.43,4138.99 cw(c4994.07,4125.12) v3@4995.65,4143.16
  MidLayer2 w4: v1@4510,4280 4530.64,4300.64 4555.29,4300.64 4572.5,4283.43 4572.5,4219.75 4572.5,4194.07 4574.06,4192.5 4584.32,4182.25 4588.06,4178.5 4603.19,4178.5 ; 4745.45,4212.51 cw(c4756.3,4201.65) v1@4761,4216.27 ; 4750.08,4217.14 cw(c4758.56,4208.66) v1@4762.23,4220.07 ; v1(4762.69,4221.5) 4754.44,4221.5 4744.94,4212 4730.75,4212 4716.25,4197.5 4683.25,4197.5 4667.75,4182 4658.06,4172.31 4627.31,4172.31 ; 4603.19,4178.5 4615.59,4166.09 ; 4603.19,4178.5 4615.59,4166.09 ; 4615.59,4166.09 4620.84,4166.09 ; 4620.84,4166.09 4627.06,4172.31 ; 4620.84,4166.09 4627.06,4172.31 ; 4627.06,4172.31 4627.31,4172.31 ; 4627.06,4172.31 4627.31,4172.31
  Bottom Layer w4: J33.B19@-785.98,3479.63 -649.38,3479.63 -619.75,3450 -142.93,3450 -133.72,3459.21 -119.23,3459.21 -100.89,3440.87 -75.87,3440.87 9.13,3440.87 25,3425 25,3375 55,3345 130,3345 145,3360 v1(145,3415) ; J33.B19@-711.58,3474.13 cw(c-698.3,3460.85) -698.3,3479.63 cw(c-698.3,3498.41) J33.B19@-711.58,3485.13 ; J33.B19@-708.76,3471.3 cw(c-688.65,3451.19) -688.65,3479.63 cw(c-688.65,3508.07) J33.B19@-708.76,3487.96 ; v1@138.28,3408.28 cw(c122.06,3392.06) 145,3392.06 cw(c167.93,3392.06) v1@151.72,3408.28 ; v1@141.11,3411.11 cw(c131.72,3401.72) 145,3401.72 cw(c158.28,3401.72) v1@148.89,3411.11 ; v1(542.86,4525.04) v1(750.86,4525.04) ; v1@546.75,4521.15 cw(c556.14,4511.76) 556.14,4525.04 cw(c556.14,4538.32) v1@546.75,4528.93 ; v1@549.57,4518.32 cw(c565.79,4502.11) 565.79,4525.04 cw(c565.79,4547.98) v1@549.57,4531.76 ; v1@744.14,4518.32 ccw(c727.92,4502.11) 727.92,4525.04 ccw(c727.92,4547.98) v1@744.14,4531.76 ; v1@746.97,4521.15 ccw(c737.58,4511.76) 737.58,4525.04 ccw(c737.58,4538.32) v1@746.97,4528.93
ATE.UIO.IO8: J33.B20 PROTOTYPE1.H7 U8.M5 UH1.10 | length 8984.4
  Top Layer w4: v1(-126.48,3441.71) 15.19,3583.37 15.19,4228.33 v1(15.19,4266.71) ; v1@-126.48,3447.21 ccw(c-126.48,3460.49) -117.09,3451.1 ccw(c-107.7,3441.71) v1@-120.98,3441.71 ; v1@-126.48,3451.21 ccw(c-126.48,3474.14) -110.26,3457.93 ccw(c-94.04,3441.71) v1@-116.98,3441.71 ; v1@8.47,4259.99 cw(c-7.74,4243.77) 15.19,4243.77 cw(c38.13,4243.77) v1@21.91,4259.99 ; v1@11.3,4262.82 cw(c1.91,4253.43) 15.19,4253.43 cw(c28.47,4253.43) v1@19.08,4262.82 ; v3(4996.3,4308.11) U8.M5@5015.98,4288.42 ; U8.M5@5008.64,4288.42 ccw(c4990.92,4288.42) 5003.45,4300.96 ccw(c5015.98,4313.49) U8.M5@5015.98,4295.77 ; 5009.1,4295.31 cw(c5021.91,4308.11) 5003.8,4308.11 ccw(c5021.91,4308.11) 5009.1,4295.31 ; 5009.1,4295.31 ccw(c4996.3,4282.5) 4996.3,4300.61 cw(c4996.3,4282.5) 5009.1,4295.31
  MidLayer1 w4: PROTOTYPE1.H7@855.62,4228.74 ccw(c802.78,4281.58) 877.5,4281.58 ; PROTOTYPE1.H7@858.44,4225.91 ccw(c812.44,4271.92) 877.5,4271.92 ; PROTOTYPE1.H7@861.27,4223.08 ccw(c822.09,4262.26) 877.5,4262.26 ; PROTOTYPE1.H7@864.1,4220.26 ccw(c831.75,4252.6) 877.5,4252.6 ; PROTOTYPE1.H7@866.93,4217.43 ccw(c841.41,4242.95) 877.5,4242.95 ; PROTOTYPE1.H7@876.12,4208.23 876.12,4210 877.5,4211.38 877.5,4395.68 956.86,4475.04 1115.19,4633.37 1115.19,4758.37 1131.86,4775.04 1293.66,4775.04 1331.86,4813.23 ; 877.5,4245.95 ccw(c913.83,4245.95) PROTOTYPE1.H7@888.14,4220.26 ; 877.5,4255.6 ccw(c923.49,4255.6) PROTOTYPE1.H7@890.97,4223.08 ; 877.5,4265.26 ccw(c933.15,4265.26) PROTOTYPE1.H7@893.8,4225.91 ; 877.5,4274.92 ccw(c942.8,4274.92) PROTOTYPE1.H7@896.63,4228.74 ; UH1.10@1351.43,4801.06 ccw(c1331.86,4791.41) 1331.86,4813.23 ; UH1.10@1351.43,4825.41 cw(c1331.86,4835.06) 1331.86,4813.23 ; UH1.10@1355.02,4802.83 ccw(c1338.29,4794.58) 1338.29,4813.23 ccw(c1338.29,4831.89) UH1.10@1355.02,4823.64 ; UH1.10@1358.61,4804.6 ccw(c1344.72,4797.75) 1344.72,4813.23 ccw(c1344.72,4828.71) UH1.10@1358.61,4821.87 ; UH1.10@1398.28,4805.32 cw(c1409.51,4801.3) 1409.51,4813.23 cw(c1409.51,4825.17) UH1.10@1398.28,4821.15 ; UH1.10@1402.04,4803.97 cw(c1415.19,4799.28) 1415.19,4813.23 ; UH1.10@1402.04,4822.5 ccw(c1415.19,4827.19) 1415.19,4813.23 ; v1@4187.02,4658.37 ccw(c4164.09,4658.37) 4180.31,4674.59 ccw(c4196.52,4690.81) v1@4196.52,4667.87 ; v1@4191.02,4658.37 ccw(c4177.75,4658.37) 4187.14,4667.76 ccw(c4196.52,4677.15) v1@4196.52,4663.87 ; v1(4196.52,4658.37) 3971.52,4883.37 3844,4883.37 3710.33,5017.04 1768.67,5017.04 1735,4983.37 1598.52,4983.37 1515.19,4900.04 1515.19,4791.71 1498.52,4775.04 1453.38,4775.04 1415.19,4813.23 ; v1@4228.81,4646.66 cw(c4212.59,4630.44) 4235.52,4630.44 cw(c4258.46,4630.44) v1@4242.24,4646.66 ; v1@4231.64,4649.49 cw(c4222.25,4640.1) 4235.52,4640.1 cw(c4248.8,4640.1) v1@4239.41,4649.49 ; v1(4235.52,4653.37) 4235.52,4579.71 4297.52,4517.71 4385.15,4517.71 4467.5,4435.36 4467.5,4422.75 4477.75,4412.5 4492.25,4412.5 4497.75,4418 4527,4418 4546.41,4398.59 4656.04,4398.59 4683.66,4370.97 4720.97,4370.97 4726.92,4376.92 4756.32,4376.92 4772,4361.25 4809.63,4323.62 4831.38,4323.62 4838.82,4323.62 4879.25,4323.62 4898.67,4323.62 4958.86,4323.62 4972.79,4323.62 cw(c4972.79,4309.57) 4982.72,4319.5 ; v3@4988.83,4307.46 ccw(c4970.79,4305.88) 4982.43,4319.75 ccw(c4994.07,4333.62) v3@4995.65,4315.58 ; 1331.86,4813.23 UH1.10@1376.12,4813.23 1415.19,4813.23
  MidLayer2 w4: v1(15.19,4266.71) 817.65,4266.71 PROTOTYPE1.H7@876.12,4208.23 ; v1@19.08,4262.82 cw(c28.47,4253.43) 28.47,4266.71 cw(c28.47,4279.99) v1@19.08,4270.6 ; v1@21.91,4259.99 cw(c38.13,4243.77) 38.13,4266.71 cw(c38.13,4289.64) v1@21.91,4273.43 ; PROTOTYPE1.H7@847.12,4208.23 ccw(c777.11,4208.23) 826.62,4257.74 ccw(c876.12,4307.25) PROTOTYPE1.H7@876.12,4237.23 ; PROTOTYPE1.H7@851.12,4208.23 ccw(c790.77,4208.23) 833.44,4250.91 ccw(c876.12,4293.59) PROTOTYPE1.H7@876.12,4233.23 ; PROTOTYPE1.H7@855.12,4208.23 ccw(c804.42,4208.23) 840.27,4244.08 ccw(c876.12,4279.93) PROTOTYPE1.H7@876.12,4229.23 ; PROTOTYPE1.H7@859.12,4208.23 ccw(c818.08,4208.23) 847.1,4237.26 ccw(c876.12,4266.28) PROTOTYPE1.H7@876.12,4225.23 ; PROTOTYPE1.H7@863.12,4208.23 ccw(c831.74,4208.23) 853.93,4230.43 ccw(c876.12,4252.62) PROTOTYPE1.H7@876.12,4221.23
  Bottom Layer w4: J33.B20@-785.98,3440.26 -155,3440.26 -153.56,3441.71 v1(-126.48,3441.71) ; J33.B20@-711.58,3434.76 cw(c-698.3,3421.48) -698.3,3440.26 cw(c-698.3,3459.04) J33.B20@-711.58,3445.76 ; J33.B20@-708.76,3431.93 cw(c-688.65,3411.82) -688.65,3440.26 cw(c-688.65,3468.7) J33.B20@-708.76,3448.59 ; v1(4196.52,4658.37) 4215,4658.37 ; v1@4204.25,4652.85 cw(c4215,4645.16) 4215,4658.37 ; v1@4204.25,4663.9 ccw(c4215,4671.59) 4215,4658.37 ; v1(4235.52,4653.37) 4220,4653.37 4215,4658.37
ATE.UIO.IO9: J33.A20 PROTOTYPE1.H8 U8.T9 UH1.11 | length 9333.5
  Top Layer w4: J33.A20@-785.98,3440.26 -394.74,3440.26 -381.5,3453.5 -381.5,3605 -376.5,3610 -216.31,3610 -118,3708.31 -118,3898.31 -105,3911.31 -105,3995.23 v1(-118.14,4008.37) ; J33.A20@-711.58,3434.76 cw(c-698.3,3421.48) -698.3,3440.26 cw(c-698.3,3459.04) J33.A20@-711.58,3445.76 ; J33.A20@-708.76,3431.93 cw(c-688.65,3411.82) -688.65,3440.26 cw(c-688.65,3468.7) J33.A20@-708.76,3448.59 ; v1(1081.52,4433.04) 1235,4586.52 1235,4740 1255,4760 1305,4760 1325,4780 1325,4840 1345,4860 1505,4860 1515.19,4849.81 1515.19,4752.3 ; v1@1081.52,4438.54 ccw(c1081.52,4451.82) 1090.91,4442.43 ccw(c1100.3,4433.04) v1@1087.02,4433.04 ; v1@1081.52,4442.54 ccw(c1081.52,4465.48) 1097.74,4449.26 ccw(c1113.96,4433.04) v1@1091.02,4433.04 ; UH1.11@1476.12,4713.23 1515.19,4752.3 ; UH1.11@1478.27,4728.61 ccw(c1481.53,4751.9) 1498.16,4735.27 ccw(c1514.78,4718.65) UH1.11@1491.5,4715.39 ; UH1.11@1478.83,4732.57 ccw(c1482.93,4761.85) 1503.83,4740.95 ccw(c1524.74,4720.04) UH1.11@1495.46,4715.94 ; UH1.11@1479.38,4736.54 ccw(c1484.32,4771.81) 1509.51,4746.62 ccw(c1534.7,4721.44) UH1.11@1499.42,4716.5 ; UH1.11@1479.94,4740.5 ccw(c1485.72,4781.77) 1515.19,4752.3 ; UH1.11@1503.38,4717.05 cw(c1544.66,4722.83) 1515.19,4752.3 ; v3(5153.78,4111.26) U8.T9@5173.46,4130.94 ; U8.T9@5166.12,4130.94 cw(c5148.4,4130.94) 5160.93,4118.41 cw(c5173.46,4105.88) U8.T9@5173.46,4123.6 ; 5166.58,4124.06 cw(c5153.78,4136.87) 5153.78,4118.76 ccw(c5153.78,4136.87) 5166.58,4124.06 ; 5166.58,4124.06 ccw(c5179.39,4111.26) 5161.28,4111.26 cw(c5179.39,4111.26) 5166.58,4124.06
  MidLayer1 w4: PROTOTYPE1.H8@955.62,4228.74 ccw(c906.11,4278.25) 976.12,4278.25 ccw(c1046.13,4278.25) PROTOTYPE1.H8@996.63,4228.74 ; PROTOTYPE1.H8@958.44,4225.91 ccw(c915.77,4268.59) 976.12,4268.59 ccw(c1036.48,4268.59) PROTOTYPE1.H8@993.8,4225.91 ; PROTOTYPE1.H8@961.27,4223.08 ccw(c925.42,4258.93) 976.12,4258.93 ccw(c1026.82,4258.93) PROTOTYPE1.H8@990.97,4223.08 ; PROTOTYPE1.H8@964.1,4220.26 ccw(c935.08,4249.28) 976.12,4249.28 ccw(c1017.16,4249.28) PROTOTYPE1.H8@988.14,4220.26 ; PROTOTYPE1.H8@966.93,4217.43 ccw(c944.74,4239.62) 976.12,4239.62 ccw(c1007.51,4239.62) PROTOTYPE1.H8@985.31,4217.43 ; PROTOTYPE1.H8@976.12,4208.23 976.12,4327.64 v1(1081.52,4433.04) ; v1@1072.02,4433.04 cw(c1049.09,4433.04) 1065.31,4416.82 cw(c1081.52,4400.61) v1@1081.52,4423.54 ; v1@1076.02,4433.04 cw(c1062.75,4433.04) 1072.14,4423.65 cw(c1081.52,4414.26) v1@1081.52,4427.54
  Bottom Layer w4: v1(-118.14,4008.37) -84.81,4008.37 -51.48,4041.71 -51.48,4150.04 231.52,4433.04 v1(1081.52,4433.04) ; v1@-114.25,4004.49 cw(c-104.86,3995.1) -104.86,4008.37 cw(c-104.86,4021.65) v1@-114.25,4012.26 ; v1@-111.43,4001.66 cw(c-95.21,3985.44) -95.21,4008.37 cw(c-95.21,4031.31) v1@-111.43,4015.09 ; v1@1074.81,4426.32 ccw(c1058.59,4410.11) 1058.59,4433.04 ccw(c1058.59,4455.98) v1@1074.81,4439.76 ; v1@1077.64,4429.15 ccw(c1068.25,4419.76) 1068.25,4433.04 ccw(c1068.25,4446.32) v1@1077.64,4436.93 ; UH1.11@1456.66,4693.77 cw(c1409.66,4646.78) 1476.12,4646.78 cw(c1542.58,4646.78) UH1.11@1495.59,4693.77 ; UH1.11@1459.48,4696.6 cw(c1419.32,4656.43) 1476.12,4656.43 cw(c1532.92,4656.43) UH1.11@1492.76,4696.6 ; UH1.11@1462.31,4699.43 cw(c1428.98,4666.09) 1476.12,4666.09 cw(c1523.26,4666.09) UH1.11@1489.93,4699.43 ; UH1.11@1465.14,4702.26 cw(c1438.63,4675.75) 1476.12,4675.75 cw(c1513.61,4675.75) UH1.11@1487.1,4702.26 ; UH1.11@1476.12,4713.23 1476.12,4596.12 1450,4570 1450,4520 1461.63,4508.37 3451.5,4508.37 3486.88,4473 4227.75,4473 4392.37,4308.37 4546.81,4308.37 4597.6,4257.59 4627.72,4257.59 4639.81,4245.5 4688.37,4245.5 4693.91,4251.04 4720.34,4251.04 4742.5,4228.88 4742.5,4201.12 4737.5,4196.12 4737.5,4152.5 4745,4145 4777.06,4145 4787.5,4134.56 4787.5,4102.5 4794.25,4095.75 5036.73,4095.75 5056.15,4095.75 5116.34,4095.75 5130.27,4095.75 ccw(c5130.27,4109.8) 5140.2,4099.87 ; v3@5146.31,4111.91 cw(c5128.27,4113.49) 5139.91,4099.62 cw(c5151.55,4085.75) v3@5153.13,4103.79
ATE.UIO.IO10: J33.A21 PROTOTYPE1.H9 U8.L8 UH1.12 | length 9801.8
  Top Layer w4: J33.A21@-785.98,3400.89 -685,3400.89 -677.52,3408.37 v1(-643.14,3408.37) ; J33.A21@-711.58,3395.39 cw(c-698.3,3382.11) -698.3,3400.89 cw(c-698.3,3419.67) J33.A21@-711.58,3406.39 ; J33.A21@-708.76,3392.56 cw(c-688.65,3372.45) -688.65,3400.89 cw(c-688.65,3429.33) J33.A21@-708.76,3409.22 ; v1@-649.86,3401.66 ccw(c-666.08,3385.44) -666.08,3408.37 ccw(c-666.08,3431.31) v1@-649.86,3415.09 ; v1@-647.03,3404.49 ccw(c-656.42,3395.1) -656.42,3408.37 ccw(c-656.42,3421.65) v1@-647.03,3412.26 ; PROTOTYPE1.H9@1076.12,4208.23 1420.73,4552.84 1420.73,4757.84 UH1.12@1476.12,4813.23 ; PROTOTYPE1.H9@1076.12,4221.23 ccw(c1076.12,4252.62) 1098.31,4230.43 ccw(c1120.51,4208.23) PROTOTYPE1.H9@1089.12,4208.23 ; PROTOTYPE1.H9@1076.12,4225.23 ccw(c1076.12,4266.28) 1105.14,4237.26 ccw(c1134.16,4208.23) PROTOTYPE1.H9@1093.12,4208.23 ; PROTOTYPE1.H9@1076.12,4229.23 ccw(c1076.12,4279.93) 1111.97,4244.08 ccw(c1147.82,4208.23) PROTOTYPE1.H9@1097.12,4208.23 ; PROTOTYPE1.H9@1076.12,4233.23 ccw(c1076.12,4293.59) 1118.8,4250.91 ccw(c1161.48,4208.23) PROTOTYPE1.H9@1101.12,4208.23 ; PROTOTYPE1.H9@1076.12,4237.23 ccw(c1076.12,4307.25) 1125.63,4257.74 ccw(c1175.13,4208.23) PROTOTYPE1.H9@1105.12,4208.23 ; UH1.12@1448.59,4813.23 cw(c1382.14,4813.23) 1429.13,4766.24 cw(c1476.12,4719.25) UH1.12@1476.12,4785.71 ; UH1.12@1452.59,4813.23 cw(c1395.79,4813.23) 1435.96,4773.07 cw(c1476.12,4732.91) UH1.12@1476.12,4789.71 ; UH1.12@1456.59,4813.23 cw(c1409.45,4813.23) 1442.79,4779.9 cw(c1476.12,4746.56) UH1.12@1476.12,4793.71 ; UH1.12@1460.59,4813.23 cw(c1423.11,4813.23) 1449.61,4786.73 cw(c1476.12,4760.22) UH1.12@1476.12,4797.71 ; v3(5114.41,4347.48) U8.L8@5134.09,4327.8 ; U8.L8@5126.75,4327.8 ccw(c5109.03,4327.8) 5121.56,4340.33 ccw(c5134.09,4352.86) U8.L8@5134.09,4335.14 ; 5127.21,4334.68 cw(c5140.02,4347.48) 5121.91,4347.48 ccw(c5140.02,4347.48) 5127.21,4334.68 ; 5127.21,4334.68 ccw(c5114.41,4321.87) 5114.41,4339.98 cw(c5114.41,4321.87) 5127.21,4334.68
  MidLayer1 w4: v1@-652.64,3408.37 cw(c-675.58,3408.37) -659.36,3392.16 cw(c-643.14,3375.94) v1@-643.14,3398.87 ; v1@-648.64,3408.37 cw(c-661.92,3408.37) -652.53,3398.99 cw(c-643.14,3389.6) v1@-643.14,3402.87 ; v1(-643.14,3408.37) -661.14,3390.37 -661.14,3341.71 -644.48,3325.04 -618.14,3325.04 -601.48,3341.71 -601.48,3473.71 -621.41,3493.64 -621.41,3513.59 -526.48,3608.52 -526.48,3693.04 v1(-516.81,3702.71) ; UH1.12@1456.66,4832.7 ccw(c1409.66,4879.69) 1476.12,4879.69 ccw(c1542.58,4879.69) UH1.12@1495.59,4832.7 ; UH1.12@1459.48,4829.87 ccw(c1419.32,4870.04) 1476.12,4870.04 ccw(c1532.92,4870.04) UH1.12@1492.76,4829.87 ; UH1.12@1462.31,4827.04 ccw(c1428.98,4860.38) 1476.12,4860.38 ccw(c1523.26,4860.38) UH1.12@1489.93,4827.04 ; UH1.12@1465.14,4824.21 ccw(c1438.63,4850.72) 1476.12,4850.72 ccw(c1513.61,4850.72) UH1.12@1487.1,4824.21 ; UH1.12@1476.12,4813.23 1476.12,5008.37 1493.12,5025.37 v1(1746.86,5025.37) ; v1@1740.14,5018.66 ccw(c1723.92,5002.44) 1723.92,5025.37 ccw(c1723.92,5048.31) v1@1740.14,5032.09 ; v1@1742.97,5021.49 ccw(c1733.58,5012.1) 1733.58,5025.37 ccw(c1733.58,5038.65) v1@1742.97,5029.26
  MidLayer2 w4: v1(-516.81,3702.71) -473,3746.52 -473,4063.71 -370,4166.71 -135,4166.71 -121.71,4180 -50,4180 -28.04,4158.04 1025.93,4158.04 PROTOTYPE1.H9@1076.12,4208.23 ; v1@-516.81,3708.21 ccw(c-516.81,3721.49) -507.42,3712.1 ccw(c-498.03,3702.71) v1@-511.31,3702.71 ; v1@-516.81,3712.21 ccw(c-516.81,3735.14) -500.59,3718.93 ccw(c-484.37,3702.71) v1@-507.31,3702.71 ; PROTOTYPE1.H9@1047.12,4208.23 cw(c977.11,4208.23) 1026.62,4158.73 cw(c1076.12,4109.22) PROTOTYPE1.H9@1076.12,4179.23 ; PROTOTYPE1.H9@1051.12,4208.23 cw(c990.77,4208.23) 1033.44,4165.56 cw(c1076.12,4122.88) PROTOTYPE1.H9@1076.12,4183.23 ; PROTOTYPE1.H9@1055.12,4208.23 cw(c1004.42,4208.23) 1040.27,4172.39 cw(c1076.12,4136.54) PROTOTYPE1.H9@1076.12,4187.23 ; PROTOTYPE1.H9@1059.12,4208.23 cw(c1018.08,4208.23) 1047.1,4179.21 cw(c1076.12,4150.19) PROTOTYPE1.H9@1076.12,4191.23 ; PROTOTYPE1.H9@1063.12,4208.23 cw(c1031.74,4208.23) 1053.93,4186.04 cw(c1076.12,4163.85) PROTOTYPE1.H9@1076.12,4195.23 ; v1@1746.86,5015.87 cw(c1746.86,4992.94) 1763.07,5009.16 cw(c1779.29,5025.37) v1@1756.36,5025.37 ; v1@1746.86,5019.87 cw(c1746.86,5006.6) 1756.25,5015.99 cw(c1765.64,5025.37) v1@1752.36,5025.37 ; v1(1746.86,5025.37) 1763.86,5008.37 3643.17,5008.37 3918.17,4733.37 4051.84,4599.71 4390.27,4599.71 4482.69,4507.29 4482.69,4492.79 4472.44,4482.54 4422.54,4482.54 4414.7,4474.7 4414.7,4426.49 4414.7,4411.46 4483.15,4343 4485.15,4341 4571.5,4341 ; v3@5106.94,4346.83 ccw(c5088.9,4345.25) 5100.54,4359.12 ; v3@5113.76,4354.95 cw(c5112.18,4372.99) 5100.54,4359.12 ; 4571.5,4341 4580.69,4331.81 ; 4571.5,4341 4580.69,4331.81 ; 4571.5,4341 4580.69,4331.81 ; 4580.69,4331.81 4626.06,4331.81 4632.68,4325.19 4703.38,4325.19 4713.81,4335.62 4713.81,4356.74 4741.28,4384.21 4775.67,4384.21 4788.54,4371.34 4830.82,4371.34 4838.82,4371.34 4841.47,4371.34 4899.73,4371.34 4957.99,4371.34 4977.41,4371.34 5051.53,4371.34 5071.03,4371.34 cw(c5071.03,4329.61) 5100.54,4359.12
ATE.UIO.IO11: J33.A22 PROTOTYPE1.H10 U8.M7 UH1.13 | length 9635.1
  Top Layer w4: J33.A22@-785.98,3361.52 -675,3361.52 -663.52,3350.04 ; J33.A22@-711.58,3356.02 cw(c-698.3,3342.74) -698.3,3361.52 ; J33.A22@-711.58,3367.02 ccw(c-698.3,3380.31) -698.3,3361.52 ; J33.A22@-708.76,3353.19 cw(c-688.65,3333.09) -688.65,3361.52 cw(c-688.64,3389.96) J33.A22@-708.76,3369.85 ; v1@-650.42,3343.93 ccw(c-663.52,3332.94) -663.52,3350.04 ; v1@-650.42,3356.15 cw(c-663.52,3367.14) -663.52,3350.04 ; v1@-647.36,3346.51 ccw(c-654.94,3340.14) -654.94,3350.04 ccw(c-654.94,3359.94) v1@-647.36,3353.58 ; v1(-643.14,3350.04) -663.52,3350.04 ; v1@1441.81,4347.43 ccw(c1425.59,4363.64) 1448.52,4363.64 ccw(c1471.46,4363.64) v1@1455.24,4347.43 ; v1@1444.64,4344.6 ccw(c1435.25,4353.99) 1448.52,4353.99 ccw(c1461.8,4353.99) v1@1452.41,4344.6 ; v1(1448.52,4340.71) 1448.52,4483.37 1576.12,4610.97 UH1.13@1576.12,4713.23 ; UH1.13@1556.66,4693.77 cw(c1509.66,4646.78) 1576.12,4646.78 cw(c1642.58,4646.78) UH1.13@1595.59,4693.77 ; UH1.13@1559.48,4696.6 cw(c1519.32,4656.43) 1576.12,4656.43 cw(c1632.92,4656.43) UH1.13@1592.76,4696.6 ; UH1.13@1562.31,4699.43 cw(c1528.98,4666.09) 1576.12,4666.09 cw(c1623.26,4666.09) UH1.13@1589.93,4699.43 ; UH1.13@1565.14,4702.26 cw(c1538.63,4675.75) 1576.12,4675.75 cw(c1613.61,4675.75) UH1.13@1587.1,4702.26 ; v3(5075.04,4308.11) U8.M7@5094.72,4288.42 ; U8.M7@5087.38,4288.42 ccw(c5069.66,4288.42) 5082.19,4300.96 ccw(c5094.72,4313.49) U8.M7@5094.72,4295.77 ; 5087.84,4295.31 cw(c5100.65,4308.11) 5082.54,4308.11 ccw(c5100.65,4308.11) 5087.84,4295.31 ; 5087.84,4295.31 ccw(c5075.04,4282.5) 5075.04,4300.61 cw(c5075.04,4282.5) 5087.84,4295.31
  MidLayer1 w4: v1(999.52,3292.71) 1063.21,3292.71 1115.19,3344.69 1115.19,4147.3 PROTOTYPE1.H10@1176.12,4208.23 1225.98,4158.37 1418.37,4158.37 1435,4175 1435,4281.48 1448.52,4295 v1(1448.52,4340.71) ; v1@1003.41,3288.82 cw(c1012.8,3279.43) 1012.8,3292.71 cw(c1012.8,3305.99) v1@1003.41,3296.6 ; v1@1006.24,3285.99 cw(c1022.46,3269.77) 1022.46,3292.71 cw(c1022.46,3315.64) v1@1006.24,3299.43 ; PROTOTYPE1.H10@1147.12,4208.23 cw(c1077.11,4208.23) 1126.62,4158.73 cw(c1176.12,4109.22) 1176.12,4179.23 cw(c1176.12,4109.22) 1225.63,4158.73 cw(c1275.13,4208.23) PROTOTYPE1.H10@1205.12,4208.23 ; PROTOTYPE1.H10@1151.12,4208.23 cw(c1090.77,4208.23) 1133.44,4165.56 cw(c1176.12,4122.88) 1176.12,4183.23 cw(c1176.12,4122.88) 1218.8,4165.56 cw(c1261.48,4208.23) PROTOTYPE1.H10@1201.12,4208.23 ; PROTOTYPE1.H10@1155.12,4208.23 cw(c1104.42,4208.23) 1140.27,4172.39 cw(c1176.12,4136.54) 1176.12,4187.23 cw(c1176.12,4136.54) 1211.97,4172.39 cw(c1247.82,4208.23) PROTOTYPE1.H10@1197.12,4208.23 ; PROTOTYPE1.H10@1159.12,4208.23 cw(c1118.08,4208.23) 1147.1,4179.21 cw(c1176.12,4150.19) 1176.12,4191.23 cw(c1176.12,4150.19) 1205.14,4179.21 cw(c1234.16,4208.23) PROTOTYPE1.H10@1193.12,4208.23 ; PROTOTYPE1.H10@1163.12,4208.23 cw(c1131.74,4208.23) 1153.93,4186.04 cw(c1176.12,4163.85) 1176.12,4195.23 cw(c1176.12,4163.85) 1198.31,4186.04 cw(c1220.51,4208.23) PROTOTYPE1.H10@1189.12,4208.23 ; v1@1441.81,4333.99 cw(c1425.59,4317.77) 1448.52,4317.77 cw(c1471.46,4317.77) v1@1455.24,4333.99 ; v1@1444.64,4336.82 cw(c1435.25,4327.43) 1448.52,4327.43 cw(c1461.8,4327.43) v1@1452.41,4336.82 ; UH1.13@1576.12,4685.71 cw(c1576.12,4619.25) 1623.11,4666.24 cw(c1670.11,4713.23) UH1.13@1603.65,4713.23 ; UH1.13@1576.12,4689.71 cw(c1576.12,4632.91) 1616.29,4673.07 cw(c1656.45,4713.23) UH1.13@1599.65,4713.23 ; UH1.13@1576.12,4693.71 cw(c1576.12,4646.56) 1609.46,4679.9 cw(c1642.79,4713.23) UH1.13@1595.65,4713.23 ; UH1.13@1576.12,4697.71 cw(c1576.12,4660.22) 1602.63,4686.73 cw(c1629.14,4713.23) UH1.13@1591.65,4713.23 ; UH1.13@1576.12,4713.23 1669.36,4620 1716.31,4620 1778.27,4558.04 4123.02,4558.04 4289.5,4391.56 4289.5,4341.71 4315,4316.21 4349.89,4316.21 4358.23,4324.54 4405,4324.54 4422.98,4324.54 4431.96,4324.54 4440.46,4316.04 4529.5,4227 v1(4590,4227)
  MidLayer2 w4: v1(4590,4227) 4608.5,4245.5 4621.5,4245.5 4655,4245.5 4682.19,4245.5 4687.19,4250.5 4725.31,4250.5 4730.62,4245.19 4739,4245.19 4752.19,4258.38 4752.19,4272.38 4774.31,4294.5 4781.81,4294.5 4810.93,4323.62 4838.82,4323.62 4841.47,4323.62 4899.73,4323.62 4957.99,4323.62 4977.41,4323.62 5037.6,4323.62 5051.53,4323.62 cw(c5051.53,4309.57) 5061.46,4319.5 ; v1@4590,4232.5 ccw(c4590,4245.78) 4599.39,4236.39 ccw(c4608.78,4227) v1@4595.5,4227 ; v1@4590,4236.5 ccw(c4590,4259.43) 4606.22,4243.22 ccw(c4622.43,4227) v1@4599.5,4227 ; v3@5067.57,4307.46 ccw(c5049.53,4305.88) 5061.17,4319.75 ccw(c5072.81,4333.62) v3@5074.39,4315.58
  Bottom Layer w4: v1(-643.14,3350.04) -609.81,3350.04 -593.14,3366.71 -34.81,3366.71 121.9,3210 710,3210 792.71,3292.71 822.67,3292.71 v1(999.52,3292.71) ; v1@-639.25,3346.15 cw(c-629.86,3336.76) -629.86,3350.04 cw(c-629.86,3363.32) v1@-639.25,3353.93 ; v1@-636.43,3343.32 cw(c-620.21,3327.11) -620.21,3350.04 cw(c-620.21,3372.98) v1@-636.43,3356.76 ; v1@992.81,3285.99 ccw(c976.59,3269.77) 976.59,3292.71 ccw(c976.59,3315.64) v1@992.81,3299.43 ; v1@995.64,3288.82 ccw(c986.25,3279.43) 986.25,3292.71 ccw(c986.25,3305.99) v1@995.64,3296.6
ATE.UIO.IO12: J33.A23 PROTOTYPE1.H11 U8.L1 UH1.14 | length 10048
  Top Layer w4: J33.A23@-785.98,3322.15 -678.81,3322.15 -674.25,3326.71 -398.29,3326.71 -359.81,3365.19 v1(-359.81,3591.71) ; J33.A23@-711.58,3316.65 cw(c-698.3,3303.37) -698.3,3322.15 cw(c-698.3,3340.94) J33.A23@-711.58,3327.65 ; J33.A23@-708.76,3313.82 cw(c-688.65,3293.72) -688.65,3322.15 cw(c-688.64,3350.59) J33.A23@-708.76,3330.48 ; v1@-366.53,3584.99 cw(c-382.74,3568.77) -359.81,3568.77 cw(c-336.87,3568.77) v1@-353.09,3584.99 ; v1@-363.7,3587.82 cw(c-373.09,3578.43) -359.81,3578.43 cw(c-346.53,3578.43) v1@-355.92,3587.82 ; v1@225.14,3490.09 ccw(c208.92,3506.31) 231.86,3506.31 ccw(c254.79,3506.31) v1@238.57,3490.09 ; v1@227.97,3487.26 ccw(c218.58,3496.65) 231.86,3496.65 ccw(c245.14,3496.65) v1@235.75,3487.26 ; v1(231.86,3483.37) 231.86,4236.86 486.71,4491.71 581.86,4491.71 685.96,4595.81 811.69,4595.81 841.13,4566.37 1056.52,4566.37 1097.97,4607.82 1115.19,4625.04 1115.19,4825.04 1165.19,4875.04 1556.86,4875.04 1576.12,4855.78 ; UH1.14@1564.84,4838.35 ccw(c1557.01,4855.78) 1576.12,4855.78 ; UH1.14@1566.48,4834.7 ccw(c1559.79,4849.59) 1576.12,4849.59 ccw(c1592.45,4849.59) UH1.14@1585.76,4834.7 ; UH1.14@1568.12,4831.05 ccw(c1562.57,4843.41) 1576.12,4843.41 ccw(c1589.68,4843.41) UH1.14@1584.12,4831.05 ; UH1.14@1576.12,4813.23 1576.12,4855.78 ; UH1.14@1587.4,4838.35 cw(c1595.23,4855.78) 1576.12,4855.78 ; v1@4361.52,4492.28 cw(c4354.07,4481.71) 4367,4481.71 ; v1(4367,4500.04) 4367,4481.71 ; v1@4372.48,4492.28 ccw(c4379.93,4481.71) 4367,4481.71 ; 4830.82,4327.79 4838.82,4327.79 ; U8.L1@4853.31,4322.6 ccw(c4840.78,4310.07) 4840.78,4327.79 ccw(c4840.78,4345.52) U8.L1@4853.31,4332.99 ; U8.L1@4858.5,4327.8 4838.82,4327.79 ; 4367,4481.71 4367,4472.81 4486.31,4353.5 4506.25,4353.5 4552.25,4399.5 4631.81,4399.5 4638.9,4406.59 4713.59,4406.59 4730.42,4389.77 4742.29,4389.77 4804.27,4327.79 4838.82,4327.79
  MidLayer1 w4: PROTOTYPE1.H11@1255.62,4228.74 ccw(c1206.11,4278.25) 1276.12,4278.25 ccw(c1346.13,4278.25) PROTOTYPE1.H11@1296.63,4228.74 ; PROTOTYPE1.H11@1258.44,4225.91 ccw(c1215.77,4268.59) 1276.12,4268.59 ccw(c1336.48,4268.59) PROTOTYPE1.H11@1293.8,4225.91 ; PROTOTYPE1.H11@1261.27,4223.08 ccw(c1225.42,4258.93) 1276.12,4258.93 ccw(c1326.82,4258.93) PROTOTYPE1.H11@1290.97,4223.08 ; PROTOTYPE1.H11@1264.1,4220.26 ccw(c1235.08,4249.28) 1276.12,4249.28 ccw(c1317.16,4249.28) PROTOTYPE1.H11@1288.14,4220.26 ; PROTOTYPE1.H11@1266.93,4217.43 ccw(c1244.74,4239.62) 1276.12,4239.62 ccw(c1307.51,4239.62) PROTOTYPE1.H11@1285.31,4217.43 ; PROTOTYPE1.H11@1276.12,4208.23 1276.12,4415 1123.19,4567.93 1123.19,4755.06 1134.84,4766.71 1529.59,4766.71 ; UH1.14@1548.59,4813.04 cw(c1483.73,4812.58) 1529.6,4766.71 ; UH1.14@1552.59,4813.07 cw(c1497.15,4812.67) 1536.36,4773.47 cw(c1575.56,4734.27) UH1.14@1575.95,4789.71 ; UH1.14@1556.59,4813.1 cw(c1510.58,4812.77) 1543.12,4780.23 cw(c1575.66,4747.69) UH1.14@1575.98,4793.71 ; UH1.14@1560.59,4813.12 cw(c1524.01,4812.86) 1549.88,4786.99 cw(c1575.75,4761.12) UH1.14@1576.01,4797.71 ; UH1.14@1575.93,4785.71 ccw(c1575.46,4720.84) 1529.6,4766.71 ; UH1.14@1576.12,4813.23 1529.59,4766.71
  MidLayer2 w4: v1(-359.81,3591.71) -68.14,3591.71 -41.44,3565 180.15,3565 190.19,3575.04 216.52,3575.04 231.86,3559.71 v1(231.86,3483.37) ; v1@-355.92,3587.82 cw(c-346.53,3578.43) -346.53,3591.71 cw(c-346.53,3604.99) v1@-355.92,3595.6 ; v1@-353.09,3584.99 cw(c-336.87,3568.77) -336.87,3591.71 cw(c-336.87,3614.64) v1@-353.09,3598.43 ; v1@225.14,3490.09 ccw(c208.92,3506.31) 231.86,3506.31 ccw(c254.79,3506.31) v1@238.57,3490.09 ; v1@227.97,3487.26 ccw(c218.58,3496.65) 231.86,3496.65 ccw(c245.14,3496.65) v1@235.75,3487.26 ; UH1.14@1576.12,4813.23 1598.52,4813.24 1598.52,4833.37 1615.19,4850.04 ; UH1.14@1579.35,4828.42 ccw(c1583.94,4850.03) 1599.56,4834.41 ; UH1.14@1580.18,4832.34 ccw(c1585.77,4858.62) 1604.77,4839.62 ; UH1.14@1581.01,4836.25 ccw(c1587.59,4867.22) 1609.98,4844.83 ; UH1.14@1581.84,4840.16 ccw(c1589.42,4875.81) 1615.19,4850.04 ; UH1.14@1595.52,4815.47 cw(c1623.15,4818.67) 1603.48,4838.33 ; UH1.14@1599.49,4815.93 cw(c1633.64,4819.88) 1609.34,4844.19 ; UH1.14@1603.47,4816.39 cw(c1644.14,4821.09) 1615.19,4850.04 ; v1@4360.28,4493.32 ccw(c4344.06,4477.11) 4344.06,4500.04 ccw(c4344.06,4522.98) v1@4360.28,4506.76 ; v1@4363.11,4496.15 ccw(c4353.72,4486.76) 4353.72,4500.04 ccw(c4353.72,4513.32) v1@4363.11,4503.93 ; v1(4367,4500.04) 4336.56,4500.04 4319.73,4516.87 4089.42,4516.87 3756.25,4850.04 1615.19,4850.04
ATE.UIO.IO13: J33.A24 PROTOTYPE1.H12 U8.M1 UH1.15 | length 8549.7
  Top Layer w4: J33.A24@-785.98,3282.78 -374.7,3282.78 -233.35,3424.13 -233.35,3581.65 -110,3705 -110,3895 -97,3908 -97,3940.48 -55,3982.48 -55,4034.93 -67.81,4047.74 -67.81,4077.81 v1(-80,4090) ; J33.A24@-711.58,3277.28 cw(c-698.3,3264) -698.3,3282.78 cw(c-698.3,3301.56) J33.A24@-711.58,3288.28 ; J33.A24@-708.76,3274.45 cw(c-688.65,3254.35) -688.65,3282.78 cw(c-688.65,3311.22) J33.A24@-708.76,3291.11 ; PROTOTYPE1.H12@1355.62,4228.74 ccw(c1306.11,4278.25) 1376.12,4278.25 ccw(c1446.13,4278.25) PROTOTYPE1.H12@1396.63,4228.74 ; PROTOTYPE1.H12@1358.44,4225.91 ccw(c1315.77,4268.59) 1376.12,4268.59 ccw(c1436.48,4268.59) PROTOTYPE1.H12@1393.8,4225.91 ; PROTOTYPE1.H12@1361.27,4223.08 ccw(c1325.42,4258.93) 1376.12,4258.93 ccw(c1426.82,4258.93) PROTOTYPE1.H12@1390.97,4223.08 ; PROTOTYPE1.H12@1364.1,4220.26 ccw(c1335.08,4249.28) 1376.12,4249.28 ccw(c1417.16,4249.28) PROTOTYPE1.H12@1388.14,4220.26 ; PROTOTYPE1.H12@1366.93,4217.43 ccw(c1344.74,4239.62) 1376.12,4239.62 ccw(c1407.51,4239.62) PROTOTYPE1.H12@1385.31,4217.43 ; v2@1369.18,4469.25 cw(c1352.44,4452.5) 1376.12,4452.5 cw(c1399.81,4452.5) v2@1383.06,4469.25 ; v2@1372.01,4472.08 cw(c1362.09,4462.16) 1376.12,4462.16 cw(c1390.15,4462.16) v2@1380.23,4472.08 ; PROTOTYPE1.H12@1376.12,4208.23 v2(1376.12,4476.19) ; v1@4733,4300 4783.69,4300 4788.58,4295.1 4814.9,4295.1 4821.58,4288.42 4831.42,4288.42 4838.82,4288.42 U8.M1@4858.5,4288.42 ; v1@4734.06,4306.06 ccw(c4748.69,4320.69) 4748.69,4300 ; v1@4736.89,4308.89 ccw(c4758.35,4330.35) 4758.35,4300 ; v1@4739.72,4298.28 cw(c4743.86,4294.14) 4743.86,4300 ; v1@4739.72,4311.72 ccw(c4768.01,4340.01) 4768.01,4300 ; 4787.54,4296.15 4787.75,4295.93 ; U8.M1@4853.31,4283.23 ccw(c4840.78,4270.7) 4840.78,4288.42 ccw(c4840.78,4306.15) U8.M1@4853.31,4293.62
  MidLayer1 w4: v2(1376.12,4476.19) 1430,4530.06 1430,4730 1450.37,4750.37 1522.37,4750.37 1522.7,4750.05 1536.5,4750.05 1536.82,4750.37 1638.05,4750.37 1638.98,4750.37 ; v2@1376.12,4482 ccw(c1376.12,4496.03) 1386.04,4486.11 ccw(c1395.96,4476.19) v2@1381.93,4476.19 ; v2@1376.12,4486 ccw(c1376.12,4509.68) 1392.87,4492.93 ccw(c1409.62,4476.19) v2@1385.93,4476.19 ; UH1.15@1649.04,4718.17 ccw(c1613.29,4724.68) 1638.98,4750.37 ; UH1.15@1652.97,4717.45 ccw(c1622.42,4723.01) 1644.38,4744.98 ccw(c1666.34,4766.94) UH1.15@1671.91,4736.38 ; UH1.15@1656.91,4716.73 ccw(c1631.55,4721.35) 1649.78,4739.58 ccw(c1668.01,4757.81) UH1.15@1672.62,4732.45 ; UH1.15@1660.84,4716.02 ccw(c1640.68,4719.69) 1655.17,4734.18 ccw(c1669.67,4748.68) UH1.15@1673.34,4728.51 ; UH1.15@1671.19,4740.32 cw(c1664.68,4776.07) 1638.98,4750.37 ; UH1.15@1676.12,4713.23 1638.98,4750.37
  MidLayer2 w4: v1(-80,4090) -19.96,4150.04 1185,4150.04 1317.89,4150 PROTOTYPE1.H12@1376.12,4208.23 ; v1@-80,4095.5 ccw(c-80,4108.78) -70.61,4099.39 ccw(c-61.22,4090) v1@-74.5,4090 ; v1@-80,4099.5 ccw(c-80,4122.43) -63.78,4106.22 ccw(c-47.57,4090) v1@-70.5,4090 ; PROTOTYPE1.H12@1347.12,4208.23 cw(c1277.11,4208.23) 1326.62,4158.73 cw(c1376.12,4109.22) PROTOTYPE1.H12@1376.12,4179.23 ; PROTOTYPE1.H12@1351.12,4208.23 cw(c1290.77,4208.23) 1333.44,4165.56 cw(c1376.12,4122.88) PROTOTYPE1.H12@1376.12,4183.23 ; PROTOTYPE1.H12@1355.12,4208.23 cw(c1304.42,4208.23) 1340.27,4172.39 cw(c1376.12,4136.54) PROTOTYPE1.H12@1376.12,4187.23 ; PROTOTYPE1.H12@1359.12,4208.23 cw(c1318.08,4208.23) 1347.1,4179.21 cw(c1376.12,4150.19) PROTOTYPE1.H12@1376.12,4191.23 ; PROTOTYPE1.H12@1363.12,4208.23 cw(c1331.74,4208.23) 1353.93,4186.04 cw(c1376.12,4163.85) PROTOTYPE1.H12@1376.12,4195.23
  Bottom Layer w4: UH1.15@1676.12,4713.23 1690.19,4727.3 1690.19,4741.71 1715.19,4766.71 1906.86,4766.71 2081.86,4591.71 4233.58,4591.71 4400.95,4424.34 4400.95,4423.95 4491.86,4333.04 4556.09,4333.04 4607.54,4281.59 4637.66,4281.59 4649.75,4269.5 4664.25,4269.5 4682.5,4287.75 4682.5,4290.25 4691.13,4298.87 ; v1@4726.28,4298.28 ccw(c4710.06,4282.06) 4710.06,4305 ccw(c4710.06,4327.93) v1@4726.28,4311.72 ; v1@4729.11,4301.11 ccw(c4719.72,4291.72) 4719.72,4305 ccw(c4719.72,4318.28) v1@4729.11,4308.89 ; v1(4733,4305) 4697.25,4305 4692.75,4300.5 ; 4691.13,4298.87 4692.75,4300.5 ; 4691.13,4298.87 4692.75,4300.5
ATE.UIO.IO14: J33.B24 PROTOTYPE1.H13 U8.L4 UH1.16 | length 9610.2
  Top Layer w4: PROTOTYPE1.H13@1476.12,4208.23 1623.52,4355.64 1623.52,4760.64 UH1.16@1676.12,4813.23 ; PROTOTYPE1.H13@1476.12,4221.23 ccw(c1476.12,4252.62) 1498.31,4230.43 ccw(c1520.51,4208.23) PROTOTYPE1.H13@1489.12,4208.23 ; PROTOTYPE1.H13@1476.12,4225.23 ccw(c1476.12,4266.28) 1505.14,4237.26 ccw(c1534.16,4208.23) PROTOTYPE1.H13@1493.12,4208.23 ; PROTOTYPE1.H13@1476.12,4229.23 ccw(c1476.12,4279.93) 1511.97,4244.08 ccw(c1547.82,4208.23) PROTOTYPE1.H13@1497.12,4208.23 ; PROTOTYPE1.H13@1476.12,4233.23 ccw(c1476.12,4293.59) 1518.8,4250.91 ccw(c1561.48,4208.23) PROTOTYPE1.H13@1501.12,4208.23 ; PROTOTYPE1.H13@1476.12,4237.23 ccw(c1476.12,4307.25) 1525.63,4257.74 ccw(c1575.13,4208.23) PROTOTYPE1.H13@1505.12,4208.23 ; UH1.16@1648.59,4813.23 cw(c1582.14,4813.23) 1629.13,4766.24 cw(c1676.12,4719.25) UH1.16@1676.12,4785.71 ; UH1.16@1652.59,4813.23 cw(c1595.79,4813.23) 1635.96,4773.07 cw(c1676.12,4732.91) UH1.16@1676.12,4789.71 ; UH1.16@1656.59,4813.23 cw(c1609.45,4813.23) 1642.79,4779.9 cw(c1676.12,4746.56) UH1.16@1676.12,4793.71 ; UH1.16@1660.59,4813.23 cw(c1623.11,4813.23) 1649.61,4786.73 cw(c1676.12,4760.22) UH1.16@1676.12,4797.71 ; v3(4956.93,4347.48) U8.L4@4976.61,4327.8 ; U8.L4@4969.27,4327.8 ccw(c4951.55,4327.8) 4964.08,4340.33 ccw(c4976.61,4352.86) U8.L4@4976.61,4335.14 ; 4969.73,4334.68 cw(c4982.54,4347.48) 4964.43,4347.48 ccw(c4982.54,4347.48) 4969.73,4334.68 ; 4969.73,4334.68 ccw(c4956.93,4321.87) 4956.93,4339.98 cw(c4956.93,4321.87) 4969.73,4334.68
  MidLayer1 w4: v1@-241.53,3355.76 ccw(c-257.74,3371.98) -234.81,3371.98 ccw(c-211.87,3371.98) v1@-228.09,3355.76 ; v1@-238.7,3352.93 ccw(c-248.09,3362.32) -234.81,3362.32 ccw(c-221.53,3362.32) v1@-230.92,3352.93 ; v1(-234.81,3349.04) -234.81,3538.88 -96.46,3677.22 -83.3,3690.39 -83.3,3805 -63.59,3824.71 -20,3824.71 ; -20,3825.04 -7.5,3837.54 -7.5,4002.35 48.52,4058.37 156.86,4058.37 173.52,4075.04 173.52,4297.67 453.97,4578.12 453.97,4699.49 490,4735.52 v1(490,4925) ; v1@483.28,4918.28 cw(c467.06,4902.06) 490,4902.06 cw(c512.93,4902.06) v1@496.72,4918.28 ; v1@486.11,4921.11 cw(c476.72,4911.72) 490,4911.72 cw(c503.28,4911.72) v1@493.89,4921.11 ; v1(4363.52,4539.69) 4416.95,4539.69 4440.86,4515.79 4440.86,4498.39 4487.73,4451.52 4506.1,4451.52 4551.03,4406.59 4650.22,4406.59 4711.22,4406.59 4717.61,4400.21 4755.81,4400.21 4788,4368.02 4808.54,4347.48 4830.82,4347.48 4838.82,4347.48 4879.25,4347.48 4898.67,4347.48 v3(4956.93,4347.48) ; v1@4367.41,4535.81 cw(c4376.8,4526.42) 4376.8,4539.69 cw(c4376.8,4552.97) v1@4367.41,4543.58 ; v1@4370.24,4532.98 cw(c4386.46,4516.76) 4386.46,4539.69 cw(c4386.46,4562.63) v1@4370.24,4546.41 ; v3@4951.63,4342.18 ccw(c4938.82,4329.37) 4938.82,4347.48 ccw(c4938.82,4365.59) v3@4951.63,4352.78 ; v3@4951.74,4342.29 ccw(c4939.2,4329.75) 4939.2,4347.48 ccw(c4939.2,4365.21) v3@4951.74,4352.67
  MidLayer2 w4: v1(490,4925) 490,4931.85 499.86,4941.71 ; v1@490,4934.5 ccw(c490,4940.9) 494.52,4936.37 ; v1@494.78,4927.73 cw(c502.19,4931.96) 496.15,4938 ; v1@498.25,4929.71 cw(c506.91,4934.66) 499.86,4941.71 ; v1@1700.14,4934.99 ccw(c1683.92,4918.77) 1683.92,4941.71 ccw(c1683.92,4964.64) v1@1700.14,4948.43 ; v1@1702.97,4937.82 ccw(c1693.58,4928.43) 1693.58,4941.71 ccw(c1693.58,4954.99) v1@1702.97,4945.6 ; v1@1706.86,4947.21 ccw(c1706.86,4960.49) 1716.25,4951.1 ccw(c1725.64,4941.71) v1@1712.36,4941.71 ; v1@1706.86,4951.21 ccw(c1706.86,4974.14) 1723.07,4957.93 ccw(c1739.29,4941.71) v1@1716.36,4941.71 ; 4330,4535 4334.69,4539.69 ; v1@4356.81,4532.98 ccw(c4340.59,4516.76) 4340.59,4539.69 ccw(c4340.59,4562.63) v1@4356.81,4546.41 ; v1@4359.63,4535.81 ccw(c4350.25,4526.42) 4350.25,4539.69 ccw(c4350.25,4552.97) v1@4359.63,4543.58 ; v1@4361.51,4539.69 4334.69,4539.69 ; 499.86,4941.71 v1(1706.86,4941.71) 1757.15,4992 3636.92,4992 4095.54,4533.37 4310,4533.37 4328.37,4533.37 4334.69,4539.69
  Bottom Layer w4: J33.B24@-785.98,3282.78 -615,3282.78 -548.74,3349.04 v1(-234.81,3349.04) ; J33.B24@-711.58,3277.28 cw(c-698.3,3264) -698.3,3282.78 cw(c-698.3,3301.56) J33.B24@-711.58,3288.28 ; J33.B24@-708.76,3274.45 cw(c-688.65,3254.35) -688.65,3282.78 cw(c-688.65,3311.22) J33.B24@-708.76,3291.11 ; v1@-241.53,3342.32 ccw(c-257.74,3326.11) -257.74,3349.04 ccw(c-257.74,3371.98) v1@-241.53,3355.76 ; v1@-238.7,3345.15 ccw(c-248.09,3335.76) -248.09,3349.04 ccw(c-248.09,3362.32) v1@-238.7,3352.93 ; UH1.16@1676.12,4813.23 1706.86,4843.97 v1(1706.86,4941.71) ; v1@1700.14,4934.99 cw(c1683.92,4918.77) 1706.86,4918.77 cw(c1729.79,4918.77) v1@1713.57,4934.99 ; v1@1702.97,4937.82 cw(c1693.58,4928.43) 1706.86,4928.43 cw(c1720.14,4928.43) v1@1710.75,4937.82
ATE.UIO.IO15: J33.B26 PROTOTYPE1.H14 U8.M9 UH1.17 | length 9197
  Top Layer w4: PROTOTYPE1.H14@1576.12,4208.23 1675,4307.11 1675,4480 1776.12,4581.12 UH1.17@1776.12,4713.23 ; PROTOTYPE1.H14@1576.12,4221.23 ccw(c1576.12,4252.62) 1598.31,4230.43 ccw(c1620.51,4208.23) PROTOTYPE1.H14@1589.12,4208.23 ; PROTOTYPE1.H14@1576.12,4225.23 ccw(c1576.12,4266.28) 1605.14,4237.26 ccw(c1634.16,4208.23) PROTOTYPE1.H14@1593.12,4208.23 ; PROTOTYPE1.H14@1576.12,4229.23 ccw(c1576.12,4279.93) 1611.97,4244.08 ccw(c1647.82,4208.23) PROTOTYPE1.H14@1597.12,4208.23 ; PROTOTYPE1.H14@1576.12,4233.23 ccw(c1576.12,4293.59) 1618.8,4250.91 ccw(c1661.48,4208.23) PROTOTYPE1.H14@1601.12,4208.23 ; PROTOTYPE1.H14@1576.12,4237.23 ccw(c1576.12,4307.25) 1625.63,4257.74 ccw(c1675.13,4208.23) PROTOTYPE1.H14@1605.12,4208.23 ; UH1.17@1756.66,4693.77 cw(c1709.66,4646.78) 1776.12,4646.78 cw(c1842.58,4646.78) UH1.17@1795.59,4693.77 ; UH1.17@1759.48,4696.6 cw(c1719.32,4656.43) 1776.12,4656.43 cw(c1832.92,4656.43) UH1.17@1792.76,4696.6 ; UH1.17@1762.31,4699.43 cw(c1728.98,4666.09) 1776.12,4666.09 cw(c1823.26,4666.09) UH1.17@1789.93,4699.43 ; UH1.17@1765.14,4702.26 cw(c1738.63,4675.75) 1776.12,4675.75 cw(c1813.61,4675.75) UH1.17@1787.1,4702.26 ; v3(5153.78,4308.11) U8.M9@5173.46,4288.42 ; U8.M9@5166.12,4288.42 ccw(c5148.4,4288.42) 5160.93,4300.96 ccw(c5173.46,4313.49) U8.M9@5173.46,4295.77 ; 5166.58,4295.31 cw(c5179.39,4308.11) 5161.28,4308.11 ccw(c5179.39,4308.11) 5166.58,4295.31 ; 5166.58,4295.31 ccw(c5153.78,4282.5) 5153.78,4300.61 cw(c5153.78,4282.5) 5166.58,4295.31
  MidLayer1 w4: v1(1203.86,3241.71) 1331.86,3369.71 1331.86,4041.71 1345.15,4055 ; v1@1203.86,3247.21 ccw(c1203.86,3260.49) 1213.25,3251.1 ccw(c1222.64,3241.71) v1@1209.36,3241.71 ; v1@1203.86,3251.21 ccw(c1203.86,3274.14) 1220.07,3257.93 ccw(c1236.29,3241.71) v1@1213.36,3241.71 ; 1345,4055 1345.15,4055 ; PROTOTYPE1.H14@1547.16,4206.75 cw(c1488.39,4203.72) 1530,4162.12 ; PROTOTYPE1.H14@1551.15,4206.95 cw(c1500.49,4204.35) 1536.36,4168.48 cw(c1572.23,4132.61) PROTOTYPE1.H14@1574.84,4183.27 ; PROTOTYPE1.H14@1555.15,4207.16 cw(c1512.59,4204.97) 1542.72,4174.84 cw(c1572.86,4144.71) PROTOTYPE1.H14@1575.04,4187.26 ; PROTOTYPE1.H14@1559.14,4207.36 cw(c1524.69,4205.59) 1549.09,4181.2 cw(c1573.48,4156.81) PROTOTYPE1.H14@1575.25,4191.26 ; PROTOTYPE1.H14@1574.63,4179.27 ccw(c1571.61,4120.51) 1530,4162.12 ; PROTOTYPE1.H14@1576.12,4208.23 1530,4162.11 ; 1345.15,4055 1510,4055 1530,4075 1530,4162.11
  Bottom Layer w4: J33.B26@-785.98,3204.04 -24.23,3204.04 -12.38,3192.19 733.46,3192.19 782.98,3241.71 v1(1203.86,3241.71) ; J33.B26@-711.58,3198.54 cw(c-698.3,3185.26) -698.3,3204.04 cw(c-698.3,3222.82) J33.B26@-711.58,3209.54 ; J33.B26@-708.76,3195.71 cw(c-688.65,3175.6) -688.65,3204.04 cw(c-688.65,3232.48) J33.B26@-708.76,3212.37 ; v1@1197.14,3234.99 ccw(c1180.92,3218.77) 1180.92,3241.71 ccw(c1180.92,3264.64) v1@1197.14,3248.43 ; v1@1199.97,3237.82 ccw(c1190.58,3228.43) 1190.58,3241.71 ccw(c1190.58,3254.99) v1@1199.97,3245.6 ; UH1.17@1756.66,4693.77 cw(c1709.66,4646.78) 1776.12,4646.78 cw(c1842.58,4646.78) UH1.17@1795.59,4693.77 ; UH1.17@1759.48,4696.6 cw(c1719.32,4656.43) 1776.12,4656.43 cw(c1832.92,4656.43) UH1.17@1792.76,4696.6 ; UH1.17@1762.31,4699.43 cw(c1728.98,4666.09) 1776.12,4666.09 cw(c1823.26,4666.09) UH1.17@1789.93,4699.43 ; UH1.17@1765.14,4702.26 cw(c1738.63,4675.75) 1776.12,4675.75 cw(c1813.61,4675.75) UH1.17@1787.1,4702.26 ; UH1.17@1776.12,4713.23 1776.12,4543.88 1803.63,4516.37 3454.82,4516.37 3490.19,4481 4231.25,4481 4395.54,4316.71 4549.79,4316.71 4600.91,4265.59 4631.03,4265.59 4643.12,4253.5 4683.5,4253.5 4695.5,4265.5 4707.25,4265.5 4716.16,4274.41 ; 4716.19,4274.38 4726.62,4284.81 4744.81,4284.81 4783.62,4323.62 5036.73,4323.62 5056.15,4323.62 5116.34,4323.62 5130.27,4323.62 cw(c5130.27,4309.57) 5140.2,4319.5 ; v3@5146.31,4307.46 ccw(c5128.27,4305.88) 5139.91,4319.75 ccw(c5151.55,4333.62) v3@5153.13,4315.58