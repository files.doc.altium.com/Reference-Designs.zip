# Altium PCB NB3000AL.PcbDoc (part 43 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ETH.E_TXD0: R45.1 U5.6 U8.G4 | length 4401.7
  Top Layer w4: v3(4956.93,4504.96) U8.G4@4976.61,4485.28 ; U8.G4@4969.27,4485.28 ccw(c4951.55,4485.28) 4964.08,4497.81 ccw(c4976.61,4510.34) U8.G4@4976.61,4492.62 ; 4969.73,4492.16 cw(c4982.54,4504.96) 4964.43,4504.96 ccw(c4982.54,4504.96) 4969.73,4492.16 ; 4969.73,4492.16 ccw(c4956.93,4479.35) 4956.93,4497.46 cw(c4956.93,4479.35) 4969.73,4492.16
  MidLayer1 w4: v1(2140.19,5208.37) 2173.52,5241.71 2231.86,5241.71 2290.19,5183.37 2348.52,5183.37 2373.52,5208.37 2373.52,5426.48 2365,5435 2365,5475 2375,5485 2405,5485 2420,5470 2420,5445 2450,5415 2780,5415 2860.72,5334.28 3600.6,5334.28 3801.67,5133.21 4400,5133.21 4435.02,5133.21 4448.08,5133.21 4615.19,4966.1 4615.19,4953.04 4615.19,4925 4615.19,4865 4594.86,4844.67 4594.86,4807.21 4594.86,4800 4594.86,4746.71 4609.27,4732.29 4621,4720.56 4621,4709.87 4706.03,4624.84 4706.03,4606.87 4706.86,4606.04 4801.8,4511.1 4807.94,4504.96 4828.82,4504.96 4838.82,4504.96 4879.25,4504.96 4898.67,4504.96 v3(4956.93,4504.96) ; v1@2140.19,5213.87 ccw(c2140.19,5227.15) 2149.58,5217.76 ccw(c2158.97,5208.37) v1@2145.69,5208.37 ; v1@2140.19,5217.87 ccw(c2140.19,5240.81) 2156.41,5224.59 ccw(c2172.63,5208.37) v1@2149.69,5208.37 ; v3@4951.74,4499.77 ccw(c4939.2,4487.23) 4939.2,4504.96 ccw(c4939.2,4522.69) v3@4951.74,4510.15 ; 4938.82,4504.96 cw(c4938.82,4486.85) 4951.63,4499.66 ccw(c4938.82,4486.85) 4938.82,4504.96 ; 4938.82,4504.96 ccw(c4938.82,4523.07) 4951.63,4510.26 cw(c4938.82,4523.07) 4938.82,4504.96
  Bottom Layer w4: v1(2140.19,5208.37) R45.1@2170,5208.37 ; v1@2144.08,5204.49 cw(c2153.47,5195.1) 2153.47,5208.37 cw(c2153.47,5221.65) v1@2144.08,5212.26 ; v1@2146.91,5201.66 cw(c2163.13,5185.44) 2163.13,5208.37 cw(c2163.13,5231.31) v1@2146.91,5215.09 ; R45.1@2166.51,5214.82 ccw(c2164.41,5220) 2170,5220 ccw(c2175.59,5220) R45.1@2173.49,5214.82 ; R45.1@2170,5206.18 2170,5220 2180,5230 2245,5230 2249.19,5234.19 2307.38,5234.19 2322.9,5249.71 2353.71,5249.71 2370.71,5266.71 U5.6@2370.71,5322.68 ; U5.6@2367.88,5296.32 cw(c2361.05,5289.49) 2370.71,5289.49 cw(c2380.36,5289.49) U5.6@2373.54,5296.32
ETH.E_TXD1: R44.1 U5.5 U8.F1 | length 3859.5
  Top Layer w4: v1@4459.03,5009.48 cw(c4447.64,4996.12) 4465.19,4996.12 ; v1@4461.62,5012.52 cw(c4455.03,5004.79) 4465.19,5004.79 cw(c4475.35,5004.79) v1@4468.76,5012.52 ; v1(4465.19,5016.71) 4465.19,4996.12 ; v1@4471.35,5009.48 ccw(c4482.74,4996.12) 4465.19,4996.12 ; U8.F1@4853.31,4519.45 ccw(c4840.78,4506.92) 4840.78,4524.65 ccw(c4840.78,4542.37) U8.F1@4853.31,4529.84 ; U8.F1@4858.5,4524.65 4838.82,4524.65 4830.35,4524.65 4761.77,4524.65 4750.41,4536 4748.82,4537.59 4728.47,4537.59 4705.56,4560.5 4671.4,4560.5 4665.19,4566.71 4648.52,4583.37 4648.52,4722.06 4553.36,4817.23 4553.36,4888.92 4553.36,4907.96 4465.19,4996.12
  MidLayer1 w4: v1@2198.52,5198.87 cw(c2198.52,5175.94) 2214.74,5192.16 cw(c2230.96,5208.37) v1@2208.02,5208.37 ; v1@2198.52,5202.87 cw(c2198.52,5189.6) 2207.91,5198.99 cw(c2217.3,5208.37) v1@2204.02,5208.37 ; v1(2198.52,5208.37) 2231.86,5175.04 2373.52,5175.04 2506.86,5308.37 3141.63,5308.37 ; 3141.29,5308.71 3141.63,5308.37 ; v1@4458.47,5023.43 ccw(c4442.26,5039.64) 4465.19,5039.64 ccw(c4488.13,5039.64) v1@4471.91,5023.43 ; v1@4461.3,5020.6 ccw(c4451.91,5029.99) 4465.19,5029.99 ccw(c4478.47,5029.99) v1@4469.08,5020.6 ; v1(4465.19,5016.71) 4465.19,5040 4465.19,5064.81 4465.19,5082.16 4438.14,5109.21 4420.79,5109.21 4395,5109.21 3791.71,5109.21 3592.54,5308.37 3141.63,5308.37
  Bottom Layer w4: v1(2198.52,5208.37) 2233.81,5208.37 R44.1@2236,5206.18 ; v1@2202.41,5204.49 cw(c2211.8,5195.1) 2211.8,5208.37 cw(c2211.8,5221.65) v1@2202.41,5212.26 ; v1@2205.24,5201.66 cw(c2221.46,5185.44) 2221.46,5208.37 cw(c2221.46,5231.31) v1@2205.24,5215.09 ; 2217.37,5208.37 cw(c2217.37,5188.04) R44.1@2231.75,5202.42 ; 2218.31,5208.37 ccw(c2218.31,5223.38) R44.1@2228.92,5212.77 ; R44.1@2236,5208.37 R44.1@2236,5206.18 ; R44.1@2236.49,5211.5 ccw(c2236.49,5223.15) R44.1@2244.73,5214.91 ; R44.1@2236.49,5215.5 ccw(c2236.49,5236.81) 2251.56,5221.74 ; R44.1@2241.81,5206.18 cw(c2255.84,5206.18) R44.1@2245.92,5216.1 ; R44.1@2245.81,5206.18 cw(c2269.5,5206.18) 2252.75,5222.93 ; U5.5@2387.57,5296.32 cw(c2380.74,5289.49) 2390.39,5289.49 cw(c2400.05,5289.49) U5.5@2393.22,5296.32 ; U5.5@2390.39,5322.68 2390.39,5267.1 2365,5241.71 2326.21,5241.71 2310.69,5226.19 2256.01,5226.19 R44.1@2236,5206.18
ETH.E_TXD2: R43.1 U5.4 U8.H6 | length 3706.3
  Top Layer w4: v3(5035.67,4465.59) U8.H6@5055.35,4445.91 ; U8.H6@5048.01,4445.91 ccw(c5030.29,4445.91) 5042.82,4458.44 ccw(c5055.35,4470.97) U8.H6@5055.35,4453.25 ; 5048.47,4452.79 cw(c5061.28,4465.59) 5043.17,4465.59 ccw(c5061.28,4465.59) 5048.47,4452.79 ; 5048.47,4452.79 ccw(c5035.67,4439.98) 5035.67,4458.09 cw(c5035.67,4439.98) 5048.47,4452.79
  MidLayer1 w4: v1(2416.86,5368.37) 2434.36,5385.87 2491.67,5385.87 2552.5,5325.04 3598.52,5325.04 3798.36,5125.21 4405,5125.21 4427.42,5125.21 4444.77,5125.21 4565,5004.98 4565,4987.63 4565,4960 4565,4865 4573.52,4856.48 4578.86,4851.14 4578.86,4765 4578.86,4736.14 4600,4715 4600,4670 4600,4640.04 4600,4636.31 4611.27,4625.04 4615,4625.04 4625,4625.04 4647.72,4625.04 4671.03,4601.73 4689.38,4583.37 4705,4583.37 4715.19,4583.37 4798.56,4500.01 4809.11,4489.45 4828.82,4489.45 4838.82,4489.45 4879.25,4489.45 4898.67,4489.45 4972.79,4489.45 ; v1@2416.86,5373.87 ccw(c2416.86,5387.15) 2426.25,5377.76 ccw(c2435.64,5368.37) v1@2422.36,5368.37 ; v1@2416.86,5377.87 ccw(c2416.86,5400.81) 2433.07,5384.59 ccw(c2449.29,5368.37) v1@2426.36,5368.37 ; 4958.86,4489.45 4972.79,4489.45 ; v3@5028.2,4464.94 ccw(c5010.16,4463.36) 5021.8,4477.23 ; v3@5035.02,4473.06 cw(c5033.44,4491.1) 5021.8,4477.23 ; 4972.79,4489.45 4992.29,4489.45 cw(c4992.29,4447.72) 5021.8,4477.23
  Bottom Layer w4: R43.1@2302,5206.18 2329.19,5233.37 2370,5233.37 2370,5233.71 2410.08,5273.79 U5.4@2410.08,5325 ; R43.1@2302.49,5211.5 ccw(c2302.49,5223.15) R43.1@2310.73,5214.91 ; R43.1@2307.81,5206.18 cw(c2321.84,5206.18) R43.1@2311.92,5216.1 ; R43.1@2311.81,5206.18 cw(c2335.5,5206.18) 2318.75,5222.93 ; U5.4@2407.25,5296.32 cw(c2400.41,5289.48) 2410.08,5289.48 ; 2410.08,5289.51 cw(c2419.72,5289.51) U5.4@2412.91,5296.32 ; U5.4@2410.08,5322.68 U5.4@2410.08,5325 ; v1@2410.6,5361.22 cw(c2401.77,5351.12) 2415.19,5351.12 cw(c2424.6,5351.12) v1@2420.75,5359.71 ; v1(2416.86,5368.37) 2415.19,5366.71 2415.19,5351.2 2410.19,5346.2 2410.08,5346.2 U5.4@2410.08,5325
ETH.E_TXD3: R42.1 U5.3 U8.G5 | length 4123.9
  Top Layer w4: v3(4996.3,4504.96) U8.G5@5015.98,4485.28 ; U8.G5@5008.64,4485.28 ccw(c4990.92,4485.28) 5003.45,4497.81 ccw(c5015.98,4510.34) U8.G5@5015.98,4492.62 ; 5009.1,4492.16 cw(c5021.91,4504.96) 5003.8,4504.96 ccw(c5021.91,4504.96) 5009.1,4492.16 ; 5009.1,4492.16 ccw(c4996.3,4479.35) 4996.3,4497.46 cw(c4996.3,4479.35) 5009.1,4492.16
  MidLayer1 w4: v1@2325.14,5215.09 ccw(c2308.92,5231.31) 2331.86,5231.31 ccw(c2354.79,5231.31) v1@2338.57,5215.09 ; v1@2327.97,5212.26 ccw(c2318.58,5221.65) 2331.86,5221.65 ccw(c2345.14,5221.65) v1@2335.75,5212.26 ; v1(2331.86,5208.37) 2331.86,5396.67 2337.81,5402.62 2337.81,5487.81 2358.71,5508.71 2523.71,5508.71 2586,5571 2810.5,5571 2825.46,5556.04 3513.96,5556.04 3530,5540 3745,5540 4034.63,5250.37 4315,5250.37 4331.52,5250.37 4342.23,5250.37 4623.19,4969.41 4623.19,4958.71 4623.19,4920 4623.19,4861.69 4602.86,4841.35 4602.86,4803.9 4602.86,4795 4602.86,4750.02 4615.93,4736.95 4629,4723.88 4629,4713.18 4714.03,4628.16 4714.03,4610.18 4803.74,4520.47 4828.82,4520.47 4838.82,4520.47 4879.25,4520.47 4898.67,4520.47 4958.86,4520.47 4972.79,4520.47 cw(c4972.79,4506.42) 4982.72,4516.35 ; v3@4988.83,4504.31 ccw(c4970.79,4502.73) 4982.43,4516.6 ccw(c4994.07,4530.47) v3@4995.65,4512.43
  Bottom Layer w4: v1(2331.86,5208.37) 2347.86,5208.37 ; v1@2340.2,5203.83 cw(c2347.86,5199.65) 2347.86,5208.37 ; v1@2340.2,5212.92 ccw(c2347.86,5217.1) 2347.86,5208.37 ; R42.1@2359.76,5201 ccw(c2350.05,5194.49) 2350.05,5206.18 ; R42.1@2359.76,5211.37 cw(c2350.05,5217.87) 2350.05,5206.18 ; R42.1@2365.81,5206.18 cw(c2389.06,5206.18) 2372.62,5222.62 ; R42.1@2369.81,5206.18 cw(c2402.72,5206.18) 2379.45,5229.45 ; R42.1@2373.81,5206.18 cw(c2416.37,5206.18) 2386.28,5236.28 ; R42.1@2377.81,5206.18 cw(c2430.03,5206.18) 2393.11,5243.11 ; U5.3@2426.94,5296.32 cw(c2420.11,5289.49) 2429.76,5289.49 cw(c2439.42,5289.49) U5.3@2432.59,5296.32 ; U5.3@2429.76,5322.68 2429.76,5279.76 2368,5218 R42.1@2368,5206.18 2350.05,5206.18 ; 2347.86,5208.37 2350.05,5206.18
ETH.E_TXEN: R41.1 U5.2 U8.G3 | length 3728.7
  Top Layer w4: v1(3523.52,5066.71) 3573.52,5116.71 4431.86,5116.71 4440.19,5108.37 4440.19,5009.81 ; v1@3523.52,5072.21 ccw(c3523.52,5085.49) 3532.91,5076.1 ccw(c3542.3,5066.71) v1@3529.02,5066.71 ; v1@3523.52,5076.21 ccw(c3523.52,5099.14) 3539.74,5082.93 ccw(c3555.96,5066.71) v1@3533.02,5066.71 ; 4448.41,5001.59 4440.19,5009.81 ; 4440.19,5009.81 4537.98,4912.02 4545.36,4904.64 4545.36,4813.91 4640.19,4719.08 4640.19,4579.56 4667.25,4552.5 4702.25,4552.5 4725.15,4529.59 4745.5,4529.59 4765.96,4509.14 4796.07,4509.14 4821,4509.14 4828.82,4509.14 4838.82,4509.14 4897.36,4509.14 ; 4897.36,4509.14 cw(c4897.36,4470.46) 4924.71,4497.81 ; 4897.36,4509.14 cw(c4897.36,4470.46) 4924.71,4497.81 ; 4924.71,4497.81 ccw(c4937.24,4510.34) 4937.24,4492.62 cw(c4937.24,4510.34) 4924.71,4497.81 ; 4924.71,4497.81 cw(c4912.18,4485.28) 4929.9,4485.28 ccw(c4912.18,4485.28) 4924.71,4497.81
  MidLayer2 w4: v1@2615.19,5140.54 cw(c2615.19,5117.61) 2631.41,5133.82 cw(c2647.63,5150.04) v1@2624.69,5150.04 ; v1@2615.19,5144.54 cw(c2615.19,5131.26) 2624.58,5140.65 cw(c2633.97,5150.04) v1@2620.69,5150.04 ; v1(2615.19,5150.04) 2698.52,5066.71 v1(3523.52,5066.71) ; v1@3516.81,5059.99 ccw(c3500.59,5043.77) 3500.59,5066.71 ccw(c3500.59,5089.64) v1@3516.81,5073.43 ; v1@3519.64,5062.82 ccw(c3510.25,5053.43) 3510.25,5066.71 ccw(c3510.25,5079.99) v1@3519.64,5070.6
  Bottom Layer w4: R41.1@2425.73,5201.04 ccw(c2416.18,5194.73) 2416.18,5206.18 ; R41.1@2425.73,5211.32 cw(c2416.18,5217.63) 2416.18,5206.18 ; R41.1@2434.52,5211.5 ccw(c2434.58,5222.94) R41.1@2442.67,5214.85 ; R41.1@2434.54,5215.5 ccw(c2434.65,5236.43) 2449.45,5221.63 ccw(c2463.18,5207.9) R41.1@2443.79,5206.74 ; R41.1@2439.8,5206.5 cw(c2451.31,5207.19) R41.1@2443.16,5215.34 ; U5.2@2446.62,5296.32 cw(c2439.79,5289.49) 2449.45,5289.49 cw(c2459.11,5289.49) U5.2@2452.28,5296.32 ; U5.2@2449.44,5299.15 2449.45,5320.32 U5.2@2449.45,5299.15 ; U5.2@2449.45,5322.68 U5.2@2449.45,5299.15 ; v1@2605.69,5150.04 cw(c2582.76,5150.04) 2598.97,5133.82 cw(c2615.19,5117.61) v1@2615.19,5140.54 ; v1@2609.69,5150.04 cw(c2596.41,5150.04) 2605.8,5140.65 cw(c2615.19,5131.26) v1@2615.19,5144.54 ; v1(2615.19,5150.04) 2575.15,5110 2420,5110 2405,5125 2405,5195 2416.18,5206.18 ; 2416.18,5206.18 R41.1@2434,5206.18 2449.45,5221.63 U5.2@2449.45,5299.15
FLASH_BOOT_CS_N: U30.D2 U69.4 | length 6362.1
  Top Layer w4: v2@6569,2118.19 cw(c6569,2094.5) 6585.75,2111.25 cw(c6602.5,2128) v2@6578.81,2128 ; v2@6569,2122.19 cw(c6569,2108.16) 6578.92,2118.08 cw(c6588.84,2128) v2@6574.81,2128 ; v2(6569,2128) 6626.81,2070.19 6653.15,2070.19 6665.67,2057.67 6695.04,2057.67 6734.38,2057.67 ; v2@7143.19,2834 cw(c7119.5,2834) 7136.25,2817.25 cw(c7153,2800.5) v2@7153,2824.19 ; v2@7147.19,2834 cw(c7133.16,2834) 7143.08,2824.08 cw(c7153,2814.16) v2@7153,2828.19 ; v2(7153,2834) 7118,2799 7118,2775 7118,2723.56 ; v2@7334.19,2418 cw(c7310.5,2418) 7327.25,2401.25 cw(c7344,2384.5) v2@7344,2408.19 ; v2@7338.19,2418 cw(c7324.16,2418) 7334.08,2408.08 cw(c7344,2398.16) v2@7344,2412.19 ; v2(7344,2418) 7274,2348 7250.56,2348 7237.86,2360.7 7237.86,2383.58 7205.5,2415.94 7205.5,2459.19 7162,2502.69 7162,2562.81 7125.31,2599.5 7103.79,2599.5 7076,2627.29 7076,2655 7076,2671 7076,2681.56 7115,2720.56 ; v1@7898.28,4973.28 cw(c7882.06,4957.06) 7905,4957.06 cw(c7927.94,4957.06) v1@7911.72,4973.28 ; v1@7901.11,4976.11 cw(c7891.72,4966.72) 7905,4966.72 cw(c7918.28,4966.72) v1@7908.89,4976.11 ; v1(7905,4980) 7905,4943.8 7975.85,4872.95 ; 7975.9,4873 7975.9,4872.7 8146.5,4702.1 8195.24,4702.1 8224.02,4673.31 8224.02,4570 8224.02,4110.74 8148.19,4034.91 8148.19,3923.81 v2(8166,3906) ; v2@8156.19,3906 ccw(c8132.5,3906) 8149.25,3922.75 ccw(c8166,3939.5) v2@8166,3915.81 ; v2@8160.19,3906 ccw(c8146.16,3906) 8156.08,3915.92 ccw(c8166,3925.84) v2@8166,3911.81 ; 6734.38,2057.67 cw(c6734.38,2047.52) 6741.56,2054.7 ; 6734.38,2057.67 cw(c6734.38,2047.52) 6741.56,2054.7 ; 6741.56,2054.7 cw(c6729.03,2042.16) 6746.75,2042.16 ccw(c6729.03,2042.16) 6741.56,2054.7 ; 6741.56,2054.7 ccw(c6754.09,2067.23) 6754.09,2049.51 cw(c6754.09,2067.23) 6741.56,2054.7 ; 7115,2720.56 7118,2723.56 ; 7115,2720.56 7118,2723.56
  MidLayer1 w4: v2@6562.06,2134.94 ccw(c6545.31,2151.69) 6569,2151.69 ccw(c6592.69,2151.69) v2@6575.94,2134.94 ; v2@6564.89,2132.11 ccw(c6554.97,2142.03) 6569,2142.03 ccw(c6583.03,2142.03) v2@6573.11,2132.11 ; v2(6569,2128) 6569,2193 6588.87,2212.87 6589.09,2212.87 6652,2275.79 6652,2295.69 6666.03,2309.72 6672.5,2316.19 6702.62,2316.19 6717.38,2316.19 6746.19,2316.19 6801.81,2371.81 6801.81,2400.62 6801.81,2410 6801.81,2460 6832.69,2490.87 6832.69,2521.69 6884,2573 6928.87,2573 6940.5,2584.63 6940.5,2601.5 6940.5,2615 6940.5,2750.6 7014.95,2825.05 ; 7015,2825 7024,2834 v2(7153,2834) ; v2@7146.06,2827.06 ccw(c7129.31,2810.31) 7129.31,2834 ccw(c7129.31,2857.69) v2@7146.06,2840.94 ; v2@7148.89,2829.89 ccw(c7138.97,2819.97) 7138.97,2834 ccw(c7138.97,2848.03) v2@7148.89,2838.11 ; v2(7564,2526) 7573.19,2535.19 7583.94,2545.94 7583.94,2585.71 7623.19,2624.96 ; v2@7564,2531.81 ccw(c7564,2545.84) 7573.92,2535.92 ccw(c7583.84,2526) v2@7569.81,2526 ; v2@7564,2535.81 ccw(c7564,2559.5) 7580.75,2542.75 ccw(c7597.5,2526) v2@7573.81,2526 ; v2@8159.06,3899.06 cw(c8142.31,3882.31) 8166,3882.31 cw(c8189.69,3882.31) v2@8172.94,3899.06 ; v2@8161.89,3901.89 cw(c8151.97,3891.97) 8166,3891.97 cw(c8180.03,3891.97) v2@8170.11,3901.89 ; v2(8166,3906) 8166,3880.27 8036.73,3751 7980.73,3751 7815.02,3585.29 7815.02,3567.79 7790.69,3543.46 7790.69,3404.27 7790.69,3383.15 7786.02,3378.48 7786.02,3293.43 7798.19,3281.27 7798.19,3257.35 7740.67,3199.83 7740.67,2899.15 7743.81,2896 7743.81,2868 7743.81,2757.94 7623.19,2637.32 ; 7623.19,2624.96 7623.19,2637.32 ; 7623.19,2624.96 7623.19,2637.32
  Bottom Layer w4: v2@7337.06,2424.94 ccw(c7320.31,2441.69) 7344,2441.69 ccw(c7367.69,2441.69) v2@7350.94,2424.94 ; v2@7339.89,2422.11 ccw(c7329.97,2432.03) 7344,2432.03 ccw(c7358.03,2432.03) v2@7348.11,2422.11 ; v2@7344,2420 v2(7344,2418) 7344,2490.18 7379.82,2526 v2(7564,2526) ; v2@7557.06,2519.06 ccw(c7540.31,2502.31) 7540.31,2526 ccw(c7540.31,2549.69) v2@7557.06,2532.94 ; v2@7559.89,2521.89 ccw(c7549.97,2511.97) 7549.97,2526 ccw(c7549.97,2540.03) v2@7559.89,2530.11 ; v1(7905,4980) 7905,4970.93 U69.4@8047.4,4828.53 ; v1@7906.5,4980 ccw(c7932.02,4980) 7913.97,4961.96 ; v1@7910.5,4980 ccw(c7945.67,4980) 7920.8,4955.13 ; v1@7914.5,4980 ccw(c7959.33,4980) 7927.63,4948.3 ; 8022.25,4853.68 ccw(c8047.4,4878.83) U69.4@8047.4,4843.27 ; 8029.08,4846.85 ccw(c8047.4,4865.18) U69.4@8047.4,4839.27 ; 8035.9,4840.03 ccw(c8047.4,4851.52) U69.4@8047.4,4835.27
FLASH_BOOT_DOUT: R160.1 U30.H2 | length 1369.9
  Top Layer w4: v1(6463,1707) 6463,1709 6482.19,1728.19 6482.19,1783.63 6485.7,1787.14 6514.3,1787.14 6521.44,1780 6533.19,1780 6545.81,1792.62 6545.81,1800 ; v1@6463,1716.5 ccw(c6463,1734.61) 6475.8,1721.8 ; v1@6468.5,1707 cw(c6486.61,1707) 6473.8,1719.8 ; v1@6472.5,1707 cw(c6500.26,1707) 6480.63,1726.63 ; 6545.81,1809.38 6545.81,1800 ; 6545.81,1800 6545.81,1812.37 6536,1822.18 6525.81,1832.37 6525.81,1907.62 6536.24,1918.06 6564.75,1918.06 6597.81,1885 6613,1885 6628.19,1900.19 6695.04,1900.19 6734.38,1900.19 ; 6734.38,1900.19 cw(c6734.38,1890.04) 6741.56,1897.22 ; 6734.38,1900.19 cw(c6734.38,1890.04) 6741.56,1897.22 ; 6741.56,1897.22 cw(c6729.03,1884.68) 6746.75,1884.68 ccw(c6729.03,1884.68) 6741.56,1897.22 ; 6741.56,1897.22 ccw(c6754.09,1909.75) 6754.09,1892.03 cw(c6754.09,1909.75) 6741.56,1897.22
  Bottom Layer w4: R160.1@5906.18,1590 6114,1590 6256,1732 6308,1732 6315,1725 6315,1703.81 6326.62,1692.19 6344.7,1692.19 6344.85,1692.04 6360.62,1707.81 6383,1707.81 6394.62,1696.19 6420,1696.19 6430.81,1707 v1@6456.48,1707 ; v1@6456.28,1700.28 ccw(c6440.06,1684.06) 6440.06,1707 ccw(c6440.06,1729.93) v1@6456.28,1713.72 ; v1@6459.11,1703.11 ccw(c6449.72,1693.72) 6449.72,1707 ccw(c6449.72,1720.28) v1@6459.11,1710.89 ; v1@6456.48,1707 v1(6463,1707) 6462,1708 6457.48,1708 v1@6456.48,1707
FLASH_BOOT_SEL: J24.1 R266.1 U30.K16 U69.6 | length 6560.6
  Top Layer w4: v1(6990.19,2425.04) 7023.52,2425.04 7060.19,2461.71 7068.82,2461.71 ; v1@6994.08,2421.15 cw(c7003.47,2411.76) 7003.47,2425.04 cw(c7003.47,2438.32) v1@6994.08,2428.93 ; v1@6996.91,2418.32 cw(c7013.13,2402.11) 7013.13,2425.04 cw(c7013.12,2447.98) v1@6996.91,2431.76 ; 7049.96,2451.48 ccw(c7026.93,2474.51) R266.1@7059.5,2474.51 ; 7056.79,2458.31 ccw(c7040.59,2474.51) R266.1@7063.5,2474.51 ; 7060.03,2461.55 cw(c7068.82,2452.76) R266.1@7068.82,2465.19 ; R266.1@7068.82,2475 7068.82,2461.71 ; U30.K16@7305.28,1805.94 7374.06,1805.94 7380,1800 ; U30.K16@7310.47,1800.75 cw(c7323,1788.22) 7323,1805.94 cw(c7323,1823.67) U30.K16@7310.47,1811.14 ; v1@7392.64,1794 ccw(c7380,1783.7) 7380,1800 ; v1@7392.64,1806 cw(c7380,1816.3) 7380,1800 ; v1@7395.74,1796.53 ccw(c7388.42,1790.56) 7388.42,1800 ccw(c7388.42,1809.44) v1@7395.74,1803.47 ; v1(7400,1800) 7380,1800 ; 7068.82,2461.71 ccw(c7064.69,2461.71) 7065.96,2465.64 cw(c7064.69,2461.71) 7068.82,2461.71 ; 7068.82,2461.71 cw(c7072.95,2461.71) 7071.68,2465.64 ccw(c7072.95,2461.71) 7068.82,2461.71
  MidLayer1 w4: v1@7740,1774 7786.81,1820.81 7786.81,1946.81 7809.81,1969.81 7809.81,1976.94 7826.19,1993.32 7826.19,2004 7864.5,2042.32 7864.5,2208.65 7855.36,2217.79 7855.36,2232.29 7865.36,2242.29 7865.36,2280 7865.36,2305.58 7865.36,2343.14 ; v1@7798.28,2613.28 cw(c7782.06,2597.06) 7805,2597.06 cw(c7827.94,2597.06) v1@7811.72,2613.28 ; v1@7800.59,2628.41 ccw(c7788.51,2651.43) 7814.5,2651.43 ; v1@7801.11,2616.11 cw(c7791.72,2606.72) 7805,2606.72 cw(c7818.28,2606.72) v1@7808.89,2616.11 ; v1@7802.44,2624.87 ccw(c7791.98,2644.81) 7814.5,2644.81 ; v1@7804.3,2621.33 ccw(c7795.45,2638.2) 7814.5,2638.2 ; v1@7806.16,2617.79 ccw(c7798.92,2631.58) 7814.5,2631.58 ; 7865,2343.5 7819,2389.5 7819,2486.19 7808.5,2496.69 7808.5,2516.12 7808.5,2588 7805,2591.5 v1(7805,2620) 7814.5,2629.5 7814.5,2651.43 ; J24.1@8074.71,4925.38 8215,4785.09 8215,4770 8215,4596.57 8205,4586.57 8205,4243.43 8224.02,4224.41 8224.02,3881.73 8148.7,3806.4 8134.23,3791.94 8133.41,3791.11 8083.36,3741.06 8083.36,3688.36 8017.21,3622.21 8014.78,3619.78 7948.72,3619.78 7922.69,3593.75 7922.69,3559.19 7922.69,3540 7922.69,3436.94 7940.69,3418.94 7940.69,3260.69 7797.69,3117.69 7797.69,3101.13 7797.69,2935 7797.69,2925 7797.69,2921.32 7799.81,2919.2 7799.81,2845 7799.81,2794.69 7799.81,2770.44 7814.5,2755.76 7814.5,2735 7814.5,2725.26 7814.5,2720 7814.5,2676.74 7814.5,2656.86 7814.5,2651.43
  MidLayer2 w4: v1(7400,1800) 7441.5,1800 7443.31,1801.81 7464.69,1801.81 7474.31,1792.19 7485.16,1781.34 7596.84,1781.34 7697.25,1781.34 7740.91,1825 7815,1825 7924.31,1825 7942.02,1807.29 7942.02,1788.02 7928.84,1774.84 7890,1774.84 v1(7738.12,1774.84) ; v1@7403.89,1796.11 cw(c7413.28,1786.72) 7413.28,1800 cw(c7413.28,1813.28) v1@7403.89,1803.89 ; v1@7406.72,1793.28 cw(c7422.94,1777.06) 7422.94,1800 cw(c7422.94,1822.93) v1@7406.72,1806.72 ; v1@7490,2750.5 cw(c7490,2722.74) 7509.63,2742.37 ; v1@7490,2754.5 cw(c7490,2736.39) 7502.8,2749.2 ; v1@7492,2760 7555,2697 v1(7555,2595) ; v1@7499.5,2760 ccw(c7517.61,2760) 7504.8,2747.2 ; v1@7548.28,2601.72 ccw(c7532.06,2617.93) 7555,2617.93 ccw(c7577.94,2617.93) v1@7561.72,2601.72 ; v1@7551.11,2598.89 ccw(c7541.72,2608.28) 7555,2608.28 ccw(c7568.28,2608.28) v1@7558.89,2598.89
  Bottom Layer w4: v1@6983.47,2431.76 ccw(c6967.26,2447.98) 6990.19,2447.98 ccw(c7013.13,2447.98) v1@6996.91,2431.76 ; v1@6986.3,2428.93 ccw(c6976.91,2438.32) 6990.19,2438.32 ccw(c7003.47,2438.32) v1@6994.08,2428.93 ; v1(6990.19,2425.04) 6990.19,2455.19 7015.81,2480.81 7015.81,2489.06 7059.56,2532.81 7077.38,2532.81 ; 7077.69,2532.5 7110,2532.5 7122.5,2532.5 7186.68,2532.5 7196.56,2532.5 7199.06,2535 7200.25,2536.19 7209.53,2545.47 7230,2565.94 7230,2670.62 7319.38,2760 7330,2760 7390,2760 v1(7490,2760) ; v1@7483.28,2753.28 ccw(c7467.06,2737.06) 7467.06,2760 ccw(c7467.06,2782.93) v1@7483.28,2766.72 ; v1@7486.11,2756.11 ccw(c7476.72,2746.72) 7476.72,2760 ccw(c7476.72,2773.28) v1@7486.11,2763.89 ; v1(7555,2595) 7587.86,2595 7592.86,2600 ; v1@7558.89,2591.11 cw(c7568.28,2581.72) 7568.28,2595 cw(c7568.28,2608.28) v1@7558.89,2598.89 ; v1@7561.72,2588.28 cw(c7577.94,2572.06) 7577.94,2595 cw(c7577.94,2617.93) v1@7561.72,2601.72 ; 7592.98,2599.87 7620.73,2599.87 7647.19,2626.33 7647.19,2627.38 7657.62,2637.81 7682.38,2637.81 7697.38,2622.81 7710,2622.81 7726.79,2622.81 7729.6,2620 v1(7805,2620) ; J24.1@8074.71,4925.38 8098.58,4901.51 U69.6@8098.58,4828.53 ; U69.6@8094.42,4841.55 ccw(c8084.4,4851.57) 8098.58,4851.57 ccw(c8112.76,4851.57) U69.6@8102.73,4841.55
GND: BT1.2 C1.2 C2.2 C3.2 C4.2 C7.2 C13.2 C18.2 C20.2 C21.2 C33.2 C34.2 C35.2 C36.2 C37.1 C39.1 C40.2 C41.1 C42.1 C43.2 C44.2 C45.1 C46.1 C47.1 C48.1 C49.2 C50.1 C51.1 C52.1 C53.1 C54.1 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.1 C89.2 C90.1 C91.1 C92.1 C93.2 C94.2 C95.2 C96.2 C98.2 C99.1 C100.2 C115.2 C116.2 C121.1 C122.1 C123.1 C124.1 C125.1 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C151.2 C152.1 C153.2 C154.2 C155.2 C156.2 C157.1 C158.2 C159.1 C160.2 C161.1 C162.2 C163.1 C164.2 C165.1 C166.2 C167.2 C168.2 C169.1 C170.1 C171.2 C172.1 C173.1 C174.1 C175.2 C176.2 C177.2 C184.2 C185.2 C187.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C231.2 C232.2 C233.2 C234.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C307.2 C308.2 C309.2 C310.2 C313.2 C314.2 C315.2 C316.2 C317.2 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C335.2 C336.2 C337.2 C338.2 C339.2 C340.2 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 D2.1 D7.1 D10.1 EXTHDR1.1 EXTHDR1.3 EXTHDR1.5 EXTHDR1.95 EXTHDR1.97 EXTHDR1.99 EXTHDR1.MH1 EXTHDR1.MH2 EXTHDR1.MH3 EXTHDR1.MH4 J1.1 J1.2 J2.1 J2.2 J3.1 J3.2 J8.8 J8.10 J9.5 J10.5 J12.1 J16.6 J17.5 J18.5 J18.6 J18.7 J18.8 J18.10 J19.2 J19.3 J25.9 J25.10 J29.3 J29.6 J29.GND1 J29.GND2 J30.3 J30.6 J30.GND1 J30.GND2 J31.3 J32.3 J33.A38 J33.A39 J33.A40 J33.B38 J36.4 J37.4 J38.4 LED1.2 LED4.2 LED5.2 LED6.2 LED7.2 NT1.2 NT5.2 NT6.2 NT7.2 NT11.2 NT28.2 NT29.2 NT30.2 NT31.2 NT38.2 NT39.2 NT40.2 NT41.2 NT44.1 NT47.1 NT48.1 PROTOTYPE1.1 PROTOTYPE1.3 PROTOTYPE1.5 PROTOTYPE1.27 PROTOTYPE1.29 PROTOTYPE1.31 Q1.3 Q2.3 Q3.3 Q4.3 Q5.3 Q6.3 Q7.3 Q8.3 Q11.3 R30.2 R34.2 R36.2 R38.1 R41.2 R42.2 R43.2 R44.2 R45.2 R46.2 R47.2 R51.2 R52.2 R56.1 R60.1 R61.2 R64.1 R65.2 R91.1 R93.1 R95.1 R97.1 R109.2 R111.2 R116.1 R117.2 R118.1 R119.2 R120.1 R121.1 R122.1 R124.1 R126.1 R128.1 R130.1 R155.1 R157.1 R202.2 R204.2 R206.2 R208.2 R246.2 R257.2 R258.2 R259.2 R266.2 R284.1 R285.1 R286.1 R287.1 R288.1 R289.1 R290.1 R291.1 R292.1 R293.1 R294.1 R295.1 R296.1 R297.1 R298.1 R299.1 R300.1 R301.1 R302.1 R303.1 R304.1 R305.1 R306.1 R307.1 R308.1 R309.1 R310.1 R311.1 R312.1 R313.1 SW1.3 SW2.3 SW3.3 SW4.3 SW5.3 SW6.3 SW6.4 SW8.1 SW8.2 SW8.3 SW8.4 SW8.5 SW8.6 SW8.7 SW8.8 T1.1 TP1.1 TP8.1 U1.6 U1.13 U2.5 U3.5 U3.7 U3.13 U4.3 U5.11 U5.17 U5.29 U5.35 U5.40 U5.43 U5.45 U6.1 U6.2 U6.4 U6.10 U6.11 U6.13 U6.15 U6.17 U7.E8 U7.H2 U7.H7 U8.AA2 U8.AA9 U8.AA20 U8.AA27 U8.AC6 U8.AC9 U8.AC13 U8.AC16 U8.AC20 U8.AC23 U8.AF1 U8.AF28 U8.AG2 U8.AG5 U8.AG9 U8.AG13 U8.AG16 U8.AG20 U8.AG24 U8.AG27 U8.B2 U8.B5 U8.B9 U8.B13 U8.B16 U8.B20 U8.B24 U8.B27 U8.C1 U8.C28 U8.F6 U8.F9 U8.F13 U8.F16 U8.F20 U8.F23 U8.H2 U8.H9 U8.H20 U8.H27 U8.J11 U8.J18 U8.K6 U8.K10 U8.K12 U8.K14 U8.K16 U8.K18 U8.K20 U8.K23 U8.L9 U8.L11 U8.L13 U8.L15 U8.L17 U8.L19 U8.M10 U8.M12 U8.M14 U8.M16 U8.M18 U8.M20 U8.M22 U8.N2 U8.N6 U8.N9 U8.N11 U8.N13 U8.N15 U8.N17 U8.N19 U8.N22 U8.N23 U8.N27 U8.P10 U8.P12 U8.P14 U8.P16 U8.P18 U8.P20 U8.P22 U8.P23 U8.R8 U8.R9 U8.R11 U8.R13 U8.R15 U8.R17 U8.R19 U8.T2 U8.T6 U8.T10 U8.T12 U8.T14 U8.T16 U8.T18 U8.T20 U8.T23 U8.T27 U8.U9 U8.U11 U8.U13 U8.U15 U8.U17 U8.U19 U8.V10 U8.V12 U8.V14 U8.V16 U8.V18 U8.W6 U8.W11 U8.W13 U8.W15 U8.W17 U8.W19 U8.W23 U8.Y11 U8.Y18 U9.2 U10.2 U11.2 U12.6 U12.12 U12.28 U12.41 U12.46 U12.52 U12.54 U13.6 U13.12 U13.28 U13.41 U13.46 U13.52 U13.54 U14.12 U14.34 U15.12 U15.34 U16.12 U16.34 U17.12 U17.34 U18.2 U19.6 U19.10 U19.12 U19.14 U19.26 U19.28 U19.41 U19.44 U19.53 U19.56 U20.2 U21.11 U21.25 U21.42 U21.46 U21.47 U21.48 U22.2 U23.1 U27.7 U30.B2 U30.B15 U30.C5 U30.C12 U30.D7 U30.D10 U30.E4 U30.E12 U30.E13 U30.G4 U30.G12 U30.G13 U30.H7 U30.H8 U30.H9 U30.H10 U30.H13 U30.J3 U30.J7 U30.J8 U30.J9 U30.J10 U30.K4 U30.K13 U30.M4 U30.M5 U30.M13 U30.N7 U30.N10 U30.P5 U30.P12 U30.R2 U30.R15 U31.7 U32.7 U33.7 U34.7 U35.7 U36.5 U37.3 U38.3 U42.3 U45.1 U46.6 U46.7 U47.12 U47.34 U48.6 U48.7 U48.8 U49.1 U50.4 U51.4 U52.4 U53.4 U54.3 U55.2 U56.6 U56.10 U56.12 U56.14 U56.26 U56.28 U56.41 U56.44 U56.53 U56.56 U59.15 U60.1 U61.3 U61.4 U61.8 U61.14 U61.15 U61.17 U61.19 U61.22 U61.24 U61.26 U61.29 U61.31 U61.33 U61.36 U61.44 U61.53 U61.55 U61.63 U61.71 U61.79 U61.81 U61.88 U61.90 U61.99 U61.109 U61.117 U61.121 U61.123 U62.2 U63.2 U64.2 U65.3 U66.3 U67.3 U68.3 U69.2 U70.4 U71.3 U72.3 UH1.20 UH2.20 Y1.2 Y1.4 Y2.2 Y2.4 Y3.2 Y3.3 Y4.2 Y4.4 Y5.2 Y5.4 | length 143199.4