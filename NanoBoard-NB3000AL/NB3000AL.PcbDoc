# Altium PCB NB3000AL.PcbDoc (part 38 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_SRAM2.A13: U8.N21 U15.26 | length 1583.9
  Top Layer w4: U8.N21@5645.91,4249.05 v3(5665.59,4268.74) ; U8.N21@5645.91,4256.4 ccw(c5645.91,4274.12) 5658.44,4261.59 ccw(c5670.97,4249.05) U8.N21@5653.25,4249.05 ; 5652.79,4255.94 cw(c5665.59,4243.13) 5665.59,4261.24 ccw(c5665.59,4243.13) 5652.79,4255.94 ; 5652.79,4255.94 ccw(c5639.98,4268.74) 5658.09,4268.74 cw(c5639.98,4268.74) 5652.79,4255.94
  MidLayer2 w4: v3@5666.24,4276.21 ccw(c5667.82,4294.25) 5679.46,4280.38 ; v3@5673.06,4268.09 cw(c5691.1,4266.51) 5679.46,4280.38 ; v1@6748.9,4283 v1(6758,4283) 6747.63,4293.37 6700.19,4293.37 6681.86,4275.04 6560,4275.04 6539.96,4275.04 6527.59,4275.04 6512.63,4290 6511.63,4291 6362.46,4291 6336.92,4316.54 6255.08,4316.54 6231.12,4340.5 6143.44,4340.5 6126.44,4323.5 6004.81,4323.5 5973.91,4292.6 5822.01,4292.6 5802.59,4292.6 5728.47,4292.6 5708.97,4292.6 ccw(c5708.97,4250.87) 5679.46,4280.38
  Bottom Layer w4: v1(6758,4283) 6758,4283.85 6773.52,4299.37 ; v1@6758,4288.5 ccw(c6758,4299.72) 6765.94,4291.79 ; v1@6758,4292.5 ccw(c6758,4313.38) 6772.77,4298.62 ; v1@6763.49,4283.31 cw(c6776.23,4284.04) 6767.21,4293.06 ; v1@6767.48,4283.54 cw(c6788.18,4284.71) 6773.52,4299.37 ; 6812.39,4414.66 ccw(c6821.68,4423.95) U15.26@6825.63,4411.41 ; 6817.05,4409.99 ccw(c6823.92,4416.86) U15.26@6826.83,4407.59 ; 6817.75,4409.29 cw(c6812.23,4403.78) U15.26@6820.03,4403.78 ; U15.26@6845.59,4403.78 6823.26,4403.78 6810,4417.04 6789.52,4417.04 6773.52,4401.04 6773.52,4299.37
DB_SRAM2.A14: U8.L23 U15.27 | length 1527.4
  Top Layer w4: U8.L23@5724.65,4327.8 v3(5744.33,4347.48) ; U8.L23@5724.65,4335.14 ccw(c5724.65,4352.86) 5737.18,4340.33 ccw(c5749.71,4327.8) U8.L23@5731.99,4327.8 ; 5731.53,4334.68 cw(c5744.33,4321.87) 5744.33,4339.98 ccw(c5744.33,4321.87) 5731.53,4334.68 ; 5731.53,4334.68 ccw(c5718.72,4347.48) 5736.83,4347.48 cw(c5718.72,4347.48) 5731.53,4334.68
  MidLayer1 w4: v3@5744.98,4354.95 ccw(c5746.56,4372.99) 5758.2,4359.12 ; v3@5751.8,4346.83 cw(c5769.84,4345.25) 5758.2,4359.12 ; 5821.14,4371.34 5807.21,4371.34 ; v1(6890.19,4442.71) 6874.52,4458.37 6632.86,4458.37 6615.19,4476.04 6422.52,4476.04 6397.69,4500.87 6391.02,4507.54 6222.69,4507.54 6216.02,4500.87 6213.43,4498.28 6102.65,4387.5 6010.44,4387.5 5994.28,4371.34 5949.18,4371.34 5941.18,4371.34 5900.75,4371.34 5881.33,4371.34 5807.21,4371.34 ; 5758.2,4359.12 cw(c5787.71,4329.61) 5787.71,4371.34 5807.21,4371.34
  Bottom Layer w4: U15.27@6845.59,4435.27 6882.76,4435.27 v1(6890.19,4442.71) ; U15.27@6849.31,4435.27 ccw(c6849.31,4483.59) v1@6883.47,4449.43 ; U15.27@6858.97,4435.27 ccw(c6858.97,4473.93) v1@6886.3,4446.6 ; U15.27@6868.62,4435.27 ccw(c6868.62,4464.27) v1@6889.13,4443.77 ; 6878.28,4435.27 ccw(c6878.28,4454.62) v1@6891.96,4440.94
DB_SRAM2.A15: U8.E18 U15.42 | length 2261.2
  Top Layer w4: U8.E18@5527.8,4564.02 v3(5547.48,4583.7) ; U8.E18@5527.8,4571.36 ccw(c5527.8,4589.08) 5540.33,4576.55 ccw(c5552.86,4564.02) U8.E18@5535.14,4564.02 ; 5534.68,4570.9 cw(c5547.48,4558.09) 5547.48,4576.2 ccw(c5547.48,4558.09) 5534.68,4570.9 ; 5534.68,4570.9 ccw(c5521.87,4583.7) 5539.98,4583.7 cw(c5521.87,4583.7) 5534.68,4570.9
  MidLayer1 w4: v3@5546.83,4591.17 ccw(c5545.25,4609.21) 5559.12,4597.57 ccw(c5572.99,4585.93) v3@5554.95,4584.35 ; 5558.87,4597.28 ccw(c5548.94,4607.21) 5562.99,4607.21 5562.99,4621.14 5562.99,4681.33 5562.99,4700.75 5562.99,4741.18 5562.99,4749.18 5562.99,4780.36 5566,4783.37 5566,4832.75 5628,4894.75 5628,4953 5658.37,4983.37 5887.01,4983.37 5973.34,4897.05 5973.34,4890.48 6039.6,4824.21 6063.11,4824.21 6073.36,4834.46 6073.36,4867.21 6056.86,4883.71 6056.86,4908.37 6066.02,4917.54 6102.46,4917.54 6111.63,4908.37 6354.56,4908.37 6371,4924.81 6399,4924.81 6412.63,4911.19 6700.85,4911.19 6745.87,4956.21 6873.42,4956.21 6882.92,4946.71 v1(6906.86,4946.71) ; v1@6900.14,4939.99 ccw(c6883.92,4923.77) 6883.92,4946.71 ccw(c6883.92,4969.64) v1@6900.14,4953.43 ; v1@6902.97,4942.82 ccw(c6893.58,4933.43) 6893.58,4946.71 ccw(c6893.58,4959.99) v1@6902.97,4950.6
  Bottom Layer w4: U15.42@6845.59,4907.72 6873.15,4907.72 6881.15,4915.72 ; U15.42@6863.15,4907.72 ccw(c6868.03,4915.04) 6874.25,4908.82 ; U15.42@6865.37,4911.04 ccw(c6870.79,4919.18) 6877.7,4912.27 ; U15.42@6867.59,4914.37 ccw(c6873.55,4923.32) 6881.15,4915.72 ; 6888.05,4924.23 ccw(c6865.57,4946.71) v1@6897.36,4946.71 ; 6894.88,4931.06 ccw(c6879.23,4946.71) v1@6901.36,4946.71 ; 6896.9,4933.08 cw(c6906.86,4923.13) v1@6906.86,4937.21 ; v1(6906.86,4946.71) 6906.86,4943.04 6881.15,4917.33 6881.15,4915.72
DB_SRAM2.A16: U8.H16 U15.43 | length 2716.3
  Top Layer w4: U8.H16@5449.06,4445.91 v3(5468.74,4465.59) ; U8.H16@5449.05,4453.25 ccw(c5449.05,4470.97) 5461.59,4458.44 ccw(c5474.12,4445.91) U8.H16@5456.4,4445.91 ; v1@5693.28,4921.72 ccw(c5677.06,4937.93) 5700,4937.93 ccw(c5722.93,4937.93) v1@5706.72,4921.72 ; v1@5696.11,4918.89 ccw(c5686.72,4928.28) 5700,4928.28 ccw(c5713.28,4928.28) v1@5703.89,4918.89 ; v1@5698.52,4915.71 5699.23,4915 v1(5700,4915) 5700,5051.52 v1(5715.19,5066.71) ; 5455.94,4452.79 cw(c5468.74,4439.98) 5468.74,4458.09 ccw(c5468.74,4439.98) 5455.94,4452.79 ; 5455.94,4452.79 ccw(c5443.13,4465.59) 5461.24,4465.59 cw(c5443.13,4465.59) 5455.94,4452.79
  MidLayer1 w4: v1(5715.19,5066.71) 5766.52,5066.71 5894.52,5194.71 6553.54,5194.71 6572.21,5176.04 6798.52,5176.04 6906.86,5067.71 v1(6906.86,5041.71) ; v1@5719.08,5062.82 cw(c5728.47,5053.43) 5728.47,5066.71 cw(c5728.47,5079.99) v1@5719.08,5070.6 ; v1@5721.91,5059.99 cw(c5738.13,5043.77) 5738.13,5066.71 cw(c5738.13,5089.64) v1@5721.91,5073.43 ; v1@6900.14,5048.43 ccw(c6883.92,5064.64) 6906.86,5064.64 ccw(c6929.79,5064.64) v1@6913.57,5048.43 ; v1@6902.97,5045.6 ccw(c6893.58,5054.99) 6906.86,5054.99 ccw(c6920.14,5054.99) v1@6910.75,5045.6
  MidLayer2 w4: v3@5468.09,4473.06 ccw(c5466.51,4491.1) 5480.38,4479.46 ; v3@5476.21,4466.24 cw(c5494.25,4467.82) 5480.38,4479.46 ; v1@5692.64,4909 ccw(c5680,4898.7) 5680,4915 ; v1@5692.64,4921 cw(c5680,4931.3) 5680,4915 ; v1@5695.74,4911.53 ccw(c5688.42,4905.56) 5688.42,4915 ccw(c5688.42,4924.44) v1@5695.74,4918.47 ; v1(5700,4915) 5680,4915 ; 5480.38,4479.46 ccw(c5450.87,4508.97) 5492.6,4508.97 5492.6,4528.47 5492.6,4602.59 5492.6,4622.01 5492.6,4741.18 5492.6,4751.18 5492.6,4798.79 5518.86,4825.04 5565.54,4825.04 5578.08,4812.5 5600.44,4790.15 5629.05,4790.15 5668,4829.1 5668,4867.85 5675,4874.85 5675,4880.94 5675,4910 5680,4915
  Bottom Layer w4: U15.43@6845.59,4939.21 6878.82,4939.21 ; U15.43@6869.63,4934.52 cw(c6878.82,4927.87) 6878.82,4939.21 ; U15.43@6869.63,4943.9 ccw(c6878.82,4950.55) 6878.82,4939.21 ; v1@6900.14,5034.99 cw(c6883.92,5018.77) 6906.86,5018.77 cw(c6929.79,5018.77) v1@6913.57,5034.99 ; v1@6902.97,5037.82 cw(c6893.58,5028.43) 6906.86,5028.43 cw(c6920.14,5028.43) v1@6910.75,5037.82 ; v1(6906.86,5041.71) 6906.86,5017.41 6881.15,4991.71 6881.15,4941.54 6878.82,4939.21
DB_SRAM2.A17: U8.D16 U15.44 | length 2298.3
  Top Layer w4: U8.D16@5449.06,4603.39 v3(5468.74,4623.07) ; U8.D16@5449.05,4610.73 ccw(c5449.05,4628.45) 5461.59,4615.92 ccw(c5474.12,4603.39) U8.D16@5456.4,4603.39 ; 5455.94,4610.27 cw(c5468.74,4597.46) 5468.74,4615.57 ccw(c5468.74,4597.46) 5455.94,4610.27 ; 5455.94,4610.27 ccw(c5443.13,4623.07) 5461.24,4623.07 cw(c5443.13,4623.07) 5455.94,4610.27
  MidLayer1 w4: v3@5463.55,4628.26 ccw(c5451.01,4640.8) 5468.74,4640.8 ccw(c5486.47,4640.8) v3@5473.93,4628.26 ; v3(5468.74,4623.07) 5468.74,4700.75 5468.74,4741.18 5468.74,4751.26 5468.74,4768.24 5491.5,4791 5491.5,4815.64 5540.19,4864.33 5540.19,4919.69 5541.81,4921.31 5541.81,4948.68 5610.01,5016.88 5634.84,5041.71 5752.84,5041.71 5897.84,5186.71 6550.23,5186.71 6568.9,5168.04 6755,5168.04 6791.52,5168.04 6795.21,5168.04 6873.52,5089.73 6873.52,5086.04 v1(6873.52,5060.04) ; v1@6866.81,5066.76 ccw(c6850.59,5082.98) 6873.52,5082.98 ccw(c6896.46,5082.98) v1@6880.24,5066.76 ; v1@6869.64,5063.93 ccw(c6860.25,5073.32) 6873.52,5073.32 ccw(c6886.8,5073.32) v1@6877.41,5063.93 ; 5468.74,4641.18 cw(c5450.63,4641.18) 5463.44,4628.37 ccw(c5450.63,4641.18) 5468.74,4641.18 ; 5468.74,4641.18 ccw(c5486.85,4641.18) 5474.04,4628.37 cw(c5486.85,4641.18) 5468.74,4641.18
  Bottom Layer w4: U15.44@6839.93,4976.36 ccw(c6826.28,4990.02) 6845.59,4990.02 ccw(c6864.9,4990.02) U15.44@6851.25,4976.36 ; U15.44@6845.59,4970.71 6845.59,5032.11 v1(6873.52,5060.04) ; v1@6864.02,5060.04 cw(c6841.09,5060.04) 6857.31,5043.82 cw(c6873.52,5027.61) v1@6873.52,5050.54 ; v1@6868.02,5060.04 cw(c6854.75,5060.04) 6864.14,5050.65 cw(c6873.52,5041.26) v1@6873.52,5054.54
DB_SRAM2.A18: U8.L22 U15.28 | length 1553.4
  Top Layer w4: U8.L22@5685.28,4327.8 v3(5704.96,4347.48) ; U8.L22@5685.28,4335.14 ccw(c5685.28,4352.86) 5697.81,4340.33 ccw(c5710.34,4327.8) U8.L22@5692.62,4327.8 ; 5692.16,4334.68 cw(c5704.96,4321.87) 5704.96,4339.98 ccw(c5704.96,4321.87) 5692.16,4334.68 ; 5692.16,4334.68 ccw(c5679.35,4347.48) 5697.46,4347.48 cw(c5679.35,4347.48) 5692.16,4334.68
  MidLayer2 w4: v3@5705.61,4354.95 ccw(c5707.19,4372.99) 5718.83,4359.12 ccw(c5730.47,4345.25) v3@5712.43,4346.83 ; 5718.54,4358.87 cw(c5728.47,4348.94) 5728.47,4362.99 5742.4,4362.99 5802.59,4362.99 5822.01,4362.99 5977.99,4362.99 5995,4380 6016,4380 6031.19,4364.81 6031.19,4356.62 6046.6,4341.21 6121.52,4341.21 6136.81,4356.5 6237.75,4356.5 6261.71,4332.54 6330.29,4332.54 6338.29,4340.54 6443.16,4340.54 6471.12,4368.5 6563.4,4368.5 6600.52,4331.37 6669.1,4331.37 6691.55,4353.83 6719.74,4353.83 v1(6723.52,4350.04)
  Bottom Layer w4: v1@6714.02,4350.04 ccw(c6691.09,4350.04) 6707.31,4366.26 ccw(c6723.52,4382.48) v1@6723.52,4359.54 ; v1@6718.02,4350.04 ccw(c6704.75,4350.04) 6714.14,4359.43 ccw(c6723.52,4368.82) v1@6723.52,4355.54 ; v1(6723.52,4350.04) 6706.86,4366.71 6706.86,4418.04 6715.19,4426.37 6765.19,4426.37 6794.01,4455.19 6805.59,4466.77 U15.28@6845.59,4466.77 ; U15.28@6822.37,4461.11 ccw(c6808.72,4447.46) 6808.72,4466.77 ccw(c6808.72,4486.08) U15.28@6822.37,4472.43
DB_SRAM2.D0: U8.J17 U15.7 | length 3221.1
  Top Layer w4: U8.J17@5488.43,4406.54 v3(5508.11,4426.22) ; U8.J17@5488.42,4413.88 ccw(c5488.42,4431.6) 5500.96,4419.07 ccw(c5513.49,4406.53) U8.J17@5495.77,4406.54 ; 5495.31,4413.42 cw(c5508.11,4400.61) 5508.11,4418.72 ccw(c5508.11,4400.61) 5495.31,4413.42 ; 5495.31,4413.42 ccw(c5482.5,4426.22) 5500.61,4426.22 cw(c5482.5,4426.22) 5495.31,4413.42
  Bottom Layer w4: v3@5507.46,4433.69 ccw(c5505.88,4451.73) 5519.75,4440.09 ccw(c5533.62,4428.45) v3@5515.58,4426.87 ; 5519.5,4439.8 ccw(c5509.57,4449.73) 5523.62,4449.73 5523.62,4463.66 5523.62,4543.27 5523.62,4659.79 5523.62,4741.18 5523.62,4751.18 5523.62,4765.63 5502.19,4787.06 5502.19,4832.02 5512.5,4842.33 5512.5,4882.25 5502.25,4892.5 5487.75,4892.5 5476.25,4881 5461.15,4881 5447.5,4894.65 5447.5,4962.5 5476.71,4991.71 5510,4991.71 5900.9,4991.71 6101.23,5192.04 6126.9,5217.71 6810.86,5217.71 6861.86,5166.71 6909.23,5166.71 6921.15,5166.71 7137.21,5166.71 7145.21,5158.71 7237.7,5066.21 7242.68,5066.21 7243.17,5066.71 7365.19,5066.71 7398.52,5033.37 7398.52,4967.71 7358.52,4927.71 7342.86,4927.71 7331.86,4916.71 7331.86,4786.73 7326.86,4781.73 ; U15.7@7294.41,4781.73 7326.86,4781.73 ; U15.7@7318.64,4777.32 cw(c7326.86,4771.88) 7326.86,4781.73 ; U15.7@7318.64,4786.15 ccw(c7326.86,4791.58) 7326.86,4781.73
DB_SRAM2.D1: U8.G21 U15.8 | length 2885.2
  Top Layer w4: U8.G21@5645.91,4485.28 v3(5665.59,4504.96) ; U8.G21@5645.91,4492.62 ccw(c5645.91,4510.34) 5658.44,4497.81 ccw(c5670.97,4485.28) U8.G21@5653.25,4485.28 ; v2@5853.06,4851.94 ccw(c5836.31,4868.69) 5860,4868.69 ; v2@5855.89,4849.11 ccw(c5845.97,4859.03) 5860,4859.03 ccw(c5874.03,4859.03) v2@5864.11,4849.11 ; v2(5860,4845) 5860,4868.69 ; v2@5866.94,4851.94 cw(c5883.69,4868.69) 5860,4868.69 ; v2(5896,4937.88) 5896,4924.01 5888.02,4916.03 ; 5652.79,4492.16 cw(c5665.59,4479.35) 5665.59,4497.46 ccw(c5665.59,4479.35) 5652.79,4492.16 ; 5652.79,4492.16 ccw(c5639.98,4504.96) 5658.09,4504.96 cw(c5639.98,4504.96) 5652.79,4492.16 ; 5860,4868.69 5888.02,4896.71 5888.02,4905 ; 5888.02,4905 5888.02,4916.03 ; 5888.02,4905 5888.02,4916.03
  MidLayer2 w4: v1(6806.86,5100.04) 6870.19,5100.04 v1(6890.19,5120.04) ; v1@6810.75,5096.15 cw(c6820.14,5086.76) 6820.14,5100.04 cw(c6820.14,5113.32) v1@6810.75,5103.93 ; v1@6813.57,5093.32 cw(c6829.79,5077.11) 6829.79,5100.04 cw(c6829.79,5122.98) v1@6813.57,5106.76 ; v1@6880.69,5120.04 cw(c6857.76,5120.04) 6873.97,5103.82 cw(c6890.19,5087.61) v1@6890.19,5110.54 ; v1@6884.69,5120.04 cw(c6871.41,5120.04) 6880.8,5110.65 cw(c6890.19,5101.26) v1@6890.19,5114.54
  Bottom Layer w4: v3@5664.29,4512.35 ccw(c5661.14,4530.18) 5675.98,4519.79 ; v3@5672.98,4506.26 cw(c5690.81,4509.41) 5675.98,4519.79 ; v2@5853.06,4838.06 ccw(c5836.31,4821.31) 5836.31,4845 ccw(c5836.31,4868.69) v2@5853.06,4851.94 ; v2@5855.89,4840.89 ccw(c5845.97,4830.97) 5845.97,4845 ccw(c5845.97,4859.03) v2@5855.89,4849.11 ; v2(5860,4845) 5825,4845 5810.53,4845 5798.07,4832.54 5792.79,4832.54 5782.75,4822.5 5775.25,4815 5772.33,4815 5757.89,4815 5745,4802.11 5745,4770 5746.9,4768.1 5768.1,4768.1 5768.1,4751.9 5768.1,4741.18 5768.1,4739.59 5768.1,4681.33 5768.1,4623.07 cw(c5744.33,4623.07) 5744.33,4599.3 ccw(c5744.33,4583.7) 5728.73,4583.7 cw(c5704.96,4583.7) 5704.96,4559.93 ccw(c5704.96,4544.33) 5689.36,4544.33 cw(c5665.59,4544.33) 5682.4,4527.52 5675.98,4519.79 ; v2(5896,4937.88) 5923.83,4965.71 5923.83,4980.68 6074.15,5131 6355.86,5131 6367.98,5118.87 6539.99,5118.87 6546.15,5125.04 6781.86,5125.04 v1(6806.86,5100.04) ; v2@5896,4943.69 ccw(c5896,4957.72) 5905.92,4947.8 ccw(c5915.84,4937.88) v2@5901.81,4937.88 ; v2@5896,4947.69 ccw(c5896,4971.38) 5912.75,4954.63 ccw(c5929.5,4937.88) v2@5905.81,4937.88 ; v1@6797.36,5100.04 ccw(c6774.42,5100.04) 6790.64,5116.26 ccw(c6806.86,5132.48) v1@6806.86,5109.54 ; v1@6801.36,5100.04 ccw(c6788.08,5100.04) 6797.47,5109.43 ccw(c6806.86,5118.82) v1@6806.86,5105.54 ; v1(6890.19,5120.04) 6925,5120.04 6950.52,5094.52 6950.52,5073.04 7131.86,4891.71 7152.92,4870.65 7152.92,4828.98 7231.66,4750.23 U15.8@7294.41,4750.23 ; v1@6894.08,5116.15 cw(c6903.47,5106.76) 6903.47,5120.04 cw(c6903.47,5133.32) v1@6894.08,5123.93 ; v1@6896.91,5113.32 cw(c6913.13,5097.11) 6913.13,5120.04 cw(c6913.13,5142.98) v1@6896.91,5126.76 ; U15.8@7271.19,4744.58 ccw(c7257.54,4730.92) 7257.54,4750.23 ccw(c7257.54,4769.55) U15.8@7271.19,4755.89
DB_SRAM2.D2: U8.C25 U15.9 | length 2730.7
  Top Layer w4: v1@5933.02,5091.71 cw(c5910.09,5091.71) 5926.31,5075.49 cw(c5942.52,5059.27) v1@5942.52,5082.21 ; v1@5937.02,5091.71 cw(c5923.75,5091.71) 5933.14,5082.32 cw(c5942.52,5072.93) v1@5942.52,5086.21 ; v1(5942.52,5091.71) 5910.97,5060.16 5903.31,5060.16 5890.19,5047.04 5890.19,4966.64 5901.14,4955.69 5903.38,4955.69 5913.81,4945.26 5913.81,4930.5 5896.02,4912.72 5896.02,4893.4 5881.5,4878.88 5881.5,4833.02 5848.52,4800.04 5848.52,4796.06 5827,4774.54 5827,4753.52 5827,4749 5827.25,4741.18 5827.25,4682.64 ; v1(6789.86,5005.37) 7018.19,5005.37 7056.86,4966.71 v1(7056.86,4832.37) ; v1@6793.75,5001.49 cw(c6803.14,4992.1) 6803.14,5005.37 cw(c6803.14,5018.65) v1@6793.75,5009.26 ; v1@6796.57,4998.66 cw(c6812.79,4982.44) 6812.79,5005.37 cw(c6812.79,5028.31) v1@6796.57,5012.09 ; v1@7050.14,4839.09 ccw(c7033.92,4855.31) 7056.86,4855.31 ccw(c7079.79,4855.31) v1@7063.57,4839.09 ; v1@7052.97,4836.26 ccw(c7043.58,4845.65) 7056.86,4845.65 ccw(c7070.14,4845.65) v1@7060.75,4836.26 ; 5815.92,4655.29 ccw(c5828.45,4642.76) 5810.73,4642.76 cw(c5828.45,4642.76) 5815.92,4655.29 ; 5815.92,4655.29 cw(c5803.39,4667.82) 5803.39,4650.1 ccw(c5803.39,4667.82) 5815.92,4655.29 ; 5815.92,4655.29 ccw(c5788.57,4682.64) 5827.25,4682.64 ; 5815.92,4655.29 ccw(c5788.57,4682.64) 5827.25,4682.64
  MidLayer2 w4: v1(5942.52,5091.71) 5986.67,5091.71 5995,5100.04 6240.19,5100.04 v1(6298.52,5041.71) ; v1@5946.41,5087.82 cw(c5955.8,5078.43) 5955.8,5091.71 cw(c5955.8,5104.99) v1@5946.41,5095.6 ; v1@5949.24,5084.99 cw(c5965.46,5068.77) 5965.46,5091.71 cw(c5965.46,5114.64) v1@5949.24,5098.43 ; v1@6289.02,5041.71 ccw(c6266.09,5041.71) 6282.31,5057.93 ccw(c6298.52,5074.14) v1@6298.52,5051.21 ; v1@6293.02,5041.71 ccw(c6279.75,5041.71) 6289.14,5051.1 ccw(c6298.52,5060.49) v1@6298.52,5047.21
  Bottom Layer w4: v1(6298.52,5041.71) 6442.21,5041.71 6467.21,5066.71 6624.19,5066.71 6665.86,5025.04 6702.17,5025.04 6737.21,4990 6774.48,4990 v1(6789.86,5005.37) v1@6784.52,5000.04 ; v1@6302.41,5037.82 cw(c6311.8,5028.43) 6311.8,5041.71 cw(c6311.8,5054.99) v1@6302.41,5045.6 ; v1@6305.24,5034.99 cw(c6321.46,5018.77) 6321.46,5041.71 cw(c6321.46,5064.64) v1@6305.24,5048.43 ; v1@7054.36,4832.37 ccw(c7078.1,4832.37) 7061.31,4815.59 ; v1(7056.86,4832.37) 7056.86,4820.04 7158.16,4718.74 U15.9@7294.41,4718.74 ; v1@7058.36,4832.37 ccw(c7091.76,4832.38) 7068.14,4808.76 ; v1@7062.36,4832.37 ccw(c7105.41,4832.38) 7074.97,4801.93 ; v1@7066.36,4832.37 ccw(c7119.07,4832.38) 7081.8,4795.1 ; U15.9@7271.19,4713.08 ccw(c7257.54,4699.42) 7257.54,4718.74 ccw(c7257.54,4738.05) U15.9@7271.19,4724.4
DB_SRAM2.D3: U8.H19 U15.10 | length 2756.6
  Top Layer w4: U8.H19@5567.17,4445.91 v3(5586.85,4465.59) ; U8.H19@5567.17,4453.25 ccw(c5567.17,4470.97) 5579.7,4458.44 ccw(c5592.23,4445.91) U8.H19@5574.51,4445.91 ; 5574.05,4452.79 cw(c5586.85,4439.98) 5586.85,4458.09 ccw(c5586.85,4439.98) 5574.05,4452.79 ; 5574.05,4452.79 ccw(c5561.24,4465.59) 5579.35,4465.59 cw(c5561.24,4465.59) 5574.05,4452.79
  MidLayer1 w4: v1@6573.52,4782.21 cw(c6573.52,4759.27) 6589.74,4775.49 cw(c6605.96,4791.71) v1@6583.02,4791.71 ; v1@6573.52,4786.21 cw(c6573.52,4772.93) 6582.91,4782.32 cw(c6592.3,4791.71) v1@6579.02,4791.71 ; v1(6573.52,4791.71) 6647.52,4717.71 6715,4717.71 6735.15,4717.71 6761.15,4691.71 6791.19,4691.71 6805,4691.71 6840.19,4691.71 6856.86,4708.37 6865.52,4717.04 7123.19,4717.04 7131.86,4708.37 v1(7140.19,4700.04) ; v1@7130.69,4700.04 ccw(c7107.76,4700.04) 7123.97,4716.26 ccw(c7140.19,4732.48) v1@7140.19,4709.54 ; v1@7134.69,4700.04 ccw(c7121.41,4700.04) 7130.8,4709.43 ccw(c7140.19,4718.82) v1@7140.19,4705.54
  MidLayer2 w4: v3@5586.2,4473.06 ccw(c5584.62,4491.1) 5598.49,4479.46 ; v3@5594.32,4466.24 cw(c5612.36,4467.82) 5598.49,4479.46 ; 5610.71,4738.53 5610.71,4680.27 ; v1@6564.02,4791.71 ccw(c6541.09,4791.71) 6557.31,4807.93 ccw(c6573.52,4824.14) v1@6573.52,4801.21 ; v1@6568.02,4791.71 ccw(c6554.75,4791.71) 6564.14,4801.1 ccw(c6573.52,4810.49) v1@6573.52,4797.21 ; v1(6573.52,4791.71) 6548.52,4816.71 6515.54,4816.71 6415.71,4716.87 6105,4716.87 6092.28,4716.87 6081.86,4727.29 6073.19,4735.96 6073.19,4746.71 6055.57,4764.32 6002.52,4817.37 5924.13,4817.37 5866.46,4875.04 5857.84,4875.04 5851.88,4875.04 ; 5598.49,4479.46 ccw(c5568.98,4508.97) 5610.71,4508.97 5610.71,4528.47 5610.71,4602.59 5610.71,4622.01 5610.71,4680.27 ; 5610.71,4680.27 5610.71,4741.18 5610.71,4749.18 5610.71,4769.4 5615.46,4774.15 5635.68,4774.15 5684.19,4822.66 5684.19,4861.41 5714.48,4891.71 5835.21,4891.71 ; 5835.21,4891.71 5851.88,4875.04 ; 5835.21,4891.71 5851.88,4875.04
  Bottom Layer w4: v1(7140.19,4700.04) 7196.67,4700.04 7205,4691.71 7276.84,4691.71 7276.84,4687.24 U15.10@7294.41,4687.24 ; v1@7144.08,4696.15 cw(c7153.47,4686.76) 7153.47,4700.04 cw(c7153.47,4713.32) v1@7144.08,4703.93 ; v1@7146.91,4693.32 cw(c7163.13,4677.11) 7163.13,4700.04 cw(c7163.13,4722.98) v1@7146.91,4706.76 ; 7246.76,4691.71 cw(c7246.76,4657.15) U15.10@7271.19,4681.59 ; 7256.41,4691.71 cw(c7256.41,4666.81) U15.10@7274.02,4684.41 ; 7266.07,4691.71 cw(c7266.07,4676.46) U15.10@7276.85,4687.24
DB_SRAM2.D4: U8.J19 U15.13 | length 3406.3
  Top Layer w4: U8.J19@5567.17,4406.54 v3(5586.85,4426.22) ; U8.J19@5567.17,4413.88 ccw(c5567.17,4431.6) 5579.7,4419.07 ccw(c5592.23,4406.53) U8.J19@5574.51,4406.54 ; v1@7100.14,4697.09 ccw(c7083.92,4713.31) 7106.86,4713.31 ccw(c7129.79,4713.31) v1@7113.57,4697.09 ; v1@7102.97,4694.26 ccw(c7093.58,4703.65) 7106.86,4703.65 ccw(c7120.14,4703.65) v1@7110.75,4694.26 ; v1(7106.86,4690.37) 7106.86,4816.71 7140.19,4850.04 7140.19,5017.71 v1(7116.19,5041.71) ; v1@7116.19,5032.21 cw(c7116.19,5009.27) 7132.41,5025.49 cw(c7148.63,5041.71) v1@7125.69,5041.71 ; v1@7116.19,5036.21 cw(c7116.19,5022.93) 7125.58,5032.32 cw(c7134.97,5041.71) v1@7121.69,5041.71 ; 5574.05,4413.42 cw(c5586.85,4400.61) 5586.85,4418.72 ccw(c5586.85,4400.61) 5574.05,4413.42 ; 5574.05,4413.42 ccw(c5561.24,4426.22) 5579.35,4426.22 cw(c5561.24,4426.22) 5574.05,4413.42
  MidLayer1 w4: v1@5575.48,4940.42 ccw(c5562.48,4954.79) 5581.86,4954.79 ; v1@5578.17,4937.45 ccw(c5570.64,4945.77) 5581.86,4945.77 ccw(c5593.08,4945.77) v1@5585.55,4937.45 ; v1(5581.86,4933.37) 5581.86,4954.79 ; v1@5588.23,4940.42 cw(c5601.23,4954.79) 5581.86,4954.79 ; v1@7109.47,5034.99 ccw(c7093.26,5018.77) 7093.26,5041.71 ccw(c7093.26,5064.64) v1@7109.47,5048.43 ; v1@7112.3,5037.82 ccw(c7102.91,5028.43) 7102.91,5041.71 ccw(c7102.91,5054.99) v1@7112.3,5045.6 ; v1(7116.19,5041.71) 6931.86,5041.71 6913.86,5023.71 6872.48,5023.71 6837.82,5058.37 6729.48,5058.37 ; 5581.86,4954.79 5619.95,4992.88 5643.78,5016.71 5915.19,5016.71 6006.86,5108.37 6500,5108.37 6523.52,5108.37 6535,5108.37 ; 6535,5108.37 6552.94,5108.37 ; 6535,5108.37 6552.94,5108.37 ; 6552.94,5108.37 6591.27,5070.04 6594.96,5070.04 6717.82,5070.04 ; 6717.82,5070.04 6729.48,5058.37 ; 6717.82,5070.04 6729.48,5058.37
  Bottom Layer w4: v1@5572.36,4933.37 cw(c5549.42,4933.37) 5565.64,4917.16 cw(c5581.86,4900.94) v1@5581.86,4923.87 ; v1@5576.36,4933.37 cw(c5563.08,4933.37) 5572.47,4923.99 cw(c5581.86,4914.6) v1@5581.86,4927.87 ; v1(5581.86,4933.37) 5520.5,4872.02 5520.5,4839.02 5510.86,4829.37 5510.86,4789.71 5531.97,4768.59 5599.41,4768.59 5602.36,4765.64 5602.36,4718.05 5602.36,4543.27 5602.36,4458.9 cw(c5569.23,4458.73) 5597.27,4441.08 ; v3@5585.55,4433.61 ccw(c5582.4,4451.44) 5597.24,4441.05 ccw(c5612.07,4430.67) v3@5594.24,4427.52 ; v1@7106.86,4680.87 cw(c7106.86,4657.94) 7123.07,4674.16 cw(c7139.29,4690.37) v1@7116.36,4690.37 ; v1@7106.86,4684.87 cw(c7106.86,4671.6) 7116.25,4680.99 cw(c7125.64,4690.37) v1@7112.36,4690.37 ; v1(7106.86,4690.37) 7204.48,4592.75 U15.13@7294.41,4592.75 ; U15.13@7271.19,4587.1 ccw(c7257.54,4573.44) 7257.54,4592.75 ccw(c7257.54,4612.07) U15.13@7271.19,4598.41
DB_SRAM2.D5: U8.E26 U15.14 | length 1934.4
  Top Layer w4: 6017.39,4587.39 cw(c6047.52,4557.27) v1@6047.52,4599.87 ; 6024.22,4594.22 cw(c6047.52,4570.92) v1@6047.52,4603.87 ; 6031.05,4601.05 cw(c6047.52,4584.58) v1@6047.52,4607.87 ; v1(6047.52,4609.37) 6039.37,4609.37 6005,4575 5985,4575 5972.12,4587.88 5949.18,4587.88 5941.18,4587.88 ; 5855.29,4576.55 cw(c5882.64,4549.2) 5882.64,4587.88 ; 5855.29,4576.55 cw(c5882.64,4549.2) 5882.64,4587.88 ; 5855.29,4576.55 cw(c5842.76,4589.08) 5842.76,4571.36 ccw(c5842.76,4589.08) 5855.29,4576.55 ; 5855.29,4576.55 ccw(c5867.82,4564.02) 5850.1,4564.02 cw(c5867.82,4564.02) 5855.29,4576.55 ; 5882.64,4587.88 5941.18,4587.88 ; 5882.64,4587.88 5941.18,4587.88
  MidLayer2 w4: v1(6047.52,4609.37) 6088.94,4609.37 6091.31,4607 6288.82,4607 6291.19,4609.37 6307.52,4625.71 6310.32,4628.5 6352.23,4628.5 6387.94,4664.21 6402.44,4664.21 6404.44,4666.21 6457.94,4666.21 6472.44,4666.21 6473.77,4667.54 6547.28,4667.54 6561.77,4667.54 6624.61,4667.54 6653.65,4638.5 6714.4,4638.5 6761.19,4591.71 7210.86,4591.71 v1(7235.86,4566.71) ; v1@6051.41,4605.49 cw(c6060.8,4596.1) 6060.8,4609.37 cw(c6060.8,4622.65) v1@6051.41,4613.26 ; v1@6054.24,4602.66 cw(c6070.46,4586.44) 6070.46,4609.37 cw(c6070.46,4632.31) v1@6054.24,4616.09 ; v1@7226.36,4566.71 ccw(c7203.42,4566.71) 7219.64,4582.93 ccw(c7235.86,4599.14) v1@7235.86,4576.21 ; v1@7230.36,4566.71 ccw(c7217.08,4566.71) 7226.47,4576.1 ccw(c7235.86,4585.49) v1@7235.86,4572.21
  Bottom Layer w4: v1(7235.86,4566.71) 7255.74,4566.71 ; v1@7240.14,4563.25 cw(c7247.37,4557.41) 7247.37,4566.71 cw(c7247.37,4576) v1@7240.14,4570.16 ; v1@7243.25,4560.74 cw(c7255.74,4550.65) 7255.74,4566.71 ; v1@7243.25,4572.68 ccw(c7255.74,4582.77) 7255.74,4566.71 ; U15.14@7270.37,4556.57 ccw(c7261.19,4549.93) 7261.19,4561.26 ; U15.14@7270.37,4565.95 cw(c7261.19,4572.59) 7261.19,4561.26 ; U15.14@7294.41,4561.26 7261.19,4561.26 ; 7255.74,4566.71 7261.19,4561.26
DB_SRAM2.D6: U8.E27 U15.15 | length 1881.7
  Top Layer w4: v1@6059.47,4547.99 ccw(c6043.26,4531.77) 6043.26,4554.71 ccw(c6043.26,4577.64) v1@6059.47,4561.43 ; v1@6062.3,4550.82 ccw(c6052.91,4541.43) 6052.91,4554.71 ccw(c6052.91,4567.99) v1@6062.3,4558.6 ; v1(6066.19,4554.71) 5986.07,4554.71 5961.26,4579.52 5949.18,4579.52 5941.18,4579.52 ; 5894.66,4576.55 cw(c5901.84,4569.37) 5901.84,4579.52 ; 5894.66,4576.55 cw(c5901.84,4569.37) 5901.84,4579.52 ; 5894.66,4576.55 ccw(c5907.19,4564.02) 5889.47,4564.02 cw(c5907.19,4564.02) 5894.66,4576.55 ; 5894.66,4576.55 cw(c5882.13,4589.08) 5882.13,4571.36 ccw(c5882.13,4589.08) 5894.66,4576.55 ; 5901.84,4579.52 5941.18,4579.52 ; 5901.84,4579.52 5941.18,4579.52
  MidLayer2 w4: v1(6066.19,4554.71) 6091,4554.71 6100,4563.71 6113.71,4563.71 6149,4599 6292.13,4599 6313.63,4620.5 6357.92,4620.5 6362.92,4625.5 6581.4,4625.5 6665.19,4541.71 6890.19,4541.71 6898.52,4550.04 7094.17,4550.04 7104.63,4560.5 7125.75,4560.5 7136.21,4550.04 v1(7183.19,4550.04) ; v1@6070.08,4550.82 cw(c6079.47,4541.43) 6079.47,4554.71 cw(c6079.47,4567.99) v1@6070.08,4558.6 ; v1@6072.91,4547.99 cw(c6089.13,4531.77) 6089.13,4554.71 cw(c6089.13,4577.64) v1@6072.91,4561.43 ; v1@7176.47,4543.32 ccw(c7160.26,4527.11) 7160.26,4550.04 ccw(c7160.26,4572.98) v1@7176.47,4556.76 ; v1@7179.3,4546.15 ccw(c7169.91,4536.76) 7169.91,4550.04 ccw(c7169.91,4563.32) v1@7179.3,4553.93
  Bottom Layer w4: v1@7183.19,4540.54 cw(c7183.19,4517.61) 7199.41,4533.82 cw(c7215.63,4550.04) v1@7192.69,4550.04 ; v1@7183.19,4544.54 cw(c7183.19,4531.26) 7192.58,4540.65 cw(c7201.97,4550.04) v1@7188.69,4550.04 ; v1(7183.19,4550.04) 7199.86,4533.37 7294.41,4533.37 7294.91,4533.37 7298.52,4529.76 U15.15@7294.41,4529.76 ; 7248.82,4533.37 cw(c7248.82,4501.73) U15.15@7271.19,4524.11 ; 7258.47,4533.37 cw(c7258.47,4511.39) U15.15@7274.02,4526.93 ; 7266.26,4533.37 ccw(c7266.26,4540.36) U15.15@7271.19,4535.42
DB_SRAM2.D7: U8.E1 U15.16 | length 5193.7
  Top Layer w4: 4569.36,5122.69 cw(c4612.31,5122.69) v2@4581.94,5153.06 ; 4569.36,5132.35 cw(c4602.65,5132.35) v2@4579.11,5155.89 ; 4569.36,5142 cw(c4593,5142) v2@4576.28,5158.72 ; v2@4573.52,5158.52 v2(4575,5160) 4569.36,5154.36 4569.36,4882.29 4569.36,4824.64 4665,4729 4665,4715 4665,4670 4680.09,4654.91 4770.98,4564.02 4830.82,4564.02 4838.82,4564.02 U8.E1@4858.5,4564.02 ; U8.E1@4853.31,4558.82 ccw(c4840.78,4546.29) 4840.78,4564.02 ccw(c4840.78,4581.74) U8.E1@4853.31,4569.21
  MidLayer2 w4: v2(4675,5160) 4742.21,5160 4814.75,5232.54 5171.94,5232.54 5209.4,5270 5235,5270 5260.82,5244.18 5260.82,5175.33 5271.07,5165.08 5290.08,5165.08 5360,5235 5590,5235 5626,5199 5750.54,5199 5758.92,5207.37 6438.58,5207.37 6452.21,5221 6583.4,5221 6646.02,5158.37 6646.02,4940.66 6671.69,4915 6750.98,4915 6793.11,4872.87 6802.77,4872.87 6838.44,4837.21 6909.44,4837.21 6926.85,4819.79 6926.85,4818.4 6937.75,4807.5 7111.49,4807.5 7171.2,4867.21 7247.46,4867.21 7254.63,4874.37 7489.81,4874.37 7499.19,4865 v2(7525,4865) ; v2@4679.11,5155.89 cw(c4689.03,5145.97) 4689.03,5160 cw(c4689.03,5174.03) v2@4679.11,5164.11 ; v2@4681.94,5153.06 cw(c4698.69,5136.31) 4698.69,5160 cw(c4698.69,5183.69) v2@4681.94,5166.94 ; v2@7518.06,4858.06 ccw(c7501.31,4841.31) 7501.31,4865 ccw(c7501.31,4888.69) v2@7518.06,4871.94 ; v2@7520.89,4860.89 ccw(c7510.97,4850.97) 7510.97,4865 ccw(c7510.97,4879.03) v2@7520.89,4869.11
  Bottom Layer w4: v2(4575,5160) v2(4675,5160) ; v2@4579.11,5155.89 cw(c4589.03,5145.97) 4589.03,5160 cw(c4589.03,5174.03) v2@4579.11,5164.11 ; v2@4581.94,5153.06 cw(c4598.69,5136.31) 4598.69,5160 cw(c4598.69,5183.69) v2@4581.94,5166.94 ; v2@4668.06,5153.06 ccw(c4651.31,5136.31) 4651.31,5160 ccw(c4651.31,5183.69) v2@4668.06,5166.94 ; v2@4670.89,5155.89 ccw(c4660.97,5145.97) 4660.97,5160 ccw(c4660.97,5174.03) v2@4670.89,5164.11 ; U15.16@7294.41,4498.27 7306.86,4498.27 7306.86,4500.04 7348.52,4500.04 7365.19,4516.71 7365.19,4563.37 7373.52,4571.71 7406.86,4571.71 7456.86,4621.71 7456.86,4725.04 7525,4793.18 v2(7525,4865) ; U15.16@7314.8,4495.44 cw(c7325.91,4484.33) 7325.91,4500.04 ; U15.16@7317.63,4492.61 cw(c7335.57,4474.67) 7335.57,4500.04 ; U15.16@7317.63,4503.92 ccw(c7327,4513.3) 7327,4500.04 ; v2@7518.06,4858.06 cw(c7501.31,4841.31) 7525,4841.31 cw(c7548.69,4841.31) v2@7531.94,4858.06 ; v2@7520.89,4860.89 cw(c7510.97,4850.97) 7525,4850.97 cw(c7539.03,4850.97) v2@7529.11,4860.89
DB_SRAM2.D8: U8.F27 U15.29 | length 1662.9
  Top Layer w4: v1@6021.86,4491.53 ccw(c6007,4477.7) 6007,4498 ; v1@6021.86,4504.47 cw(c6007,4518.3) 6007,4498 ; v1@6024.79,4494.25 ccw(c6016.19,4486.25) 6016.19,4498 ccw(c6016.19,4509.75) v1@6024.79,4501.75 ; v1(6028.82,4498) 6007,4498 ; 5894.66,4537.18 ccw(c5907.19,4524.65) 5889.47,4524.65 cw(c5907.19,4524.65) 5894.66,4537.18 ; 5894.66,4537.18 cw(c5882.13,4549.71) 5882.13,4531.99 ccw(c5882.13,4549.71) 5894.66,4537.18 ; 5894.66,4537.18 cw(c5901.84,4530) 5901.84,4540.15 ; 5894.66,4537.18 cw(c5901.84,4530) 5901.84,4540.15 ; 5901.84,4540.15 5941.18,4540.15 ; 5901.84,4540.15 5941.18,4540.15 ; 5941.18,4540.15 5949.18,4540.15 5964.85,4540.15 6007,4498
  MidLayer2 w4: v1@6022.1,4504.72 ccw(c6005.88,4520.93) 6028.82,4520.93 ccw(c6051.75,4520.93) v1@6035.53,4504.72 ; v1@6024.93,4501.89 ccw(c6015.54,4511.28) 6028.82,4511.28 ccw(c6042.09,4511.28) v1@6032.71,4501.89 ; v1(6028.82,4498) 6028.82,4523.82 6038.37,4533.37 6051.63,4533.37 ; 6640,4555 6661.29,4533.71 ; 6640.29,4555.29 6585.88,4609.71 6585.29,4609.71 ; v1@6779.69,4491.71 ccw(c6756.76,4491.71) 6772.97,4507.93 ccw(c6789.19,4524.14) v1@6789.19,4501.21 ; v1@6783.69,4491.71 ccw(c6770.41,4491.71) 6779.8,4501.1 ccw(c6789.19,4510.49) v1@6789.19,4497.21 ; v1(6789.19,4491.71) 6747.19,4533.71 6661.29,4533.71 ; 6051.63,4533.37 6060,4533.37 ; 6051.63,4533.37 6060,4533.37 ; 6060,4533.37 6073.52,4533.37 6081.86,4525.04 6248.52,4525.04 6290.82,4567.34 6330.09,4567.34 6358.5,4595.75 6358.5,4607.25 6368.75,4617.5 6375,4617.5 ; 6375,4617.5 6383.25,4617.5 ; 6375,4617.5 6383.25,4617.5 ; 6383.25,4617.5 6577.5,4617.5 6585.29,4609.71 ; 6585.29,4609.71 6661.29,4533.71
  Bottom Layer w4: v1@6787.42,4493.48 cw(c6803.27,4477.63) 6803.27,4500.04 ; v1(6789.19,4491.71) 6797.52,4500.04 6845.59,4500.04 6848.52,4500.04 6848.52,4498.27 U15.29@6845.59,4498.27 ; v1@6790.25,4490.65 cw(c6812.93,4467.97) 6812.93,4500.04 ; v1@6793.08,4487.82 cw(c6822.59,4458.31) U15.29@6822.59,4500.04 ; v1@6795.91,4484.99 cw(c6832.24,4448.66) U15.29@6832.24,4500.04 ; 6804.43,4500.04 cw(c6804.43,4474.67) U15.29@6822.37,4492.61 ; 6813,4500.04 ccw(c6813,4513.3) U15.29@6822.37,4503.92 ; 6814.09,4500.04 cw(c6814.09,4484.33) U15.29@6825.2,4495.44
DB_SRAM2.D9: U8.F26 U15.30 | length 1534.3
  Top Layer w4: v1(6054,4511) 6049.5,4515.5 6002.65,4515.5 5969.65,4548.51 5949.18,4548.51 5941.18,4548.51 ; 5855.29,4537.18 cw(c5842.76,4549.71) 5842.76,4531.99 ccw(c5842.76,4549.71) 5855.29,4537.18 ; 5855.29,4537.18 ccw(c5867.82,4524.65) 5850.1,4524.65 cw(c5867.82,4524.65) 5855.29,4537.18 ; 5855.29,4537.18 cw(c5882.64,4509.83) 5882.64,4548.51 ; 5855.29,4537.18 cw(c5882.64,4509.83) 5882.64,4548.51 ; 5882.64,4548.51 5941.18,4548.51 ; 5882.64,4548.51 5941.18,4548.51
  MidLayer1 w4: v1(6525.19,4573.37) 6558.52,4573.37 6581.86,4550.04 6856.86,4550.04 v1(6890.19,4516.71) ; v1@6529.08,4569.49 cw(c6538.47,4560.1) 6538.47,4573.37 cw(c6538.47,4586.65) v1@6529.08,4577.26 ; v1@6531.91,4566.66 cw(c6548.13,4550.44) 6548.13,4573.37 cw(c6548.13,4596.31) v1@6531.91,4580.09 ; v1@6880.69,4516.71 ccw(c6857.76,4516.71) 6873.97,4532.93 ccw(c6890.19,4549.14) v1@6890.19,4526.21 ; v1@6884.69,4516.71 ccw(c6871.41,4516.71) 6880.8,4526.1 ccw(c6890.19,4535.49) v1@6890.19,4522.21
  MidLayer2 w4: v1(6054,4511) 6055,4512 6080.13,4512 6084.84,4516.71 6251.52,4516.71 6294.02,4559.21 6362.02,4559.21 6376.19,4573.37 v1(6525.19,4573.37) ; v1@6057.89,4507.11 cw(c6069.69,4495.31) 6069.69,4512 ; v1@6060.72,4504.28 cw(c6079.35,4485.65) 6079.35,4512 ; v1@6060.72,4517.72 ccw(c6074.52,4531.52) 6074.52,4512 ; v1@6518.47,4566.66 ccw(c6502.26,4550.44) 6502.26,4573.37 ccw(c6502.26,4596.31) v1@6518.47,4580.09 ; v1@6521.3,4569.49 ccw(c6511.91,4560.1) 6511.91,4573.37 ccw(c6511.91,4586.65) v1@6521.3,4577.26
  Bottom Layer w4: U15.30@6845.59,4529.76 6877.14,4529.76 ; U15.30@6870.05,4525.71 cw(c6877.14,4521.54) 6877.14,4529.76 ; U15.30@6870.05,4533.82 ccw(c6877.14,4537.99) 6877.14,4529.76 ; v1(6890.19,4516.71) 6877.14,4529.76
DB_SRAM2.D10: U8.D27 U15.31 | length 1870.3
  Top Layer w4: v1@6038.28,4688.28 cw(c6022.06,4672.06) 6045,4672.06 cw(c6067.93,4672.06) v1@6051.72,4688.28 ; v1@6041.11,4691.11 cw(c6031.72,4681.72) 6045,4681.72 cw(c6058.28,4681.72) v1@6048.89,4691.11 ; v1@6045,4693.18 6045,4660 ; 5894.66,4615.92 ccw(c5907.19,4603.39) 5889.47,4603.39 cw(c5907.19,4603.39) 5894.66,4615.92 ; 5894.66,4615.92 cw(c5882.13,4628.45) 5882.13,4610.73 ccw(c5882.13,4628.45) 5894.66,4615.92 ; 5894.66,4615.92 cw(c5901.84,4608.74) 5901.84,4618.89 ; 5894.66,4615.92 cw(c5901.84,4608.74) 5901.84,4618.89 ; 5901.84,4618.89 5941.18,4618.89 ; 5901.84,4618.89 5941.18,4618.89 ; 5941.18,4618.89 5949.11,4618.89 5967.23,4618.89 5973.62,4612.5 6000.38,4612.5 6017.5,4612.5 6045,4640 6045,4657.12 ; 6045,4657.12 6045,4660 ; 6045,4657.12 6045,4660
  MidLayer1 w4: v1(6045,4695) 6070,4695 6112.55,4652.45 6125,4652.45 ; v1@6048.89,4691.11 cw(c6058.28,4681.72) 6058.28,4695 cw(c6058.28,4708.28) v1@6048.89,4698.89 ; v1@6051.72,4688.28 cw(c6067.93,4672.06) 6067.93,4695 cw(c6067.93,4717.93) v1@6051.72,4701.72 ; v1(6890.19,4566.71) 6915.19,4566.71 6940.19,4591.71 6940.19,4658.37 6940.19,4688.73 6927.88,4701.04 6872.15,4701.04 6846.15,4675.04 6755.19,4675.04 6748.52,4681.71 6590,4681.71 ; v1@6894.08,4562.82 cw(c6903.47,4553.43) 6903.47,4566.71 cw(c6903.47,4579.99) v1@6894.08,4570.6 ; v1@6896.91,4559.99 cw(c6913.13,4543.77) 6913.13,4566.71 cw(c6913.13,4589.64) v1@6896.91,4573.43 ; 6125,4652.45 6142.45,4652.45 ; 6125,4652.45 6142.45,4652.45 ; 6142.45,4652.45 6146.13,4652.45 6191.69,4698 ; 6191.69,4698 6235,4698 ; 6191.69,4698 6235,4698 ; 6235,4698 6330,4698 ; 6330,4698 6338,4698 ; 6330,4698 6338,4698 ; 6338,4698 6342,4698 6367,4673 6405,4673 ; 6405,4673 6419.58,4673 ; 6405,4673 6419.58,4673 ; 6419.58,4673 6451.69,4673 6460.39,4681.71 ; 6460.39,4681.71 6490,4681.71 ; 6460.39,4681.71 6490,4681.71 ; 6490,4681.71 6571.19,4681.71 ; 6571.19,4681.71 6590,4681.71 ; 6571.19,4681.71 6590,4681.71
  Bottom Layer w4: U15.31@6845.59,4561.26 6884.74,4561.26 v1(6890.19,4566.71) ; U15.31@6854.1,4561.26 ccw(c6854.1,4602.8) v1@6883.47,4573.43 ; U15.31@6863.76,4561.26 ccw(c6863.76,4593.14) v1@6886.3,4570.6 ; 6873.41,4561.26 ccw(c6873.41,4583.48) v1@6889.13,4567.77
DB_SRAM2.D11: U8.E25 U15.32 | length 1595
  Top Layer w4: U8.E25@5803.39,4564.02 v3(5823.07,4583.7) ; U8.E25@5803.39,4571.36 ccw(c5803.39,4589.08) 5815.92,4576.55 ccw(c5828.45,4564.02) U8.E25@5810.73,4564.02 ; 5810.27,4570.9 cw(c5823.07,4558.09) 5823.07,4576.2 ccw(c5823.07,4558.09) 5810.27,4570.9 ; 5810.27,4570.9 ccw(c5797.46,4583.7) 5815.57,4583.7 cw(c5797.46,4583.7) 5810.27,4570.9
  MidLayer1 w4: v3(5823.07,4583.7) 5881.33,4583.7 5900.75,4583.7 5906.95,4577.5 6002.25,4577.5 6024.87,4600.13 6024.87,4620.39 6048.93,4644.45 6149.45,4644.45 6195,4690 6338.69,4690 6363.69,4665 6455,4665 6460,4670 6463.71,4673.71 6566.29,4673.71 6570,4670 6598.29,4641.71 6706.86,4641.71 6715.19,4633.37 6890.19,4633.37 v1(6906.86,4616.71) ; v3@5828.26,4578.51 cw(c5840.8,4565.97) 5840.8,4583.7 cw(c5840.8,4601.43) v3@5828.26,4588.89 ; v1@6897.36,4616.71 ccw(c6874.42,4616.71) 6890.64,4632.93 ccw(c6906.86,4649.14) v1@6906.86,4626.21 ; v1@6901.36,4616.71 ccw(c6888.08,4616.71) 6897.47,4626.1 ccw(c6906.86,4635.49) v1@6906.86,4622.21 ; 5841.18,4583.7 cw(c5841.18,4601.81) 5828.37,4589 ccw(c5841.18,4601.81) 5841.18,4583.7 ; 5841.18,4583.7 ccw(c5841.18,4565.59) 5828.37,4578.4 cw(c5841.18,4565.59) 5841.18,4583.7
  Bottom Layer w4: U15.32@6845.59,4592.75 6882.9,4592.75 v1(6906.86,4616.71) ; U15.32@6868.81,4587.1 cw(c6882.46,4573.44) 6882.46,4592.75 cw(c6882.46,4612.07) U15.32@6868.81,4598.41 ; v1@6897.36,4616.71 cw(c6874.42,4616.71) 6890.64,4600.49 cw(c6906.86,4584.27) v1@6906.86,4607.21 ; v1@6901.36,4616.71 cw(c6888.08,4616.71) 6897.47,4607.32 cw(c6906.86,4597.93) v1@6906.86,4611.21
DB_SRAM2.D12: U8.A19 U15.35 | length 2558.1
  Top Layer w4: v1@6741.81,5106.76 ccw(c6725.59,5122.98) 6748.52,5122.98 ccw(c6771.46,5122.98) v1@6755.24,5106.76 ; v1@6744.64,5103.93 ccw(c6735.25,5113.32) 6748.52,5113.32 ccw(c6761.8,5113.32) v1@6752.41,5103.93 ; v1(6748.52,5100.04) 6748.52,5129.39 6699.27,5178.64 6683.21,5194.71 6486.69,5194.71 6475.35,5183.37 5765.19,5183.37 5731.86,5150.04 5638.21,5150.04 5556.52,5068.35 5556.52,4933.71 5558.52,4931.71 5590.19,4900.04 5590.19,4884.46 5567.17,4861.43 5567.17,4748.83 5567.17,4741.18 ; 5567.17,4739.22 cw(c5549.44,4739.22) 5561.97,4726.69 ccw(c5549.44,4739.22) 5567.17,4739.22 ; 5567.17,4739.22 ccw(c5584.89,4739.22) 5572.36,4726.69 cw(c5584.89,4739.22) 5567.17,4739.22 ; 5567.17,4741.18 U8.A19@5567.17,4721.5 5567.17,4741.18
  Bottom Layer w4: v1@6748.52,5090.54 cw(c6748.52,5067.61) 6764.74,5083.82 cw(c6780.96,5100.04) v1@6758.02,5100.04 ; v1@6748.52,5094.54 cw(c6748.52,5081.26) 6757.91,5090.65 cw(c6767.3,5100.04) v1@6754.02,5100.04 ; v1(6748.52,5100.04) 6773.52,5075.04 6837.21,5075.04 6853.88,5091.71 6924.52,5091.71 6934.52,5081.71 6934.52,4880.71 6881.86,4828.04 6881.86,4695.24 ; U15.35@6845.59,4687.24 6873.86,4687.24 6881.86,4695.24 ; U15.35@6863.15,4687.24 ccw(c6868.38,4695) 6875,4688.38 ; U15.35@6865.39,4690.56 ccw(c6871.15,4699.09) 6878.43,4691.81 ; U15.35@6867.62,4693.87 ccw(c6873.91,4703.19) 6881.86,4695.24
DB_SRAM2.D13: U8.B25 U15.36 | length 1972.3
  Top Layer w4: v1@5855.69,4907.04 cw(c5832.76,4907.04) 5848.97,4890.82 cw(c5865.19,4874.61) v1@5865.19,4897.54 ; v1@5859.69,4907.04 cw(c5846.41,4907.04) 5855.8,4897.65 cw(c5865.19,4888.26) v1@5865.19,4901.54 ; v1(5865.19,4907.04) 5840,4881.85 5840,4860 5840,4798.85 5818.89,4777.74 5818.89,4749.18 5818.89,4741.18 5818.89,4701.84 ; 5815.92,4694.66 cw(c5803.39,4707.19) 5803.39,4689.47 ccw(c5803.39,4707.19) 5815.92,4694.66 ; 5815.92,4694.66 ccw(c5828.45,4682.13) 5810.73,4682.13 cw(c5828.45,4682.13) 5815.92,4694.66 ; 5815.92,4694.66 ccw(c5808.74,4701.84) 5818.89,4701.84 ; 5815.92,4694.66 ccw(c5808.74,4701.84) 5818.89,4701.84
  MidLayer2 w4: 5873.52,4898.71 v1(5865.19,4907.04) 5880.86,4891.37 5951.15,4891.37 6025.49,4817.04 6115,4817.04 6182,4750.04 6215.04,4750.04 6256.71,4791.71 6359.19,4791.71 6472.48,4905 6576.9,4905 6615.19,4866.71 6615.19,4700.04 6633.52,4681.71 6695,4681.71 6706.86,4693.56 v1(6706.86,4758.37) ; v1@6700.14,4751.66 cw(c6683.92,4735.44) 6706.86,4735.44 cw(c6729.79,4735.44) v1@6713.57,4751.66 ; v1@6702.97,4754.49 cw(c6693.58,4745.1) 6706.86,4745.1 cw(c6720.14,4745.1) v1@6710.75,4754.49
  Bottom Layer w4: v1(6706.86,4758.37) 6747.19,4758.37 ; v1@6710.75,4754.49 cw(c6720.14,4745.1) 6720.14,4758.37 cw(c6720.14,4771.65) v1@6710.75,4762.26 ; v1@6713.57,4751.66 cw(c6729.79,4735.44) 6729.79,4758.37 cw(c6729.79,4781.31) v1@6713.57,4765.09 ; 6818.07,4725.38 ccw(c6824.98,4732.29) U15.36@6827.87,4722.95 ; U15.36@6818.73,4724.72 cw(c6813.15,4719.13) U15.36@6821.05,4719.13 ; U15.36@6823.3,4718.74 U15.36@6824.71,4718.74 ; U15.36@6826.68,4726.78 cw(c6822.76,4739.45) 6813.38,4730.07 ; 6747.19,4758.37 6765.24,4740.32 ; 6747.19,4758.37 6765.24,4740.32 ; 6765.24,4740.32 6788.63,4740.32 ; 6788.63,4740.32 6803.13,4740.32 ; 6788.63,4740.32 6803.13,4740.32 ; 6803.13,4740.32 6813.38,4730.07 ; 6803.13,4740.32 6813.38,4730.07 ; 6813.38,4730.07 U15.36@6824.71,4718.74 ; U15.36@6824.71,4718.74 U15.36@6845.59,4718.74 U15.36@6824.71,4718.74
DB_SRAM2.D14: U8.A26 U15.37 | length 1998.3
  Top Layer w4: U8.A26@5837.56,4726.69 ccw(c5825.03,4739.22) 5842.76,4739.22 ccw(c5860.48,4739.22) U8.A26@5847.95,4726.69 ; U8.A26@5842.76,4721.5 5842.76,4741.18 5842.76,4750 5842.76,4757.96 5864.34,4779.54 5879.44,4779.54 5929.5,4829.6 5929.5,4845.56 5965.19,4881.25 5965.19,4892.69 5989.7,4917.2 5989.7,5047.19 6034.7,5092.2 6388.36,5092.2 v1(6415.19,5065.37) ; v1@6405.69,5065.37 ccw(c6382.76,5065.37) 6398.97,5081.59 ccw(c6415.19,5097.81) v1@6415.19,5074.87 ; v1@6409.69,5065.37 ccw(c6396.41,5065.37) 6405.8,5074.76 ccw(c6415.19,5084.15) v1@6415.19,5070.87
  Bottom Layer w4: v1@6408.47,5058.66 ccw(c6392.26,5042.44) 6392.26,5065.37 ccw(c6392.26,5088.31) v1@6408.47,5072.09 ; v1@6411.3,5061.49 ccw(c6401.91,5052.1) 6401.91,5065.37 ccw(c6401.91,5078.65) v1@6411.3,5069.26 ; v1(6415.19,5065.37) 6297.44,5065.37 6281.02,5048.96 6281.02,5034.46 6307.78,5007.71 6390.86,5007.71 6406.86,4991.71 6440.19,4991.71 6465.19,5016.71 6565.19,5016.71 6590.19,4991.71 6644.86,4991.71 6656.36,5003.21 6686.77,5003.21 6697.02,4992.96 6697.02,4884.74 6685.02,4872.74 6685.02,4843.87 6684.52,4843.37 6706.86,4821.04 6706.86,4816.9 6757.05,4766.71 6773.52,4750.23 U15.37@6845.59,4750.23 ; U15.37@6822.37,4744.58 ccw(c6808.72,4730.92) 6808.72,4750.23 ccw(c6808.72,4769.55) U15.37@6822.37,4755.89
DB_SRAM2.D15: U8.E21 U15.38 | length 2161.6
  Top Layer w4: U8.E21@5645.91,4564.02 v3(5665.59,4583.7) ; U8.E21@5645.91,4571.36 ccw(c5645.91,4589.08) 5658.44,4576.55 ccw(c5670.97,4564.02) U8.E21@5653.25,4564.02 ; 5652.79,4570.9 cw(c5665.59,4558.09) 5665.59,4576.2 ccw(c5665.59,4558.09) 5652.79,4570.9 ; 5652.79,4570.9 ccw(c5639.98,4583.7) 5658.09,4583.7 cw(c5639.98,4583.7) 5652.79,4570.9
  MidLayer1 w4: v3@5664.94,4591.17 ccw(c5663.36,4609.21) 5677.23,4597.57 ccw(c5691.1,4585.93) v3@5673.06,4584.35 ; 5676.98,4597.28 ccw(c5667.05,4607.21) 5681.1,4607.21 5681.1,4621.14 5681.1,4681.33 5681.1,4700.75 5681.1,4741.18 5681.1,4749.18 5681.02,4749.25 5681.02,4768.7 5685.08,4772.76 5685.08,4782.01 5705.81,4802.74 5705.81,4835.09 5751.72,4881 5840.08,4881 5848.08,4873 5875,4873 5878.31,4873 5886.31,4865 v1(5915,4865) ; v1@5908.28,4858.28 ccw(c5892.06,4842.06) 5892.06,4865 ccw(c5892.06,4887.93) v1@5908.28,4871.72 ; v1@5911.11,4861.11 ccw(c5901.72,4851.72) 5901.72,4865 ccw(c5901.72,4878.28) v1@5911.11,4868.89
  Bottom Layer w4: v1(5915,4865) 5902.5,4877.5 5902.5,4917.25 5937.5,4952.25 5937.5,4983.04 5949.73,4995.27 6077.46,5123 6352.54,5123 6364.67,5110.87 6512.69,5110.87 6548.52,5075.04 6627.17,5075.04 6643.84,5058.37 6790.86,5058.37 6807.52,5041.71 6807.52,4908.37 6752.86,4853.71 6752.86,4825.04 6769.52,4808.37 6777.21,4808.37 6803.86,4781.73 U15.38@6845.59,4781.73 ; U15.38@6822.37,4776.07 ccw(c6808.72,4762.42) 6808.72,4781.73 ccw(c6808.72,4801.04) U15.38@6822.37,4787.39
DB_SRAM2.NBHE: U8.C21 U15.40 | length 2863.3
  Top Layer w4: U8.C21@5645.91,4650.1 ccw(c5645.91,4667.82) 5658.44,4655.29 ; U8.C21@5653.25,4642.76 cw(c5670.97,4642.76) 5658.44,4655.29 ; v1@5764.02,5129.04 cw(c5741.09,5129.04) 5757.31,5112.82 cw(c5773.52,5096.61) v1@5773.52,5119.54 ; v1@5768.02,5129.04 cw(c5754.75,5129.04) 5764.14,5119.65 cw(c5773.52,5110.26) v1@5773.52,5123.54 ; v1(5773.52,5129.04) 5753,5108.52 5753,5048.87 5727.52,5023.39 5727.52,4845 5727.52,4831.21 5669.77,4773.45 5669.77,4768.45 5669.77,4750 5669.77,4741.18 5669.77,4682.64 cw(c5631.09,4682.64) 5658.44,4655.29
  MidLayer2 w4: v1(6906.86,4886.71) 6937.19,4917.04 7032.52,4917.04 ; v1@6906.86,4892.21 ccw(c6906.86,4905.49) 6916.25,4896.1 ccw(c6925.64,4886.71) v1@6912.36,4886.71 ; v1@6906.86,4896.21 ccw(c6906.86,4919.14) 6923.07,4902.93 ccw(c6939.29,4886.71) v1@6916.36,4886.71 ; v1@7066.81,5200.99 cw(c7050.59,5184.77) 7073.52,5184.77 cw(c7096.46,5184.77) v1@7080.24,5200.99 ; v1@7069.64,5203.82 cw(c7060.25,5194.43) 7073.52,5194.43 cw(c7086.8,5194.43) v1@7077.41,5203.82 ; v1(7073.52,5207.71) 7073.52,4958.04 7044.59,4929.11 ; 7032.52,4917.04 7044.59,4929.11 ; 7032.52,4917.04 7044.59,4929.11
  Bottom Layer w4: v1@5766.81,5135.76 ccw(c5750.59,5151.98) 5773.52,5151.98 ccw(c5796.46,5151.98) v1@5780.24,5135.76 ; v1@5769.64,5132.93 ccw(c5760.25,5142.32) 5773.52,5142.32 ccw(c5786.8,5142.32) v1@5777.41,5132.93 ; v1(5773.52,5129.04) 5773.52,5175.04 5840.19,5241.71 7039.52,5241.71 v1(7073.52,5207.71) ; U15.40@6845.59,4844.72 6873.15,4844.72 6881.15,4852.72 ; U15.40@6863.15,4844.72 ccw(c6868.03,4852.04) 6874.25,4845.82 ; U15.40@6865.37,4848.05 ccw(c6870.79,4856.18) 6877.7,4849.27 ; U15.40@6867.59,4851.38 ccw(c6873.55,4860.32) 6881.15,4852.72 ; v1@6897.36,4886.71 cw(c6874.42,4886.71) 6890.64,4870.49 cw(c6906.86,4854.27) v1@6906.86,4877.21 ; v1@6901.36,4886.71 cw(c6888.08,4886.71) 6897.47,4877.32 cw(c6906.86,4867.93) v1@6906.86,4881.21 ; v1(6906.86,4886.71) 6881.15,4861 6881.15,4852.72 ; v1@7064.02,5207.71 ccw(c7041.09,5207.71) 7057.31,5223.93 ccw(c7073.52,5240.14) v1@7073.52,5217.21 ; v1@7068.02,5207.71 ccw(c7054.75,5207.71) 7064.14,5217.1 ccw(c7073.52,5226.49) v1@7073.52,5213.21
DB_SRAM2.NBLE: U8.B23 U15.39 | length 2104.3
  Top Layer w4: v1@6766.81,4840.09 ccw(c6750.59,4856.31) 6773.52,4856.31 ccw(c6796.46,4856.31) v1@6780.24,4840.09 ; v1@6769.64,4837.26 ccw(c6760.25,4846.65) 6773.52,4846.65 ccw(c6786.8,4846.65) v1@6777.41,4837.26 ; v1(6773.52,4833.37) 6773.52,4871.37 6773.52,4898.24 6706.86,4964.91 6706.86,5030 6706.86,5159.75 6679.9,5186.71 6490,5186.71 6478.33,5175.04 5856.86,5175.04 5761,5079.18 5761,5045.56 5735.52,5020.08 5735.52,4779.48 5740.15,4774.85 5740.15,4749.18 5740.15,4741.18 5740.15,4701.84 ; 5737.18,4694.66 cw(c5724.65,4707.19) 5724.65,4689.47 ccw(c5724.65,4707.19) 5737.18,4694.66 ; 5737.18,4694.66 ccw(c5749.71,4682.13) 5731.99,4682.13 cw(c5749.71,4682.13) 5737.18,4694.66 ; 5737.18,4694.66 ccw(c5730,4701.84) 5740.15,4701.84 ; 5737.18,4694.66 ccw(c5730,4701.84) 5740.15,4701.84
  Bottom Layer w4: v1(6773.52,4833.37) 6773.52,4825.04 6792.34,4806.23 6809.03,4806.23 ; v1@6774.97,4832.98 ccw(c6787.75,4829.53) 6778.39,4820.17 ; v1@6778.83,4831.94 ccw(c6795.45,4827.46) 6783.28,4815.28 ; v1@6782.7,4830.9 ccw(c6803.15,4825.38) 6788.17,4810.39 ; 6810.03,4807.23 cw(c6816.38,4800.88) U15.39@6822.54,4807.41 ; 6812.25,4809.45 cw(c6823.22,4798.48) 6828.03,4813.23 ccw(c6822.03,4806.87) 6815.86,4813.05 ; 6812.94,4810.14 cw(c6819.21,4803.88) U15.39@6825.29,4810.32 ; 6816.86,4814.06 cw(c6825.49,4805.43) U15.39@6829.27,4817.03 ; U15.39@6820.65,4810.15 ccw(c6816.03,4808.23) 6816.03,4813.23 ; U15.39@6820.65,4816.3 cw(c6816.03,4818.23) 6816.03,4813.23 ; U15.39@6826.79,4809.42 6815.81,4813 6816.03,4813.23 ; U15.39@6845.59,4813.23 6816.03,4813.23