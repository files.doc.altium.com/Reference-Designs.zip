# Altium PCB NB3000AL.PcbDoc (part 18 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.UIO.IO26: J33.A33 PROTOTYPE1.H25 U8.R7 UH2.10 | length 10124.1
  Top Layer w4: J33.A33@-785.98,2928.45 -696.55,2928.45 ; J33.A33@-706.91,2922.51 cw(c-696.55,2916.45) -696.55,2928.45 ; J33.A33@-706.92,2934.4 ccw(c-696.55,2940.45) -696.55,2928.45 ; v1(-684.81,2916.71) -696.55,2928.45 ; PROTOTYPE1.H25@2676.12,4208.23 2715.19,4247.3 ; PROTOTYPE1.H25@2679.19,4224.96 ccw(c2683.22,4246.94) 2699.02,4231.14 ccw(c2714.83,4215.33) PROTOTYPE1.H25@2692.84,4211.3 ; PROTOTYPE1.H25@2679.91,4228.89 ccw(c2684.89,4256.05) 2704.41,4236.52 ccw(c2723.94,4217) PROTOTYPE1.H25@2696.78,4212.02 ; PROTOTYPE1.H25@2680.63,4232.82 ccw(c2686.56,4265.16) 2709.8,4241.91 ccw(c2733.04,4218.67) PROTOTYPE1.H25@2700.71,4212.74 ; PROTOTYPE1.H25@2681.35,4236.76 ccw(c2688.23,4274.26) 2715.19,4247.3 ; PROTOTYPE1.H25@2704.65,4213.46 cw(c2742.15,4220.34) 2715.19,4247.3 ; UH2.10@2746.23,4813.23 cw(c2679.77,4813.23) 2726.77,4766.24 cw(c2773.76,4719.25) UH2.10@2773.76,4785.71 ; UH2.10@2750.23,4813.23 cw(c2693.43,4813.23) 2733.59,4773.07 cw(c2773.76,4732.91) UH2.10@2773.76,4789.71 ; UH2.10@2754.23,4813.23 cw(c2707.09,4813.23) 2740.42,4779.9 cw(c2773.76,4746.57) UH2.10@2773.76,4793.71 ; UH2.10@2758.23,4813.23 cw(c2720.74,4813.23) 2747.25,4786.73 cw(c2773.76,4760.22) UH2.10@2773.76,4797.71 ; UH2.10@2773.76,4813.23 2715.19,4754.66 2715.19,4247.3 ; v3(5075.04,4150.63) U8.R7@5094.72,4170.31 ; U8.R7@5087.38,4170.31 cw(c5069.66,4170.31) 5082.19,4157.78 cw(c5094.72,4145.25) U8.R7@5094.72,4162.97 ; 5087.84,4163.43 cw(c5075.04,4176.24) 5075.04,4158.13 ccw(c5075.04,4176.24) 5087.84,4163.43 ; 5087.84,4163.43 ccw(c5100.65,4150.63) 5082.54,4150.63 cw(c5100.65,4150.63) 5087.84,4163.43
  MidLayer1 w4: v1(1841.52,3216.71) 2246.71,3216.71 2415.19,3385.19 2415.19,4390.19 2445,4420 2660,4420 2676.12,4403.88 PROTOTYPE1.H25@2676.12,4208.23 ; v1@1845.41,3212.82 cw(c1854.8,3203.43) 1854.8,3216.71 cw(c1854.8,3229.99) v1@1845.41,3220.6 ; v1@1848.24,3209.99 cw(c1864.46,3193.77) 1864.46,3216.71 cw(c1864.46,3239.64) v1@1848.24,3223.43 ; PROTOTYPE1.H25@2655.62,4228.74 ccw(c2606.11,4278.25) 2676.12,4278.25 ccw(c2746.13,4278.25) PROTOTYPE1.H25@2696.63,4228.74 ; PROTOTYPE1.H25@2658.44,4225.91 ccw(c2615.77,4268.59) 2676.12,4268.59 ccw(c2736.48,4268.59) PROTOTYPE1.H25@2693.8,4225.91 ; PROTOTYPE1.H25@2661.27,4223.08 ccw(c2625.42,4258.93) 2676.12,4258.93 ccw(c2726.82,4258.93) PROTOTYPE1.H25@2690.97,4223.08 ; PROTOTYPE1.H25@2664.1,4220.26 ccw(c2635.08,4249.28) 2676.12,4249.28 ccw(c2717.16,4249.28) PROTOTYPE1.H25@2688.14,4220.26 ; PROTOTYPE1.H25@2666.93,4217.43 ccw(c2644.74,4239.62) 2676.12,4239.62 ccw(c2707.51,4239.62) PROTOTYPE1.H25@2685.31,4217.43
  MidLayer2 w4: v1(-684.81,2916.71) -526.48,3075.04 192.59,3075.04 365.63,2902 1020.13,2902 1318.17,3200.04 1656.73,3200.04 1681.69,3225 1725,3225 1749.96,3200.04 1790.04,3200.04 1806.71,3216.71 v1(1841.52,3216.71) ; v1@-684.81,2922.21 ccw(c-684.81,2935.49) -675.42,2926.1 ccw(c-666.03,2916.71) v1@-679.31,2916.71 ; v1@-684.81,2926.21 ccw(c-684.81,2949.14) -668.59,2932.93 ccw(c-652.37,2916.71) v1@-675.31,2916.71 ; v1@1834.81,3209.99 ccw(c1818.59,3193.77) 1818.59,3216.71 ccw(c1818.59,3239.64) v1@1834.81,3223.43 ; v1@1837.64,3212.82 ccw(c1828.25,3203.43) 1828.25,3216.71 ccw(c1828.25,3229.99) v1@1837.64,3220.6 ; PROTOTYPE1.H25@2655.62,4228.74 ccw(c2606.11,4278.25) 2676.12,4278.25 ccw(c2746.13,4278.25) PROTOTYPE1.H25@2696.63,4228.74 ; PROTOTYPE1.H25@2658.44,4225.91 ccw(c2615.77,4268.59) 2676.12,4268.59 ccw(c2736.48,4268.59) PROTOTYPE1.H25@2693.8,4225.91 ; PROTOTYPE1.H25@2661.27,4223.08 ccw(c2625.42,4258.93) 2676.12,4258.93 ccw(c2726.82,4258.93) PROTOTYPE1.H25@2690.97,4223.08 ; PROTOTYPE1.H25@2664.1,4220.26 ccw(c2635.08,4249.28) 2676.12,4249.28 ccw(c2717.16,4249.28) PROTOTYPE1.H25@2688.14,4220.26 ; PROTOTYPE1.H25@2666.93,4217.43 ccw(c2644.74,4239.62) 2676.12,4239.62 ccw(c2707.51,4239.62) PROTOTYPE1.H25@2685.31,4217.43 ; PROTOTYPE1.H25@2676.12,4208.23 2676.12,4351.12 2708.71,4383.71 4074.67,4383.71 4132.19,4326.18 4132.19,4311.5 4149,4294.69 4149,4294.53 4176.53,4267 4273.82,4267 4290.19,4283.37 4306.86,4300.04 4308.63,4301.81 4394.42,4301.81 4396.19,4300.04 4424.54,4300.04 4458.42,4266.17 4486.77,4237.81 4507.38,4237.81 4517.81,4227.38 4517.81,4192.19 4562.5,4147.5 4562.5,4123.75 4572.75,4113.5 4638.82,4113.5 4640.13,4112.19 4686.06,4112.19 4690.44,4107.81 4729.13,4107.81 4756.44,4135.12 4828.82,4135.12 4838.82,4135.12 4841.47,4135.12 4899.73,4135.12 4957.99,4135.12 4977.41,4135.12 5037.6,4135.12 5051.53,4135.12 ccw(c5051.53,4149.17) 5061.46,4139.24 ; v3@5067.57,4151.28 cw(c5049.53,4152.86) 5061.17,4138.99 cw(c5072.81,4125.12) v3@5074.39,4143.16
ATE.UIO.IO27: J33.B33 PROTOTYPE1.H26 U8.K2 UH2.11 | length 9845.1
  Top Layer w4: PROTOTYPE1.H26@2755.62,4228.74 ccw(c2706.11,4278.25) 2776.12,4278.25 ccw(c2846.13,4278.25) PROTOTYPE1.H26@2796.63,4228.74 ; PROTOTYPE1.H26@2758.44,4225.91 ccw(c2715.77,4268.59) 2776.12,4268.59 ccw(c2836.48,4268.59) PROTOTYPE1.H26@2793.8,4225.91 ; PROTOTYPE1.H26@2761.27,4223.08 ccw(c2725.42,4258.93) 2776.12,4258.93 ccw(c2826.82,4258.93) PROTOTYPE1.H26@2790.97,4223.08 ; PROTOTYPE1.H26@2764.1,4220.26 ccw(c2735.08,4249.28) 2776.12,4249.28 ccw(c2817.16,4249.28) PROTOTYPE1.H26@2788.14,4220.26 ; PROTOTYPE1.H26@2766.93,4217.43 ccw(c2744.74,4239.62) 2776.12,4239.62 ccw(c2807.51,4239.62) PROTOTYPE1.H26@2785.31,4217.43 ; PROTOTYPE1.H26@2776.12,4208.23 2776.12,4408.37 2873.76,4506.01 UH2.11@2873.76,4713.23 ; UH2.11@2854.29,4693.77 cw(c2807.3,4646.78) 2873.76,4646.78 cw(c2940.21,4646.78) UH2.11@2893.22,4693.77 ; UH2.11@2857.12,4696.6 cw(c2816.96,4656.43) 2873.76,4656.43 cw(c2930.56,4656.43) UH2.11@2890.4,4696.6 ; UH2.11@2859.95,4699.43 cw(c2826.61,4666.09) 2873.76,4666.09 cw(c2920.9,4666.09) UH2.11@2887.57,4699.43 ; UH2.11@2862.78,4702.25 cw(c2836.27,4675.75) 2873.76,4675.75 cw(c2911.24,4675.75) UH2.11@2884.74,4702.25 ; v1@4494.98,4459.52 cw(c4494.98,4434.17) 4512.9,4452.1 ; v1@4494.98,4463.52 cw(c4494.98,4447.83) 4506.08,4458.92 ; v1@4495.48,4469.52 4532.5,4432.5 4619.56,4432.5 4625.65,4438.59 4726.85,4438.59 4743.67,4421.77 4755.55,4421.77 4794.64,4382.67 4813.9,4382.67 4830.82,4382.67 4838.82,4382.67 4878.16,4382.67 ; v1@4500.48,4469.02 ccw(c4511.34,4469.02) 4503.66,4461.34 ; v1@4504.48,4469.02 ccw(c4525,4469.02) 4510.49,4454.51 ; 4878.16,4382.67 cw(c4878.16,4372.52) 4885.34,4379.7 ; 4878.16,4382.67 cw(c4878.16,4372.52) 4885.34,4379.7 ; 4885.34,4379.7 ccw(c4897.87,4392.23) 4897.87,4374.51 cw(c4897.87,4392.23) 4885.34,4379.7 ; 4885.34,4379.7 cw(c4872.81,4367.16) 4890.53,4367.16 ccw(c4872.81,4367.16) 4885.34,4379.7
  MidLayer1 w4: v1(2157.86,2858.37) 2182.86,2883.37 2263.86,2883.37 2266.12,2881.12 ; v1@2157.86,2863.87 ccw(c2157.86,2877.15) 2167.25,2867.76 ccw(c2176.64,2858.37) v1@2163.36,2858.37 ; v1@2157.86,2867.87 ccw(c2157.86,2890.81) 2174.07,2874.59 ccw(c2190.29,2858.37) v1@2167.36,2858.37 ; 2265,2880 2320.29,2824.71 2545.21,2824.71 2610,2889.5 2610,3378.18 2623.52,3391.71 2623.52,4138.52 2645,4160 2727.89,4160 ; PROTOTYPE1.H26@2747.13,4207.7 cw(c2681.42,4206.47) 2727.89,4160 ; PROTOTYPE1.H26@2751.13,4207.77 cw(c2694.48,4206.72) 2734.54,4166.66 cw(c2774.6,4126.59) PROTOTYPE1.H26@2775.66,4183.24 ; PROTOTYPE1.H26@2755.12,4207.84 cw(c2707.54,4206.96) 2741.19,4173.31 cw(c2774.85,4139.66) PROTOTYPE1.H26@2775.73,4187.24 ; PROTOTYPE1.H26@2759.12,4207.92 cw(c2720.61,4207.2) 2747.85,4179.96 cw(c2775.09,4152.72) PROTOTYPE1.H26@2775.8,4191.24 ; PROTOTYPE1.H26@2775.58,4179.24 ccw(c2774.36,4113.53) 2727.89,4160 ; PROTOTYPE1.H26@2776.12,4208.23 2727.89,4160
  MidLayer2 w4: v1(-635.48,2908.37) -615,2908.37 ; v1@-631.28,2904.82 cw(c-623.62,2898.35) -623.62,2908.37 cw(c-623.62,2918.4) v1@-631.28,2911.93 ; v1@-628.22,2902.24 cw(c-615,2891.06) -615,2908.37 ; v1@-628.22,2914.51 ccw(c-615,2925.69) -615,2908.37 ; v1@2148.36,2858.37 ccw(c2125.42,2858.37) 2141.64,2874.59 ccw(c2157.86,2890.81) v1@2157.86,2867.87 ; v1@2152.36,2858.37 ccw(c2139.08,2858.37) 2148.47,2867.76 ccw(c2157.86,2877.15) v1@2157.86,2863.87 ; v1(2157.86,2858.37) 2138.23,2878 623,2878 560,2815 418.69,2815 395.84,2837.85 183.65,3050.04 -498.5,3050.04 -580,2968.54 -580,2943.37 -615,2908.37
  Bottom Layer w4: J33.B33@-785.98,2928.45 -701.3,2928.45 ; J33.B33@-705.79,2925.1 cw(c-701.31,2923.77) -701.31,2928.45 ; J33.B33@-705.79,2931.8 ccw(c-701.31,2933.13) -701.31,2928.45 ; v1@-644.98,2908.37 ccw(c-667.91,2908.37) -651.69,2924.59 ccw(c-635.48,2940.81) v1@-635.48,2917.87 ; v1@-640.98,2908.37 ccw(c-654.25,2908.37) -644.86,2917.76 ccw(c-635.48,2927.15) v1@-635.48,2913.87 ; v1(-635.48,2908.37) -667.45,2940.35 -689.41,2940.35 -701.3,2928.45 ; UH2.11@2873.76,4685.71 cw(c2873.76,4616.27) 2922.86,4665.37 ; UH2.11@2873.76,4689.71 cw(c2873.76,4629.92) 2916.03,4672.2 ; UH2.11@2873.76,4693.71 cw(c2873.76,4643.58) 2909.2,4679.03 ; UH2.11@2873.76,4697.71 cw(c2873.76,4657.24) 2902.37,4685.85 ; UH2.11@2873.76,4701.71 cw(c2873.76,4670.9) 2895.55,4692.68 ; UH2.11@2873.76,4713.23 UH2.11@2875,4713.23 ; UH2.11@2875,4715 UH2.11@2875,4713.23 ; UH2.11@2889.29,4713.23 ccw(c2923.79,4713.23) 2899.39,4688.84 ; UH2.11@2893.29,4713.23 ccw(c2937.45,4713.23) 2906.22,4682.01 ; UH2.11@2897.29,4713.23 ccw(c2951.11,4713.23) 2913.05,4675.18 ; UH2.11@2901.29,4713.23 ccw(c2964.76,4713.23) 2919.88,4668.35 ; 4404.37,4617.2 4404.04,4616.87 ; 4473.03,4617.2 4473.36,4616.87 ; v1@4488.26,4475.74 ccw(c4472.05,4491.95) 4494.98,4491.95 ccw(c4517.92,4491.95) v1@4501.7,4475.74 ; 4490.19,4600.04 4473.52,4616.71 ; v1@4491.09,4472.91 ccw(c4481.7,4482.3) 4494.98,4482.3 ccw(c4508.26,4482.3) v1@4498.87,4472.91 ; v1(4494.98,4469.02) 4494.98,4595.25 ; UH2.11@2875,4713.23 2971.36,4616.87 4325,4616.87 ; 4325,4616.87 4404.04,4616.87 ; 4325,4616.87 4404.04,4616.87 ; 4404.04,4616.87 4473.36,4616.87 ; 4473.36,4616.87 4473.52,4616.71 ; 4473.36,4616.87 4473.52,4616.71 ; 4473.52,4616.71 4494.98,4595.25 ; 4473.52,4616.71 4494.98,4595.25
ATE.UIO.IO28: J33.B34 PROTOTYPE1.H27 U8.U6 UH2.12 | length 10289.2
  Top Layer w4: v1@908.3,3221.74 ccw(c892.14,3238.01) 915.07,3237.93 ccw(c938.01,3237.86) v1@921.74,3221.7 ; v1@911.12,3218.9 ccw(c901.76,3228.32) 915.04,3228.28 ccw(c928.32,3228.24) v1@918.9,3218.88 ; v1(915,3215) 915.15,3262.19 928,3275.04 1512.21,3275.04 1586.88,3349.71 2371.52,3349.71 2396.86,3375.04 2431.86,3375.04 2448.52,3358.37 v1(2631.86,3358.37) ; v1@2625.14,3351.66 ccw(c2608.92,3335.44) 2608.92,3358.37 ccw(c2608.92,3381.31) v1@2625.14,3365.09 ; v1@2627.97,3354.49 ccw(c2618.58,3345.1) 2618.58,3358.37 ccw(c2618.58,3371.65) v1@2627.97,3362.26 ; PROTOTYPE1.H27@2855.62,4228.74 ccw(c2806.11,4278.25) 2876.12,4278.25 ccw(c2946.13,4278.25) PROTOTYPE1.H27@2896.63,4228.74 ; PROTOTYPE1.H27@2858.44,4225.91 ccw(c2815.77,4268.59) 2876.12,4268.59 ccw(c2936.48,4268.59) PROTOTYPE1.H27@2893.8,4225.91 ; PROTOTYPE1.H27@2861.27,4223.08 ccw(c2825.42,4258.93) 2876.12,4258.93 ccw(c2926.82,4258.93) PROTOTYPE1.H27@2890.97,4223.08 ; PROTOTYPE1.H27@2864.1,4220.26 ccw(c2835.08,4249.28) 2876.12,4249.28 ccw(c2917.16,4249.28) PROTOTYPE1.H27@2888.14,4220.26 ; PROTOTYPE1.H27@2866.93,4217.43 ccw(c2844.74,4239.62) 2876.12,4239.62 ccw(c2907.51,4239.62) PROTOTYPE1.H27@2885.31,4217.43 ; UH2.12@2873.76,4813.23 2915.19,4771.8 ; UH2.12@2875.2,4797.77 cw(c2877.75,4770.48) 2897.13,4789.86 cw(c2916.51,4809.24) UH2.12@2889.22,4811.79 ; UH2.12@2875.57,4793.79 cw(c2878.77,4759.47) 2903.15,4783.84 cw(c2927.52,4808.22) UH2.12@2893.2,4811.42 ; UH2.12@2875.94,4789.81 cw(c2879.8,4748.46) 2909.17,4777.82 cw(c2938.53,4807.19) UH2.12@2897.18,4811.05 ; PROTOTYPE1.H27@2876.12,4208.23 2876.12,4433.37 2915.19,4472.44 2915.19,4771.8 ; UH2.12@2876.32,4785.83 cw(c2880.83,4737.45) 2915.19,4771.8 ; UH2.12@2901.17,4810.68 ccw(c2949.55,4806.16) 2915.19,4771.8 ; v3(5035.67,4071.89) U8.U6@5055.35,4091.57 ; U8.U6@5048.01,4091.57 cw(c5030.29,4091.57) 5042.82,4079.04 cw(c5055.35,4066.51) U8.U6@5055.35,4084.23 ; 5048.47,4084.69 cw(c5035.67,4097.5) 5035.67,4079.39 ccw(c5035.67,4097.5) 5048.47,4084.69 ; 5048.47,4084.69 ccw(c5061.28,4071.89) 5043.17,4071.89 cw(c5061.28,4071.89) 5048.47,4084.69
  MidLayer1 w4: v1@2631.86,3348.87 cw(c2631.86,3325.94) 2648.07,3342.16 cw(c2664.29,3358.37) v1@2641.36,3358.37 ; v1@2631.86,3352.87 cw(c2631.86,3339.6) 2641.25,3348.99 cw(c2650.64,3358.37) v1@2637.36,3358.37 ; v1(2631.86,3358.37) 2650.23,3340 2810,3340 2823.52,3353.52 2823.52,4155.64 PROTOTYPE1.H27@2876.12,4208.23 ; PROTOTYPE1.H27@2847.12,4208.23 cw(c2777.11,4208.23) 2826.62,4158.73 cw(c2876.12,4109.22) PROTOTYPE1.H27@2876.12,4179.23 ; PROTOTYPE1.H27@2851.12,4208.23 cw(c2790.77,4208.23) 2833.44,4165.56 cw(c2876.12,4122.88) PROTOTYPE1.H27@2876.12,4183.23 ; PROTOTYPE1.H27@2855.12,4208.23 cw(c2804.42,4208.23) 2840.27,4172.39 cw(c2876.12,4136.54) PROTOTYPE1.H27@2876.12,4187.23 ; PROTOTYPE1.H27@2859.12,4208.23 cw(c2818.08,4208.23) 2847.1,4179.21 cw(c2876.12,4150.19) PROTOTYPE1.H27@2876.12,4191.23 ; PROTOTYPE1.H27@2863.12,4208.23 cw(c2831.74,4208.23) 2853.93,4186.04 cw(c2876.12,4163.85) PROTOTYPE1.H27@2876.12,4195.23 ; UH2.12@2873.52,4813.23 UH2.12@2873.76,4813.23 2945.54,4885 3744.71,4885 3855,4774.71 3951.61,4774.71 4152.61,4573.71 v1(4191.52,4573.71) ; UH2.12@2873.76,4828.76 ccw(c2873.76,4866.28) 2900.29,4839.75 ; UH2.12@2873.76,4832.76 ccw(c2873.76,4879.93) 2907.11,4846.58 ; UH2.12@2873.76,4836.76 ccw(c2873.76,4893.59) 2913.94,4853.41 ; UH2.12@2873.76,4840.76 ccw(c2873.76,4907.25) 2920.77,4860.23 ; UH2.12@2889.29,4813.23 cw(c2926.74,4813.23) 2900.26,4839.72 ; UH2.12@2893.29,4813.23 cw(c2940.4,4813.23) 2907.09,4846.55 ; UH2.12@2897.29,4813.23 cw(c2954.06,4813.23) 2913.91,4853.38 ; UH2.12@2901.29,4813.23 cw(c2967.71,4813.23) 2920.74,4860.21 ; v1@4184.81,4566.99 ccw(c4168.59,4550.77) 4168.59,4573.71 ccw(c4168.59,4596.64) v1@4184.81,4580.43 ; v1@4187.64,4569.82 ccw(c4178.25,4560.43) 4178.25,4573.71 ccw(c4178.25,4586.99) v1@4187.64,4577.6 ; v1@4300.04,4475.04 4373.52,4475.04 4432,4416.56 4432,4410 4432,4382.03 4479.03,4335 4526.79,4287.25 4526.79,4275.6 ; v1@4303.89,4471.11 cw(c4313.38,4461.62) 4313.38,4475.04 ; v1@4303.89,4478.89 ccw(c4313.18,4488.18) 4313.18,4475.04 ; v1@4306.72,4468.28 cw(c4323.03,4451.97) 4323.03,4475.04 ; v1@4306.72,4481.72 ccw(c4322.84,4497.84) 4322.84,4475.04 ; 4958.86,4048.03 4972.79,4048.03 ; v3@5028.2,4072.54 cw(c5010.16,4074.12) 5021.8,4060.25 ; v3@5035.02,4064.42 ccw(c5033.44,4046.38) 5021.8,4060.25 ; 4526.79,4259.21 4539,4247 4581,4247 4597,4247 4616,4228 4616,4216.75 4682.75,4150 4718.66,4150 4725.66,4143 4745,4143 ; 4526.79,4259.21 4526.79,4275.6 ; 4526.79,4259.21 4526.79,4275.6 ; 4745,4143 4754.01,4143 ; 4745,4143 4754.01,4143 ; 4754.01,4143 4754.75,4143 4771.75,4126 4779.5,4118.25 4779.5,4103.75 4779.5,4070 4779.5,4055.75 4779.5,4045.5 4787.5,4037.5 4812.25,4037.5 4822.78,4048.03 4831.97,4048.03 4838.82,4048.03 4879.25,4048.03 4898.67,4048.03 4972.79,4048.03 ; 4972.79,4048.03 4992.29,4048.03 ccw(c4992.29,4089.76) 5021.8,4060.25
  Bottom Layer w4: J33.B34@-785.98,2889.08 -567.81,2889.08 -554.41,2902.48 -554.41,3179.28 -546.69,3187 -29.82,3187 -19,3176.19 740.09,3176.19 778.9,3215 v1(915,3215) ; J33.B34@-711.58,2883.58 cw(c-698.3,2870.3) -698.3,2889.08 ; J33.B34@-711.58,2894.58 ccw(c-698.3,2907.86) -698.3,2889.08 ; J33.B34@-708.76,2880.75 cw(c-688.65,2860.64) -688.65,2889.08 cw(c-688.64,2917.52) J33.B34@-708.76,2897.41 ; v1@908.28,3208.28 ccw(c892.06,3192.06) 892.06,3215 ccw(c892.06,3237.93) v1@908.28,3221.72 ; v1@911.11,3211.11 ccw(c901.72,3201.72) 901.72,3215 ccw(c901.72,3228.28) v1@911.11,3218.89 ; v1(4191.52,4573.71) 4240.27,4573.71 4300,4513.98 v1@4300,4475.04 ; v1@4195.41,4569.82 cw(c4204.8,4560.43) 4204.8,4573.71 cw(c4204.8,4586.99) v1@4195.41,4577.6 ; v1@4198.24,4566.99 cw(c4214.46,4550.77) 4214.46,4573.71 cw(c4214.46,4596.64) v1@4198.24,4580.43 ; v1@4293.28,4481.72 ccw(c4277.06,4497.93) 4300,4497.93 ccw(c4322.93,4497.93) v1@4306.72,4481.72 ; v1@4296.11,4478.89 ccw(c4286.72,4488.28) 4300,4488.28 ccw(c4313.28,4488.28) v1@4303.89,4478.89
  other v1: 4300,4475
ATE.UIO.IO29: J33.A34 PROTOTYPE1.H28 U8.P1 UH2.13 | length 9978.7
  Top Layer w4: J33.A34@-785.98,2889.08 -503.06,2889.08 -492.14,2900 -492.14,3154.02 -292.32,3353.85 -225.35,3420.81 -225.35,3578.34 -102,3701.69 -102,3838.1 -68.14,3871.96 -68.14,3888.14 -81,3901 -81,3933.85 -35,3979.85 -35,4037.56 -51.48,4054.04 -51.48,4081.15 -21,4111.63 -21,4401 -59.81,4439.81 v1(-59.81,4508.37) ; J33.A34@-711.58,2883.58 cw(c-698.3,2870.3) -698.3,2889.08 ; J33.A34@-711.58,2894.58 ccw(c-698.3,2907.86) -698.3,2889.08 ; J33.A34@-708.76,2880.75 cw(c-688.65,2860.64) -688.65,2889.08 cw(c-688.64,2917.52) J33.A34@-708.76,2897.41 ; v1@-66.53,4501.66 cw(c-82.74,4485.44) -59.81,4485.44 cw(c-36.87,4485.44) v1@-53.09,4501.66 ; v1@-63.7,4504.49 cw(c-73.09,4495.1) -59.81,4495.1 cw(c-46.53,4495.1) v1@-55.92,4504.49 ; UH2.13@2954.29,4693.77 cw(c2907.3,4646.78) 2973.76,4646.78 cw(c3040.21,4646.78) UH2.13@2993.22,4693.77 ; PROTOTYPE1.H28@2955.62,4228.74 ccw(c2906.11,4278.25) 2976.12,4278.25 ccw(c3046.13,4278.25) PROTOTYPE1.H28@2996.63,4228.74 ; UH2.13@2957.12,4696.6 cw(c2916.96,4656.43) 2973.76,4656.43 cw(c3030.56,4656.43) UH2.13@2990.4,4696.6 ; PROTOTYPE1.H28@2958.44,4225.91 ccw(c2915.77,4268.59) 2976.12,4268.59 ccw(c3036.48,4268.59) PROTOTYPE1.H28@2993.8,4225.91 ; UH2.13@2959.95,4699.43 cw(c2926.61,4666.09) 2973.76,4666.09 cw(c3020.9,4666.09) UH2.13@2987.57,4699.43 ; PROTOTYPE1.H28@2961.27,4223.08 ccw(c2925.42,4258.93) 2976.12,4258.93 ccw(c3026.82,4258.93) PROTOTYPE1.H28@2990.97,4223.08 ; UH2.13@2962.78,4702.25 cw(c2936.27,4675.75) 2973.76,4675.75 cw(c3011.24,4675.75) UH2.13@2984.74,4702.25 ; PROTOTYPE1.H28@2964.1,4220.26 ccw(c2935.08,4249.28) 2976.12,4249.28 ccw(c3017.16,4249.28) PROTOTYPE1.H28@2988.14,4220.26 ; PROTOTYPE1.H28@2966.93,4217.43 ccw(c2944.74,4239.62) 2976.12,4239.62 ccw(c3007.51,4239.62) PROTOTYPE1.H28@2985.31,4217.43 ; UH2.13@2973.76,4713.23 2973.76,4460.74 2976.12,4458.37 PROTOTYPE1.H28@2976.12,4208.23 ; v1@4332.29,4662.66 cw(c4316.08,4646.44) 4339.01,4646.44 cw(c4361.95,4646.44) v1@4345.73,4662.66 ; v1@4335.12,4665.49 cw(c4325.73,4656.1) 4339.01,4656.1 cw(c4352.29,4656.1) v1@4342.9,4665.49 ; v1(4339.01,4669.38) 4339.01,4643.99 4330.02,4635 4330.02,4492.35 4333.5,4488.88 4333.5,4396.67 4408.67,4321.5 4519.98,4321.5 4523.52,4325.04 4538.36,4339.88 4542.02,4339.88 4555,4339.88 4606.68,4339.88 4633,4313.56 4633,4299.06 4628.66,4294.72 4628.66,4279.28 4654.7,4253.24 4673.94,4234 4675.94,4234 ; U8.P1@4853.31,4204.49 ccw(c4840.78,4191.96) 4840.78,4209.68 ccw(c4840.78,4227.41) U8.P1@4853.31,4214.88 ; U8.P1@4858.5,4209.68 4838.82,4209.68 4830.82,4209.68 4775.68,4209.68 4770,4204 4755.44,4204 4739.64,4219.81 4729.94,4219.81 4715.75,4234 4690,4234 ; 4675.94,4234 4690,4234 ; 4675.94,4234 4690,4234
  MidLayer2 w4: v1@-59.81,4498.87 cw(c-59.81,4475.94) -43.59,4492.16 cw(c-27.37,4508.37) v1@-50.31,4508.37 ; v1@-59.81,4502.87 cw(c-59.81,4489.6) -50.42,4498.99 cw(c-41.03,4508.37) v1@-54.31,4508.37 ; v1(-59.81,4508.37) -34.81,4483.37 394.96,4483.37 515.4,4603.81 858,4603.81 889.31,4572.5 1445.98,4572.5 1448.52,4575.04 1456.86,4583.37 1505.5,4583.37 1532.88,4556 2955,4556 2973.76,4574.76 UH2.13@2973.76,4713.23 ; UH2.13@2954.29,4693.77 cw(c2907.3,4646.78) 2973.76,4646.78 cw(c3040.22,4646.78) UH2.13@2993.22,4693.77 ; UH2.13@2957.12,4696.6 cw(c2916.96,4656.43) 2973.76,4656.43 cw(c3030.56,4656.43) UH2.13@2990.4,4696.6 ; UH2.13@2959.95,4699.43 cw(c2926.62,4666.09) 2973.76,4666.09 cw(c3020.9,4666.09) UH2.13@2987.57,4699.43 ; UH2.13@2962.78,4702.25 cw(c2936.27,4675.75) 2973.76,4675.75 cw(c3011.25,4675.75) UH2.13@2984.74,4702.25
  Bottom Layer w4: UH2.13@2973.76,4685.71 cw(c2973.76,4619.25) 3020.75,4666.24 cw(c3067.74,4713.23) UH2.13@3001.29,4713.23 ; UH2.13@2973.76,4689.71 cw(c2973.76,4632.91) 3013.92,4673.07 cw(c3054.09,4713.23) UH2.13@2997.29,4713.23 ; UH2.13@2973.76,4693.71 cw(c2973.76,4646.56) 3007.09,4679.9 cw(c3040.43,4713.23) UH2.13@2993.29,4713.23 ; UH2.13@2973.76,4697.71 cw(c2973.76,4660.22) 3000.27,4686.73 cw(c3026.77,4713.23) UH2.13@2989.29,4713.23 ; UH2.13@2973.76,4713.23 3054.12,4632.87 4267.87,4632.87 4304.37,4669.37 v1(4339.01,4669.38) ; v1@4332.29,4662.66 ccw(c4316.08,4646.44) 4316.08,4669.37 ccw(c4316.08,4692.31) v1@4332.29,4676.09 ; v1@4335.12,4665.49 ccw(c4325.73,4656.1) 4325.73,4669.37 ccw(c4325.73,4682.65) v1@4335.12,4673.26
ATE.UIO.IO30: J33.B35 PROTOTYPE1.H29 U8.U4 UH2.14 | length 10728.4
  Top Layer w4: UH2.14@2973.76,4785.71 cw(c2973.76,4719.25) 3020.75,4766.24 cw(c3067.74,4813.23) UH2.14@3001.29,4813.23 ; UH2.14@2973.76,4789.71 cw(c2973.76,4732.91) 3013.92,4773.07 cw(c3054.09,4813.23) UH2.14@2997.29,4813.23 ; UH2.14@2973.76,4793.71 cw(c2973.76,4746.56) 3007.09,4779.9 cw(c3040.43,4813.23) UH2.14@2993.29,4813.23 ; UH2.14@2973.76,4797.71 cw(c2973.76,4760.22) 3000.27,4786.73 cw(c3026.77,4813.23) UH2.14@2989.29,4813.23 ; UH2.14@2973.76,4813.23 3023.52,4763.47 3023.52,4260.83 PROTOTYPE1.H29@3076.12,4208.23 ; PROTOTYPE1.H29@3047.12,4208.23 ccw(c2977.11,4208.23) 3026.62,4257.74 ccw(c3076.12,4307.25) PROTOTYPE1.H29@3076.12,4237.23 ; PROTOTYPE1.H29@3051.12,4208.23 ccw(c2990.77,4208.23) 3033.44,4250.91 ccw(c3076.12,4293.59) PROTOTYPE1.H29@3076.12,4233.23 ; PROTOTYPE1.H29@3055.12,4208.23 ccw(c3004.42,4208.23) 3040.27,4244.08 ccw(c3076.12,4279.93) PROTOTYPE1.H29@3076.12,4229.23 ; PROTOTYPE1.H29@3059.12,4208.23 ccw(c3018.08,4208.23) 3047.1,4237.26 ccw(c3076.12,4266.28) PROTOTYPE1.H29@3076.12,4225.23 ; PROTOTYPE1.H29@3063.12,4208.23 ccw(c3031.74,4208.23) 3053.93,4230.43 ccw(c3076.12,4252.62) PROTOTYPE1.H29@3076.12,4221.23 ; v3(4956.93,4071.89) U8.U4@4976.61,4091.57 ; U8.U4@4969.27,4091.57 cw(c4951.55,4091.57) 4964.08,4079.04 cw(c4976.61,4066.51) U8.U4@4976.61,4084.23 ; 4969.73,4084.69 cw(c4956.93,4097.5) 4956.93,4079.39 ccw(c4956.93,4097.5) 4969.73,4084.69 ; 4969.73,4084.69 ccw(c4982.54,4071.89) 4964.43,4071.89 cw(c4982.54,4071.89) 4969.73,4084.69
  MidLayer1 w4: v1(2782.86,3241.71) 2998.52,3241.71 3031.86,3275.04 3031.86,4163.97 ; v1@2786.75,3237.82 cw(c2796.14,3228.43) 2796.14,3241.71 cw(c2796.14,3254.99) v1@2786.75,3245.6 ; v1@2789.57,3234.99 cw(c2805.79,3218.77) 2805.79,3241.71 cw(c2805.79,3264.64) v1@2789.57,3248.43 ; PROTOTYPE1.H29@3047.22,4205.85 cw(c2994.34,4201.49) 3031.86,4163.97 ; PROTOTYPE1.H29@3051.21,4206.18 cw(c3005.62,4202.42) 3037.96,4170.08 cw(c3070.31,4137.74) PROTOTYPE1.H29@3074.07,4183.32 ; PROTOTYPE1.H29@3055.19,4206.51 cw(c3016.9,4203.35) 3044.07,4176.18 cw(c3071.24,4149.02) PROTOTYPE1.H29@3074.39,4187.31 ; PROTOTYPE1.H29@3059.18,4206.84 cw(c3028.18,4204.28) 3050.17,4182.29 cw(c3072.17,4160.3) PROTOTYPE1.H29@3074.72,4191.29 ; PROTOTYPE1.H29@3073.74,4179.33 ccw(c3069.37,4126.46) 3031.86,4163.97 ; PROTOTYPE1.H29@3076.12,4208.23 3031.86,4163.97 ; v1@4754.18,4169.81 cw(c4749.21,4161.38) 4759,4161.38 ; v1(4759,4178) 4759,4161.38 ; v1@4763.82,4169.81 ccw(c4768.79,4161.38) 4759,4161.38 ; v3@4951.63,4066.59 ccw(c4938.82,4053.78) 4938.82,4071.89 ccw(c4938.82,4090) v3@4951.63,4077.19 ; v3@4951.74,4066.7 ccw(c4939.2,4054.16) 4939.2,4071.89 ccw(c4939.2,4089.62) v3@4951.74,4077.08 ; v3(4956.93,4071.89) 4898.67,4071.89 4879.25,4071.89 4838.82,4071.89 4830.82,4071.89 4829.42,4071.89 4818.31,4083 4797,4083 4796,4084 4796,4115 ; 4759,4161.38 4791.02,4129.35 ; 4791.02,4129.35 4796,4124.38 ; 4791.02,4129.35 4796,4124.38 ; 4796,4115 4796,4124.38 ; 4796,4115 4796,4124.38
  MidLayer2 w4: PROTOTYPE1.H29@3047.62,4213.59 ccw(c3010.68,4220.52) 3037.26,4247.1 ; PROTOTYPE1.H29@3051.55,4212.85 ccw(c3019.7,4218.83) 3042.62,4241.74 ccw(c3065.53,4264.65) PROTOTYPE1.H29@3071.51,4232.81 ; PROTOTYPE1.H29@3055.48,4212.11 ccw(c3028.73,4217.13) 3047.98,4236.38 ccw(c3067.22,4255.63) PROTOTYPE1.H29@3072.25,4228.87 ; PROTOTYPE1.H29@3059.41,4211.37 ccw(c3037.76,4215.44) 3053.34,4231.02 ccw(c3068.92,4246.6) PROTOTYPE1.H29@3072.98,4224.94 ; PROTOTYPE1.H29@3070.77,4236.74 cw(c3063.83,4273.68) 3037.26,4247.1 ; PROTOTYPE1.H29@3076.12,4208.23 3037.25,4247.1 ; v1@4751.85,4171.74 ccw(c4738.06,4159.68) 4738.06,4178 ; v1@4751.85,4184.26 cw(c4738.06,4196.32) 4738.06,4178 ; v1@4754.86,4174.38 ccw(c4746.88,4167.39) 4746.88,4178 ccw(c4746.88,4188.61) v1@4754.86,4181.62 ; v1(4759,4178) 4738.06,4178 ; 3037.25,4247.1 2845.59,4247.1 2831.86,4233.37 2831.86,4183.37 2815.19,4166.71 2640.19,4166.71 2631.86,4175.04 2631.86,4358.37 2665.19,4391.71 4156.86,4391.71 4165,4383.56 4165,4301.15 4176.61,4289.54 4273.73,4289.54 4302,4317.81 4401.04,4317.81 4402.81,4316.04 4432.52,4316.04 4494.75,4253.81 4514,4253.81 4533.81,4234 4533.81,4198.81 4578.12,4154.5 4593.25,4154.5 4605.65,4142.09 4630.78,4142.09 4636.5,4147.81 4684.13,4147.81 4685.44,4146.5 4706.56,4146.5 4738.06,4178
  Bottom Layer w4: J33.B35@-785.98,2849.71 -668.14,2849.71 -651.14,2866.71 -518.14,2866.71 -501.48,2883.37 -501.48,3041.71 -484.81,3058.37 448.33,3058.37 465,3041.71 550,3041.71 556.6,3048.31 1672.48,3048.31 1807.21,3183.04 1836.88,3183.04 1895.54,3241.71 v1(2782.86,3241.71) ; J33.B35@-711.58,2844.21 cw(c-698.3,2830.93) -698.3,2849.71 ; J33.B35@-711.58,2855.21 ccw(c-698.3,2868.49) -698.3,2849.71 ; J33.B35@-708.76,2841.38 cw(c-688.65,2821.27) -688.65,2849.71 cw(c-688.64,2878.15) J33.B35@-708.76,2858.04 ; v1@2776.14,3234.99 ccw(c2759.92,3218.77) 2759.92,3241.71 ccw(c2759.92,3264.64) v1@2776.14,3248.43 ; v1@2778.97,3237.82 ccw(c2769.58,3228.43) 2769.58,3241.71 ccw(c2769.58,3254.99) v1@2778.97,3245.6
ATE.UIO.IO31: J33.A35 PROTOTYPE1.H30 U8.R1 UH2.15 | length 9971.9
  Top Layer w4: J33.A35@-785.98,2849.71 -685,2849.71 -677,2841.71 v1(-650.48,2841.71) ; J33.A35@-711.58,2844.21 cw(c-698.3,2830.93) -698.3,2849.71 ; J33.A35@-711.58,2855.21 ccw(c-698.3,2868.49) -698.3,2849.71 ; J33.A35@-708.76,2841.38 cw(c-688.65,2821.27) -688.65,2849.71 cw(c-688.64,2878.15) J33.A35@-708.76,2858.04 ; v1@-657.19,2834.99 ccw(c-673.41,2818.77) -673.41,2841.71 ccw(c-673.41,2864.64) v1@-657.19,2848.43 ; v1@-654.36,2837.82 ccw(c-663.75,2828.43) -663.75,2841.71 ccw(c-663.75,2854.99) v1@-654.36,2845.6 ; UH2.15@3054.29,4693.77 cw(c3007.3,4646.78) 3073.76,4646.78 cw(c3140.21,4646.78) UH2.15@3093.22,4693.77 ; UH2.15@3057.12,4696.6 cw(c3016.96,4656.43) 3073.76,4656.43 cw(c3130.56,4656.43) UH2.15@3090.4,4696.6 ; UH2.15@3059.95,4699.43 cw(c3026.61,4666.09) 3073.76,4666.09 cw(c3120.9,4666.09) UH2.15@3087.57,4699.43 ; UH2.15@3062.78,4702.25 cw(c3036.27,4675.75) 3073.76,4675.75 cw(c3111.24,4675.75) UH2.15@3084.74,4702.25 ; UH2.15@3073.76,4713.23 3073.76,4310.6 PROTOTYPE1.H30@3176.12,4208.23 ; PROTOTYPE1.H30@3147.12,4208.23 ccw(c3077.11,4208.23) 3126.62,4257.74 ccw(c3176.12,4307.25) PROTOTYPE1.H30@3176.12,4237.23 ; PROTOTYPE1.H30@3151.12,4208.23 ccw(c3090.77,4208.23) 3133.44,4250.91 ccw(c3176.12,4293.59) PROTOTYPE1.H30@3176.12,4233.23 ; PROTOTYPE1.H30@3155.12,4208.23 ccw(c3104.42,4208.23) 3140.27,4244.08 ccw(c3176.12,4279.93) PROTOTYPE1.H30@3176.12,4229.23 ; PROTOTYPE1.H30@3159.12,4208.23 ccw(c3118.08,4208.23) 3147.1,4237.26 ccw(c3176.12,4266.28) PROTOTYPE1.H30@3176.12,4225.23 ; PROTOTYPE1.H30@3163.12,4208.23 ccw(c3131.74,4208.23) 3153.93,4230.43 ccw(c3176.12,4252.62) PROTOTYPE1.H30@3176.12,4221.23 ; v1(4591.56,4199.75) 4601.82,4210 4622.75,4210 4626.25,4206.5 4645.25,4187.5 4674.67,4187.5 4684.67,4197.5 4715.17,4197.5 4741.5,4171.17 ; 4741.5,4170.75 4751.75,4160.5 4766.25,4160.5 4776.06,4170.32 4777.43,4170.32 4829.45,4170.32 4838.82,4170.32 U8.R1@4858.5,4170.31 ; U8.R1@4853.31,4165.12 ccw(c4840.78,4152.59) 4840.78,4170.32 ccw(c4840.78,4188.04) U8.R1@4853.31,4175.51
  MidLayer1 w4: v1@-659.98,2841.71 ccw(c-682.91,2841.71) -666.69,2857.93 ccw(c-650.48,2874.14) v1@-650.48,2851.21 ; v1@-655.98,2841.71 ccw(c-669.25,2841.71) -659.86,2851.1 ccw(c-650.48,2860.49) v1@-650.48,2847.21 ; v1(-650.48,2841.71) -709.81,2901.04 -709.81,3021.46 -681.22,3050.04 -572.33,3050.04 -529,3093.37 -529,3201.2 ; -528.98,3201.22 -528.98,3412.99 -395,3546.97 -395,3602.38 -428.81,3636.19 -428.81,3737.82 -293.23,3873.4 -293.23,4003.46 -295,4005.23 -295,4148.18 -84.81,4358.37 v1(-84.81,4475.04) ; v1@-91.53,4468.32 cw(c-107.74,4452.11) -84.81,4452.11 cw(c-61.87,4452.11) v1@-78.09,4468.32 ; v1@-88.7,4471.15 cw(c-98.09,4461.76) -84.81,4461.76 cw(c-71.53,4461.76) v1@-80.92,4471.15 ; v1@3873.52,4323.87 cw(c3873.52,4300.94) 3889.74,4317.16 cw(c3905.96,4333.37) v1@3883.02,4333.37 ; v1@3873.52,4327.87 cw(c3873.52,4314.6) 3882.91,4323.99 cw(c3892.3,4333.37) v1@3879.02,4333.37 ; v1(3873.52,4333.37) 3917.36,4289.54 4288.23,4289.54 4306.89,4308.21 4353.21,4308.21 4361.54,4316.54 4400,4316.54 4419.66,4316.54 4428.65,4316.54 4507.38,4237.81 4515.78,4229.41 ; v1@4582.07,4199.75 ccw(c4559.13,4199.75) 4575.35,4215.97 ccw(c4591.56,4232.18) v1@4591.56,4209.25 ; v1@4586.06,4199.75 ccw(c4572.79,4199.75) 4582.18,4209.14 ccw(c4591.56,4218.53) v1@4591.56,4205.25 ; v1@4589.31,4202 4572.31,4219 4526.19,4219 ; 4515.78,4229.41 4526.19,4219 ; 4515.78,4229.41 4526.19,4219
  MidLayer2 w4: v1(-84.81,4475.04) 397.94,4475.04 518.71,4595.81 854.19,4595.81 885.5,4564.5 1449.3,4564.5 1460.17,4575.37 1502.19,4575.37 1529.56,4548 3058,4548 3073.76,4563.76 UH2.15@3073.76,4713.23 ; v1@-80.92,4471.15 cw(c-71.53,4461.76) -71.53,4475.04 cw(c-71.53,4488.32) v1@-80.92,4478.93 ; v1@-78.09,4468.32 cw(c-61.87,4452.11) -61.87,4475.04 cw(c-61.87,4497.98) v1@-78.09,4481.76 ; UH2.15@3054.29,4693.77 cw(c3007.3,4646.78) 3073.76,4646.78 cw(c3140.22,4646.78) UH2.15@3093.22,4693.77 ; UH2.15@3057.12,4696.6 cw(c3016.96,4656.43) 3073.76,4656.43 cw(c3130.56,4656.43) UH2.15@3090.4,4696.6 ; UH2.15@3059.95,4699.43 cw(c3026.62,4666.09) 3073.76,4666.09 cw(c3120.9,4666.09) UH2.15@3087.57,4699.43 ; UH2.15@3062.78,4702.25 cw(c3036.27,4675.75) 3073.76,4675.75 cw(c3111.25,4675.75) UH2.15@3084.74,4702.25 ; PROTOTYPE1.H30@3155.62,4228.74 ccw(c3106.1,4278.25) 3176.12,4278.25 ; PROTOTYPE1.H30@3158.44,4225.91 ccw(c3115.76,4268.6) 3176.12,4268.6 ccw(c3236.47,4268.58) PROTOTYPE1.H30@3193.8,4225.91 ; PROTOTYPE1.H30@3161.27,4223.08 ccw(c3125.42,4258.94) 3176.12,4258.94 ccw(c3226.81,4258.93) PROTOTYPE1.H30@3190.97,4223.08 ; PROTOTYPE1.H30@3164.1,4220.26 ccw(c3135.07,4249.28) 3176.12,4249.28 ccw(c3217.16,4249.27) PROTOTYPE1.H30@3188.14,4220.26 ; PROTOTYPE1.H30@3166.93,4217.43 ccw(c3144.73,4239.63) 3176.12,4239.63 ccw(c3207.5,4239.61) PROTOTYPE1.H30@3185.31,4217.43 ; PROTOTYPE1.H30@3176.12,4208.23 3176.12,4316.31 3193.19,4333.37 3723.52,4333.37 3734.19,4322.71 3781.86,4322.71 3792.52,4333.37 v1(3873.52,4333.37) ; 3176.12,4278.24 ccw(c3246.13,4278.24) PROTOTYPE1.H30@3196.63,4228.74 ; v1@3866.81,4326.66 ccw(c3850.59,4310.44) 3850.59,4333.37 ccw(c3850.59,4356.31) v1@3866.81,4340.09 ; v1@3869.64,4329.49 ccw(c3860.25,4320.1) 3860.25,4333.37 ccw(c3860.25,4346.65) v1@3869.64,4337.26
ATE.UIO.IO32: J33.B36 PROTOTYPE1.H31 U8.V9 UH2.16 | length 10051.3
  Top Layer w4: UH2.16@3073.76,4813.23 3109.4,4777.59 ; UH2.16@3077.91,4794.15 cw(c3082.8,4771.7) 3099.04,4787.95 cw(c3115.29,4804.2) UH2.16@3092.84,4809.08 ; UH2.16@3078.76,4790.24 cw(c3084.65,4763.19) 3104.22,4782.77 cw(c3123.8,4802.34) UH2.16@3096.75,4808.23 ; UH2.16@3079.61,4786.34 cw(c3086.5,4754.69) 3109.4,4777.59 ; UH2.16@3100.66,4807.38 ccw(c3132.31,4800.49) 3109.4,4777.59 ; PROTOTYPE1.H31@3255.62,4228.74 ccw(c3206.11,4278.25) 3276.12,4278.25 ccw(c3346.13,4278.25) PROTOTYPE1.H31@3296.63,4228.74 ; PROTOTYPE1.H31@3258.44,4225.91 ccw(c3215.77,4268.59) 3276.12,4268.59 ccw(c3336.48,4268.59) PROTOTYPE1.H31@3293.8,4225.91 ; PROTOTYPE1.H31@3261.27,4223.08 ccw(c3225.42,4258.93) 3276.12,4258.93 ccw(c3326.82,4258.93) PROTOTYPE1.H31@3290.97,4223.08 ; v1@3264.02,4308.37 ccw(c3241.09,4308.37) 3257.31,4324.59 ccw(c3273.52,4340.81) v1@3273.52,4317.87 ; PROTOTYPE1.H31@3264.1,4220.26 ccw(c3235.08,4249.28) 3276.12,4249.28 ccw(c3317.16,4249.28) PROTOTYPE1.H31@3288.14,4220.26 ; v1@3266.81,4301.66 cw(c3244.32,4279.17) 3276.12,4279.17 ; PROTOTYPE1.H31@3266.93,4217.43 ccw(c3244.74,4239.62) 3276.12,4239.62 ccw(c3307.51,4239.62) PROTOTYPE1.H31@3285.31,4217.43 ; v1@3268.02,4308.37 ccw(c3254.75,4308.37) 3264.14,4317.76 ccw(c3273.52,4327.15) v1@3273.52,4313.87 ; v1@3269.64,4304.49 cw(c3253.98,4288.83) 3276.12,4288.83 ; PROTOTYPE1.H31@3276.12,4208.23 3276.12,4305.78 v1(3273.52,4308.37) 3109.4,4472.49 3109.4,4777.59 ; 3276.12,4291.71 cw(c3290.19,4291.71) v1@3280.24,4301.66 ; v3(5153.78,4032.52) U8.V9@5173.46,4052.2 ; U8.V9@5166.12,4052.2 cw(c5148.4,4052.2) 5160.93,4039.67 cw(c5173.46,4027.14) U8.V9@5173.46,4044.86 ; 5166.58,4045.32 cw(c5153.78,4058.13) 5153.78,4040.02 ccw(c5153.78,4058.13) 5166.58,4045.32 ; 5166.58,4045.32 ccw(c5179.39,4032.52) 5161.28,4032.52 cw(c5179.39,4032.52) 5166.58,4045.32
  MidLayer1 w4: v1(2916.19,3150.04) 2923.52,3150.04 3123.52,3350.04 3123.52,4143.52 3140,4160 3227.89,4160 ; v1@2916.19,3151.54 ccw(c2916.19,3172.87) 2931.27,3157.79 ; v1@2916.19,3155.54 ccw(c2916.19,3186.52) 2938.1,3164.62 ; v1@2916.19,3159.54 ccw(c2916.19,3200.18) 2944.93,3171.44 ; v1@2925.69,3150.04 cw(c2930.92,3150.04) 2927.22,3153.74 ; PROTOTYPE1.H31@3247.13,4207.7 cw(c3181.42,4206.47) 3227.89,4160 ; PROTOTYPE1.H31@3251.13,4207.77 cw(c3194.48,4206.72) 3234.54,4166.66 cw(c3274.6,4126.59) PROTOTYPE1.H31@3275.66,4183.24 ; PROTOTYPE1.H31@3255.12,4207.84 cw(c3207.54,4206.96) 3241.19,4173.31 cw(c3274.85,4139.66) PROTOTYPE1.H31@3275.73,4187.24 ; PROTOTYPE1.H31@3259.12,4207.92 cw(c3220.61,4207.2) 3247.85,4179.96 cw(c3275.09,4152.72) PROTOTYPE1.H31@3275.8,4191.24 ; PROTOTYPE1.H31@3275.58,4179.24 ccw(c3274.36,4113.53) 3227.89,4160 ; PROTOTYPE1.H31@3276.12,4208.23 3227.89,4160
  MidLayer2 w4: v1@-476.53,2809.99 ccw(c-492.74,2793.77) -492.74,2816.71 ccw(c-492.74,2839.64) v1@-476.53,2823.43 ; v1@-473.7,2812.82 ccw(c-483.09,2803.43) -483.09,2816.71 ccw(c-483.09,2829.99) v1@-473.7,2820.6 ; v1(-469.81,2816.71) -661.71,2816.71 -670,2825 -670,2907.38 -661.14,2916.24 -661.14,2924.37 -518.81,3066.71 189.61,3066.71 362.31,2894 1219,2894 1231.86,2906.86 1231.86,2950.37 1265.19,2983.71 1265.19,3032.04 1358.19,3125.04 2197.92,3125.04 2214.25,3141.37 2628.63,3141.37 2636.96,3133.04 2899.19,3133.04 v1(2916.19,3150.04) ; v1@2906.69,3150.04 cw(c2883.76,3150.04) 2899.97,3133.82 cw(c2916.19,3117.61) v1@2916.19,3140.54 ; v1@2910.69,3150.04 cw(c2897.41,3150.04) 2906.8,3140.65 cw(c2916.19,3131.26) v1@2916.19,3144.54
  Bottom Layer w4: J33.B36@-785.98,2810.34 -545,2810.34 -538.63,2816.71 v1(-469.81,2816.71) ; J33.B36@-711.58,2804.84 cw(c-698.3,2791.56) -698.3,2810.34 cw(c-698.3,2829.12) J33.B36@-711.58,2815.84 ; J33.B36@-708.76,2802.01 cw(c-688.65,2781.9) -688.65,2810.34 cw(c-688.64,2838.78) J33.B36@-708.76,2818.67 ; v1@-476.53,2809.99 ccw(c-492.74,2793.77) -492.74,2816.71 ccw(c-492.74,2839.64) v1@-476.53,2823.43 ; v1@-473.7,2812.82 ccw(c-483.09,2803.43) -483.09,2816.71 ccw(c-483.09,2829.99) v1@-473.7,2820.6 ; v1(3273.52,4308.37) 3341.19,4376.04 4041.6,4376.04 4240.05,4177.6 4246.43,4171.21 4419.04,4171.21 4482.44,4107.81 4736.44,4107.81 4760.6,4083.65 4770.66,4083.65 4785.5,4068.81 4785.5,4025.81 4794.3,4017.01 4830.82,4017.01 4838.82,4017.01 5036.73,4017.01 5130.27,4017.01 ccw(c5130.27,4031.06) 5140.2,4021.13 ; v1@3273.52,4313.87 ccw(c3273.52,4327.15) 3282.91,4317.76 ccw(c3292.3,4308.37) v1@3279.02,4308.37 ; v1@3273.52,4317.87 ccw(c3273.52,4340.81) 3289.74,4324.59 ccw(c3305.96,4308.37) v1@3283.02,4308.37 ; v3@5146.31,4033.17 cw(c5128.27,4034.75) 5139.91,4020.88 cw(c5151.55,4007.01) v3@5153.13,4025.05
ATE.UIO.IO33: J33.A36 PROTOTYPE1.H32 U8.U5 UH2.17 | length 10141.5
  Top Layer w4: J33.A36@-785.98,2810.34 -527.49,2810.34 -484.14,2853.69 -484.14,3150.71 -235.05,3399.8 -217.35,3417.5 -217.35,3575.02 -100.05,3692.32 -94,3698.37 -94,3821.31 -9.14,3906.17 -9.14,4023.02 -43.14,4057.02 -43.14,4078.17 -13,4108.31 -13,4408 -25,4420 -25,4439.75 18.63,4483.37 228.86,4483.37 233.88,4483.37 270.52,4520.02 v1(270.52,4650.04) ; J33.A36@-711.58,2804.84 cw(c-698.3,2791.56) -698.3,2810.34 cw(c-698.3,2829.12) J33.A36@-711.58,2815.84 ; J33.A36@-708.76,2802.01 cw(c-688.65,2781.9) -688.65,2810.34 cw(c-688.64,2838.78) J33.A36@-708.76,2818.67 ; v1@263.81,4643.32 cw(c247.59,4627.11) 270.52,4627.11 cw(c293.46,4627.11) v1@277.24,4643.32 ; v1@266.64,4646.15 cw(c257.25,4636.76) 270.52,4636.76 cw(c283.8,4636.76) v1@274.41,4646.15 ; UH2.17@3146.33,4715.55 ccw(c3096.5,4719.77) 3131.86,4755.13 ; UH2.17@3150.31,4715.22 ccw(c3107.72,4718.82) 3137.95,4749.04 ccw(c3168.17,4779.27) UH2.17@3171.77,4736.68 ; UH2.17@3154.3,4714.88 ccw(c3118.95,4717.87) 3144.04,4742.96 ccw(c3169.12,4768.04) UH2.17@3172.11,4732.69 ; UH2.17@3158.29,4714.54 ccw(c3130.18,4716.92) 3150.12,4736.87 ccw(c3170.07,4756.81) UH2.17@3172.45,4728.71 ; UH2.17@3171.44,4740.66 cw(c3167.22,4790.5) 3131.86,4755.13 ; UH2.17@3173.76,4713.23 3131.86,4755.13 ; PROTOTYPE1.H32@3355.62,4228.74 ccw(c3312.38,4271.98) 3373.52,4271.98 ; PROTOTYPE1.H32@3358.44,4225.91 ccw(c3322.04,4262.32) 3373.52,4262.32 ; PROTOTYPE1.H32@3361.27,4223.08 ccw(c3331.69,4252.66) 3373.52,4252.66 ; PROTOTYPE1.H32@3364.1,4220.26 ccw(c3341.35,4243.01) 3373.52,4243.01 ; v1@3366.81,4418.32 cw(c3350.59,4402.11) 3373.52,4402.11 cw(c3396.46,4402.11) v1@3380.24,4418.32 ; v1@3366.81,4431.76 ccw(c3350.59,4447.98) 3373.52,4447.98 ccw(c3396.46,4447.98) v1@3380.24,4431.76 ; v1@3369.64,4421.15 cw(c3360.25,4411.76) 3373.52,4411.76 cw(c3386.8,4411.76) v1@3377.41,4421.15 ; v1@3369.64,4428.93 ccw(c3360.25,4438.32) 3373.52,4438.32 ccw(c3386.8,4438.32) v1@3377.41,4428.93 ; 3373.52,4245.89 ccw(c3413.78,4245.89) PROTOTYPE1.H32@3385.31,4217.43 ; 3373.52,4255.55 ccw(c3423.43,4255.55) PROTOTYPE1.H32@3388.14,4220.26 ; 3373.52,4265.2 ccw(c3433.09,4265.2) PROTOTYPE1.H32@3390.97,4223.08 ; 3373.52,4274.86 ccw(c3442.75,4274.86) PROTOTYPE1.H32@3393.8,4225.91 ; 3373.52,4284.52 ccw(c3452.4,4284.52) PROTOTYPE1.H32@3396.63,4228.74 ; PROTOTYPE1.H32@3376.12,4208.23 3373.52,4210.83 v1(3373.52,4425.04) 3373.52,4766.71 3290.19,4850.04 3148.52,4850.04 3131.86,4833.37 3131.86,4755.13 ; v3(4996.3,4071.89) U8.U5@5015.98,4091.57 ; U8.U5@5008.64,4091.57 cw(c4990.92,4091.57) 5003.45,4079.04 cw(c5015.98,4066.51) U8.U5@5015.98,4084.23 ; 5009.1,4084.69 cw(c4996.3,4097.5) 4996.3,4079.39 ccw(c4996.3,4097.5) 5009.1,4084.69 ; 5009.1,4084.69 ccw(c5021.91,4071.89) 5003.8,4071.89 cw(c5021.91,4071.89) 5009.1,4084.69
  MidLayer1 w4: v1(4709,4215) 4709,4200.06 4787.5,4121.56 4787.5,4077.5 4790,4075 4815,4075 4822.07,4067.93 4822.07,4062.93 4828.62,4056.38 4830.82,4056.38 4838.82,4056.38 4879.25,4056.38 4898.67,4056.38 4958.86,4056.38 4972.79,4056.38 ccw(c4972.79,4070.43) 4982.72,4060.5 ; v3@4988.83,4072.54 cw(c4970.79,4074.12) 4982.43,4060.25 cw(c4994.07,4046.38) v3@4995.65,4064.42
  MidLayer2 w4: v1@263.81,4643.32 cw(c247.59,4627.11) 270.52,4627.11 cw(c293.46,4627.11) v1@277.24,4643.32 ; v1@266.64,4646.15 cw(c257.25,4636.76) 270.52,4636.76 cw(c283.8,4636.76) v1@274.41,4646.15 ; v1(270.52,4650.04) 270.52,4594.48 282.96,4582.04 448.37,4582.04 502.14,4635.81 974.07,4635.81 1010.17,4599.71 1634.71,4599.71 1651.71,4616.71 2481.86,4616.71 2523.52,4658.37 2523.52,4743.52 2540,4760 3126.99,4760 UH2.17@3173.76,4713.23 ; UH2.17@3146.23,4713.33 ccw(c3080.56,4713.56) 3127,4760 ccw(c3173.44,4806.44) UH2.17@3173.66,4740.76 ; UH2.17@3150.23,4713.32 ccw(c3094.1,4713.51) 3133.79,4753.2 ccw(c3173.48,4792.9) UH2.17@3173.68,4736.76 ; UH2.17@3154.23,4713.3 ccw(c3107.64,4713.46) 3140.59,4746.41 ccw(c3173.53,4779.35) UH2.17@3173.69,4732.76 ; UH2.17@3158.23,4713.29 ccw(c3121.19,4713.42) 3147.38,4739.61 ccw(c3173.58,4765.81) UH2.17@3173.71,4728.76
  Bottom Layer w4: v1@3373.52,4415.54 cw(c3373.52,4392.61) 3389.74,4408.82 cw(c3405.96,4425.04) v1@3383.02,4425.04 ; v1@3373.52,4419.54 cw(c3373.52,4406.26) 3382.91,4415.65 cw(c3392.3,4425.04) v1@3379.02,4425.04 ; v1(3373.52,4425.04) 3390.52,4408.04 4054.86,4408.04 4083.58,4379.32 4212.86,4250.04 4412.21,4250.04 4421.04,4258.87 4450,4258.87 4459.34,4258.87 4480.4,4237.81 4499.42,4237.81 4507.38,4237.81 4517.81,4227.38 4517.81,4219.44 4582.75,4154.5 4703.25,4154.5 4713.5,4164.75 4713.5,4179.25 4709,4183.75 v1(4709,4215) ; v1@4702.28,4208.28 cw(c4686.06,4192.06) 4709,4192.06 cw(c4731.93,4192.06) v1@4715.72,4208.28 ; v1@4705.11,4211.11 cw(c4695.72,4201.72) 4709,4201.72 cw(c4722.28,4201.72) v1@4712.89,4211.11
ATE.UIO.IO34: J33.A37 PROTOTYPE1.A32 U8.V5 UH2.18 | length 10140.7
  Top Layer w4: J33.A37@-781.91,2775.04 -551.48,2775.04 -493.14,2833.37 -476.14,2850.35 -476.14,3147.39 -209.35,3414.19 -209.35,3571.71 -86,3695.06 -86,3818 -1.14,3902.86 -1.14,4026.33 -34.81,4060 -34.81,4075.19 -5,4105 v1(-5,4435) ; J33.A37@-714.41,2768.3 cw(c-698.14,2752.02) -698.14,2775.04 ; J33.A37@-711.58,2765.47 cw(c-688.48,2742.37) -688.48,2775.04 ; J33.A37@-708.76,2762.64 cw(c-678.82,2732.71) -678.82,2775.04 ; J33.A37@-708.76,2779.3 ccw(c-698.47,2789.58) -698.47,2775.04 ; v1@-11.72,4428.28 cw(c-27.94,4412.06) -5,4412.06 cw(c17.93,4412.06) v1@1.72,4428.28 ; v1@-8.89,4431.11 cw(c-18.28,4421.72) -5,4421.72 cw(c8.28,4421.72) v1@-1.11,4431.11 ; UH2.18@3173.76,4785.71 cw(c3173.76,4719.25) 3220.75,4766.24 cw(c3267.74,4813.23) UH2.18@3201.29,4813.23 ; UH2.18@3173.76,4789.71 cw(c3173.76,4732.91) 3213.92,4773.07 cw(c3254.09,4813.23) UH2.18@3197.29,4813.23 ; UH2.18@3173.76,4793.71 cw(c3173.76,4746.56) 3207.09,4779.9 cw(c3240.43,4813.23) UH2.18@3193.29,4813.23 ; UH2.18@3173.76,4797.71 cw(c3173.76,4760.22) 3200.27,4786.73 cw(c3226.77,4813.23) UH2.18@3189.29,4813.23 ; UH2.18@3173.76,4813.23 3226.07,4760.92 3305,4760.92 3331.86,4734.06 3331.86,4198.71 3376.12,4154.44 ; PROTOTYPE1.A32@3363.51,4134.35 ccw(c3353.81,4154.44) 3376.12,4154.44 ; PROTOTYPE1.A32@3365.25,4130.75 ccw(c3356.89,4148.07) 3376.12,4148.07 ccw(c3395.36,4148.07) PROTOTYPE1.A32@3386.99,4130.75 ; PROTOTYPE1.A32@3366.99,4127.15 ccw(c3359.96,4141.7) 3376.12,4141.7 ccw(c3392.28,4141.7) PROTOTYPE1.A32@3385.25,4127.15 ; PROTOTYPE1.A32@3376.12,4108.23 3376.12,4154.44 ; PROTOTYPE1.A32@3388.73,4134.35 cw(c3398.43,4154.44) 3376.12,4154.44 ; v3(4996.3,4032.52) U8.V5@5015.98,4052.2 ; U8.V5@5008.64,4052.2 cw(c4990.92,4052.2) 5003.45,4039.67 cw(c5015.98,4027.14) U8.V5@5015.98,4044.86 ; 5009.1,4045.32 cw(c4996.3,4058.13) 4996.3,4040.02 ccw(c4996.3,4058.13) 5009.1,4045.32 ; 5009.1,4045.32 ccw(c5021.91,4032.52) 5003.8,4032.52 cw(c5021.91,4032.52) 5009.1,4045.32
  MidLayer1 w4: v1(4195,4070) 4245.21,4120.21 4404.95,4120.21 4411.55,4126.81 4481.55,4126.81 4513.61,4158.87 4556.36,4158.87 4556.86,4158.37 4565.19,4150.04 4565.19,4140.04 4565.19,4133.06 4608.75,4089.5 4665.5,4089.5 4733,4022 4766.66,4022 4771.65,4017.01 4830.82,4017.01 4838.82,4017.01 4879.25,4017.01 4972.79,4017.01 ccw(c4972.79,4031.06) 4982.72,4021.13 ; v1@4195,4075.5 ccw(c4195,4088.78) 4204.39,4079.39 ccw(c4213.78,4070) v1@4200.5,4070 ; v1@4195,4079.5 ccw(c4195,4102.43) 4211.22,4086.22 ccw(c4227.43,4070) v1@4204.5,4070 ; v3@4988.83,4033.17 cw(c4970.79,4034.75) 4982.43,4020.88 cw(c4994.07,4007.01) v3@4995.65,4025.05
  MidLayer2 w4: v1@-5,4428.5 ccw(c-5,4445.36) 6.92,4433.44 ; v1@-5,4432.5 ccw(c-5,4459.01) 13.75,4440.27 ; v1(-5,4435) 8.48,4435 40.52,4467.04 401.26,4467.04 522.03,4587.81 850.88,4587.81 882.19,4556.5 1452.61,4556.5 1463.49,4567.37 1498.88,4567.37 1526.25,4540 3200.19,4540 3215.19,4555 3215.19,4771.8 ; v1@-5,4436.5 ccw(c-5,4472.67) 20.58,4447.09 ; v1@-5,4440.5 ccw(c-5,4486.33) 27.41,4453.92 ; v1@-5,4444.5 ccw(c-5,4499.98) 34.23,4460.75 ; UH2.18@3173.76,4813.23 3215.19,4771.8 ; UH2.18@3175.2,4797.77 cw(c3177.75,4770.48) 3197.13,4789.86 cw(c3216.51,4809.25) UH2.18@3189.22,4811.79 ; UH2.18@3175.57,4793.79 cw(c3178.78,4759.47) 3203.15,4783.84 cw(c3227.52,4808.22) UH2.18@3193.2,4811.42 ; UH2.18@3175.94,4789.81 cw(c3179.8,4748.46) 3209.17,4777.82 cw(c3238.53,4807.19) UH2.18@3197.18,4811.05 ; UH2.18@3176.32,4785.83 cw(c3180.83,4737.45) 3215.19,4771.8 ; UH2.18@3201.17,4810.68 ccw(c3249.55,4806.16) 3215.19,4771.8
  Bottom Layer w4: PROTOTYPE1.A32@3376.12,4108.23 3376.12,4108.37 3506.86,4108.37 3523.52,4091.71 3523.52,3991.71 3548.52,3966.71 3648.52,3966.71 3723.52,4041.71 3880,4041.71 3915.83,4077.54 4015.88,4077.54 4052.62,4040.79 4165.79,4040.79 v1(4195,4070) ; PROTOTYPE1.A32@3385.31,4099.04 cw(c3407.84,4076.51) 3407.84,4108.37 ; PROTOTYPE1.A32@3385.31,4117.43 ccw(c3407.17,4139.28) 3407.17,4108.37 ; PROTOTYPE1.A32@3388.14,4096.21 cw(c3417.5,4066.85) 3417.5,4108.37 ; PROTOTYPE1.A32@3388.14,4120.26 ccw(c3416.82,4148.94) 3416.82,4108.37 ; PROTOTYPE1.A32@3390.97,4093.39 cw(c3427.16,4057.2) 3427.16,4108.37 ; PROTOTYPE1.A32@3390.97,4123.08 ccw(c3426.48,4158.59) 3426.48,4108.37 ; PROTOTYPE1.A32@3393.8,4090.56 cw(c3436.81,4047.54) 3436.81,4108.37 ; PROTOTYPE1.A32@3393.8,4125.91 ccw(c3436.14,4168.25) 3436.14,4108.37 ; PROTOTYPE1.A32@3396.63,4087.73 cw(c3446.47,4037.88) 3446.47,4108.37 ; PROTOTYPE1.A32@3396.63,4128.74 ccw(c3445.8,4177.91) 3445.8,4108.37 ; v1@4185.5,4070 cw(c4162.56,4070) 4178.78,4053.78 cw(c4195,4037.56) v1@4195,4060.5 ; v1@4189.5,4070 cw(c4176.22,4070) 4185.61,4060.61 cw(c4195,4051.22) v1@4195,4064.5