# Altium PCB NB3000AL.PcbDoc (part 32 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_D11: U7.G4 U8.R23 U12.47 U16.32 U61.52 | length 5770.4
  Top Layer w4: U8.R23@5724.65,4162.97 cw(c5724.65,4145.25) 5737.18,4157.78 cw(c5749.71,4170.31) U8.R23@5731.99,4170.31 ; U8.R23@5724.65,4170.31 v3(5744.33,4150.63) ; v1(6290.19,2550.04) U61.52@6351.93,2550.04 ; v1@6294.08,2546.15 cw(c6303.47,2536.76) 6303.47,2550.04 cw(c6303.47,2563.32) v1@6294.08,2553.93 ; v1@6296.91,2543.32 cw(c6313.13,2527.11) 6313.13,2550.04 cw(c6313.13,2572.98) v1@6296.91,2556.76 ; 6323.87,2550.04 cw(c6323.87,2533.01) U61.52@6335.91,2545.05 ; v1(7203.52,4016.71) 7190.19,4003.37 7190.19,3969.81 7206.02,3953.98 U12.47@7294.41,3953.98 ; U12.47@7271.19,3948.32 ccw(c7257.54,3934.66) 7257.54,3953.98 ccw(c7257.54,3973.29) U12.47@7271.19,3959.63 ; U16.32@7294.41,4592.76 7323.14,4592.76 ; U16.32@7311.97,4592.76 cw(c7317.53,4586.17) 7323.64,4592.26 ; U16.32@7319.54,4590.18 cw(c7323.14,4588.95) 7323.14,4592.76 ; U16.32@7319.54,4595.33 ccw(c7323.14,4596.56) 7323.14,4592.76 ; v1(7340.19,4600.04) 7331.86,4591.71 7324.19,4591.71 7323.14,4592.76 ; 5731.53,4163.43 cw(c5718.72,4150.63) 5736.83,4150.63 ccw(c5718.72,4150.63) 5731.53,4163.43 ; 5731.53,4163.43 ccw(c5744.33,4176.24) 5744.33,4158.13 cw(c5744.33,4176.24) 5731.53,4163.43
  Top Layer w8: v5@7731.89,4515.37 cw(c7731.89,4493.64) 7747.25,4509.01 cw(c7762.62,4524.37) v5@7740.89,4524.37 ; v5(7731.89,4524.37) U7.G4@7751.58,4504.69
  MidLayer1 w4: v3@5744.98,4143.16 cw(c5746.56,4125.12) 5758.2,4138.99 ; v3@5751.8,4151.28 ccw(c5769.84,4152.86) 5758.2,4138.99 ; v1@6283.47,2556.76 ccw(c6267.26,2572.98) 6290.19,2572.98 ccw(c6313.13,2572.98) v1@6296.91,2556.76 ; v1@6286.3,2553.93 ccw(c6276.91,2563.32) 6290.19,2563.32 ccw(c6303.47,2563.32) v1@6294.08,2553.93 ; v1(6290.19,2550.04) 6290.19,2758.37 6331.86,2800.04 6331.86,2850.04 6348.52,2866.71 6348.52,2900.04 6373.52,2925.04 6373.52,2969.08 6353.52,2989.08 6353.52,3062.36 6374,3082.83 6374,3315 ; 6374,3315.75 6374,3315 ; v1@6395.5,3685 ccw(c6372.56,3685) 6388.78,3701.22 ccw(c6405,3717.43) v1@6405,3694.5 ; v1@6399.5,3685 ccw(c6386.22,3685) 6395.61,3694.39 ccw(c6405,3703.78) v1@6405,3690.5 ; v1(6405,3685) 6380,3710 6365,3710 ; v1@7196.81,4023.43 ccw(c7180.59,4039.64) 7203.52,4039.64 ccw(c7226.46,4039.64) v1@7210.24,4023.43 ; v1@7199.64,4020.6 ccw(c7190.25,4029.99) 7203.52,4029.99 ccw(c7216.8,4029.99) v1@7207.41,4020.6 ; v1(7203.52,4016.71) 7203.52,4125.04 7231.86,4153.37 7231.86,4290.37 7273.52,4332.04 7273.52,4768.04 7285.48,4780 7353.23,4780 7358.19,4775.04 7358.19,4747.77 7312.69,4702.27 7312.69,4627.54 v1(7340.19,4600.04) ; v1@7330.69,4600.04 ccw(c7307.76,4600.04) 7323.97,4616.26 ccw(c7340.19,4632.48) v1@7340.19,4609.54 ; v1@7334.69,4600.04 ccw(c7321.41,4600.04) 7330.8,4609.43 ccw(c7340.19,4618.82) v1@7340.19,4605.54 ; 5758.2,4138.99 ccw(c5787.71,4168.5) 5787.71,4126.77 5807.21,4126.77 5881.33,4126.77 5900.75,4126.77 5941.18,4126.77 5949.18,4126.77 5966.96,4126.77 6002.02,4091.71 6018.52,4091.71 6073.66,4036.57 6074.53,4035.7 6146.2,4035.7 6215.19,3966.71 6283.86,3966.71 6310.75,3939.81 6321.38,3939.81 6333.81,3927.38 6333.81,3774.88 6365,3743.69 6365,3710 ; 6365,3710 6345,3710 6322.19,3687.19 6322.19,3662.62 6348.69,3636.12 6348.69,3558.69 6341.36,3551.36 6341.36,3501.36 6373.52,3469.19 6373.52,3425.04 6367.19,3418.71 6367.19,3321.81 6374,3315
  MidLayer2 w4: v1(7340.19,4600.04) 7372,4600.04 7377,4600 7391.29,4585.71 7527.92,4585.71 7569.92,4543.71 7712.55,4543.71 v5(7731.89,4524.37) ; v1@7344.08,4596.15 cw(c7353.47,4586.76) 7353.47,4600.04 cw(c7353.47,4613.32) v1@7344.08,4603.93 ; v1@7346.91,4593.32 cw(c7363.13,4577.11) 7363.13,4600.04 cw(c7363.13,4622.98) v1@7346.91,4606.76 ; v5@7720.89,4524.37 ccw(c7694.33,4524.37) 7713.11,4543.15 ccw(c7731.89,4561.93) v5@7731.89,4535.37 ; v5@7724.89,4524.37 ccw(c7707.99,4524.37) 7719.94,4536.32 ccw(c7731.89,4548.27) v5@7731.89,4531.37
  Bottom Layer w4: v1(6405,3685) 6443.92,3685 6455.21,3673.71 6485.17,3673.71 6527.5,3716.04 6725.84,3716.04 6760.5,3750.71 7040.71,3750.71 7049.21,3759.21 7114.21,3759.21 7127.02,3772.02 7127.02,3812.18 7127.02,3904.94 7196.69,3974.6 7196.69,4009.87 v1(7203.52,4016.71) ; v1@6408.89,3681.11 cw(c6418.28,3671.72) 6418.28,3685 cw(c6418.28,3698.28) v1@6408.89,3688.89 ; v1@6411.72,3678.28 cw(c6427.93,3662.06) 6427.93,3685 cw(c6427.93,3707.93) v1@6411.72,3691.72
DB_MEM.BUS_D12: U7.F5 U8.R24 U12.48 U16.35 U61.54 | length 6408.1
  Top Layer w4: U8.R24@5764.02,4162.97 cw(c5764.02,4145.25) 5776.55,4157.78 cw(c5789.08,4170.31) U8.R24@5771.36,4170.31 ; U8.R24@5764.02,4170.31 v3(5783.7,4150.63) ; U61.54@6351.93,2587.25 6394.65,2587.25 v1@6427.95,2553.95 ; U61.54@6367.95,2584.42 cw(c6374.78,2577.59) 6374.78,2587.25 cw(c6374.78,2596.91) U61.54@6367.95,2590.08 ; 6401.95,2579.95 ccw(c6432,2609.99) v1@6432,2567.5 ; 6408.78,2573.12 ccw(c6432,2596.34) v1@6432,2563.5 ; 6415.61,2566.29 ccw(c6432,2582.68) v1@6432,2559.5 ; v1@7145.5,4085 ccw(c7122.56,4085) 7138.78,4101.22 ccw(c7155,4117.43) v1@7155,4094.5 ; v1@7149.5,4085 ccw(c7136.22,4085) 7145.61,4094.39 ccw(c7155,4103.78) v1@7155,4090.5 ; v1(7155,4085) 7089.52,4150.48 7089.52,4418.41 7092.86,4421.75 7092.86,4611.54 7168.56,4687.24 U16.35@7294.41,4687.24 7333.73,4687.24 v1(7338.19,4691.71) ; v1(7214.19,3989.71) 7252.29,3989.71 7256.52,3985.47 U12.48@7294.41,3985.47 ; v1@7218.08,3985.82 cw(c7227.47,3976.43) 7227.47,3989.71 cw(c7227.47,4002.99) v1@7218.08,3993.6 ; v1@7220.91,3982.99 cw(c7237.13,3966.77) 7237.13,3989.71 cw(c7237.13,4012.64) v1@7220.91,3996.43 ; U12.48@7271.19,3979.82 ccw(c7257.54,3966.16) 7257.54,3985.47 ccw(c7257.54,4004.79) U12.48@7271.19,3991.13 ; U16.35@7271.19,4681.59 ccw(c7257.54,4667.93) 7257.54,4687.24 ccw(c7257.54,4706.56) U16.35@7271.19,4692.9 ; U16.35@7304.48,4687.24 ccw(c7304.48,4725.42) v1@7331.47,4698.43 ; U16.35@7314.13,4687.24 ccw(c7314.13,4715.76) v1@7334.3,4695.6 ; 7323.79,4687.24 ccw(c7323.79,4706.11) v1@7337.13,4692.77 ; 7326.03,4687.24 cw(c7326.03,4679.55) v1@7331.47,4684.99 ; 5770.9,4163.43 cw(c5758.09,4150.63) 5776.2,4150.63 ccw(c5758.09,4150.63) 5770.9,4163.43 ; 5770.9,4163.43 ccw(c5783.7,4176.24) 5783.7,4158.13 cw(c5783.7,4176.24) 5770.9,4163.43
  Top Layer w8: v5(7771.26,4445.63) U7.F5@7790.95,4465.32 ; v5@7771.26,4454.63 ccw(c7771.26,4476.36) 7786.62,4460.99 ccw(c7801.99,4445.63) v5@7780.26,4445.63
  MidLayer1 w4: v3@5784.35,4143.16 cw(c5785.93,4125.12) 5797.57,4138.99 cw(c5809.21,4152.86) v3@5791.17,4151.28 ; 5797.28,4139.24 ccw(c5807.21,4149.17) 5807.21,4135.12 5900.75,4135.12 5941.18,4135.12 5949.18,4135.12 5969.92,4135.12 6004.5,4100.54 6021.03,4100.54 6077.86,4043.7 6149.51,4043.7 6201.5,3991.71 ; v1@6216.61,3985.19 ccw(c6201.51,3970.94) 6201.51,3991.71 ; v1@6216.61,3998.23 cw(c6201.51,4012.48) 6201.51,3991.71 ; v1@6219.52,3987.93 ccw(c6210.78,3979.68) 6210.78,3991.71 ccw(c6210.78,4003.73) v1@6219.52,3995.48 ; v1(6223.52,3991.71) 6201.5,3991.71 ; v1@6432,2550.04 6504.86,2550.04 6648.52,2693.71 6648.52,2758.37 6740.19,2850.04 6740.19,2916.71 6723.52,2933.37 6723.52,3258.37 6881.86,3416.71 6945.23,3416.71 6973.52,3445 6973.52,3513.73 7114.89,3655.09 7138.24,3655.09 7148.52,3665.37 7148.52,3691.71 7156.86,3700.04 7156.86,3760 7113.86,3803 7113.86,4009.92 7155,4051.06 v1(7155,4085) ; v1@6432,2550.18 v1(6432,2558) ; v1@7148.28,4078.28 cw(c7132.06,4062.06) 7155,4062.06 cw(c7177.94,4062.06) v1@7161.72,4078.28 ; v1@7151.11,4081.11 cw(c7141.72,4071.72) 7155,4071.72 cw(c7168.28,4071.72) v1@7158.89,4081.11
  MidLayer2 w4: v1@7148.28,4078.28 cw(c7132.06,4062.06) 7155,4062.06 cw(c7177.94,4062.06) v1@7161.72,4078.28 ; v1@7151.11,4081.11 cw(c7141.72,4071.72) 7155,4071.72 cw(c7168.28,4071.72) v1@7158.89,4081.11 ; v1(7155,4085) 7155,4023 7188.29,3989.71 v1(7214.19,3989.71) ; v1@7207.47,3982.99 ccw(c7191.26,3966.77) 7191.26,3989.71 ccw(c7191.26,4012.64) v1@7207.47,3996.43 ; v1@7210.3,3985.82 ccw(c7200.91,3976.43) 7200.91,3989.71 ccw(c7200.91,4002.99) v1@7210.3,3993.6 ; v1(7338.19,4691.71) 7340.02,4693.54 7563.36,4693.54 v1(7565.19,4691.71) ; v1@7342.08,4687.82 cw(c7355.89,4674) 7355.89,4693.54 ; v1@7344.91,4684.99 cw(c7365.55,4664.35) 7365.55,4693.54 ; v1@7344.91,4698.43 ccw(c7356.7,4710.22) 7356.7,4693.54 ; 7537.83,4693.54 cw(c7537.83,4664.35) v1@7558.47,4684.99 ; 7546.68,4693.54 ccw(c7546.68,4710.22) v1@7558.47,4698.43 ; 7547.49,4693.54 cw(c7547.49,4674) v1@7561.3,4687.82
  Bottom Layer w4: v1(6223.52,3991.71) 6286.67,3991.71 6295,4000.04 6365.19,4000.04 6390.19,3975.04 6686.86,3975.04 ; v1@6227.41,3987.82 cw(c6236.8,3978.43) 6236.8,3991.71 cw(c6236.8,4004.99) v1@6227.41,3995.6 ; v1@6230.24,3984.99 cw(c6246.46,3968.77) 6246.46,3991.71 cw(c6246.46,4014.64) v1@6230.24,3998.43 ; 6685,3975 6760,3975 6815,4030 6815,4069.32 6863.22,4117.55 6864.26,4117.55 6864.76,4118.04 7121.96,4118.04 v1(7155,4085) ; v1@7145.5,4085 ccw(c7122.56,4085) 7138.78,4101.22 ccw(c7155,4117.43) v1@7155,4094.5 ; v1@7149.5,4085 ccw(c7136.22,4085) 7145.61,4094.39 ccw(c7155,4103.78) v1@7155,4090.5 ; v1(7565.19,4691.71) 7608.29,4691.71 7640.19,4659.81 7640.19,4616.71 7640.19,4600 7640.19,4476.71 7651.52,4465.37 7751.52,4465.37 v5(7771.26,4445.63) ; v1@7569.08,4687.82 cw(c7578.47,4678.43) 7578.47,4691.71 cw(c7578.47,4704.99) v1@7569.08,4695.6 ; v1@7571.91,4684.99 cw(c7588.13,4668.77) 7588.13,4691.71 cw(c7588.13,4714.64) v1@7571.91,4698.43 ; v5@7760.26,4445.63 ccw(c7733.7,4445.63) 7752.48,4464.41 ccw(c7771.26,4483.19) v5@7771.26,4456.63 ; v5@7764.26,4445.63 ccw(c7747.36,4445.63) 7759.31,4457.58 ccw(c7771.26,4469.53) v5@7771.26,4452.63
DB_MEM.BUS_D13: U7.G6 U8.T21 U12.50 U16.36 U61.56 | length 6345.2
  Top Layer w4: U8.T21@5645.91,4123.6 cw(c5645.91,4105.88) 5658.44,4118.41 cw(c5670.97,4130.94) U8.T21@5653.25,4130.94 ; U8.T21@5645.91,4130.94 v3(5665.59,4111.26) ; U61.56@6351.93,2626.62 6365.12,2626.61 6365.12,2626.71 v1(6390.19,2626.71) ; U61.56@6367.95,2623.79 cw(c6374.99,2616.75) 6374.99,2626.71 ; U61.56@6367.95,2629.45 ccw(c6374.57,2636.07) 6374.57,2626.71 ; v1@6383.47,2619.99 ccw(c6367.26,2603.77) 6367.26,2626.71 ccw(c6367.26,2649.64) v1@6383.47,2633.43 ; v1@6386.3,2622.82 ccw(c6376.91,2613.43) 6376.91,2626.71 ccw(c6376.91,2639.99) v1@6386.3,2630.6 ; U12.50@7294.41,4048.46 7332.28,4048.46 v1(7345.19,4061.37) ; U16.36@7294.41,4718.74 7306.86,4718.73 7306.86,4716.71 7348.52,4716.71 7365.19,4700.04 7365.19,4375.04 7415.19,4325.04 v1(7415.19,4250.04) ; U16.36@7314.8,4721.57 ccw(c7326.53,4733.3) 7326.53,4716.71 ; U12.50@7317.63,4042.81 cw(c7331.28,4029.15) 7331.28,4048.46 cw(c7331.28,4067.78) U12.50@7317.63,4054.12 ; U16.36@7317.63,4713.08 cw(c7326.38,4704.33) 7326.38,4716.71 ; U16.36@7317.63,4724.4 ccw(c7336.19,4742.96) 7336.19,4716.71 ; v1@7408.47,4256.76 ccw(c7392.26,4272.98) 7415.19,4272.98 ccw(c7438.13,4272.98) v1@7421.91,4256.76 ; v1@7411.3,4253.93 ccw(c7401.91,4263.32) 7415.19,4263.32 ccw(c7428.47,4263.32) v1@7419.08,4253.93 ; 5652.79,4124.06 cw(c5639.98,4111.26) 5658.09,4111.26 ccw(c5639.98,4111.26) 5652.79,4124.06 ; 5652.79,4124.06 ccw(c5665.59,4136.87) 5665.59,4118.76 cw(c5665.59,4136.87) 5652.79,4124.06
  Top Layer w8: v5(7731.89,4406.26) U7.G6@7751.58,4425.94 ; v5@7731.89,4415.26 ccw(c7731.89,4436.99) 7747.25,4421.62 ccw(c7762.62,4406.26) v5@7740.89,4406.26
  MidLayer1 w4: v1@7335.69,4061.37 ccw(c7312.76,4061.37) 7328.97,4077.59 ccw(c7345.19,4093.81) v1@7345.19,4070.87 ; v1@7339.69,4061.37 ccw(c7326.41,4061.37) 7335.8,4070.76 ccw(c7345.19,4080.15) v1@7345.19,4066.87 ; v1(7345.19,4061.37) 7314.52,4092.04 7314.52,4194.73 7369.84,4250.04 v1(7415.19,4250.04) ; v1@7408.47,4243.32 ccw(c7392.26,4227.11) 7392.26,4250.04 ccw(c7392.26,4272.98) v1@7408.47,4256.76 ; v1@7411.3,4246.15 ccw(c7401.91,4236.76) 7401.91,4250.04 ccw(c7401.91,4263.32) v1@7411.3,4253.93
  MidLayer2 w4: v3@5666.24,4103.79 cw(c5667.82,4085.75) 5679.46,4099.62 ; v3@5673.06,4111.91 ccw(c5691.1,4113.49) 5679.46,4099.62 ; v1(6993.52,2678.37) 7048.52,2733.37 7048.52,2833.91 7083.69,2869.07 7083.69,2975.11 7090.52,2981.94 7090.52,3103.36 7148.52,3161.36 7148.52,3520.37 7186.52,3558.37 7236.52,3558.37 7265.19,3587.04 7265.19,3866.71 7232.86,3899.04 7165.19,3899.04 7156.86,3907.37 7144.23,3920 ; v1@6993.52,2683.87 ccw(c6993.52,2697.15) 7002.91,2687.76 ccw(c7012.3,2678.37) v1@6999.02,2678.37 ; v1@6993.52,2687.87 ccw(c6993.52,2710.81) 7009.74,2694.59 ccw(c7025.96,2678.37) v1@7003.02,2678.37 ; v1@7335.69,4061.37 cw(c7312.76,4061.37) 7328.97,4045.16 cw(c7345.19,4028.94) v1@7345.19,4051.87 ; v1@7339.69,4061.37 cw(c7326.41,4061.37) 7335.8,4051.99 cw(c7345.19,4042.6) v1@7345.19,4055.87 ; v1(7345.19,4061.37) 7239.82,3956 7180.23,3956 7144.23,3920 ; v1(7415.19,4250.04) 7448.86,4283.71 7530.02,4283.71 7633.02,4386.71 7712.34,4386.71 v5(7731.89,4406.26) ; v1@7415.19,4255.54 ccw(c7415.19,4268.82) 7424.58,4259.43 ccw(c7433.97,4250.04) v1@7420.69,4250.04 ; v1@7415.19,4259.54 ccw(c7415.19,4282.48) 7431.41,4266.26 ccw(c7447.63,4250.04) v1@7424.69,4250.04 ; v5@7720.89,4406.26 cw(c7694.33,4406.26) 7713.11,4387.48 cw(c7731.89,4368.7) v5@7731.89,4395.26 ; v5@7724.89,4406.26 cw(c7707.99,4406.26) 7719.94,4394.31 cw(c7731.89,4382.36) v5@7731.89,4399.26 ; 5679.46,4099.62 ccw(c5708.97,4129.13) 5708.97,4087.4 5728.47,4087.4 5802.59,4087.4 5822.01,4087.4 5975,4087.4 5980,4092.4 5980,4134.25 6021.25,4175.5 6095.25,4175.5 6104.75,4185 6145.88,4185 6173,4157.87 6385.81,4157.87 6401.98,4141.71 6486.86,4141.71 6490.15,4145 6508.69,4145 6525,4128.69 6525,4095.26 6562.26,4058 6701.69,4058 6735.39,4091.71 6823.52,4091.71 6851.82,4120 6940,4120 6950,4110 6950,4095 6950,4018.69 7048.69,3920 7144.23,3920
  Bottom Layer w4: v1@6383.5,2633.46 ccw(c6367.6,2649.5) 6390.19,2649.5 ccw(c6412.78,2649.5) v1@6396.88,2633.46 ; v1@6386.32,2630.61 ccw(c6377.11,2639.9) 6390.19,2639.9 ccw(c6403.27,2639.9) v1@6394.06,2630.61 ; v1(6390.19,2626.71) 6390.19,2649.5 6429.19,2688.5 6460.56,2688.5 6486.27,2714.21 6664.95,2714.21 6673.78,2723.04 6712.71,2723.04 6726.54,2709.21 6866.28,2709.21 6880.77,2709.21 6911.61,2678.37 v1(6993.52,2678.37) ; v1@6986.81,2671.66 ccw(c6970.59,2655.44) 6970.59,2678.37 ccw(c6970.59,2701.31) v1@6986.81,2685.09 ; v1@6989.64,2674.49 ccw(c6980.25,2665.1) 6980.25,2678.37 ccw(c6980.25,2691.65) v1@6989.64,2682.26
DB_MEM.BUS_D14: U7.F6 U8.P27 U12.51 U16.37 U61.57 | length 6727.7
  Top Layer w4: U8.P27@5882.13,4217.03 ccw(c5882.13,4234.75) 5894.66,4222.22 ; U8.P27@5889.47,4209.68 cw(c5907.19,4209.68) 5894.66,4222.22 ; v1@6080.5,4195 cw(c6057.56,4195) 6073.78,4178.78 cw(c6090,4162.56) v1@6090,4185.5 ; v1@6084.5,4195 cw(c6071.22,4195) 6080.61,4185.61 cw(c6090,4176.22) v1@6090,4189.5 ; v1(6090,4195) 6070.5,4175.5 ; U61.57@6351.93,2646.31 6406.86,2646.31 6423,2630.16 ; U61.57@6367.95,2643.48 cw(c6374.78,2636.65) 6374.78,2646.31 cw(c6374.78,2655.96) U61.57@6367.95,2649.13 ; v1@6416.25,2616.56 ccw(c6405.93,2630.16) 6423,2630.16 ; v1@6418.67,2613.38 ccw(c6412.05,2622.1) 6423,2622.1 ; v1(6422,2609) 6423,2610 6423,2630.16 ; 6423,2629.52 ccw(c6442.52,2629.52) v1@6428.72,2615.72 ; v1(7248.52,4065.37) 7263.11,4079.96 ; U12.51@7269.89,4076.01 ccw(c7263.11,4072.16) 7263.11,4079.96 ; U12.51@7269.89,4083.91 cw(c7263.11,4087.76) 7263.11,4079.96 ; U16.37@7294.41,4750.24 U16.37@7311.96,4750.24 ; U16.37@7311.97,4746.24 cw(c7311.97,4709.15) 7338.19,4735.37 ; U16.37@7311.97,4754.24 cw(c7311.97,4736.47) 7324.53,4749.03 ; U12.51@7317.63,4074.3 cw(c7331.28,4060.65) 7331.28,4079.96 cw(c7331.28,4099.27) U12.51@7317.63,4085.62 ; 7331.36,4742.2 ccw(c7311.97,4722.81) U16.37@7311.97,4750.24 ; v1@7370.02,4147.37 cw(c7347.09,4147.37) 7363.31,4131.16 cw(c7379.52,4114.94) v1@7379.52,4137.87 ; v1@7374.02,4147.37 cw(c7360.75,4147.37) 7370.14,4137.99 cw(c7379.52,4128.6) v1@7379.52,4141.87 ; v1(7379.52,4147.37) 7345.52,4113.37 7345.52,4091.63 7333.86,4079.96 U12.51@7294.41,4079.96 7263.11,4079.96 ; v1(7431.86,4192.04) 7462.19,4222.37 7462.19,4502.19 7423.52,4540.86 7423.52,4560 7462.19,4598.67 7462.19,4775.06 7437.21,4800.04 7381.86,4800.04 7365.19,4783.37 7365.19,4750.04 7348.52,4733.37 7340.19,4733.37 7315.19,4758.37 7311.96,4758.37 U16.37@7311.96,4750.24 ; v1@7431.86,4197.54 ccw(c7431.86,4210.82) 7441.25,4201.43 ccw(c7450.64,4192.04) v1@7437.36,4192.04 ; v1@7431.86,4201.54 ccw(c7431.86,4224.48) 7448.07,4208.26 ccw(c7464.29,4192.04) v1@7441.36,4192.04 ; 5894.66,4222.22 cw(c5901.84,4215.04) 5901.84,4225.19 5952.43,4225.19 6002.12,4175.5 6060,4175.5 ; 6060,4175.5 6070.5,4175.5 ; 6060,4175.5 6070.5,4175.5
  Top Layer w8: v5(7771.26,4406.26) U7.F6@7790.95,4425.94 ; v5@7771.26,4415.26 ccw(c7771.26,4436.99) 7786.62,4421.62 ccw(c7801.99,4406.26) v5@7780.26,4406.26
  MidLayer1 w4: v1(6998.52,2766.71) 7028.17,2796.35 ; v1@6998.52,2772.21 ccw(c6998.52,2785.49) 7007.91,2776.1 ccw(c7017.3,2766.71) v1@7004.02,2766.71 ; v1@6998.52,2776.21 ccw(c6998.52,2799.14) 7014.74,2782.93 ccw(c7030.96,2766.71) v1@7008.02,2766.71 ; v1(7248.52,4065.37) 7248.52,3939.37 7231.86,3922.71 7231.86,3900.04 7273.52,3858.37 7282.19,3849.71 7282.19,3098 7273.63,3089.44 7253.69,3069.5 7253.69,3047.25 7253.69,3040 7253.69,3025 7253.69,3001.48 7253.69,2908.8 7248.52,2903.63 7241.42,2896.52 7161.08,2816.19 7145.62,2816.19 7143.94,2817.87 7120,2817.87 ; 7028.17,2796.35 7049.69,2817.87 ; 7028.17,2796.35 7049.69,2817.87 ; 7049.69,2817.87 7100,2817.87 ; 7100,2817.87 7120,2817.87 ; 7100,2817.87 7120,2817.87
  MidLayer2 w4: v1(7431.86,4192.04) 7682.19,4192.04 7752.19,4262.04 7752.19,4387.19 v5(7771.26,4406.26) ; v1@7435.75,4188.15 cw(c7445.14,4178.76) 7445.14,4192.04 cw(c7445.14,4205.32) v1@7435.75,4195.93 ; v1@7438.57,4185.32 cw(c7454.79,4169.11) 7454.79,4192.04 cw(c7454.79,4214.98) v1@7438.57,4198.76 ; v5@7760.26,4406.26 cw(c7733.7,4406.26) 7752.48,4387.48 cw(c7771.26,4368.7) v5@7771.26,4395.26 ; v5@7764.26,4406.26 cw(c7747.36,4406.26) 7759.31,4394.31 cw(c7771.26,4382.36) v5@7771.26,4399.26
  Bottom Layer w4: v1(6090,4195) 6126.71,4195 6130,4191.71 6135.14,4191.71 ; v1@6093.89,4191.11 cw(c6103.28,4181.72) 6103.28,4195 cw(c6103.28,4208.28) v1@6093.89,4198.89 ; v1@6096.72,4188.28 cw(c6112.93,4172.06) 6112.93,4195 cw(c6112.93,4217.93) v1@6096.72,4201.72 ; v1@6422,2614.5 ccw(c6422,2627.78) 6431.39,2618.39 ccw(c6440.78,2609) v1@6427.5,2609 ; v1@6422,2618.5 ccw(c6422,2641.43) 6438.22,2625.22 ccw(c6454.43,2609) v1@6431.5,2609 ; v1@6424,2600 6424,2609 6424,2611 6448.37,2635.37 6481.86,2635.37 6492.19,2625.04 6660,2625.04 ; v1@6998.52,2757.21 cw(c6998.52,2734.27) 7014.74,2750.49 cw(c7030.96,2766.71) v1@7008.02,2766.71 ; v1@6998.52,2761.21 cw(c6998.52,2747.93) 7007.91,2757.32 cw(c7017.3,2766.71) v1@7004.02,2766.71 ; v1(6998.52,2766.71) 7015.19,2750.04 7015.19,2675.04 6999.02,2658.87 ; v1@7370.02,4147.37 ccw(c7347.09,4147.37) 7363.31,4163.59 ccw(c7379.52,4179.81) 7379.52,4156.87 ccw(c7379.52,4179.81) 7395.74,4163.59 ccw(c7411.96,4147.37) v1@7389.02,4147.37 ; v1@7374.02,4147.37 ccw(c7360.75,4147.37) 7370.13,4156.76 ccw(c7379.52,4166.15) 7379.52,4152.87 ccw(c7379.52,4166.15) 7388.91,4156.76 ccw(c7398.3,4147.37) v1@7385.02,4147.37 ; 7402.55,4170.4 cw(c7431.86,4141.1) v1@7431.86,4182.54 ; 7409.38,4177.23 cw(c7431.86,4154.75) v1@7431.86,4186.54 ; 7416.21,4184.06 cw(c7431.86,4168.41) v1@7431.86,4190.54 ; v1(7431.86,4192.04) 7424.19,4192.04 v1(7379.52,4147.37) 7351.86,4175.04 7348.9,4178 7029.46,4178 6993.5,4142.04 6854.82,4142.04 6854.32,4141.55 6842.72,4141.55 6842.23,4142.04 6732.86,4142.04 6696.9,4178 6509.82,4178 6481.03,4149.21 6427.1,4149.21 6416.81,4159.5 6260.71,4159.5 6259.09,4157.87 6205.81,4157.87 6180.75,4182.94 ; 6135.14,4191.71 6140,4191.71 ; 6135.14,4191.71 6140,4191.71 ; 6140,4191.71 6156.86,4191.71 ; 6140,4191.71 6156.86,4191.71 ; 6140,4191.71 6156.86,4191.71 ; 6156.86,4191.71 6171.98,4191.71 6173.69,4190 ; 6173.69,4190 6180.75,4182.94 ; 6173.69,4190 6180.75,4182.94 ; 6660,2625.04 6672.52,2625.04 ; 6660,2625.04 6672.52,2625.04 ; 6672.52,2625.04 6680.19,2632.71 ; 6672.52,2625.04 6680.19,2632.71 ; 6672.52,2625.04 6680.19,2632.71 ; 6680.19,2632.71 6681.21,2633.72 ; 6680.19,2632.71 6681.21,2633.72 ; 6680.19,2632.71 6681.21,2633.72 ; 6681.21,2633.72 6682.98,2635.5 ; 6681.21,2633.72 6682.98,2635.5 ; 6682.98,2635.5 6809.44,2635.5 6837.31,2663.37 6845.44,2671.5 6866.56,2671.5 ; 6866.56,2671.5 6874.69,2663.37 ; 6866.56,2671.5 6874.69,2663.37 ; 6874.69,2663.37 6879.19,2658.87 6969.43,2658.87 ; 6969.43,2658.87 6999.02,2658.87 ; 6969.43,2658.87 6999.02,2658.87
DB_MEM.BUS_D15: U7.G7 U8.P26 U12.53 U16.38 U61.58 | length 6652.3
  Top Layer w4: U8.P26@5842.76,4217.03 ccw(c5842.76,4234.75) 5855.29,4222.22 ; U8.P26@5850.1,4209.68 cw(c5867.82,4209.68) 5855.29,4222.22 ; 6031.89,4194.32 cw(c6031.89,4166.89) v1@6051.28,4186.28 ; 6038.24,4194.32 ccw(c6038.24,4212.76) v1@6051.28,4199.72 ; 6041.55,4194.32 cw(c6041.55,4176.55) v1@6054.11,4189.11 ; v1(6058,4193) 6056.68,4194.32 5994.62,4194.32 5955.39,4233.55 5949.18,4233.55 5941.18,4233.55 5882.64,4233.55 ccw(c5882.64,4194.87) 5855.29,4222.22 ; v1(6190.19,2516.71) 6215,2541.52 6215,2560 6320.99,2665.99 U61.58@6351.93,2665.99 ; v1@6190.19,2522.21 ccw(c6190.19,2535.49) 6199.58,2526.1 ccw(c6208.97,2516.71) v1@6195.69,2516.71 ; v1@6190.19,2526.21 ccw(c6190.19,2549.14) 6206.41,2532.93 ccw(c6222.63,2516.71) v1@6199.69,2516.71 ; U61.58@6335.91,2663.16 ccw(c6329.08,2656.33) 6329.08,2665.99 ccw(c6329.08,2675.65) U61.58@6335.91,2668.82 ; v1(7246.52,4125.04) 7264.44,4142.95 ; v1@7246.52,4130.54 ccw(c7246.52,4143.82) 7255.91,4134.43 ccw(c7265.3,4125.04) v1@7252.02,4125.04 ; v1@7246.52,4134.54 ccw(c7246.52,4157.48) 7262.74,4141.26 ccw(c7278.96,4125.04) v1@7256.02,4125.04 ; U12.53@7269.57,4139.65 ccw(c7264.44,4137.32) 7264.44,4142.95 ; U12.53@7269.57,4146.26 cw(c7264.44,4148.59) 7264.44,4142.95 ; U16.38@7294.41,4781.73 7332.19,4781.73 7340.19,4773.73 v1(7340.19,4758.37) ; U12.53@7314.35,4146.17 ccw(c7318.06,4151.16) 7322.45,4146.76 ; U16.38@7317.63,4776.08 cw(c7331.28,4762.42) 7331.28,4781.73 cw(c7331.28,4801.05) U16.38@7317.63,4787.39 ; v1(7338.19,4150.04) 7325.74,4150.04 ; 7264.44,4142.95 U12.53@7294.41,4142.95 ; U12.53@7294.41,4142.95 U12.53@7318.65,4142.95 ; U12.53@7294.41,4142.95 U12.53@7318.65,4142.95 ; U12.53@7318.65,4142.95 7322.19,4146.5 ; 7322.19,4146.5 7325.74,4150.04 ; 7322.19,4146.5 7325.74,4150.04 ; 7322.96,4147.26 cw(c7331.1,4139.11) 7337.37,4148.78 ccw(c7331.1,4139.11) 7322.95,4147.26 ; 7326.45,4150.76 cw(c7333.85,4143.36) 7339.55,4152.14 ccw(c7333.85,4143.35) 7326.45,4150.76
  Top Layer w8: v5(7731.89,4366.89) U7.G7@7751.57,4386.57 ; v5@7731.89,4375.89 ccw(c7731.89,4397.62) 7747.25,4382.25 ccw(c7762.62,4366.89) v5@7740.89,4366.89
  MidLayer1 w4: v1@6548.14,2460.09 ccw(c6531.92,2476.31) 6554.86,2476.31 ccw(c6577.79,2476.31) v1@6561.57,2460.09 ; v1@6550.97,2457.26 ccw(c6541.58,2466.65) 6554.86,2466.65 ccw(c6568.14,2466.65) v1@6558.75,2457.26 ; v1(6554.86,2453.37) 6554.86,2478.39 6790.19,2713.73 6790.19,2799.68 7265.52,3275.02 7265.52,3843.75 7215.03,3894.24 7215.03,3965.8 7231.69,3982.46 7231.69,4008.54 7223.02,4017.21 7223.02,4101.54 v1(7246.52,4125.04) 7246.52,4293.73 7281.86,4329.06 7281.86,4746.86 7293.37,4758.37 v1(7340.19,4758.37) ; v1@7237.02,4125.04 cw(c7214.09,4125.04) 7230.31,4108.82 cw(c7246.52,4092.61) v1@7246.52,4115.54 ; v1@7239.81,4131.76 ccw(c7223.59,4147.98) 7246.52,4147.98 ccw(c7269.46,4147.98) v1@7253.24,4131.76 ; v1@7241.02,4125.04 cw(c7227.75,4125.04) 7237.14,4115.65 cw(c7246.52,4106.26) v1@7246.52,4119.54 ; v1@7242.64,4128.93 ccw(c7233.25,4138.32) 7246.52,4138.32 ccw(c7259.8,4138.32) v1@7250.41,4128.93 ; v1@7333.47,4751.66 ccw(c7317.26,4735.44) 7317.26,4758.37 ccw(c7317.26,4781.31) v1@7333.47,4765.09 ; v1@7336.3,4754.49 ccw(c7326.91,4745.1) 7326.91,4758.37 ccw(c7326.91,4771.65) v1@7336.3,4762.26
  MidLayer2 w4: v1(7338.19,4150.04) 7340.04,4150.04 7440.04,4250.04 7687.86,4250.04 7712.78,4274.97 7712.78,4347.78 7713.04,4347.78 7722.38,4357.12 7722.38,4357.37 v5(7731.89,4366.89) ; v1@7338.19,4155.54 ccw(c7338.19,4173.29) 7350.74,4160.74 ; v1@7338.19,4159.54 ccw(c7338.19,4186.94) 7357.57,4167.57 ; v1@7347.69,4150.04 cw(c7366.16,4150.04) 7353.1,4163.1 ; 7713.17,4347.91 ccw(c7694.53,4366.55) v5@7720.89,4366.79 ; 7713.55,4348.29 cw(c7731.89,4329.96) v5@7731.89,4355.89 ; 7719.91,4354.65 ccw(c7707.9,4366.67) v5@7724.89,4366.83 ; 7720.38,4355.12 cw(c7731.89,4343.62) v5@7731.89,4359.89
  Bottom Layer w4: v1(6058,4193) 6073.5,4177.5 6105,4177.5 6109.5,4182 6136.75,4182 ; 6155.25,4182 6136.75,4182 ; v1@6183.47,2509.99 cw(c6167.26,2493.77) 6190.19,2493.77 cw(c6213.13,2493.77) v1@6196.91,2509.99 ; v1@6186.3,2512.82 cw(c6176.91,2503.43) 6190.19,2503.43 cw(c6203.47,2503.43) v1@6194.08,2512.82 ; v1(6190.19,2516.71) 6190.19,2479.81 6195.29,2474.71 6240,2474.71 ; v1@6548.14,2460.09 ccw(c6531.92,2476.31) 6554.86,2476.31 ccw(c6577.79,2476.31) v1@6561.57,2460.09 ; v1@6550.97,2457.26 ccw(c6541.58,2466.65) 6554.86,2466.65 ccw(c6568.14,2466.65) v1@6558.75,2457.26 ; v1(6554.86,2453.37) 6554.86,2485.14 6548.96,2491.04 6517.19,2491.04 ; 6710.67,4134.04 6838.92,4134.04 6839.41,4133.55 6857.64,4133.55 6858.13,4134.04 7145.96,4134.04 7154.96,4125.04 7225,4125.04 ; 6710.67,4134.71 6655,4134.71 6628.72,4160.99 ; v1@7239.51,4118.64 ccw(c7225,4105.41) 7225,4125.04 ; v1@7239.51,4131.44 cw(c7225,4144.67) 7225,4125.04 ; v1@7242.46,4121.33 ccw(c7234.06,4113.68) 7234.06,4125.04 ccw(c7234.06,4136.41) v1@7242.46,4128.75 ; v1(7246.52,4125.04) 7225,4125.04 ; 6136.75,4182 6170.37,4182 6202.5,4149.87 6262.4,4149.87 6264.03,4151.5 6413.5,4151.5 6423.79,4141.21 6484.34,4141.21 6513.13,4170 6619.71,4170 6622,4167.71 ; 6240,2474.71 6253.31,2474.71 ; 6240,2474.71 6253.31,2474.71 ; 6253.31,2474.71 6267.52,2460.5 6282.1,2460.5 ; 6282.1,2460.5 6310,2460.5 ; 6282.1,2460.5 6310,2460.5 ; 6310,2460.5 6431,2460.5 ; 6431,2460.5 6445.92,2475.42 ; 6431,2460.5 6445.92,2475.42 ; 6445.92,2475.42 6461.54,2491.04 ; 6445.92,2475.42 6461.54,2491.04 ; 6445.92,2475.42 6461.54,2491.04 ; 6461.54,2491.04 6485.5,2491.04 ; 6485.5,2491.04 6510,2491.04 ; 6485.5,2491.04 6510,2491.04 ; 6510,2491.04 6517.19,2491.04 ; 6510,2491.04 6517.19,2491.04 ; 6510,2491.04 6517.19,2491.04 ; 6622,4167.71 6628.72,4160.99 ; 6622,4167.71 6628.72,4160.99
DB_MEM.BUS_D16: U8.R28 U13.2 U17.7 U61.60 | length 3577.9
  Top Layer w4: U8.R28@5921.5,4170.31 5984.68,4170.32 5995.5,4159.5 6073.1,4159.5 v1(6104.6,4128) ; U8.R28@5926.69,4165.12 cw(c5939.22,4152.59) 5939.22,4170.32 cw(c5939.22,4188.04) U8.R28@5926.69,4175.51 ; v1@6095.1,4128 ccw(c6072.17,4128) 6088.38,4144.22 ccw(c6104.6,4160.43) v1@6104.6,4137.5 ; v1@6099.1,4128 ccw(c6085.82,4128) 6095.21,4137.39 ccw(c6104.6,4146.78) v1@6104.6,4133.5 ; v1@6104.9,4128 6109.27,4132.37 6135,4132.37 6145.58,4142.95 U13.2@6170.59,4142.95 ; v1@6105.73,4127.02 cw(c6117.47,4116.84) 6117.47,4132.37 ; v1@6108.76,4124.4 cw(c6126.23,4109.24) 6126.23,4132.37 ; v1@6111.32,4134.72 ccw(c6116.97,4140.37) 6116.97,4132.37 ; v1@6111.78,4121.78 cw(c6135,4101.64) 6135,4132.37 ; 6136.71,4134.08 cw(c6149.26,4121.53) U13.2@6152.34,4139.01 ; 6142.14,4139.52 cw(c6150.89,4130.77) U13.2@6153.03,4142.95 ; U17.7@6188.98,4785.64 ccw(c6191.55,4797.73) 6200.29,4788.99 ; U17.7@6189.81,4789.56 ccw(c6193.38,4806.32) 6205.49,4794.2 ; U17.7@6193.02,4781.73 6205.5,4794.2 ; U17.7@6196.15,4781.73 cw(c6203.7,4781.73) 6198.36,4787.07 ; U61.60@6351.93,2705.36 6387.36,2705.36 v1(6398,2716) ; U61.60@6367.95,2702.53 cw(c6374.78,2695.7) 6374.78,2705.36 cw(c6374.78,2715.02) U61.60@6367.95,2708.19 ; v1@6383.28,4086.72 ccw(c6367.06,4102.93) 6390,4102.93 ccw(c6412.93,4102.93) v1@6396.72,4086.72 ; v1@6386.11,4083.89 ccw(c6376.72,4093.28) 6390,4093.28 ccw(c6403.28,4093.28) v1@6393.89,4083.89 ; v1(6390,4080) 6390,4186.62 6370.5,4206.12 6370.5,4233.88 6419.5,4282.88 6419.5,4355.5 6392.5,4382.5 6392.5,4431.99 6398.36,4437.86 6398.36,4609 6368.19,4639.17 6368.19,4748.12 6322.11,4794.2 6205.5,4794.2
  MidLayer1 w4: v1@6390,4070.5 cw(c6390,4059.08) 6398.08,4067.15 ; v1(6390,4080) 6390,4075.23 6498.36,3966.87 6498.36,3674.88 6490.19,3666.71 6490.19,3375.37 6452.22,3337.4 6415.69,3300.87 6415.69,3091.11 6422.86,3083.94 6422.86,2995.37 6455,2963.23 6455,2813.09 6415.19,2773.28 6415.19,2733.19 v1(6398,2716) ; v1@6391.5,4080 ccw(c6406.63,4080) 6395.93,4069.3 ; v1@6395.5,4080 ccw(c6420.29,4080) 6402.76,4062.47 ; v1@6398,2721.5 ccw(c6398,2734.78) 6407.39,2725.39 ccw(c6416.78,2716) v1@6403.5,2716 ; v1@6398,2725.5 ccw(c6398,2748.43) 6414.22,2732.22 ccw(c6430.43,2716) v1@6407.5,2716 ; v1@6399.5,4080 ccw(c6433.95,4080) 6409.59,4055.64
  MidLayer2 w4: v1@6105.1,4128.4 6109.07,4132.37 6152.63,4132.37 6181.29,4103.71 6218.92,4103.71 6231.12,4091.5 6294.31,4091.5 6306.62,4103.81 6361.42,4103.81 6366.19,4099.04 6381.86,4083.37 6385.23,4080 v1(6390,4080) ; v1@6105.66,4126.94 cw(c6118.78,4113.82) 6118.78,4132.37 ; v1@6108.49,4124.11 cw(c6128.44,4104.16) 6128.44,4132.37 ; v1@6111.32,4121.28 cw(c6138.1,4094.5) 6138.1,4132.37 ; v1@6111.32,4134.72 ccw(c6116.97,4140.37) 6116.97,4132.37 ; 6368.58,4096.66 ccw(c6386.32,4114.41) v1@6388.99,4089.45 ; 6374.49,4090.74 ccw(c6387.47,4103.71) v1@6389.42,4085.47 ; 6377.15,4088.08 cw(c6369.08,4080) v1@6380.5,4080
DB_MEM.BUS_D17: U8.T26 U13.4 U17.8 U61.61 | length 4923.5
  Top Layer w4: U8.T26@5842.76,4123.6 cw(c5842.76,4105.88) 5855.29,4118.41 ; U8.T26@5850.1,4130.94 ccw(c5867.82,4130.94) 5855.29,4118.41 ; 6084.32,4101.97 ccw(c6084.32,4147.91) v1@6116.81,4115.43 ; 6093.98,4101.97 ccw(c6093.98,4138.25) v1@6119.64,4112.6 ; 6103.64,4101.97 ccw(c6103.64,4128.6) v1@6122.46,4109.77 ; 6113.29,4101.97 ccw(c6113.29,4118.94) v1@6125.29,4106.94 ; v1@6117.62,4101.27 cw(c6107.92,4089.04) 6123.52,4089.04 ; v1@6129.43,4101.27 ccw(c6139.13,4089.04) 6123.52,4089.04 ; U13.4@6147.37,4074.3 ccw(c6133.72,4060.65) 6133.72,4079.96 ccw(c6133.72,4099.27) U13.4@6147.37,4085.62 ; U13.4@6170.59,4079.96 6132.6,4079.96 6123.52,4089.04 ; U17.8@6170.59,4750.24 6199.72,4750.24 ; U17.8@6187.19,4746.35 ccw(c6190.23,4758.62) 6199.17,4749.68 ; U17.8@6188.15,4750.24 ccw(c6192.22,4766.65) 6204.17,4754.69 ; U17.8@6189.11,4754.12 ccw(c6194.21,4774.67) 6209.18,4759.7 ; U17.8@6195.63,4747.41 cw(c6199.72,4745.87) 6199.72,4750.24 ; U17.8@6195.63,4753.06 ccw(c6199.72,4754.6) 6199.72,4750.24 ; 6204.89,4755.4 ccw(c6196.85,4763.44) v1@6206.29,4769.76 ; 6208.33,4758.85 ccw(c6200.98,4766.2) v1@6209.62,4771.98 ; 6211.77,4762.29 ccw(c6205.1,4768.96) v1@6212.94,4774.21 ; v1@6240,4120.5 cw(c6240,4097.56) 6256.22,4113.78 cw(c6272.43,4130) 6249.5,4130 cw(c6272.43,4130) 6256.22,4146.22 cw(c6240,4162.43) v1@6240,4139.5 ; v1@6240,4124.5 cw(c6240,4111.22) 6249.39,4120.61 cw(c6258.78,4130) 6245.5,4130 cw(c6258.78,4130) 6249.39,4139.39 cw(c6240,4148.78) v1@6240,4135.5 ; v1@6273.28,3939.72 ccw(c6257.06,3955.93) 6280,3955.93 ccw(c6302.93,3955.93) v1@6286.72,3939.72 ; v1@6276.11,3936.89 ccw(c6266.72,3946.28) 6280,3946.28 ccw(c6293.28,3946.28) v1@6283.89,3936.89 ; v1@6279.36,3933.64 v1(6280,3933) 6280,3956.07 6279.36,3956.71 6279.36,3970 6279.36,4048.79 6281.69,4051.13 6281.69,4065.62 6279.19,4068.12 6279.19,4090.81 v1(6240,4130) 6268.37,4158.37 6290.19,4158.37 6306.5,4174.68 6306.5,4180 ; 6306.5,4177.4 6306.5,4180 ; 6308.44,4334.96 ccw(c6291.4,4352) v1@6315.5,4352 ; 6309.61,4336.12 cw(c6325,4320.73) v1@6325,4342.5 ; 6315.27,4341.79 ccw(c6305.06,4352) v1@6319.5,4352 ; 6316.43,4342.95 cw(c6325,4334.39) v1@6325,4346.5 ; v1(6325,4352) 6325,4351.52 6288,4314.52 6288,4266.21 6306.5,4247.71 6306.5,4180 ; U61.61@6351.93,2725.05 6373.53,2725.05 ; v1@6366.5,4600 ccw(c6343.56,4600) 6359.78,4616.22 ccw(c6376,4632.43) v1@6376,4609.5 ; U61.61@6368.23,2722.52 cw(c6373.53,2718.22) 6373.53,2725.05 ; U61.61@6368.23,2727.57 ccw(c6373.53,2731.87) 6373.53,2725.05 ; v1@6370.5,4600 ccw(c6357.22,4600) 6366.61,4609.39 ccw(c6376,4618.78) v1@6376,4605.5 ; v1(6376,4600) 6357.69,4618.31 6357.69,4665.62 6349.02,4674.3 6349.02,4742.63 6337,4754.65 6337,4755 6306.63,4785.37 6224.52,4785.37 v1(6214.19,4775.04) 6214.19,4764.71 6199.72,4750.24 ; v1(6665.19,2925.04) 6581.86,2841.71 6498.52,2841.71 6406.86,2750.04 6398.52,2750.04 6373.53,2725.05 ; 5855.29,4118.41 ccw(c5882.64,4145.76) 5882.64,4107.08 5941.18,4107.08 5949.18,4107.08 5968.98,4107.08 5984.52,4091.54 6008,4091.54 6025.19,4091.54 6043.6,4091.54 6046.95,4088.19 6061.38,4088.19 6075.16,4101.97 6116.79,4101.97 v1(6123.52,4108.71) 6123.52,4089.04
  MidLayer1 w4: v1(6123.52,4108.71) 6144.82,4130 v1(6240,4130) ; v1@6123.52,4114.21 ccw(c6123.52,4127.49) 6132.91,4118.1 ccw(c6142.3,4108.71) v1@6129.02,4108.71 ; v1@6123.52,4118.21 ccw(c6123.52,4141.14) 6139.74,4124.93 ccw(c6155.96,4108.71) v1@6133.02,4108.71 ; v1@6233.28,4123.28 ccw(c6217.06,4107.06) 6217.06,4130 ccw(c6217.06,4152.93) v1@6233.28,4136.72 ; v1@6236.11,4126.11 ccw(c6226.72,4116.72) 6226.72,4130 ccw(c6226.72,4143.28) v1@6236.11,4133.89 ; v1(6665.19,2925.04) 6698.52,2958.37 6698.52,3286.35 6639.7,3345.18 6639.7,3696.21 v1(6801.86,3858.37) ; v1@6665.19,2930.54 ccw(c6665.19,2943.82) 6674.58,2934.43 ccw(c6683.97,2925.04) v1@6670.69,2925.04 ; v1@6665.19,2934.54 ccw(c6665.19,2957.48) 6681.41,2941.26 ccw(c6697.63,2925.04) v1@6674.69,2925.04 ; v1@6792.36,3858.37 cw(c6769.42,3858.37) 6785.64,3842.16 cw(c6801.86,3825.94) v1@6801.86,3848.87 ; v1@6796.36,3858.37 cw(c6783.08,3858.37) 6792.47,3848.99 cw(c6801.86,3839.6) v1@6801.86,3852.87
  Bottom Layer w4: v1@6273.28,3926.28 ccw(c6257.06,3910.06) 6257.06,3933 ccw(c6257.06,3955.93) v1@6273.28,3939.72 ; v1@6276.11,3929.11 ccw(c6266.72,3919.72) 6266.72,3933 ccw(c6266.72,3946.28) v1@6276.11,3936.89 ; v1(6280,3933) 6224.07,3933 6197.69,3906.62 6197.69,3891.44 6225.51,3863.62 6225.51,3860 6243.97,3841.54 6277.88,3841.54 6322.53,3886.19 6358.3,3886.19 6422.82,3950.71 6564.52,3950.71 6606.86,3908.37 6751.86,3908.37 v1(6801.86,3858.37) ; v1(6325,4352) 6376.02,4403.02 v1(6376,4600) ; v1@6325,4357.5 ccw(c6325,4370.78) 6334.39,4361.39 ccw(c6343.78,4352) v1@6330.5,4352 ; v1@6325,4361.5 ccw(c6325,4384.43) 6341.22,4368.22 ccw(c6357.43,4352) v1@6334.5,4352 ; v1@6369.28,4593.28 cw(c6353.01,4577.01) 6376.02,4577.01 ; v1@6372.11,4596.11 cw(c6362.66,4586.66) 6376.02,4586.66 ; 6376.02,4577.12 cw(c6398.88,4577.12) v1@6382.72,4593.28 ; 6376.02,4586.78 cw(c6389.22,4586.78) v1@6379.89,4596.11 ; v1@6792.36,3858.37 ccw(c6769.42,3858.37) 6785.64,3874.59 ccw(c6801.86,3890.81) v1@6801.86,3867.87 ; v1@6796.36,3858.37 ccw(c6783.08,3858.37) 6792.47,3867.76 ccw(c6801.86,3877.15) v1@6801.86,3863.87
DB_MEM.BUS_D18: U8.U26 U13.5 U17.9 U61.62 | length 3326.7
  Top Layer w4: U8.U26@5842.76,4084.23 cw(c5842.76,4066.51) 5855.29,4079.04 ; U8.U26@5850.1,4091.57 ccw(c5867.82,4091.57) 5855.29,4079.04 ; U13.5@6147.37,4042.81 ccw(c6133.72,4029.15) 6133.72,4048.46 ccw(c6133.72,4067.78) U13.5@6147.37,4054.12 ; U17.9@6170.59,4718.74 6313.16,4718.74 6340.19,4691.71 v1(6340.19,4658.37) ; U17.9@6193.81,4713.08 cw(c6207.46,4699.43) 6207.46,4718.74 cw(c6207.46,4738.05) U17.9@6193.81,4724.4 ; v1@6212.69,4073.87 6200.15,4061.33 6200.15,4050.46 6198.15,4048.46 U13.5@6170.59,4048.46 6083.72,4048.46 6080.39,4051.8 6019.55,4051.8 6016.25,4048.5 6001.75,4048.5 5982.71,4067.54 5941.35,4067.54 5941.18,4067.71 5882.64,4067.71 cw(c5882.64,4106.39) 5855.29,4079.04 ; v1@6309.64,4052.84 ccw(c6302.7,4063) 6315,4063 ccw(c6327.3,4063) v1@6320.36,4052.84 ; v1(6315,4045) 6315,4063 6309.81,4068.19 6301.75,4068.19 6295.19,4074.75 6295.19,4110.88 6322.5,4138.19 6322.5,4260 6325,4262.5 v1(6325,4295) ; v1@6318.28,4288.28 cw(c6302.06,4272.06) 6325,4272.06 cw(c6347.93,4272.06) v1@6331.72,4288.28 ; v1@6319.64,2734.37 6330,2744.73 ; v1@6321.11,4291.11 cw(c6311.72,4281.72) 6325,4281.72 cw(c6338.28,4281.72) v1@6328.89,4291.11 ; U61.62@6335.71,2742.12 ccw(c6330,2737.18) 6330,2744.73 ; U61.62@6335.71,2747.35 cw(c6330,2752.28) 6330,2744.73 ; U61.62@6351.93,2744.73 6330,2744.73
  MidLayer1 w4: v1@6308.28,4038.28 cw(c6291.61,4021.61) 6315.19,4021.61 ; v1@6311.11,4041.11 cw(c6301.26,4031.26) 6315.19,4031.26 ; 6315.19,4022.52 cw(c6337.48,4022.52) v1@6321.72,4038.28 ; 6315.19,4032.18 cw(c6327.82,4032.18) v1@6318.89,4041.11 ; v1@6315.19,4044.81 6315.19,4018.04 6398.52,3934.71 6398.52,3803.04 6415.69,3785.88 6415.69,3780.89 6415.69,3733.55 6440.86,3708.37 6441.69,3707.54 6441.69,3700.94 6441.69,3652.21 6440.86,3651.37 6423.52,3634.04 6423.52,3384.37 6398.86,3359.71 6398.86,3317.98 6391.69,3310.81 6391.69,3083.14 ; v1(6315.52,2734.37) 6374.86,2793.71 6374.86,2901.37 6390.19,2916.71 6390.19,2975.04 6371.19,2994.04 6371.19,3057.39 6391.83,3078.03 6391.83,3083 ; v1@6315.52,2739.87 ccw(c6315.52,2753.15) 6324.91,2743.76 ccw(c6334.3,2734.37) v1@6321.02,2734.37 ; v1@6315.52,2743.87 ccw(c6315.52,2766.81) 6331.74,2750.59 ccw(c6347.96,2734.37) v1@6325.02,2734.37
  MidLayer2 w4: v1(6213.65,4072.91) 6218.65,4072.91 6256.56,4035 6275,4035 6284.81,4044.81 v1@6315,4044.81 ; 6291.61,4044.81 ccw(c6291.61,4068.39) v1@6308.28,4051.72 ; 6292.52,4044.81 cw(c6292.52,4022.52) v1@6308.28,4038.28 ; 6301.26,4044.81 ccw(c6301.26,4058.74) v1@6311.11,4048.89 ; 6302.18,4044.81 cw(c6302.18,4032.18) v1@6311.11,4041.11
  Bottom Layer w4: v1@6318.28,4301.72 ccw(c6302.06,4317.93) 6325,4317.93 ccw(c6347.93,4317.93) v1@6331.72,4301.72 ; v1@6321.11,4298.89 ccw(c6311.72,4308.28) 6325,4308.28 ccw(c6338.28,4308.28) v1@6328.89,4298.89 ; v1@6325,4300.23 6325,4327.25 6307.5,4344.75 6307.5,4374.06 6332.86,4399.42 6332.86,4415 6332.86,4570.11 6358.5,4595.75 6358.5,4610.25 6340.19,4628.56 v1(6340.19,4658.37) ; v1@6333.47,4651.66 cw(c6317.26,4635.44) 6340.19,4635.44 cw(c6363.13,4635.44) v1@6346.91,4651.66 ; v1@6336.3,4654.49 cw(c6326.91,4645.1) 6340.19,4645.1 cw(c6353.47,4645.1) v1@6344.08,4654.49
DB_MEM.BUS_D19: U8.V27 U13.7 U17.10 U61.64 | length 3770.3
  Top Layer w4: U8.V27@5882.13,4044.86 cw(c5882.13,4027.14) 5894.66,4039.67 ; U8.V27@5889.47,4052.2 ccw(c5907.19,4052.2) 5894.66,4039.67 ; v1@6114.73,3992.85 ccw(c6101.09,4007.5) 6121.1,4007.5 ccw(c6140.7,4007.5) v1@6127.57,3992.95 ; v1@6117.45,3989.92 ccw(c6109.64,3998.31) 6121.1,3998.31 ; v1@6121.1,3985.9 6121.1,4007.5 6111.8,4016.8 6008.2,4016.8 5988.3,4036.7 5901.84,4036.7 cw(c5901.84,4046.85) 5894.66,4039.67 ; 6121.1,3998.5 ccw(c6132.57,3998.5) v1@6124.89,3989.98 ; v1(6121.2,3985.9) 6170.16,3985.9 U13.7@6170.59,3985.47 6135,3985.47 ; v1@6125.09,3982.01 cw(c6134.48,3972.62) 6134.48,3985.9 cw(c6134.48,3999.18) v1@6125.09,3989.79 ; v1@6127.92,3979.18 cw(c6144.13,3962.96) 6144.13,3985.9 cw(c6144.13,4008.83) v1@6127.92,3992.62 ; U13.7@6147.1,3980.1 ccw(c6135,3969.15) 6135,3985.47 ; U13.7@6147.1,3990.84 cw(c6135,4001.79) 6135,3985.47 ; U17.10@6170.59,4687.24 6294.66,4687.24 6315.19,4666.71 6315.19,4603 6323.81,4594.38 6323.81,4558.09 6332.86,4549.04 6332.86,4449.04 6350.52,4431.37 6357.36,4424.54 6359,4422.9 6359,4370.74 ; U17.10@6193.81,4681.59 cw(c6207.46,4667.93) 6207.46,4687.24 cw(c6207.46,4706.56) U17.10@6193.81,4692.9 ; v1(6312.86,3976.71) 6329.91,3993.76 6329.91,4023.85 6340.5,4034.44 6340.5,4055.56 6340.36,4055.71 6340.36,4191.01 6338.5,4192.87 6338.5,4220 ; v1@6312.86,3982.21 ccw(c6312.86,3995.49) 6322.25,3986.1 ccw(c6331.64,3976.71) v1@6318.36,3976.71 ; v1@6312.86,3986.21 ccw(c6312.86,4009.14) 6329.07,3992.93 ccw(c6345.29,3976.71) v1@6322.36,3976.71 ; U61.64@6351.93,2784.1 6377.52,2784.1 6384.68,2791.26 6393.92,2800.5 6399.75,2800.5 ; U61.64@6367.96,2781.27 cw(c6374.78,2774.44) 6374.78,2784.1 cw(c6374.78,2793.76) U61.64@6367.96,2786.93 ; v1@6425.14,2930.66 cw(c6408.92,2914.44) 6431.86,2914.44 cw(c6454.79,2914.44) v1@6438.57,2930.66 ; v1@6427.97,2933.49 cw(c6418.58,2924.1) 6431.86,2924.1 cw(c6445.14,2924.1) v1@6435.75,2933.49 ; v1(6431.86,2937.37) 6431.86,2811.86 6420.5,2800.5 ; 6338.5,4220 6338.5,4247.13 ; 6338.5,4220 6338.5,4247.13 ; 6338.5,4247.13 6387.5,4296.13 6387.5,4309.07 ; 6359,4370.74 6387.5,4342.24 ; 6359,4370.74 6387.5,4342.24 ; 6387.5,4309.07 6387.5,4342.24 ; 6387.5,4309.07 6387.5,4342.24 ; 6399.75,2800.5 6420.5,2800.5 ; 6399.75,2800.5 6420.5,2800.5
  MidLayer1 w4: v1@6422.36,3908.37 cw(c6399.42,3908.37) 6415.64,3892.16 cw(c6431.86,3875.94) v1@6431.86,3898.87 ; v1@6425.14,2944.09 ccw(c6408.92,2960.31) 6431.86,2960.31 ccw(c6454.79,2960.31) v1@6438.57,2944.09 ; v1@6426.36,3908.37 cw(c6413.08,3908.37) 6422.47,3898.99 cw(c6431.86,3889.6) v1@6431.86,3902.87 ; v1@6427.97,2941.26 ccw(c6418.58,2950.65) 6431.86,2950.65 ccw(c6445.14,2950.65) v1@6435.75,2941.26 ; v1(6431.86,2937.37) 6431.86,2975.06 6414.86,2992.06 ; v1(6431.86,3908.37) 6415.19,3891.71 6415.19,3865 ; 6407.69,3202.85 6407.69,3270 ; 6407.69,3202.85 6407.69,3270 ; 6407.69,3202.85 6407.69,3087.8 6414.86,3080.63 ; 6407.69,3270 6407.69,3304.19 6414.86,3311.35 6481.86,3378.36 6481.86,3669.69 6484.69,3672.52 6490.36,3678.19 6490.36,3780.36 6415.19,3855.53 ; 6414.86,2992.06 6414.86,3005 ; 6414.86,2992.06 6414.86,3005 ; 6414.86,3005 6414.86,3070 ; 6414.86,3070 6414.86,3080.63 ; 6414.86,3070 6414.86,3080.63 ; 6415.19,3855.53 6415.19,3865 ; 6415.19,3855.53 6415.19,3865
  MidLayer2 w4: v1(6121.2,3985.9) 6174.1,3985.9 6207,3953 6240.15,3953 6263.86,3976.71 v1(6312.86,3976.71) 6363.52,3976.71 6385.4,3954.83 v1(6431.86,3908.37) ; v1@6125.09,3982.01 cw(c6134.48,3972.62) 6134.48,3985.9 cw(c6134.48,3999.18) v1@6125.09,3989.79 ; v1@6127.92,3979.18 cw(c6144.13,3962.96) 6144.13,3985.9 cw(c6144.13,4008.83) v1@6127.92,3992.62 ; v1@6306.14,3969.99 ccw(c6289.92,3953.77) 6289.92,3976.71 ccw(c6289.92,3999.64) v1@6306.14,3983.43 ; v1@6308.97,3972.82 ccw(c6299.58,3963.43) 6299.58,3976.71 ccw(c6299.58,3989.99) v1@6308.97,3980.6 ; v1@6316.75,3972.82 cw(c6326.14,3963.43) 6326.14,3976.71 cw(c6326.14,3989.99) v1@6316.75,3980.6 ; v1@6319.57,3969.99 cw(c6335.79,3953.77) 6335.79,3976.71 cw(c6335.79,3999.64) v1@6319.57,3983.43 ; v1@6422.36,3908.37 ccw(c6399.42,3908.37) 6415.64,3924.59 ccw(c6431.86,3940.81) v1@6431.86,3917.87 ; v1@6426.36,3908.37 ccw(c6413.08,3908.37) 6422.47,3917.76 ccw(c6431.86,3927.15) v1@6431.86,3913.87
DB_MEM.BUS_D20: U8.W27 U13.8 U17.13 U61.65 | length 3653.5
  Top Layer w4: v1@6122.43,3945.65 ccw(c6112.75,3939.29) 6112.75,3950.87 ; v1@6122.43,3956.09 cw(c6112.75,3962.45) 6112.75,3950.87 ; v1(6130.36,3950.87) 6112.75,3950.87 ; v1@6130.36,3953.98 U13.8@6170.59,3953.98 ; v1@6131.43,3949.81 cw(c6141.49,3939.74) 6141.49,3953.98 ; v1@6134.25,3946.98 cw(c6151.15,3930.08) U13.8@6151.15,3953.98 ; v1@6137.08,3944.15 cw(c6160.8,3920.43) U13.8@6160.8,3953.98 ; v1@6137.08,3957.58 ccw(c6145.8,3966.3) U13.8@6145.8,3953.98 ; U17.13@6170.59,4592.76 6249.81,4592.76 v1(6267.52,4575.04) ; U17.13@6193.81,4587.1 cw(c6207.46,4573.44) 6207.46,4592.76 cw(c6207.46,4612.07) U17.13@6193.81,4598.41 ; v1@6258.02,4575.04 ccw(c6235.09,4575.04) 6251.31,4591.26 ccw(c6267.52,4607.48) v1@6267.52,4584.54 ; v1@6262.02,4575.04 ccw(c6248.75,4575.04) 6258.14,4584.43 ccw(c6267.52,4593.82) v1@6267.52,4580.54 ; U61.65@6298.34,2837.34 cw(c6308.9,2826.79) 6308.9,2841.71 ; U61.65@6298.35,2841.71 6325,2841.71 6329.33,2837.37 v1(6356.86,2837.37) ; U61.65@6301.17,2834.51 cw(c6318.55,2817.13) 6318.55,2841.71 ; v1@6338,4600 v1(6341,4603) 6381.36,4562.64 6390.36,4553.64 6390.36,4441.17 6384.5,4435.31 6384.5,4414.5 6384.5,4379.19 6411.5,4352.19 6411.5,4348.5 6411.5,4286.19 6362.5,4237.19 6362.5,4202.81 6364.36,4200.95 ; v1@6341,4593.5 cw(c6341,4570.56) 6357.22,4586.78 cw(c6373.43,4603) v1@6350.5,4603 ; v1@6341,4597.5 cw(c6341,4584.22) 6350.39,4593.61 cw(c6359.78,4603) v1@6346.5,4603 ; v1@6350.14,2830.66 ccw(c6333.92,2814.44) 6333.92,2837.37 ccw(c6333.92,2860.31) v1@6350.14,2844.09 ; v1@6350.14,3948.43 ccw(c6333.92,3964.64) 6356.86,3964.64 ccw(c6379.79,3964.64) v1@6363.57,3948.43 ; v1@6352.97,2833.49 ccw(c6343.58,2824.1) 6343.58,2837.37 ccw(c6343.58,2850.65) v1@6352.97,2841.26 ; v1@6352.97,3945.6 ccw(c6343.58,3954.99) 6356.86,3954.99 ccw(c6370.14,3954.99) v1@6360.75,3945.6 ; v1(6356.86,3941.71) 6356.86,4016.85 6364.5,4024.5 ; 6364.36,4065.65 6364.36,4200.95 ; 5894.66,4000.3 ccw(c5882.13,3987.77) 5882.13,4005.49 cw(c5882.13,3987.77) 5894.66,4000.3 ; 5894.66,4000.3 cw(c5907.19,4012.83) 5889.47,4012.83 ccw(c5907.19,4012.83) 5894.66,4000.3 ; 5894.66,4000.3 ccw(c5901.84,4007.48) 5901.84,3997.33 ; 5894.66,4000.3 ccw(c5901.84,4007.48) 5901.84,3997.33 ; 5901.84,3997.33 5985.78,3997.33 6009.31,3973.8 6053.3,3973.8 6055.21,3975.71 6087.9,3975.71 6112.75,3950.87 ; 6364.36,4200.95 6364.5,4200.81 6364.5,4035 ; 6364.5,4024.5 6364.5,4035 ; 6364.5,4024.5 6364.5,4035
  MidLayer1 w4: v1@6271.58,4571.32 cw(c6280.04,4563.54) 6280.04,4575.04 cw(c6280.04,4586.54) v1@6271.58,4578.76 ; v1@6273.38,4569.19 v1(6267.52,4575.04) 6289.15,4575.04 ; v1@6274.52,4568.61 cw(c6289.15,4555.18) 6289.15,4575.04 ; v1@6274.52,4581.47 ccw(c6289.15,4594.9) 6289.15,4575.04 ; v1@6334.49,4596.08 cw(c6320.28,4581) 6341,4581 ; v1@6337.23,4599 cw(c6329,4590.26) 6341,4590.26 cw(c6353,4590.26) v1@6344.77,4599 ; v1(6341,4603) 6341,4581 ; v1@6347.51,4596.08 ccw(c6361.72,4581) 6341,4581 ; v1@6350.14,2844.09 ccw(c6333.92,2860.31) 6356.86,2860.31 ccw(c6379.79,2860.31) v1@6363.57,2844.09 ; v1@6352.97,2841.26 ccw(c6343.58,2850.65) 6356.86,2850.65 ccw(c6370.14,2850.65) v1@6360.75,2841.26 ; v1(6356.86,2837.37) 6356.86,2896.04 6381.86,2921.04 6381.86,2972.06 6361.52,2992.39 6361.52,3059.04 6375.97,3073.49 6376.19,3073.71 ; v1@6356.86,3932.21 cw(c6356.86,3909.27) 6373.07,3925.49 cw(c6389.29,3941.71) v1@6366.36,3941.71 ; v1@6356.86,3936.21 cw(c6356.86,3922.93) 6366.25,3932.32 cw(c6375.64,3941.71) v1@6362.36,3941.71 ; v1(6356.86,3941.71) 6390.19,3908.37 6390.19,3800.04 6407.69,3782.55 6407.69,3730.23 6433.69,3704.23 6433.69,3655.52 6415.52,3637.36 6415.52,3387.69 6390.86,3363.02 6390.86,3321.3 6383,3313.44 6383,3080.52 ; 6289.15,4575.04 6295,4569.19 6313.38,4569.19 6318.9,4574.71 6334.71,4574.71 6341,4581 ; 6376.19,3073.71 6383,3080.52 ; 6376.19,3073.71 6383,3080.52
  MidLayer2 w4: v1(6130.36,3950.87) 6197.82,3950.87 6203.69,3945 6243.69,3945 6257.73,3959.04 6339.52,3959.04 v1(6356.86,3941.71) ; v1@6134.25,3946.98 cw(c6143.64,3937.59) 6143.64,3950.87 cw(c6143.64,3964.15) v1@6134.25,3954.76 ; v1@6137.08,3944.15 cw(c6153.3,3927.93) 6153.3,3950.87 cw(c6153.3,3973.8) v1@6137.08,3957.58 ; v1@6347.36,3941.71 ccw(c6324.42,3941.71) 6340.64,3957.93 ccw(c6356.86,3974.14) v1@6356.86,3951.21 ; v1@6351.36,3941.71 ccw(c6338.08,3941.71) 6347.47,3951.1 ccw(c6356.86,3960.49) v1@6356.86,3947.21