# Altium PCB NB3000AL.PcbDoc (part 4 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad) (continued)
FBGA780-2 [mil] "BGA, 780-Leads, Body 29x29mm, Pitch 1mm"
  round 19 smd paste+1.5: A2(-492.13,531.5) A3(-452.76,531.5) A4(-413.39,531.5) A5(-374.02,531.5) A6(-334.65,531.5) A7(-295.28,531.5) A8(-255.91,531.5) A9(-216.54,531.5) A10(-177.17,531.5) A11(-137.8,531.5) A12(-98.43,531.5) A13(-59.06,531.5) A14(-19.69,531.5) A15(19.69,531.5) A16(59.06,531.5) A17(98.43,531.5) A18(137.8,531.5) A19(177.17,531.5) A20(216.54,531.5) A21(255.91,531.5) A22(295.28,531.5) A23(334.65,531.5) A24(374.02,531.5) A25(413.39,531.5) A26(452.76,531.5) A27(492.13,531.5) AA1(-531.5,-255.91) AA3(-452.76,-255.91) AA4(-413.39,-255.91) AA5(-374.02,-255.91) AA6(-334.65,-255.91) AA7(-295.28,-255.91) AA8(-255.91,-255.91) AA10(-177.17,-255.91) AA11(-137.8,-255.91) AA12(-98.43,-255.91) AA13(-59.06,-255.91) AA14(-19.69,-255.91) AA15(19.69,-255.91) AA16(59.06,-255.91) AA17(98.43,-255.91) AA18(137.8,-255.91) AA19(177.17,-255.91) AA21(255.91,-255.91) AA22(295.28,-255.91) AA23(334.65,-255.91) AA24(374.02,-255.91) AA25(413.39,-255.91) AA26(452.76,-255.91) AA28(531.5,-255.91) AB1(-531.5,-295.28) AB2(-492.13,-295.28) AB3(-452.76,-295.28) AB4(-413.39,-295.28) AB5(-374.02,-295.28) AB6(-334.65,-295.28) AB7(-295.28,-295.28) AB8(-255.91,-295.28) AB9(-216.54,-295.28) AB10(-177.17,-295.28) AB11(-137.8,-295.28) AB12(-98.43,-295.28) AB13(-59.06,-295.28) AB14(-19.69,-295.28) AB15(19.69,-295.28) AB16(59.06,-295.28) AB17(98.43,-295.28) AB18(137.8,-295.28) AB19(177.17,-295.28) AB20(216.54,-295.28) AB21(255.91,-295.28) AB22(295.28,-295.28) AB23(334.65,-295.28) AB24(374.02,-295.28) AB25(413.39,-295.28) AB26(452.76,-295.28) AB27(492.13,-295.28) AB28(531.5,-295.28) AC1(-531.5,-334.65) AC2(-492.13,-334.65) AC3(-452.76,-334.65) AC4(-413.39,-334.65) AC5(-374.02,-334.65) AC7(-295.28,-334.65) AC8(-255.91,-334.65) AC10(-177.17,-334.65) AC11(-137.8,-334.65) AC12(-98.43,-334.65) AC14(-19.69,-334.65) AC15(19.69,-334.65) AC17(98.43,-334.65) AC18(137.8,-334.65) AC19(177.17,-334.65) AC21(255.91,-334.65) AC22(295.28,-334.65) AC24(374.02,-334.65) AC25(413.39,-334.65) AC26(452.76,-334.65) AC27(492.13,-334.65) AC28(531.5,-334.65) AD1(-531.5,-374.02) AD2(-492.13,-374.02) AD3(-452.76,-374.02) AD4(-413.39,-374.02) AD5(-374.02,-374.02) AD6(-334.65,-374.02) AD7(-295.28,-374.02) AD8(-255.91,-374.02) AD9(-216.54,-374.02) AD10(-177.17,-374.02) AD11(-137.8,-374.02) AD12(-98.43,-374.02) AD13(-59.06,-374.02) AD14(-19.69,-374.02) AD15(19.69,-374.02) AD16(59.06,-374.02) AD17(98.43,-374.02) AD18(137.8,-374.02) AD19(177.17,-374.02) AD20(216.54,-374.02) AD21(255.91,-374.02) AD22(295.28,-374.02) AD23(334.65,-374.02) AD24(374.02,-374.02) AD25(413.39,-374.02) AD26(452.76,-374.02) AD27(492.13,-374.02) AD28(531.5,-374.02) AE1(-531.5,-413.39) AE2(-492.13,-413.39) AE3(-452.76,-413.39) AE4(-413.39,-413.39) AE5(-374.02,-413.39) AE6(-334.65,-413.39) AE7(-295.28,-413.39) AE8(-255.91,-413.39) AE9(-216.54,-413.39) AE10(-177.17,-413.39) AE11(-137.8,-413.39) AE12(-98.43,-413.39) AE13(-59.06,-413.39) AE14(-19.69,-413.39) AE15(19.69,-413.39) AE16(59.06,-413.39) AE17(98.43,-413.39) AE18(137.8,-413.39) AE19(177.17,-413.39) AE20(216.54,-413.39) AE21(255.91,-413.39) AE22(295.28,-413.39) AE23(334.65,-413.39) AE24(374.02,-413.39) AE25(413.39,-413.39) AE26(452.76,-413.39) AE27(492.13,-413.39) AE28(531.5,-413.39) AF2(-492.13,-452.76) AF3(-452.76,-452.76) AF4(-413.39,-452.76) AF5(-374.02,-452.76) AF6(-334.65,-452.76) AF7(-295.28,-452.76) AF8(-255.91,-452.76) AF9(-216.54,-452.76) AF10(-177.17,-452.76) AF11(-137.8,-452.76) AF12(-98.43,-452.76) AF13(-59.06,-452.76) AF14(-19.69,-452.76) AF15(19.69,-452.76) AF16(59.06,-452.76) AF17(98.43,-452.76) AF18(137.8,-452.76) AF19(177.17,-452.76) AF20(216.54,-452.76) AF21(255.91,-452.76) AF22(295.28,-452.76) AF23(334.65,-452.76) AF24(374.02,-452.76) AF25(413.39,-452.76) AF26(452.76,-452.76) AF27(492.13,-452.76) AG1(-531.5,-492.13) AG3(-452.76,-492.13) AG4(-413.39,-492.13) AG6(-334.65,-492.13) AG7(-295.28,-492.13) AG8(-255.91,-492.13) AG10(-177.17,-492.13) AG11(-137.8,-492.13) AG12(-98.43,-492.13) AG14(-19.69,-492.13) AG15(19.69,-492.13) AG17(98.43,-492.13) AG18(137.8,-492.13) AG19(177.17,-492.13) AG21(255.91,-492.13) AG22(295.28,-492.13) AG23(334.65,-492.13) AG25(413.39,-492.13) AG26(452.76,-492.13) AG28(531.5,-492.13) AH2(-492.13,-531.5) AH3(-452.76,-531.5) AH4(-413.39,-531.5) AH5(-374.02,-531.5) AH6(-334.65,-531.5) AH7(-295.28,-531.5) AH8(-255.91,-531.5) AH9(-216.54,-531.5) AH10(-177.17,-531.5) AH11(-137.8,-531.5) AH12(-98.43,-531.5) AH13(-59.06,-531.5) AH14(-19.69,-531.5) AH15(19.69,-531.5) AH16(59.06,-531.5) AH17(98.43,-531.5) AH18(137.8,-531.5) AH19(177.17,-531.5) AH20(216.54,-531.5) AH21(255.91,-531.5) AH22(295.28,-531.5) AH23(334.65,-531.5) AH24(374.02,-531.5) AH25(413.39,-531.5) AH26(452.76,-531.5) AH27(492.13,-531.5) B1(-531.5,492.13) B3(-452.76,492.13) B4(-413.39,492.13) B6(-334.65,492.13) B7(-295.28,492.13) B8(-255.91,492.13) B10(-177.17,492.13) B11(-137.8,492.13) B12(-98.43,492.13) B14(-19.69,492.13) B15(19.69,492.13) B17(98.43,492.13) B18(137.8,492.13) B19(177.17,492.13) B21(255.91,492.13) B22(295.28,492.13) B23(334.65,492.13) B25(413.39,492.13) B26(452.76,492.13) B28(531.5,492.13) C2(-492.13,452.76) C3(-452.76,452.76) C4(-413.39,452.76) C5(-374.02,452.76) C6(-334.65,452.76) C7(-295.28,452.76) C8(-255.91,452.76) C9(-216.54,452.76) C10(-177.17,452.76) C11(-137.8,452.76) C12(-98.43,452.76) C13(-59.06,452.76) C14(-19.69,452.76) C15(19.69,452.76) C16(59.06,452.76) C17(98.43,452.76) C18(137.8,452.76) C19(177.17,452.76) C20(216.54,452.76) C21(255.91,452.76) C22(295.28,452.76) C23(334.65,452.76) C24(374.02,452.76) C25(413.39,452.76) C26(452.76,452.76) C27(492.13,452.76) D1(-531.5,413.39) D2(-492.13,413.39) D3(-452.76,413.39) D4(-413.39,413.39) D5(-374.02,413.39) D6(-334.65,413.39) D7(-295.28,413.39) D8(-255.91,413.39) D9(-216.54,413.39) D10(-177.17,413.39) D11(-137.8,413.39) D12(-98.43,413.39) D13(-59.06,413.39) D14(-19.69,413.39) D15(19.69,413.39) D16(59.06,413.39) D17(98.43,413.39) D18(137.8,413.39) D19(177.17,413.39) D20(216.54,413.39) D21(255.91,413.39) D22(295.28,413.39) D23(334.65,413.39) D24(374.02,413.39) D25(413.39,413.39) D26(452.76,413.39) D27(492.13,413.39) D28(531.5,413.39) E1(-531.5,374.02) E2(-492.13,374.02) E3(-452.76,374.02) E4(-413.39,374.02) E5(-374.02,374.02) E6(-334.65,374.02) E7(-295.28,374.02) E8(-255.91,374.02) E9(-216.54,374.02) E10(-177.17,374.02) E11(-137.8,374.02) E12(-98.43,374.02) E13(-59.06,374.02) E14(-19.69,374.02) E15(19.69,374.02) E16(59.06,374.02) E17(98.43,374.02) E18(137.8,374.02) E19(177.17,374.02) E20(216.54,374.02) E21(255.91,374.02) E22(295.28,374.02) E23(334.65,374.02) E24(374.02,374.02) E25(413.39,374.02) E26(452.76,374.02) E27(492.13,374.02) E28(531.5,374.02) F1(-531.5,334.65) F2(-492.13,334.65) F3(-452.76,334.65) F4(-413.39,334.65) F5(-374.02,334.65) F7(-295.28,334.65) F8(-255.91,334.65) F10(-177.17,334.65) F11(-137.8,334.65) F12(-98.43,334.65) F14(-19.69,334.65) F15(19.69,334.65) F17(98.43,334.65) F18(137.8,334.65) F19(177.17,334.65) F21(255.91,334.65) F22(295.28,334.65) F24(374.02,334.65) F25(413.39,334.65) F26(452.76,334.65) F27(492.13,334.65) F28(531.5,334.65) G1(-531.5,295.28) G2(-492.13,295.28) G3(-452.76,295.28) G4(-413.39,295.28) G5(-374.02,295.28) G6(-334.65,295.28) G7(-295.28,295.28) G8(-255.91,295.28) G9(-216.54,295.28) G10(-177.17,295.28) G11(-137.8,295.28) G12(-98.43,295.28) G13(-59.06,295.28) G14(-19.69,295.28) G15(19.69,295.28) G16(59.06,295.28) G17(98.43,295.28) G18(137.8,295.28) G19(177.17,295.28) G20(216.54,295.28) G21(255.91,295.28) G22(295.28,295.28) G23(334.65,295.28) G24(374.02,295.28) G25(413.39,295.28) G26(452.76,295.28) G27(492.13,295.28) G28(531.5,295.28) H1(-531.5,255.91) H3(-452.76,255.91) H4(-413.39,255.91) H5(-374.02,255.91) H6(-334.65,255.91) H7(-295.28,255.91) H8(-255.91,255.91) H10(-177.17,255.91) H11(-137.8,255.91) H12(-98.43,255.91) H13(-59.06,255.91) H14(-19.69,255.91) H15(19.69,255.91) H16(59.06,255.91) H17(98.43,255.91) H18(137.8,255.91) H19(177.17,255.91) H21(255.91,255.91) H22(295.28,255.91) H23(334.65,255.91) H24(374.02,255.91) H25(413.39,255.91) H26(452.76,255.91) H28(531.5,255.91) J1(-531.5,216.54) J2(-492.13,216.54) J3(-452.76,216.54) J4(-413.39,216.54) J5(-374.02,216.54) J6(-334.65,216.54) J7(-295.28,216.54) J8(-255.91,216.54) J9(-216.54,216.54) J10(-177.17,216.54) J12(-98.43,216.54) J13(-59.06,216.54) J14(-19.69,216.54) J15(19.69,216.54) J16(59.06,216.54) J17(98.43,216.54) J19(177.17,216.54) J20(216.54,216.54) J21(255.91,216.54) J22(295.28,216.54) J23(334.65,216.54) J24(374.02,216.54) J25(413.39,216.54) J26(452.76,216.54) J27(492.13,216.54) J28(531.5,216.54) K1(-531.5,177.17) K2(-492.13,177.17) K3(-452.76,177.17) K4(-413.39,177.17) K5(-374.02,177.17) K7(-295.28,177.17) K8(-255.91,177.17) K9(-216.54,177.17) K11(-137.8,177.17) K13(-59.06,177.17) K15(19.69,177.17) K17(98.43,177.17) K19(177.17,177.17) K21(255.91,177.17) K22(295.28,177.17) K24(374.02,177.17) K25(413.39,177.17) K26(452.76,177.17) K27(492.13,177.17) K28(531.5,177.17) L1(-531.5,137.8) L2(-492.13,137.8) L3(-452.76,137.8) L4(-413.39,137.8) L5(-374.02,137.8) L6(-334.65,137.8) L7(-295.28,137.8) L8(-255.91,137.8) L10(-177.17,137.8) L12(-98.43,137.8) L14(-19.69,137.8) L16(59.06,137.8) L18(137.8,137.8) L20(216.54,137.8) L21(255.91,137.8) L22(295.28,137.8) L23(334.65,137.8) L24(374.02,137.8) L25(413.39,137.8) L26(452.76,137.8) L27(492.13,137.8) L28(531.5,137.8) M1(-531.5,98.43) M2(-492.13,98.43) M3(-452.76,98.43) M4(-413.39,98.43) M5(-374.02,98.43) M6(-334.65,98.43) M7(-295.28,98.43) M8(-255.91,98.43) M9(-216.54,98.43) M11(-137.8,98.43) M13(-59.06,98.43) M15(19.69,98.43) M17(98.43,98.43) M19(177.17,98.43) M21(255.91,98.43) M23(334.65,98.43) M24(374.02,98.43) M25(413.39,98.43) M26(452.76,98.43) M27(492.13,98.43) M28(531.5,98.43) N1(-531.5,59.06) N3(-452.76,59.06) N4(-413.39,59.06) N5(-374.02,59.06) N7(-295.28,59.06) N8(-255.91,59.06) N10(-177.17,59.06) N12(-98.43,59.06) N14(-19.69,59.06) N16(59.06,59.06) N18(137.8,59.06) N20(216.54,59.06) N21(255.91,59.06) N24(374.02,59.06) N25(413.39,59.06) N26(452.76,59.06) N28(531.5,59.06) P1(-531.5,19.69) P2(-492.13,19.69) P3(-452.76,19.69) P4(-413.39,19.69) P5(-374.02,19.69) P6(-334.65,19.69) P7(-295.28,19.69) P8(-255.91,19.69) P9(-216.54,19.69) P11(-137.8,19.69) P13(-59.06,19.69) P15(19.69,19.69) P17(98.43,19.69) P19(177.17,19.69) P21(255.91,19.69) P24(374.02,19.69) P25(413.39,19.69) P26(452.76,19.69) P27(492.13,19.69) P28(531.5,19.69) R1(-531.5,-19.69) R2(-492.13,-19.69) R3(-452.76,-19.69) R4(-413.39,-19.69) R5(-374.02,-19.69) R6(-334.65,-19.69) R7(-295.28,-19.69) R10(-177.17,-19.69) R12(-98.43,-19.69) R14(-19.69,-19.69) R16(59.06,-19.69) R18(137.8,-19.69) R20(216.54,-19.69) R21(255.91,-19.69) R22(295.28,-19.69) R23(334.65,-19.69) R24(374.02,-19.69) R25(413.39,-19.69) R26(452.76,-19.69) R27(492.13,-19.69) R28(531.5,-19.69) T1(-531.5,-59.06) T3(-452.76,-59.06) T4(-413.39,-59.06) T5(-374.02,-59.06) T7(-295.28,-59.06) T8(-255.91,-59.06) T9(-216.54,-59.06) T11(-137.8,-59.06) T13(-59.06,-59.06) T15(19.69,-59.06) T17(98.43,-59.06) T19(177.17,-59.06) T21(255.91,-59.06) T22(295.28,-59.06) T24(374.02,-59.06) T25(413.39,-59.06) T26(452.76,-59.06) T28(531.5,-59.06) U1(-531.5,-98.43) U2(-492.13,-98.43) U3(-452.76,-98.43) U4(-413.39,-98.43) U5(-374.02,-98.43) U6(-334.65,-98.43) U7(-295.28,-98.43) U8(-255.91,-98.43) U10(-177.17,-98.43) U12(-98.43,-98.43) U14(-19.69,-98.43) U16(59.06,-98.43) U18(137.8,-98.43) U20(216.54,-98.43) U21(255.91,-98.43) U22(295.28,-98.43) U23(334.65,-98.43) U24(374.02,-98.43) U25(413.39,-98.43) U26(452.76,-98.43) U27(492.13,-98.43) U28(531.5,-98.43) V1(-531.5,-137.8) V2(-492.13,-137.8) V3(-452.76,-137.8) V4(-413.39,-137.8) V5(-374.02,-137.8) V6(-334.65,-137.8) V7(-295.28,-137.8) V8(-255.91,-137.8) V9(-216.54,-137.8) V11(-137.8,-137.8) V13(-59.06,-137.8) V15(19.69,-137.8) V17(98.43,-137.8) V19(177.17,-137.8) V20(216.54,-137.8) V21(255.91,-137.8) V22(295.28,-137.8) V23(334.65,-137.8) V24(374.02,-137.8) V25(413.39,-137.8) V26(452.76,-137.8) V27(492.13,-137.8) V28(531.5,-137.8) W1(-531.5,-177.17) W2(-492.13,-177.17) W3(-452.76,-177.17) W4(-413.39,-177.17) W5(-374.02,-177.17) W7(-295.28,-177.17) W8(-255.91,-177.17) W9(-216.54,-177.17) W10(-177.17,-177.17) W12(-98.43,-177.17) W14(-19.69,-177.17) W16(59.06,-177.17) W18(137.8,-177.17) W20(216.54,-177.17) W21(255.91,-177.17) W22(295.28,-177.17) W24(374.02,-177.17) W25(413.39,-177.17) W26(452.76,-177.17) W27(492.13,-177.17) W28(531.5,-177.17) Y1(-531.5,-216.54) Y2(-492.13,-216.54) Y3(-452.76,-216.54) Y4(-413.39,-216.54) Y5(-374.02,-216.54) Y6(-334.65,-216.54) Y7(-295.28,-216.54) Y8(-255.91,-216.54) Y9(-216.54,-216.54) Y10(-177.17,-216.54) Y12(-98.43,-216.54) Y13(-59.06,-216.54) Y14(-19.69,-216.54) Y15(19.69,-216.54) Y16(59.06,-216.54) Y17(98.43,-216.54) Y19(177.17,-216.54) Y20(216.54,-216.54) Y21(255.91,-216.54) Y22(295.28,-216.54) Y23(334.65,-216.54) Y24(374.02,-216.54) Y25(413.39,-216.54) Y26(452.76,-216.54) Y27(492.13,-216.54) Y28(531.5,-216.54)
  round 19 smd paste+1.5 mask+0: AA2(-492.13,-255.91) AA9(-216.54,-255.91) AA20(216.54,-255.91) AA27(492.13,-255.91) AC6(-334.65,-334.65) AC9(-216.54,-334.65) AC13(-59.06,-334.65) AC16(59.06,-334.65) AC20(216.54,-334.65) AC23(334.65,-334.65) AF1(-531.5,-452.76) AF28(531.5,-452.76) AG2(-492.13,-492.13) AG5(-374.02,-492.13) AG9(-216.54,-492.13) AG13(-59.06,-492.13) AG16(59.06,-492.13) AG20(216.54,-492.13) AG24(374.02,-492.13) AG27(492.13,-492.13) B2(-492.13,492.13) B5(-374.02,492.13) B9(-216.54,492.13) B13(-59.06,492.13) B16(59.06,492.13) B20(216.54,492.13) B24(374.02,492.13) B27(492.13,492.13) C1(-531.5,452.76) C28(531.5,452.76) F6(-334.65,334.65) F9(-216.54,334.65) F13(-59.06,334.65) F16(59.06,334.65) F20(216.54,334.65) F23(334.65,334.65) H2(-492.13,255.91) H9(-216.54,255.91) H20(216.54,255.91) H27(492.13,255.91) J11(-137.8,216.54) J18(137.8,216.54) K6(-334.65,177.17) K10(-177.17,177.17) K12(-98.43,177.17) K14(-19.69,177.17) K16(59.06,177.17) K18(137.8,177.17) K20(216.54,177.17) K23(334.65,177.17) L9(-216.54,137.8) L11(-137.8,137.8) L13(-59.06,137.8) L15(19.69,137.8) L17(98.43,137.8) L19(177.17,137.8) M10(-177.17,98.43) M12(-98.43,98.43) M14(-19.69,98.43) M16(59.06,98.43) M18(137.8,98.43) M20(216.54,98.43) M22(295.28,98.43) N2(-492.13,59.06) N6(-334.65,59.06) N9(-216.54,59.06) N11(-137.8,59.06) N13(-59.06,59.06) N15(19.69,59.06) N17(98.43,59.06) N19(177.17,59.06) N22(295.28,59.06) N23(334.65,59.06) N27(492.13,59.06) P10(-177.17,19.69) P12(-98.43,19.69) P14(-19.69,19.69) P16(59.06,19.69) P18(137.8,19.69) P20(216.54,19.69) P22(295.28,19.69) P23(334.65,19.69) R8(-255.91,-19.69) R9(-216.54,-19.69) R11(-137.8,-19.69) R13(-59.06,-19.69) R15(19.69,-19.69) R17(98.43,-19.69) R19(177.17,-19.69) T2(-492.13,-59.06) T6(-334.65,-59.06) T10(-177.17,-59.06) T12(-98.43,-59.06) T14(-19.69,-59.06) T16(59.06,-59.06) T18(137.8,-59.06) T20(216.54,-59.06) T23(334.65,-59.06) T27(492.13,-59.06) U9(-216.54,-98.43) U11(-137.8,-98.43) U13(-59.06,-98.43) U15(19.69,-98.43) U17(98.43,-98.43) U19(177.17,-98.43) V10(-177.17,-137.8) V12(-98.43,-137.8) V14(-19.69,-137.8) V16(59.06,-137.8) V18(137.8,-137.8) W6(-334.65,-177.17) W11(-137.8,-177.17) W13(-59.06,-177.17) W15(19.69,-177.17) W17(98.43,-177.17) W19(177.17,-177.17) W23(334.65,-177.17) Y11(-137.8,-216.54) Y18(137.8,-216.54)
  silkscreen extent -601,-571 571,571, body extent -591,-590 581,581, height 96
"FIDUCIAL ROUND" [mm] "FIDUCIAL ROUND"
  round 1.5 all layers, no hole paste-1.524 mask+1.1: 0(0,0)
  Top Layer lines w0.127: 0,1.778 cw(c0,0) 0,-1.778 cw(c0,0) 0,1.778
  Bottom Layer lines w0.127: 0,1.778 cw(c0,0) 0,-1.778 cw(c0,0) 0,1.778
FPC-XXS1VN3R [mm] "Connector; ZIF FPC 40 Position; 0.5mm Spaced Vertical Mounting"
  rrect50% 0.4x1.524 smd: 1(-9.75,-0.975) 2(-9.25,0.975) 3(-8.75,-0.975) 4(-8.25,0.975) 5(-7.75,-0.975) 6(-7.25,0.975) 7(-6.75,-0.975) 8(-6.25,0.975) 9(-5.75,-0.975) 10(-5.25,0.975) 11(-4.75,-0.975) 12(-4.25,0.975) 13(-3.75,-0.975) 14(-3.25,0.975) 15(-2.75,-0.975) 16(-2.25,0.975) 17(-1.75,-0.975) 18(-1.25,0.975) 19(-0.75,-0.975) 20(-0.25,0.975) 21(0.25,-0.975) 22(0.75,0.975) 23(1.25,-0.975) 24(1.75,0.975) 25(2.25,-0.975) 26(2.75,0.975) 27(3.25,-0.975) 28(3.75,0.975) 29(4.25,-0.975) 30(4.75,0.975) 31(5.25,-0.975) 32(5.75,0.975) 33(6.25,-0.975) 34(6.75,0.975) 35(7.25,-0.975) 36(7.75,0.975) 37(8.25,-0.975) 38(8.75,0.975) 39(9.25,-0.975) 40(9.75,0.975)
  rect 2x2.4 smd: 41(-11.55,0) 42(11.55,0)
  silkscreen extent -10.58,-2.12 -10.33,-1.88, body extent -12.12,-1.45 12.18,1.48, height 4.47
H11L1SR2VM [mil] "Recommended pad layout for surface mount leadform"
  rect 70x80 smd: 1(-100,-182.48) 2(0,-182.48) 3(100,-182.48) 5(0,182.48) 6(-100,182.48)
  rect 70x80 smd mask+0: 4(100,182.48)
  silkscreen extent -162,-187 130,137, body extent -138,-212 138,211, height 141
HDR1X2#1 [mm]
  rect 1.5x1.5 hole 0.9 mask+0: 1(-0.01,0.007)
  round 1.5 hole 0.9 mask+0: 2(2.53,0.007)
  silkscreen extent -1.28,-1.26 3.8,1.28, body extent -1.28,-1.26 3.8,1.28, height 8.41
HDR1X2#2 [mm]
  rect 1.5x1.5 hole 0.9: 1(-0.01,0.007)
  round 1.5 hole 0.9: 2(2.53,0.007)
  silkscreen extent -1.28,-1.26 3.8,1.28, body extent -1.28,-1.26 3.8,1.28, height 8.41
HDR2X2 [mm]
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(0,2.54) 3(2.54,0) 4(2.54,2.54)
  silkscreen extent -1.27,-1.27 3.81,3.81, body extent -1.27,-1.27 3.81,3.81, height 8.41
HDR2X10 [mm]
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0)
  round 1.5 hole 0.9 mask+0: 20(22.86,2.54)
  silkscreen extent -1.27,-1.27 24.13,3.81, body extent -1.28,-1.26 24.12,3.82, height 8.38
IM03GR [mm]
  rrect50% 2x1 smd paste+0 mask+0: 1(0,0) 2(0,3.2) 3(0,5.4) 4(0,7.6) 5(-6,7.6) 6(-6,5.4) 7(-6,3.2) 8(-6,0)
  silkscreen extent -6.1,-1.5 0.1,8.8, body extent -6.79,-1.02 0.7,8.64, height 3.8
INDC1005 [mm] "Chip Inductor 1005"
  rect 0.6x0.6 smd mask+0.038: 1(-0.525,0) 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.69,-0.22 0.71,0.23, height 0.5
INDC3225 [mm]
  rect 1x2.5 smd: 1(-1.5,0) 2(1.5,0)
  silkscreen extent -0.6,-1.6 0.6,1.6, body extent -1.38,-1.14 1.41,1.15, height 1.78
KLD-0202 [mm]
  oval 2x4.5 hole 1 slot 3.5 at 90 deg: 1(13.7,0)
  oval 2x4 hole 1 slot 3 at 90 deg mask+0: 2(7.5,0)
  oval 4x2 hole 1 slot 3 at 0 deg mask+0: 3(10.5,-5)
  silkscreen extent 0,-4.5 13.7,4.5, body extent -0.15,-5 14.35,4.5, height 11
KME04-USBMU03A01-1 [mm] "KME04-USBMU03A01-1"
  rrect50% 2.8x0.5 smd: 1(0,0) 2(0,-0.8) 3(0,-1.6) 4(0,-2.4)
  rrect50% 2.8x0.5 smd mask+0: 5(0,-3.2)
  rrect50% 3.5x2.05 smd: 6(0.025,3.325) 8(0.025,-6.525)
  rrect50% 4x2.05 smd: 7(-4.225,3.325) 9(-4.225,-6.525)
  round 0.9 hole 0.9 unplated: X(-2.325,-3.8) Y(-2.325,0.6)
  silkscreen extent -8.25,-4.85 2,1.65, body extent -8.22,-6.56 0.78,3.34, height 3.95
KMFCDIN76005 [mm]
  round 2.5 hole 1.3: 1(7.5,3.75) 2(0,3.75) 3(-7.5,3.75) 4(5,6.25) 5(-5,6.25) MH1(2.5,-6.25) MH2(-2.5,-6.25)
  silkscreen extent -10.5,-8.75 10.5,7.25, body extent -10.34,-8.95 10.36,7.31, height 21.4
KMRJ103-5-508-6#1 [mm] "5.0mm pitch terminal block, 6-way"
  round 2.1 hole 1.2: 1(-12.5,0) 2(-7.5,0) 3(-2.5,0) 4(2.5,0) 5(7.5,0) 6(12.5,0)
  silkscreen extent -15.05,-7.8 15.05,5.5, body extent -15.83,-6.4 14.91,7, height 15.3
KMRJ103-5-508-6#2 [mm] "5.0mm pitch terminal block, 6-way"
  round 2.1 hole 1.2: 1(-12.5,0) 2(-7.5,0) 3(-2.5,0) 4(2.5,0) 5(7.5,0)
  round 2.1 hole 1.2 mask+0: 6(12.5,0)
  silkscreen extent -15.05,-7.8 15.05,5.5, body extent -15.83,-6.4 14.91,7, height 15.3
KMRJ103-5-508-12 [mm] "5.0mm pitch terminal block, 12-way"
  round 2.1 hole 1.2: 1(-27.5,0) 2(-22.5,0) 3(-17.5,0) 4(-12.5,0) 5(-7.5,0) 6(-2.5,0) 7(2.5,0) 8(7.5,0) 9(12.5,0) 10(17.5,0) 11(22.5,0) 12(27.5,0)
  silkscreen extent -30.05,-7.8 30.05,5.5, body extent -30.7,-6.4 30.04,7, height 15.3
KSDC012551#1 [mm] "SD Card socket"
  rrect50% 1.16x2.5 smd: 1(-6.48,-12.15) 2(-3.98,-12.15) 4(1.03,-12.15) 5(3.53,-12.15) 7(8.45,-12.15) 8(10.15,-12.15) 9(-8.98,-12.15) CD(-2.33,-12.15) WP(13.5,-12.15)
  rrect50% 1.16x2.5 smd mask+0: 3(-0.68,-12.15) 6(6.03,-12.15)
  rect 2.2x2.2 smd mask+0: GND1(14,10.05)
  rect 2.2x2.134 smd mask+0: GND2(-14,10.05)
  round 1.55 hole 1.55 unplated: MH1(12.5,12.15) MH2(-11.7,12.15)
  silkscreen extent -14.22,-11.4 14.22,17.4, body extent -14.32,-12.74 14.4,21.53, height 2.9
KSDC012551#2 [mm] "SD Card socket"
  rrect50% 1.16x2.5 smd: 1(-6.48,-12.15) 2(-3.98,-12.15) 4(1.03,-12.15) 5(3.53,-12.15) 7(8.45,-12.15) 8(10.15,-12.15) 9(-8.98,-12.15) CD(-2.33,-12.15) WP(13.5,-12.15)
  rrect50% 1.16x2.5 smd mask+0: 3(-0.68,-12.15) 6(6.03,-12.15)
  rrect50% 1.524x3.048 smd mask+0: GND1(14,10.05) GND2(-14,10.05)
  round 1.55 hole 1.55 unplated: MH1(12.5,12.15) MH2(-11.7,12.15)
  silkscreen extent -14.22,-11.4 14.22,17.4, body extent -14.32,-12.74 14.4,21.53, height 2.9
LEAD_FREE_S [mil]
  silkscreen extent -125,-125 125,125
LOGO-ALTIUM-NEW [mil]
  silkscreen extent -211,-34 202,54
MF_SM250 [mm] "PTC Resetatable Fuse"
  rect 2.3x4.6 smd: 1(-2.323,0.127) 2(6.077,0.127)
  silkscreen extent -4.12,-2.62 7.88,2.88, body extent -2.78,-3.01 6.33,3.34, height 3.17
MINIDIN6PURPLE [mm]
  round 1.6 hole 0.9: 1(8.45,-1.25) 2(8.45,1.25) 4(8.45,3.25) 5(10.95,-3.25) 6(10.95,3.25)
  round 1.6 hole 0.9 mask+0: 3(8.45,-3.25)
  round 3.5 hole 2.3: MH1(4.7,0)
  oval 4.4x2.4 hole 0.9 slot 2.4 at 0 deg: MH2(5.45,6.905) MH3(5.45,-6.595)
  silkscreen extent -0.05,-7 12.7,7, body extent -0.1,-7.03 12.7,6.97, height 13
"NANOBOARD LOGO" [mil]
  silkscreen extent -442,-67 456,59
"NB2STR01 Blank PCB" [mil]
NETTIE-SMT2-8X8#1 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-47.2,-0.24) 2(-27.2,-0.24)
NETTIE-SMT2-8X8#2 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-45,0)
  rect 21x12 smd paste-22 mask+0: 2(-25,0)
NETTIE-SMT2-8X8#3 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-47.2,-0.24)
  rect 21x12 smd paste-22 mask+0: 2(-27.2,-0.24)
NETTIE-SMT2-8X8#4 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-45,-1.11)
  rect 21x12 smd paste-22 mask+0: 2(-25,-1.11)
NETTIE-SMT2-8X8#5 [mil]
  rect 25x30 smd paste-22 mask+0: 1(-40,0)
  rect 25x30 smd paste-22 mask-22: 2(-15,0)
NETTIE-SMT2-8X8#6 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30.08,-2.56) 2(-10.08,-2.56)
NETTIE-SMT2-8X8#7 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30.08,3.07) 2(-10.08,3.07)
NETTIE-SMT2-8X8#8 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30.08,-4.49)
  rect 21x12 smd paste-22 mask+0: 2(-10.08,-4.49)
NETTIE-SMT2-8X8#9 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-31.22,-2.28)
  rect 21x12 smd paste-22 mask+0: 2(-51.22,-2.28)
NETTIE-SMT2-8X8#10 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-31.06,3.03)
  rect 21x12 smd paste-22 mask+0: 2(-11.06,3.03)
NETTIE-SMT2-8X8#11 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30.08,-1.3)
  rect 21x12 smd paste-22 mask+0: 2(-10.08,-1.3)
NETTIE-SMT2-8X8#12 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-31.06,3.66) 2(-11.06,3.66)
NETTIE-SMT2-8X8#13 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,-0.46) 2(-10,-0.46)
NETTIE-SMT2-8X8#14 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,-2.14) 2(-10,-2.14)
NETTIE-SMT2-8X8#15 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,-1.51) 2(-10,-1.51)
NETTIE-SMT2-8X8#16 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,-1.76) 2(-10,-1.76)
NETTIE-SMT2-8X8#17 [mil]
  rect 20x12 smd paste-20 mask-4.33: 1(-30,1.39)
  rect 20x12 smd paste-20 mask+0: 2(-10,1.39)
NETTIE-SMT2-8X8#18 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,0.93)
  rect 21x12 smd paste-22 mask+0: 2(-10,0.93)
NETTIE-SMT2-8X8#19 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,-0.88)
  rect 21x12 smd paste-22 mask+0: 2(-10,-0.88)
NETTIE-SMT2-8X8#20 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-30,-2.39)
  rect 21x12 smd paste-22 mask+0: 2(-10,-2.39)
NETTIE-SMT2-8X8#21 [mil]
  rect 21x12 smd paste-22 mask-22: 1(-40,0) 2(-20,0)
NETTIE-SMT2-8X8#22 [mil]
  rect 21x12 smd paste-22 mask+0: 1(-40,0)
  rect 21x12 smd paste-22 mask-22: 2(-20,0)
NETTIE-SMT2-8X8#23 [mil]
  rect 21x12 smd paste-22 mask+0: 1(-30,0)
  rect 21x12 smd paste-22 mask-22: 2(-10,0)
NETTIE-SMT2-31X39 [mil]
  rect 40x31.5 smd paste-19.68 mask-19.68: 1(-66.57,0.24)
  rect 40x31.5 smd paste-19.68 mask+0: 2(-27.2,0.24)
NETTIE-SMT2-31X51#1 [mil]
  rect 52x31.5 smd paste-52 mask-19.68: 1(-35.08,0.24) 2(16.1,0.24)
NETTIE-SMT2-31X51#2 [mil]
  rect 52x31.5 smd paste-52 mask+0: 1(-35.08,0.24)
  rect 52x31.5 smd paste-52 mask-19.68: 2(16.1,0.24)
PERIPHERAL_BOARD_1SLOT [mil] "Outline of 2-Slot Peripheral Board"
  Top Layer region: 728.35,3228.35 653.54,3153.54 287.4,3153.54 212.6,3228.35
  Top Layer region: 0,2216.54 74.8,2291.34 74.8,2940.94 0,3015.75
  Top Layer region: 0,452.76 74.8,527.56 74.8,937.01 0,1011.81
  Top Layer region: 2440.94,2216.54 2366.14,2291.34 2366.14,2940.94 2440.94,3015.75
  Top Layer region: 2440.94,452.76 2366.14,527.56 2366.14,937.01 2440.94,1011.81
  silkscreen extent 0,0 2441,3228
PH-2 [mm]
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(2,0)
  silkscreen extent -2.15,-2.85 4.15,1.85, body extent -3.88,-5.28 5.91,4.33, height 6
POT-R0911G-A1 [mm]
  round 2 hole 0.9: 1(-2.5,0) 2(0,0) 3(2.5,0) 4(-2.5,-2.5) 5(0,-2.5) 6(2.5,-2.5)
  silkscreen extent -4.9,-22.3 4.5,2.3, body extent -5.73,-27.97 5.76,1.5, height 12.64
PT4812 [mm] "Transformer for Digital Audio Data Transmission"
  rrect50% 1.27x3.05 smd mask+0: 1(0,0)
  rrect50% 1.27x3.05 smd: 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(7.62,13.21) 6(5.08,13.21) 7(2.54,13.21) 8(0,13.21)
  silkscreen extent -2.22,1.52 9.84,11.69, body extent -2.28,-0.29 9.78,13.24, height 8.86
QFN50P800X800_HS-57 [mm] "Quad Flat No Lead; 56 Terminals; Body 8 x 8 mm; Pitch 0.5 mm, Punch Version"
  rrect50% 0.305x0.86 smd mask+0.051: 1(-3.25,-3.92) 29(3.25,3.92) 42(-3.25,3.92)
  rrect50% 0.305x0.86 smd mask+0.038: 2(-2.75,-3.92) 3(-2.25,-3.92) 4(-1.75,-3.92) 5(-1.25,-3.92) 7(-0.25,-3.92) 8(0.25,-3.92) 9(0.75,-3.92) 11(1.75,-3.92) 13(2.75,-3.92) 30(2.75,3.92) 31(2.25,3.92) 32(1.75,3.92) 33(1.25,3.92) 34(0.75,3.92) 35(0.25,3.92) 36(-0.25,3.92) 37(-0.75,3.92) 38(-1.25,3.92) 39(-1.75,3.92) 40(-2.25,3.92)
  rrect50% 0.305x0.86 smd mask+0: 6(-0.75,-3.92) 10(1.25,-3.92) 12(2.25,-3.92) 14(3.25,-3.92) 41(-2.75,3.92)
  rrect50% 0.86x0.305 smd mask+0.051: 15(3.92,-3.25) 43(-3.92,3.25)
  rrect50% 0.86x0.305 smd mask+0.038: 16(3.92,-2.75) 17(3.92,-2.25) 18(3.92,-1.75) 19(3.92,-1.25) 20(3.92,-0.75) 21(3.92,-0.25) 22(3.92,0.25) 23(3.92,0.75) 24(3.92,1.25) 25(3.92,1.75) 27(3.92,2.75) 45(-3.92,2.25) 46(-3.92,1.75) 47(-3.92,1.25) 48(-3.92,0.75) 49(-3.92,0.25) 50(-3.92,-0.25) 51(-3.92,-0.75) 52(-3.92,-1.25) 54(-3.92,-2.25) 55(-3.92,-2.75)
  rrect50% 0.86x0.305 smd mask+0: 26(3.92,2.25) 28(3.92,3.25) 44(-3.92,2.75) 53(-3.92,-1.75) 56(-3.92,-3.25)
  Top Layer region: -2.75,2.75 2.75,2.75 2.75,-2.75 -2.75,-2.75
  silkscreen extent -4.05,-4.83 4.05,4.05, body extent -4.32,-4.24 4.26,4.28, height 0.55
RESC1005-STAR#1 [mm] "Chip Inductor 1005"
  rect 0.575x0.6 smd: 1(-0.538,0) 2(0.538,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.71,-0.25 0.72,0.26, height 0.25
RESC1005-STAR#2 [mm] "Chip Inductor 1005"
  rect 0.575x0.6 smd: 1(-0.538,0)
  rect 0.575x0.6 smd mask+0: 2(0.538,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.71,-0.25 0.72,0.26, height 0.25
RESC1005-STAR#3 [mm] "Chip Inductor 1005"
  rect 0.575x0.6 smd mask+0: 1(-0.538,0)
  rect 0.575x0.6 smd: 2(0.538,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.71,-0.25 0.72,0.26, height 0.25
RESC2012-STAR [mm] "0805 Resistor SMD - Startronics"
  rect 1x1.25 smd: 1(-1,0) 2(1,0)
  silkscreen extent -0.4,-1 0.4,1, body extent -1.03,-0.54 1.07,0.57, height 0.25
RESC3216 [mm]
  rect 1.6x1.8 smd: 1(-1.4,0)
  rect 1.6x1.8 smd mask+0: 2(1.4,0)
  silkscreen extent -0.3,-0.8 0.3,0.8, body extent -1.33,-0.81 1.37,0.85, height 0.55
S1206RGBSDJC [mm]
  rrect50% 0.8x0.7 smd mask+0.038: 1(1.3,-0.55) 2(-1.3,-0.55) 3(-1.3,0.55) 4(1.3,0.55)
  silkscreen extent -2.19,-0.05 -2.09,0.05, body extent -1.48,-0.76 1.51,0.78, height 0.7
SC70_6L#1 [mm]
  rrect50% 0.4x0.85 smd: 1(0,0) 3(1.3,0) 4(1.3,1.85) 5(0.65,1.85) 6(0,1.85)
  rrect50% 0.4x0.85 smd mask+0: 2(0.65,0)
  silkscreen extent -0.8,-0.55 1.8,1.85, body extent -0.43,-0.38 1.73,2.22, height 0.64
SC70_6L#2 [mm]
  rrect50% 0.4x0.85 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.85) 5(0.65,1.85) 6(0,1.85)
  silkscreen extent -0.8,-0.55 1.8,1.85, body extent -0.43,-0.38 1.73,2.22, height 0.64
SC70_6L#3 [mm]
  rrect50% 0.4x0.85 smd mask+0.038: 1(0,0) 3(1.3,0) 4(1.3,1.85) 5(0.65,1.85) 6(0,1.85)
  rrect50% 0.4x0.85 smd mask+0: 2(0.65,0)
  silkscreen extent -0.8,-0.55 1.8,1.85, body extent -0.43,-0.38 1.73,2.22, height 0.64
SOD323 [mil] "SOD-323/SC-76; 2 Leads; Body 1.7 x 1.3 mm, (LxW)"
  rect 45x30 smd: 1(-46.26,0) 2(46.26,0)
  silkscreen extent -37,-30 37,30, body extent -39,-27 38,28, height 20
SOIC8-200-BODY [mm] "SOIC (JEDEC) 8 PIN, 200 mils body width"
  rrect50% 0.7x2.2 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 5(3.81,7) 6(2.54,7) 7(1.27,7) 8(0,7)
  rrect50% 0.7x2.2 smd mask+0: 4(3.81,0)
  silkscreen extent -1.34,0.54 4.4,5.4, body extent -0.7,0.12 4.71,6.88, height 1.06
SOIC127P600-8 [mm] "SOIC 50mil pitch narrow-body"
  rrect50% 0.7x1.8 smd: 1(-1.905,-2.85) 2(-0.635,-2.85) 3(0.635,-2.85) 4(1.905,-2.85) 5(1.905,2.85) 6(0.635,2.85) 7(-0.635,2.85) 8(-1.905,2.85)
  silkscreen extent -2.6,-1.12 2.6,1.12, body extent -2.51,-3.45 2.56,3.28, height 1
SOIC127P600-14N [mm] "SOIC, 14-Leads, Body 8.7x3.9mm, Pitch 1.27mm, IPC Medium Density"
  rrect50% 2.2x0.6 smd: 1(-2.4,3.81) 2(-2.4,2.54) 3(-2.4,1.27) 4(-2.4,0) 5(-2.4,-1.27) 8(2.4,-3.81) 9(2.4,-2.54) 10(2.4,-1.27) 11(2.4,0) 12(2.4,1.27) 13(2.4,2.54) 14(2.4,3.81)
  rrect50% 2.2x0.6 smd mask+0: 6(-2.4,-2.54) 7(-2.4,-3.81)
  silkscreen extent -2.53,-4.4 0.9,4.78, body extent -2.88,-4.28 2.92,4.28, height 1.75
SOIC127P600-16#1 [mm]
  rrect50% 0.7x1.8 smd: 1(-4.445,-2.85) 2(-3.175,-2.85) 3(-1.905,-2.85) 4(-0.635,-2.85) 6(1.905,-2.85) 7(3.175,-2.85) 8(4.445,-2.85) 9(4.445,2.85) 10(3.175,2.85) 11(1.905,2.85) 12(0.635,2.85) 13(-0.635,2.85) 14(-1.905,2.85) 15(-3.175,2.85) 16(-4.445,2.85)
  rrect50% 0.7x1.8 smd mask+0: 5(0.635,-2.85)
  silkscreen extent -5.42,-2.72 5,1.1, body extent -4.9,-2.87 4.9,2.93, height 1.75
SOIC127P600-16#2 [mm]
  rrect50% 0.7x1.8 smd: 1(-4.445,-2.85) 2(-3.175,-2.85) 3(-1.905,-2.85) 4(-0.635,-2.85) 5(0.635,-2.85) 6(1.905,-2.85) 7(3.175,-2.85) 8(4.445,-2.85) 9(4.445,2.85) 10(3.175,2.85) 11(1.905,2.85) 12(0.635,2.85) 13(-0.635,2.85) 14(-1.905,2.85) 16(-4.445,2.85)
  rrect50% 0.7x1.8 smd mask+0: 15(-3.175,2.85)
  silkscreen extent -5.42,-2.72 5,1.1, body extent -4.9,-2.87 4.9,2.93, height 1.75
SOIC127P1030-16N [mm] "SOIC, 16-Leads, Body 10.3x7.5mm, Pitch 1.27mm, IPC Medium Density"
  rrect50% 2.3x0.6 smd: 1(-4.55,4.445) 2(-4.55,3.175) 3(-4.55,1.905) 4(-4.55,0.635) 5(-4.55,-0.635) 6(-4.55,-1.905) 7(-4.55,-3.175) 8(-4.55,-4.445) 9(4.55,-4.445) 10(4.55,-3.175) 11(4.55,-1.905) 12(4.55,-0.635) 13(4.55,0.635) 14(4.55,1.905) 15(4.55,3.175) 16(4.55,4.445)
  silkscreen extent -4.67,-5.25 3,5.42, body extent -4.9,-5.25 4.89,5.25, height 2.65
SOP65P780-20 [mm]
  rrect50% 0.45x2.15 smd mask+0: 1(-2.925,-3.275) 2(-2.275,-3.275) 4(-0.975,-3.275) 10(2.925,-3.275) 11(2.925,3.275) 13(1.625,3.275) 15(0.325,3.275) 17(-0.975,3.275)
  rrect50% 0.45x2.15 smd: 3(-1.625,-3.275) 5(-0.325,-3.275) 6(0.325,-3.275) 7(0.975,-3.275) 8(1.625,-3.275) 9(2.275,-3.275) 12(2.275,3.275) 14(0.975,3.275) 16(-0.325,3.275) 18(-1.625,3.275) 19(-2.275,3.275) 20(-2.925,3.275)
  silkscreen extent -3.8,-3.4 3.75,1.8, body extent -3.33,-3.33 3.43,3.28, height 1
SOT65P210X80-5N [mm] "SOT23, 5-Leads, Body 2.0x2.1mm (max), Pitch 0.65mm, IPC Medium Density"
  rrect50% 0.8x0.35 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0.65)
  silkscreen extent -1.07,-1 0.15,1.5, body extent -1.02,-0.99 0.9,0.99, height 0.57
SOT95P230-3C#1 [mm] "SOT23, 1=bottom-left, 2=bottom-right, 3=top"
  rect 0.9x0.95 smd: 1(-0.95,-1.25) 2(0.95,-1.25) 3(0,1.25)
  silkscreen extent -1.3,-0.38 1.3,1.25, body extent -1.14,-1.18 1.17,1.44, height 0.38
SOT95P230-3C#2 [mm] "SOT23, 1=bottom-left, 2=bottom-right, 3=top"
  rect 0.9x0.95 smd mask+0: 1(-0.95,-1.25)
  rect 0.9x0.95 smd: 2(0.95,-1.25) 3(0,1.25)
  silkscreen extent -1.3,-0.38 1.3,1.25, body extent -1.14,-1.18 1.17,1.44, height 0.38
SOT95P230-3D#1 [mm] "SOT23, 1=bottom-left, 2=top, 3=bottom-right"
  rect 0.9x0.95 smd mask+0: 1(-0.95,-1.25)
  rect 0.9x0.95 smd: 2(0,1.25) 3(0.95,-1.25)
  silkscreen extent -1.3,-0.38 1.3,1.25, body extent -1.14,-1.25 1.17,1.36, height 0.38
SOT95P230-3D#2 [mm] "SOT23, 1=bottom-left, 2=top, 3=bottom-right"
  rect 0.9x0.95 smd: 1(-0.95,-1.25) 2(0,1.25)
  rect 0.9x0.95 smd mask+0: 3(0.95,-1.25)
  silkscreen extent -1.3,-0.38 1.3,1.25, body extent -1.14,-1.25 1.17,1.36, height 0.38
SOT95P280-5 [mm] "SOT-23/SC-74A; 5 Leads; Body 3.1 x 3 mm, inc. leads (LxW max)33"
  rrect50% 0.6x1.3 smd: 1(-0.95,-1.4) 2(0,-1.4) 4(0.95,1.4)
  rrect50% 0.6x1.3 smd mask+0: 3(0.95,-1.4)
  rrect50% 0.6x1.25 smd: 5(-0.95,1.4)
  silkscreen extent -1.55,-0.9 1.55,0.9, body extent -1.45,-1.45 1.45,1.35, height 0.78
SOT143 [mm] "SOT-143; 4 Leads; Body 3 x 2.6 mm, inc. leads (LxW max)"
  rect 1.35x1.35 smd mask+0: 1(-0.75,-1.1)
  rect 0.9x1.35 smd: 2(0.95,-1.1) 3(0.95,1.1) 4(-0.95,1.1)
  silkscreen extent -1.88,-2.22 1.75,0.7, body extent -1.52,-1.5 1.51,1.46, height 0.8
SOT323-3AL [mm] "SOT323, 3-Leads, Body 2.0x1.3mm, Pitch 0.65mm, Lead Span 2.1mm, IPC High Density"
  rect 0.9x0.508 smd: 1(-0.9,0.65) 2(-0.9,-0.65) 3(0.9,0)
  silkscreen extent -1.02,-1.1 0.7,1.57, body extent -0.7,-1.1 0.7,1.1, height 1
SOT425-1 [mm] "LQFP128: plastic low profile quad flat package; 128 leads; body 14 x 20 x 1.4 mm"
  rrect50% 0.305x0.975 smd mask+0.05: 1(0,0) 2(0.5,0) 5(2,0) 6(2.5,0) 7(3,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 16(7.5,0) 18(8.5,0) 20(9.5,0) 21(10,0) 23(11,0) 25(12,0) 27(13,0) 28(13.5,0) 30(14.5,0) 32(15.5,0) 34(16.5,0) 35(17,0) 37(18,0) 38(18.5,0) 65(18.5,15.172) 66(18,15.172) 67(17.5,15.172) 68(17,15.172) 69(16.5,15.172) 70(16,15.172) 72(15,15.172) 73(14.5,15.172) 74(14,15.172) 75(13.5,15.172) 76(13,15.172) 77(12.5,15.172) 78(12,15.172) 80(11,15.172) 82(10,15.172) 83(9.5,15.172) 84(9,15.172) 85(8.5,15.172) 86(8,15.172) 87(7.5,15.172) 89(6.5,15.172) 91(5.5,15.172) 92(5,15.172) 93(4.5,15.172) 94(4,15.172) 95(3.5,15.172) 96(3,15.172) 97(2.5,15.172) 98(2,15.172) 100(1,15.172) 101(0.5,15.172) 102(0,15.172)
  rrect50% 0.305x0.975 smd mask+0: 3(1,0) 4(1.5,0) 8(3.5,0) 14(6.5,0) 15(7,0) 17(8,0) 19(9,0) 22(10.5,0) 24(11.5,0) 26(12.5,0) 29(14,0) 31(15,0) 33(16,0) 36(17.5,0) 71(15.5,15.172) 79(11.5,15.172) 81(10.5,15.172) 88(7,15.172) 90(6,15.172) 99(1.5,15.172)
  rrect50% 0.975x0.305 smd mask+0.05: 39(19.861,1.32) 40(19.861,1.82) 41(19.861,2.32) 42(19.861,2.82) 43(19.861,3.32) 45(19.861,4.32) 46(19.861,4.82) 47(19.861,5.32) 48(19.861,5.82) 49(19.861,6.32) 50(19.861,6.82) 51(19.861,7.32) 52(19.861,7.82) 54(19.861,8.82) 56(19.861,9.82) 57(19.861,10.32) 58(19.861,10.82) 59(19.861,11.32) 60(19.861,11.82) 61(19.861,12.32) 62(19.861,12.82) 64(19.861,13.82) 103(-1.35,13.82) 104(-1.35,13.32) 105(-1.35,12.82) 106(-1.35,12.32) 107(-1.35,11.82) 108(-1.35,11.32) 110(-1.35,10.32) 111(-1.35,9.82) 112(-1.35,9.32) 113(-1.35,8.82) 114(-1.35,8.32) 115(-1.35,7.82) 116(-1.35,7.32) 118(-1.35,6.32) 119(-1.35,5.82) 120(-1.35,5.32) 122(-1.35,4.32) 124(-1.35,3.32) 125(-1.35,2.82) 126(-1.35,2.32) 127(-1.35,1.82) 128(-1.35,1.32)
  rrect50% 0.975x0.305 smd mask+0: 44(19.861,3.82) 53(19.861,8.32) 55(19.861,9.32) 63(19.861,13.32) 109(-1.35,10.82) 117(-1.35,6.82) 121(-1.35,4.82) 123(-1.35,3.82)
  silkscreen extent -0.66,0.68 19.26,14.49, body extent -1.67,-0.34 20.2,15.54, height 1.61
STANDOFF_SOLDER_3MM#1 [mm] "Non-plated hole for 3mm Soldered Standoff"
  round 6 / inner round 5 / far side round 5 hole 3.15 mask+0.1: STAND(0,0)
  Top Layer lines w0.254: 3.3,0 cw(c0,0) -3.3,0 cw(c0,0) 3.3,0
  Top Layer lines w1: 2.2,0 cw(c0,0) -2.2,0 cw(c0,0) 2.2,0
  Bottom Layer lines w0.4: 3.3,3.3 -3.3,3.3 -3.3,-3.3 3.3,-3.3 3.3,3.3
  body extent -2.76,-2.76 2.74,2.74, height 8.5
STANDOFF_SOLDER_3MM#2 [mm] "Non-plated hole for 3mm Soldered Standoff"
  round 6 / inner round 5 / far side round 5 hole 3.15: STAND(0,0)
  Top Layer lines w0.254: 3.3,0 cw(c0,0) -3.3,0 cw(c0,0) 3.3,0
  Top Layer lines w1: 2.2,0 cw(c0,0) -2.2,0 cw(c0,0) 2.2,0
  Bottom Layer lines w0.635: 3.3,3.3 3.3,-3.3 -3.3,-3.3 -3.3,3.3 3.3,3.3
  body extent -2.76,-2.76 2.74,2.74, height 8.5
SW_DTSM-61NT/R#1 [mil] "Switch, Push Button, Thru-Hole; 4 Leads; Body 8.5 x 8.5 mm (LxW typ); Row Spacing 9.0 mm; Pitch 4.5 mm"
  rrect50% 57x45 smd: 1(157.87,-88.58) 2(-157.48,-88.58) 4(-157.48,88.19)
  rrect50% 57x45 smd mask+0: 3(157.87,88.19)
  silkscreen extent -124,-124 124,124, body extent -177,-122 177,122, height 177
SW_DTSM-61NT/R#2 [mil] "Switch, Push Button, Thru-Hole; 4 Leads; Body 8.5 x 8.5 mm (LxW typ); Row Spacing 9.0 mm; Pitch 4.5 mm"
  rrect50% 57x45 smd: 1(157.87,-88.58) 2(-157.48,-88.58)
  rrect50% 57x45 smd mask+0: 3(157.87,88.19) 4(-157.48,88.19)
  silkscreen extent -124,-124 124,124, body extent -177,-122 177,122, height 177
T8019L-TNQ [mm]
  round 3.048 hole 1.5: 1(0,20.142) 2(0,23.952) 3(0,27.762)
  oval 2.7x3.81 hole 1.6: S1(2.54,7.442) S2(-2.54,7.442)
  silkscreen extent -3.43,0 3.43,26.11, body extent -3.5,-8.38 3.5,28.01, height 13
TESTPIN#1 [mil]
  round 60 hole 35.43 mask+0: 1(0,0)
  silkscreen extent -41,-39 156,39
TESTPIN#2 [mil]
  round 60 hole 35.43: 1(0,0)
  silkscreen extent -41,-39 156,39
TESTPOINT_ARRAY [mil]
  round 62 hole 35.43 mask+0: 1(0,0) 3(200,0) 5(400,0) 27(2600,0) 29(2800,0) 31(3000,0)
  round 62 hole 35.43: 2(100,0) 4(300,0) 6(500,0) 7(600,0) 8(700,0) 9(800,0) 10(900,0) 11(1000,0) 12(1100,0) 13(1200,0) 14(1300,0) 15(1400,0) 16(1500,0) 17(1600,0) 18(1700,0) 19(1800,0) 20(1900,0) 21(2000,0) 22(2100,0) 23(2200,0) 24(2300,0) 25(2400,0) 26(2500,0) 28(2700,0) 30(2900,0) 32(3100,0) A1(0,700) A2(100,700) A3(200,700) A4(300,700) A5(400,700) A6(500,700) A7(600,700) A8(700,700) A9(800,700) A10(900,700) A11(1000,700) A12(1100,700) A13(1200,700) A14(1300,700) A15(1400,700) A16(1500,700) A17(1600,700) A18(1700,700) A19(1800,700) A20(1900,700) A21(2000,700) A22(2100,700) A23(2200,700) A24(2300,700) A25(2400,700) A26(2500,700) A27(2600,700) A28(2700,700) A29(2800,700) A30(2900,700) A31(3000,700) A32(3100,700) B1(0,600) B2(100,600) B3(200,600) B4(300,600) B5(400,600) B6(500,600) B7(600,600) B8(700,600) B9(800,600) B10(900,600) B11(1000,600) B12(1100,600) B13(1200,600) B14(1300,600) B15(1400,600) B16(1500,600) B17(1600,600) B18(1700,600) B19(1800,600) B20(1900,600) B21(2000,600) B22(2100,600) B23(2200,600) B24(2300,600) B25(2400,600) B26(2500,600) B27(2600,600) B28(2700,600) B29(2800,600) B30(2900,600) B31(3000,600) B32(3100,600) C1(0,500) C2(100,500) C3(200,500) C4(300,500) C5(400,500) C6(500,500) C7(600,500) C8(700,500) C9(800,500) C10(900,500) C11(1000,500) C12(1100,500) C13(1200,500) C14(1300,500) C15(1400,500) C16(1500,500) C17(1600,500) C18(1700,500) C19(1800,500) C20(1900,500) C21(2000,500) C22(2100,500) C23(2200,500) C24(2300,500) C25(2400,500) C26(2500,500) C27(2600,500) C28(2700,500) C29(2800,500) C30(2900,500) C31(3000,500) C32(3100,500) D1(0,400) D2(100,400) D3(200,400) D4(300,400) D5(400,400) D6(500,400) D7(600,400) D8(700,400) D9(800,400) D10(900,400) D11(1000,400) D12(1100,400) D13(1200,400) D14(1300,400) D15(1400,400) D16(1500,400) D17(1600,400) D18(1700,400) D19(1800,400) D20(1900,400) D21(2000,400) D22(2100,400) D23(2200,400) D24(2300,400) D25(2400,400) D26(2500,400) D27(2600,400) D28(2700,400) D29(2800,400) D30(2900,400) D31(3000,400) D32(3100,400) E1(0,300) E2(100,300) E3(200,300) E4(300,300) E5(400,300) E6(500,300) E7(600,300) E8(700,300) E9(800,300) E10(900,300) E11(1000,300) E12(1100,300) E13(1200,300) E14(1300,300) E15(1400,300) E16(1500,300) E17(1600,300) E18(1700,300) E19(1800,300) E20(1900,300) E21(2000,300) E22(2100,300) E23(2200,300) E24(2300,300) E25(2400,300) E26(2500,300) E27(2600,300) E28(2700,300) E29(2800,300) E30(2900,300) E31(3000,300) E32(3100,300) F1(0,200) F2(100,200) F3(200,200) F4(300,200) F5(400,200) F6(500,200) F7(600,200) F8(700,200) F9(800,200) F10(900,200) F11(1000,200) F12(1100,200) F13(1200,200) F14(1300,200) F15(1400,200) F16(1500,200) F17(1600,200) F18(1700,200) F19(1800,200) F20(1900,200) F21(2000,200) F22(2100,200) F23(2200,200) F24(2300,200) F25(2400,200) F26(2500,200) F27(2600,200) F28(2700,200) F29(2800,200) F30(2900,200) F31(3000,200) F32(3100,200) G1(0,100) G2(100,100) G3(200,100) G4(300,100) G5(400,100) G6(500,100) G7(600,100) G8(700,100) G9(800,100) G10(900,100) G11(1000,100) G12(1100,100) G13(1200,100) G14(1300,100) G15(1400,100) G16(1500,100) G17(1600,100) G18(1700,100) G19(1800,100) G20(1900,100) G21(2000,100) G22(2100,100) G23(2200,100) G24(2300,100) G25(2400,100) G26(2500,100) G27(2600,100) G28(2700,100) G29(2800,100) G30(2900,100) G31(3000,100) G32(3100,100) H1(0,800) H2(100,800) H3(200,800) H4(300,800) H5(400,800) H6(500,800) H7(600,800) H8(700,800) H9(800,800) H10(900,800) H11(1000,800) H12(1100,800) H13(1200,800) H14(1300,800) H15(1400,800) H16(1500,800) H17(1600,800) H18(1700,800) H19(1800,800) H20(1900,800) H21(2000,800) H22(2100,800) H23(2200,800) H24(2300,800) H25(2400,800) H26(2500,800) H27(2600,800) H28(2700,800) H29(2800,800) H30(2900,800) H31(3000,800) H32(3100,800)
  silkscreen extent -136,-149 3234,958
TO254P-3N [mm] "D2-PAK, 3-Pads, IPC Medium Density"
  rrect50% 3x1.3 smd: 1(-6.35,2.54) 2(-6.35,0) 3(-6.35,-2.54)
  Top Layer region: 9.252,5.949 9.252,-6.051 -4.64,-6.051 -4.64,5.949
  silkscreen extent -8.73,-6.05 9.27,5.95, body extent -7.34,-5.09 8.1,5.08, height 2.53
TO-263-2 [mm]
  rrect50% 1x3.4 smd: 1(-3.4,0) 2(-1.7,0) 4(1.7,0) 5(3.4,0)
  rrect50% 1x3.4 smd mask+0: 3(0,0)
  Top Layer region: -5.949,15.619 6.051,15.619 6.051,2.032 -5.949,2.032
  silkscreen extent -5.95,-2.38 6.05,15.62, body extent -5.11,-0.87 5.05,13.77, height 4.57
TRC-005#1 [mm] "RCA Phono Jack, Right Angle, Thru-Hole, Body 20.8 x 9.8 x 11 mm (LxWxH)"
  rrect50% 3.2x4 hole 1.3 slot 2.5 at 90 deg: 1(-7,0)
  rrect50% 3.556x2.032 hole 1 slot 2.5 at 0 deg: 2(-2.3,5.1) 3(-2.3,-5.1)
  rrect50% 3.2x4 hole 1 slot 2.5 at 90 deg: 4(0,0)
  silkscreen extent -20.05,-4.9 0.75,4.9, body extent -20.02,-5.26 0.48,5.52, height 13.58
TRC-005#2 [mm] "RCA Phono Jack, Right Angle, Thru-Hole, Body 20.8 x 9.8 x 11 mm (LxWxH)"
  rrect50% 3.2x4 hole 1.3 slot 2.5 at 90 deg mask+0: 1(-7,0)
  rrect50% 3.556x2.032 hole 1 slot 2.5 at 0 deg: 2(-2.3,5.1) 3(-2.3,-5.1)
  rrect50% 3.2x4 hole 1 slot 2.5 at 90 deg: 4(0,0)
  silkscreen extent -20.05,-4.9 0.75,4.9, body extent -20.02,-5.26 0.48,5.52, height 13.58
TSH-3675 [mm]
  oval 3x1.6 hole 0.6 slot 2 at 0 deg: 1(-0.2,3.85) 2(6.3,-3.85)
  oval 2.5x1.6 hole 0.6 slot 1.5 at 0 deg: 3(6,3.85) 10(1.9,-3.85) 11(3.1,3.85)
  round 1.3 hole 1.6 unplated: 12(6,0) 13(0,0)
  silkscreen extent -6,-4.75 9,4.75, body extent -5.97,-4.72 9.02,4.78, height 5
TSM-105-01-DV [mil] "SMT 100mil space smt pin header"
  rect 50x125 smd: 1(0,-215)
  rrect50% 50x125 smd: 2(0,0) 3(100,-215) 4(100,0) 5(200,-215) 6(200,0) 7(300,-215) 8(300,0) 10(400,0)
  rrect50% 50x125 smd mask+0: 9(400,-215)
  round 59.05 hole 59.06 unplated mask+1.5: PEGA(50,-108) PEGB(350,-108)
  silkscreen extent -35,-287 435,73, body extent -52,-253 448,37, height 10
TSOP65P640-14AN [mm] "TSOP, 14-Leads, Body 5x4.4mm, Pitch 0.65mm, IPC Medium Density"
  rrect50% 1.7x0.35 smd: 1(-2.85,1.95) 2(-2.85,1.3) 3(-2.85,0.65) 4(-2.85,0) 5(-2.85,-0.65) 6(-2.85,-1.3) 8(2.85,-1.95) 9(2.85,-1.3) 10(2.85,-0.65) 11(2.85,0) 12(2.85,0.65) 13(2.85,1.3) 14(2.85,1.95)
  rrect50% 1.7x0.35 smd mask+0: 7(-2.85,-1.95)
  silkscreen extent -2.97,-2.55 1.6,2.8, body extent -3.05,-2.53 3.34,2.47, height 0.64
TSOP65P640-16AN [mm] "TSOP, 16-Leads, Body 5x4.4mm, Pitch 0.65mm, IPC Medium Density"
  rrect50% 1.7x0.35 smd: 1(-2.85,2.275) 2(-2.85,1.625) 3(-2.85,0.975) 4(-2.85,0.325) 5(-2.85,-0.325) 9(2.85,-2.275) 10(2.85,-1.625) 11(2.85,-0.975) 12(2.85,-0.325) 13(2.85,0.325) 14(2.85,0.975) 15(2.85,1.625) 16(2.85,2.275)
  rrect50% 1.7x0.35 smd mask+0: 6(-2.85,-0.975) 7(-2.85,-1.625) 8(-2.85,-2.275)
  silkscreen extent -2.97,-2.55 1.6,3.12, body extent -3.3,-2.38 3.37,2.77, height 0.64
TSOP80P1176-44 [mm]
  rrect50% 0.508x1.4 smd: 1(-8.4,-5.7) 2(-7.6,-5.7) 3(-6.8,-5.7) 4(-6,-5.7) 5(-5.2,-5.7) 6(-4.4,-5.7) 7(-3.6,-5.7) 8(-2.8,-5.7) 9(-2,-5.7) 10(-1.2,-5.7) 11(-0.4,-5.7) 13(1.2,-5.7) 14(2,-5.7) 15(2.8,-5.7) 16(3.6,-5.7) 17(4.4,-5.7) 18(5.2,-5.7) 19(6,-5.7) 20(6.8,-5.7) 21(7.6,-5.7) 22(8.4,-5.7) 23(8.4,5.7) 24(7.6,5.7) 25(6.8,5.7) 26(6,5.7) 27(5.2,5.7) 28(4.4,5.7) 29(3.6,5.7) 30(2.8,5.7) 31(2,5.7) 32(1.2,5.7) 33(0.4,5.7) 35(-1.2,5.7) 36(-2,5.7) 37(-2.8,5.7) 38(-3.6,5.7) 39(-4.4,5.7) 40(-5.2,5.7) 41(-6,5.7) 42(-6.8,5.7) 43(-7.6,5.7) 44(-8.4,5.7)
  rrect50% 0.508x1.4 smd mask+0: 12(0.4,-5.7) 34(-0.4,5.7)
  silkscreen extent -9.29,-5.7 9.26,4.45, body extent -9.24,-5.95 9.26,5.84, height 1
TSOP80P1176-54 [mm] "Plastic Small Outline; 54 Leads; Body Width 10.16 mm"
  rrect50% 0.508x1.4 smd: 1(-10.4,-5.7) 2(-9.6,-5.7) 3(-8.8,-5.7) 4(-8,-5.7) 5(-7.2,-5.7) 7(-5.6,-5.7) 8(-4.8,-5.7) 9(-4,-5.7) 10(-3.2,-5.7) 11(-2.4,-5.7) 13(-0.8,-5.7) 14(0,-5.7) 15(0.8,-5.7) 16(1.6,-5.7) 17(2.4,-5.7) 18(3.2,-5.7) 19(4,-5.7) 20(4.8,-5.7) 21(5.6,-5.7) 22(6.4,-5.7) 23(7.2,-5.7) 24(8,-5.7) 25(8.8,-5.7) 26(9.6,-5.7) 27(10.4,-5.7) 29(9.6,5.7) 30(8.8,5.7) 31(8,5.7) 32(7.2,5.7) 33(6.4,5.7) 34(5.6,5.7) 35(4.8,5.7) 36(4,5.7) 37(3.2,5.7) 38(2.4,5.7) 39(1.6,5.7) 40(0.8,5.7) 42(-0.8,5.7) 43(-1.6,5.7) 44(-2.4,5.7) 45(-3.2,5.7) 47(-4.8,5.7) 48(-5.6,5.7) 49(-6.4,5.7) 50(-7.2,5.7) 51(-8,5.7) 53(-9.6,5.7)
  rrect50% 0.508x1.4 smd mask+0: 6(-6.4,-5.7) 12(-1.6,-5.7) 28(10.4,5.7) 41(0,5.7) 46(-4,5.7) 52(-8.8,5.7) 54(-10.4,5.7)
  silkscreen extent -11.33,-5.67 11.15,4.4, body extent -11.23,-5.96 11.19,5.97, height 1
TSOP95P275-6 [mm]
  rrect50% 0.7x1 smd: 1(-0.95,-1.2) 3(0.95,-1.2) 4(0.95,1.2) 5(0,1.2) 6(-0.95,1.2)
  rrect50% 0.7x1 smd mask+0: 2(0,-1.2)
  silkscreen extent -1.87,-1.32 1.5,0.7, body extent -1.49,-1.3 1.51,1.3, height 0.8
TSQFP50P900X900-48 [mm]
  rrect50% 1.5x0.305 smd: 1(-4.25,2.75) 2(-4.25,2.25) 3(-4.25,1.75) 4(-4.25,1.25) 5(-4.25,0.75) 6(-4.25,0.25) 7(-4.25,-0.25) 8(-4.25,-0.75) 9(-4.25,-1.25) 10(-4.25,-1.75) 12(-4.25,-2.75) 25(4.25,-2.75) 26(4.25,-2.25) 27(4.25,-1.75) 28(4.25,-1.25) 30(4.25,-0.25) 31(4.25,0.25) 32(4.25,0.75) 33(4.25,1.25) 34(4.25,1.75) 36(4.25,2.75)
  rrect50% 1.5x0.305 smd mask+0: 11(-4.25,-2.25) 29(4.25,-0.75) 35(4.25,2.25)
  rrect50% 0.305x1.5 smd: 13(-2.75,-4.25) 14(-2.25,-4.25) 15(-1.75,-4.25) 16(-1.25,-4.25) 18(-0.25,-4.25) 19(0.25,-4.25) 20(0.75,-4.25) 21(1.25,-4.25) 22(1.75,-4.25) 23(2.25,-4.25) 24(2.75,-4.25) 37(2.75,4.25) 38(2.25,4.25) 39(1.75,4.25) 41(0.75,4.25) 42(0.25,4.25) 44(-0.75,4.25) 46(-1.75,4.25) 47(-2.25,4.25) 48(-2.75,4.25)
  rrect50% 0.305x1.5 smd mask+0: 17(-0.75,-4.25) 40(1.25,4.25) 43(-0.25,4.25) 45(-1.25,4.25)
  silkscreen extent -4.75,-4 4,4, body extent -4.04,-4.14 4.01,4.24, height 0.85
TSQFP50P900X900_HS-48 [mm]
  rrect50% 1.5x0.305 smd: 1(-4.25,2.75) 2(-4.25,2.25) 3(-4.25,1.75) 4(-4.25,1.25) 5(-4.25,0.75) 6(-4.25,0.25) 7(-4.25,-0.25) 8(-4.25,-0.75) 9(-4.25,-1.25) 10(-4.25,-1.75) 12(-4.25,-2.75) 26(4.25,-2.25) 27(4.25,-1.75) 28(4.25,-1.25) 29(4.25,-0.75) 30(4.25,-0.25) 31(4.25,0.25) 32(4.25,0.75) 33(4.25,1.25) 34(4.25,1.75) 35(4.25,2.25) 36(4.25,2.75)
  rrect50% 1.5x0.305 smd mask+0: 11(-4.25,-2.25) 25(4.25,-2.75)
  rrect50% 0.305x1.5 smd: 13(-2.75,-4.25) 14(-2.25,-4.25) 15(-1.75,-4.25) 16(-1.25,-4.25) 17(-0.75,-4.25) 18(-0.25,-4.25) 19(0.25,-4.25) 20(0.75,-4.25) 21(1.25,-4.25) 22(1.75,-4.25) 23(2.25,-4.25) 24(2.75,-4.25) 37(2.75,4.25) 38(2.25,4.25) 39(1.75,4.25) 40(1.25,4.25) 41(0.75,4.25) 43(-0.25,4.25) 44(-0.75,4.25) 45(-1.25,4.25)
  rrect50% 0.305x1.5 smd mask+0: 42(0.25,4.25) 46(-1.75,4.25) 47(-2.25,4.25) 48(-2.75,4.25)
  Top Layer region: -2.25,2.25 2.25,2.25 2.25,-2.25 -2.25,-2.25
  silkscreen extent -4.75,-4 4,4, body extent -4.07,-4.14 3.98,4.24, height 0.8