# Altium PCB NB3000AL.PcbDoc (part 12 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ADC.DOUT: U8.L3 U24.9 | length 4895.4
  Top Layer w4: v1(1823.52,5435.04) 1858.15,5435.04 1873.52,5419.67 1873.52,5335.31 1863.52,5325.31 U24.9@1824.29,5325.31 ; v1@1827.41,5431.15 cw(c1836.8,5421.76) 1836.8,5435.04 cw(c1836.8,5448.32) v1@1827.41,5438.93 ; v1@1830.24,5428.32 cw(c1846.46,5412.11) 1846.46,5435.04 cw(c1846.46,5457.98) v1@1830.24,5441.76 ; U24.9@1854.58,5322.49 cw(c1861.41,5315.66) 1861.41,5325.31 cw(c1861.41,5334.97) U24.9@1854.58,5328.14 ; v1@4556.5,4506 ccw(c4533.56,4506) 4549.78,4522.22 ccw(c4566,4538.43) v1@4566,4515.5 ; v1@4560.5,4506 ccw(c4547.22,4506) 4556.61,4515.39 ccw(c4566,4524.78) v1@4566,4511.5 ; v1(4566,4506) 4546.96,4525.04 4456.86,4525.04 4440.19,4508.37 4440.19,4459.06 4467.5,4431.75 4467.5,4422.75 ; U8.L3@4929.9,4327.79 ccw(c4912.18,4327.79) 4924.71,4340.33 ; U8.L3@4937.24,4335.14 cw(c4937.24,4352.86) 4924.71,4340.33 ; 4467.5,4422.75 4480.25,4410 ; 4467.5,4422.75 4480.25,4410 ; 4480.25,4410 4494.5,4410 4500,4415.5 4625.18,4415.5 4632.28,4422.59 4720.22,4422.59 4737.05,4405.77 4748.92,4405.77 4803.03,4351.66 4838.82,4351.66 4897.36,4351.66 cw(c4897.36,4312.98) 4924.71,4340.33
  MidLayer2 w4: v1@1823.52,5433.37 v1(1823.52,5435.04) 1937.77,5435.04 1945,5427.81 2444.72,5427.81 2449.45,5432.54 2824.97,5432.54 3010.51,5247 3120.29,5247 3128.29,5255 3210,5255 3331.63,5133.37 4256.86,5133.37 4340.19,5050.04 4365,5050.04 ; v1@1827.41,5431.15 cw(c1836.8,5421.76) 1836.8,5435.04 cw(c1836.8,5448.32) v1@1827.41,5438.93 ; v1@1830.24,5428.32 cw(c1846.46,5412.11) 1846.46,5435.04 cw(c1846.46,5457.98) v1@1830.24,5441.76 ; v1(4566,4506) 4566,4507.56 4566,4509.18 4581.86,4525.04 ; v1@4566,4515.5 ccw(c4566,4530.75) 4576.78,4519.97 ; v1@4571.47,4506.57 cw(c4586.85,4508.17) 4575.92,4519.1 ; v1@4575.45,4506.98 cw(c4597.61,4509.28) 4581.86,4525.04 ; 4365,5050.04 4380.29,5050.04 ; 4365,5050.04 4380.29,5050.04 ; 4380.29,5050.04 4409.71,5050.04 ; 4409.71,5050.04 4503.65,5050.04 ; 4409.71,5050.04 4503.65,5050.04 ; 4503.65,5050.04 4541.27,5050.04 4612.36,4978.96 4612.36,4941.33 4612.36,4824.71 4601.36,4813.71 4601.36,4783.89 4604,4781.25 4604,4781 4605.36,4779.64 4605.36,4774.89 4605.36,4737.05 4605.36,4656.63 4603.02,4654.29 4603.02,4635.29 4611.34,4626.98 4632.69,4605.62 4632.69,4589.37 4653.5,4568.56 4653.5,4547.44 ; 4581.86,4525.04 4589.32,4532.5 4638.56,4532.5 ; 4638.56,4532.5 4653.5,4547.44 ; 4638.56,4532.5 4653.5,4547.44
ADCDAC_3V3: NT17.1 U24.2 U25.6 U28.1 U28.7 U29.6 | length 3385.2
  Top Layer w4: v1@841.81,5231.76 ccw(c825.59,5247.98) 848.52,5247.98 ccw(c871.46,5247.98) v1@855.24,5231.76 ; v1@844.64,5228.93 ccw(c835.25,5238.32) 848.52,5238.32 ccw(c861.8,5238.32) v1@852.41,5228.93 ; v1(848.52,5225.04) 848.52,5266.67 840.19,5275 840.19,5372 848.19,5380 ; U29.6@854.04,5376.81 ccw(c848.19,5373.03) 848.19,5380 ; U29.6@854.04,5383.19 cw(c848.19,5386.96) 848.19,5380 ; U29.6@867.83,5380 848.19,5380
  Top Layer w12: U28.1@509.29,5399.37 572.8,5399.37 631.86,5340.31 U28.7@670.71,5340.31 719.69,5340.31 723.52,5336.48 723.52,5201.04 v1(757.86,5166.71) ; 623.81,5348.37 ccw(c643.24,5367.81) U28.7@643.24,5340.32 ; v1@752.36,5166.71 ccw(c739.08,5166.71) 748.47,5176.1 ccw(c757.86,5185.49) v1@757.86,5172.21 ; U24.2@1985.71,5325.31 2023.84,5325.31 2040,5309.15 2040,5216.52 v1(2019.19,5195.71) ; v1@2019.19,5201.21 ccw(c2019.19,5214.49) 2028.58,5205.1 ccw(c2037.97,5195.71) v1@2024.69,5195.71 ; 2029.17,5319.98 ccw(c2015.84,5306.65) 2013.17,5325.31 cw(c2013.17,5299.56) 2031.38,5317.77 ; U25.6@2307.83,5370 v2(2350,5370) ; v2@2345.89,5365.89 ccw(c2335.97,5355.97) 2335.97,5370 ccw(c2335.97,5384.03) v2@2345.89,5374.11
  MidLayer1 w12: v2@1900.89,5365.89 cw(c1890.97,5355.97) 1905,5355.97 cw(c1919.03,5355.97) v2@1909.11,5365.89 ; v2(1905,5370) 1905,5273.97 1928.36,5250.61 1928.36,5121.54 v1(1906.86,5100.04) ; v1@1906.86,5105.54 ccw(c1906.86,5118.82) 1916.25,5109.43 ccw(c1925.64,5100.04) v1@1912.36,5100.04 ; 1929.06,5195.71 v1(2019.19,5195.71) ; v1@2015.3,5191.82 ccw(c2005.91,5182.43) 2005.91,5195.71 ccw(c2005.91,5208.99) v1@2015.3,5199.6
  MidLayer2 w12: v2(1905,5370) v2(2350,5370) ; v2@1909.11,5365.89 cw(c1919.03,5355.97) 1919.03,5370 cw(c1919.03,5384.03) v2@1909.11,5374.11 ; v2@2345.89,5365.89 ccw(c2335.97,5355.97) 2335.97,5370 ccw(c2335.97,5384.03) v2@2345.89,5374.11
  Bottom Layer w12: v1(757.86,5166.71) 848.52,5166.71 ; v1@761.75,5162.82 cw(c771.14,5153.43) 771.14,5166.71 cw(c771.14,5179.99) v1@761.75,5170.6 ; v1@844.64,5221.15 cw(c835.25,5211.76) 848.52,5211.76 cw(c861.8,5211.76) v1@852.41,5221.15 ; v1(848.52,5225.04) 848.52,5166.71 ; NT17.1@1773.56,5097.98 cw(c1760.44,5083.38) 1780.08,5083.38 cw(c1799.72,5083.38) NT17.1@1786.59,5097.98 ; NT17.1@1797.22,5098.34 cw(c1813.86,5081.7) 1813.86,5105.24 cw(c1813.86,5128.77) NT17.1@1797.22,5112.13 ; v1@1902.97,5096.15 ccw(c1893.58,5086.76) 1893.58,5100.04 ccw(c1893.58,5113.32) v1@1902.97,5103.93 ; v1(1906.86,5100.04) 1864.96,5100.04 1859.76,5105.24 NT17.1@1780.08,5105.24 1780.08,5071.08 1764,5055 1275,5055 1163.29,5166.71 848.52,5166.71
AGND: C101.2 C102.2 C103.2 C104.2 C117.2 C118.2 C119.2 C120.2 J13.6 J15.6 NT11.1 NT19.1 U24.3 U25.2 U28.6 U29.2 | length 2461.8
  Top Layer w4: v1@189.61,5313.28 cw(c173.4,5297.06) 196.33,5297.06 cw(c219.27,5297.06) v1@203.05,5313.28 ; v1@189.61,5386.72 ccw(c173.4,5402.93) 196.33,5402.93 ccw(c219.27,5402.93) v1@203.05,5386.72 ; C120.2@192.22,5289.11 ccw(c182.3,5299.03) 196.33,5299.03 ccw(c210.36,5299.03) C120.2@200.44,5289.11 ; C117.2@192.22,5410.89 cw(c182.3,5400.97) 196.33,5400.97 cw(c210.36,5400.97) C117.2@200.44,5410.89 ; v1@192.44,5316.11 cw(c183.05,5306.72) 196.33,5306.72 cw(c209.61,5306.72) v1@200.22,5316.11 ; v1@192.44,5383.89 ccw(c183.05,5393.28) 196.33,5393.28 ccw(c209.61,5393.28) v1@200.22,5383.89 ; C120.2@196.33,5285 v1(196.33,5320) ; v1(196.33,5380) C117.2@196.33,5415 ; v1@763.28,5398.28 cw(c747.06,5382.06) 770,5382.06 cw(c792.93,5382.06) v1@776.72,5398.28 ; v1@766.11,5401.11 cw(c756.72,5391.72) 770,5391.72 cw(c783.28,5391.72) v1@773.89,5401.11 ; v1(770,5405) 770,5360 775.59,5354.41 ; U29.2@780.19,5354.41 U29.2@795,5354.41 775.59,5354.41 ; U29.2@781.15,5351.32 ccw(c775.59,5347.87) 775.59,5354.41 ; U29.2@781.15,5357.5 cw(c775.59,5360.95) 775.59,5354.41 ; C104.2@2530.2,5415 C104.2@2531.86,5416.66
  Top Layer w12: U28.6@670.71,5320.63 670.71,5304.29 670.71,5284.29 675,5280 v1(695,5280) ; v1@691.11,5276.11 ccw(c681.72,5266.72) 681.72,5280 ccw(c681.72,5293.28) v1@691.11,5283.89 ; C119.2@1199.56,5289.11 ccw(c1189.64,5299.03) 1203.67,5299.03 ccw(c1217.7,5299.03) 1207.78,5289.11 ccw(c1217.7,5299.03) 1217.7,5285 ccw(c1217.7,5270.97) C119.2@1207.78,5280.89 ; C118.2@1199.56,5410.89 cw(c1189.64,5400.97) 1203.67,5400.97 cw(c1217.7,5400.97) C118.2@1207.78,5410.89 ; v1@1199.78,5346.11 cw(c1190.39,5336.72) 1203.67,5336.72 cw(c1216.95,5336.72) v1@1207.56,5346.11 ; v1@1199.78,5353.89 ccw(c1190.39,5363.28) 1203.67,5363.28 ccw(c1216.95,5363.28) v1@1207.56,5353.89 ; C118.2@1203.67,5415 C119.2@1203.67,5285 1230.48,5285 v1(1245.52,5300.04) ; U24.3@1985.71,5345 v2(2035,5345) ; v2@2030.89,5340.89 ccw(c2020.97,5330.97) 2020.97,5345 ccw(c2020.97,5359.03) v2@2030.89,5349.11 ; v1@2161.11,5308.89 ccw(c2151.72,5318.28) 2165,5318.28 ccw(c2178.28,5318.28) v1@2168.89,5308.89 ; v1(2165,5305) 2165,5335 2174.41,5344.41 U25.2@2235,5344.41 ; C103.2@2422.43,5264.11 ccw(c2412.51,5274.03) 2426.54,5274.03 ccw(c2440.56,5274.03) 2430.64,5264.11 ccw(c2441.02,5274.49) 2441.02,5259.81 ; C101.2@2422.43,5410.89 cw(c2380,5368.46) 2440,5368.46 ; C103.2@2425,5260 2425.19,5259.81 C103.2@2426.54,5259.81 ; C101.2@2425.87,5409.23 cw(c2424.04,5393.37) 2440,5393.37 ; C103.2@2430.64,5255.89 cw(c2440.1,5246.43) 2440.1,5259.81 ; C101.2@2430.64,5410.89 cw(c2440.56,5400.97) 2440.56,5415 cw(c2440.56,5429.03) C101.2@2430.64,5419.11 ; C101.2@2430.91,5419.38 cw(c2408.97,5397.43) 2440,5397.43 ; C101.2@2432.34,5414.81 ccw(c2452.6,5414.13) 2438.27,5399.8 ; v1@2495.92,5255.92 ccw(c2486.53,5246.53) 2486.53,5259.81 ccw(c2486.53,5273.09) v1@2495.92,5263.7 ; v1(2499.81,5259.81) C103.2@2426.54,5259.81 ; v1@2499.81,5260 C102.2@2530.2,5260 ; v1@2503.7,5255.92 cw(c2513.55,5246.07) 2513.55,5260 ; v1@2503.7,5263.7 ccw(c2512.63,5272.63) 2512.63,5260 ; C104.2@2526.09,5410.89 ccw(c2516.17,5400.97) 2516.17,5415 ccw(c2516.17,5429.03) C104.2@2526.09,5419.11 ; C104.2@2530.2,5415 C101.2@2426.54,5415 2426.54,5411.54 2440,5398.07 2440,5345 2426.54,5331.54 C103.2@2426.54,5260 C103.2@2426.54,5259.81
  Bottom Layer w4: v1@690,5275 v1(695,5280)
  Bottom Layer w12: v1@1241.64,5296.15 cw(c1232.25,5286.76) 1245.52,5286.76 cw(c1258.8,5286.76) v1@1249.41,5296.15 ; v1(1245.52,5300.04) 1245.52,5108.49 1280,5074.02 1583.97,5074.02 1595.08,5085.12 ; NT19.1@1589.04,5097.59 cw(c1579.2,5085.12) 1595.08,5085.12 ; NT19.1@1601.12,5097.59 ccw(c1610.96,5085.12) 1595.08,5085.12 ; NT19.1@1615.08,5105.24 cw(c1663.36,5105.24) 1629.22,5139.38 ; v1@1640.92,5215.92 cw(c1631.07,5206.07) 1645,5206.07 ; v1@1640.92,5223.7 ccw(c1631.07,5233.55) v1@1645,5233.55 ; v1@1640.92,5235.92 cw(c1631.07,5226.07) v1@1645,5226.07 ; 1645,5206.99 cw(c1657.63,5206.99) v1@1648.7,5215.92 ; v1@1645,5226.99 cw(c1657.63,5226.99) v1@1648.7,5235.92 ; v1@1645,5232.63 ccw(c1657.63,5232.63) v1@1648.7,5223.7 ; v1@1645,5240 1645,5239.81 1645,5219.81 1645,5155.16 NT19.1@1595.08,5105.24 1595.08,5085.12
  other v1: 1644.81,5219.81 1644.81,5239.81 1203.67,5350
ATE.AUDIO.AMP_L: C11.2 J7.2 J7.10 | length 5390.5
  Top Layer w4: v1(-159.81,3559.86) -159.81,3305 -121.52,3266.71 83.29,3266.71 281.86,3068.14 281.86,1811.92 225,1755.06 225,1410 v1(355,1280)
  Bottom Layer w4: C11.2@-224.78,3620.89 cw(c-234.7,3610.97) -220.67,3610.97 cw(c-206.64,3610.97) C11.2@-216.56,3620.89 ; C11.2@-220.67,3625 -220.67,3574.71 -205.82,3559.86 v1(-159.81,3559.86) ; v1(355,1280) 355,1283.15 371.8,1299.95 755.05,1299.95 885,1170 1810,1170 1968.43,1011.57 J7.2@1968.43,388.03 J7.10@1968.43,214.8 ; J7.10@1958.88,242.06 ccw(c1935.84,265.1) 1968.43,265.1 ccw(c2001.01,265.1) J7.10@1977.97,242.06
ATE.AUDIO.AMP_R: C14.2 J7.3 J7.11 | length 6462.6
  MidLayer1 w4: v1(-156.5,4095) -218.14,4033.36 -218.14,3858.14 -185,3825 -185,3686.31 -301.31,3570 -301.31,3394.95 -490,3206.26 -490,3060 -517.69,3032.31 -517.69,2499.07 -350.34,2331.71 -321.71,2331.71 -80.92,2090.92 ; -80.88,2090.92 169.08,2090.92 230,2030 v1(230,1285)
  Bottom Layer w4: C14.2@-179.33,4073.18 -165,4073.18 ; C14.2@-170.18,4069.63 cw(c-165,4067.62) -165,4073.18 ; C14.2@-170.18,4076.73 ccw(c-165,4078.74) -165,4073.18 ; v1(-156.5,4095) -156.5,4081.68 -165,4073.18 ; v1(230,1285) 280,1335 865,1335 965,1235 1880,1235 2271.57,843.43 J7.3@2271.57,376.22 J7.11@2271.57,262.05 ; J7.11@2262.03,289.31 ccw(c2238.99,312.35) 2271.57,312.35 ccw(c2304.16,312.35) J7.11@2281.12,289.31 ; J7.3@2262.03,348.96 cw(c2238.99,325.92) 2271.57,325.92 cw(c2304.16,325.92) J7.3@2281.12,348.96
ATE.AUDIO.HP_L: C106.2 J6.2 J33.B6 R140.2 | length 7306.5
  MidLayer1 w4: v1(-235,4925) -235,4887.05 -193.47,4845.52 -159.48,4845.52 -101.48,4903.52 -101.48,5000 -126.48,5025 -126.48,5103.52 v1(-125,5105)
  MidLayer2 w4: v1@-678.57,4053.56 v1(-675,4050) -715,4050 -730,4035 -730,3955 -713.88,3938.88 -676.12,3938.88 -666.29,3929.04 -569.04,3929.04 -525,3885 -525,3800 -588,3737 -693,3737 -723,3707 -723,2338 -683,2298 -588,2298 -565,2275 -565,1750 -580,1735 -580,1605 -556.59,1581.59 -399.97,1581.59 -308.38,1490 -120,1490 125,1245 125,475 211.97,388.03 J6.2@753.43,388.03 ; J6.2@743.88,378.49 ccw(c720.84,355.45) 720.84,388.03 ccw(c720.84,420.61) J6.2@743.88,397.57
  Bottom Layer w4: J33.B6@-785.98,4070.18 -695.18,4070.18 ; J33.B6@-710.59,4065.9 cw(c-702.62,4060.63) -702.62,4070.18 cw(c-702.62,4079.74) J33.B6@-710.59,4074.47 ; J33.B6@-707.26,4063.69 cw(c-695.18,4055.72) -695.18,4070.18 ; -648.5,4067.31 -630,4067.31 ; C106.2@-261.05,4820.26 cw(c-277.31,4793.39) -245.91,4793.39 cw(c-214.5,4793.39) C106.2@-230.76,4820.26 ; C106.2@-259,4807.7 cw(c-259.17,4794.35) -245.81,4794.35 ; C106.2@-252.06,4868.42 ccw(c-263.41,4894.46) -235,4894.46 ; C106.2@-248.2,4884 ccw(c-248.37,4897.35) -235.01,4897.35 ; -245.79,4794.35 cw(c-232.43,4794.35) C106.2@-232.6,4807.7 ; C106.2@-243.14,4848.04 C106.2@-245.91,4845.28 ; -234.99,4897.35 ccw(c-221.63,4897.35) C106.2@-221.8,4884 ; v1(-235,4925) -235,4856.18 C106.2@-245.91,4845.28 ; R140.2@-160.85,5110.08 R140.2@-155.24,5110.08 ; R140.2@-153.24,5104.7 cw(c-142.85,5097.36) -142.85,5110.08 -136.81,5104.04 -125.96,5104.04 v1(-125,5105) ; R140.2@-153.24,5115.46 R140.2@-149.95,5110.81 ; R140.2@-150.98,5112.44 ccw(c-145.7,5116.17) -145.7,5109.7 ; -695.18,4070.18 v1(-675,4050) -657.69,4067.31 -630,4067.31 ; -630,4067.31 -555.31,4067.31 -476.5,4146.12 -476.5,4540 -428,4588.5 -428,4732 -405,4755 -255.91,4755 -245.91,4765 C106.2@-245.91,4845.28
ATE.AUDIO.HP_R: C107.2 J6.3 J33.B14 R139.2 | length 8389.2
  Top Layer w4: v1(-680,3675) -584.81,3675 -560.98,3698.83 ; -564.38,3695.43 -510,3749.81 -510,3795 ; v1(-515,4165) -515,4110.19 -509.81,4105 -509.81,4070.19 ; -510,4070 -509.81,4070.19 ; -509.81,3795 -509.81,4070.19
  MidLayer1 w4: v1(-680,3675) -760,3595 -760,2330 -728,2298 -568,2298 -557.02,2287.02 -557.02,1810 -512.02,1765 -225,1765 -180.09,1720.09 -180.09,1570.09 40.19,1349.81 v1(40.19,858.37) ; v1@184.4,4947.5 v1(181.86,4950.04) 281.82,4950.04 320,4911.86 320,4782.05 330,4772.05 v1(330,4675)
  MidLayer2 w4: v1(-515,4165) -484.81,4195.19 -484.81,4540.13 -451.22,4573.71 -316.19,4573.71 -295.85,4553.37 -212.19,4553.37 -181.69,4583.87 93.87,4583.87 204.5,4694.5 310.5,4694.5 v1(330,4675) ; v1(-126.48,5216.71) -160.14,5183.04 -160.14,4900.88 -64.27,4805 160,4805 181.86,4826.86 v1(181.86,4950.04)
  Bottom Layer w4: J33.B14@-785.98,3676.48 -784.5,3675 v1(-680,3675) ; J33.B14@-711.58,3670.98 cw(c-701.88,3661.28) -701.88,3675 ; R139.2@-160.85,5220.92 -130.68,5220.92 v1(-126.48,5216.71) ; R139.2@-157.09,5217.15 cw(c-148.01,5208.07) -148.01,5220.92 cw(c-148.01,5233.76) R139.2@-157.09,5224.68 ; v1(40.19,858.37) 200,858.37 300,758.37 1010,758.37 1056.57,711.8 J6.3@1056.57,376.22 ; C107.2@169.48,4865.95 ccw(c139.59,4895.84) 181.86,4895.84 ; C107.2@178.01,4889.68 ccw(c172.5,4897.3) 181.9,4897.3 ccw(c191.3,4897.3) C107.2@185.79,4889.68 ; 181.86,4895.25 ccw(c226.28,4895.25) C107.2@200.26,4859.25 ; v1(181.86,4950.04) 181.86,4857.51 C107.2@194.09,4845.28
ATE.AUDIO.HP_SENSE: J6.11 R141.1 R142.2 | length 6901.7
  MidLayer1 w4: v1@41.81,5208.99 cw(c25.59,5192.77) 48.52,5192.77 cw(c71.46,5192.77) v1@55.24,5208.99 ; v1@44.64,5211.82 cw(c35.25,5202.43) 48.52,5202.43 cw(c61.8,5202.43) v1@52.41,5211.82 ; v1(48.52,5215.71) 48.52,5160 6.52,5118 6.52,5037.44 200,4843.97 200,4635 230,4605 230,4429.5 147.32,4346.81 105.19,4304.69 105.19,4259.94 -62.5,4092.25 -62.5,3970 -80,3952.5 -80,3904.86 -70.14,3895 -70.14,3864.86 -91.3,3843.7 -91.3,3693.7 -248.81,3536.19 -248.81,3373.2 -259.81,3362.2 -259.81,3250.04 -326.48,3183.37 -326.48,3091.71 -309.81,3075.04 -75,3075.04 -50,3050.04 -50,2917.93 -57.5,2910.43 -57.5,2909.75 -58,2909.25 -58,2331.56 71.06,2202.5 120.43,2202.5 582.5,1740.43 582.5,862.25 919.75,525 1225,525 1250,500 1250,320 1225,295 1140,295 1107.05,262.05 ; J6.11@1056.57,262.05 1107.05,262.05 ; J6.11@1075.3,251.5 cw(c1093.36,241.33) 1093.36,262.05 cw(c1093.36,282.77) J6.11@1075.3,272.6 ; J6.11@1078.79,249.53 cw(c1100.2,237.47) 1100.2,262.05 cw(c1100.2,286.62) J6.11@1078.79,274.56 ; J6.11@1082.27,247.57 cw(c1107.05,233.62) 1107.05,262.05 ; J6.11@1082.27,276.52 ccw(c1107.05,290.48) 1107.05,262.05
  Bottom Layer w4: v1@41.81,5222.43 ccw(c23.17,5241.06) 49.52,5241.06 ; v1@44.64,5219.6 ccw(c32.83,5231.4) 49.52,5231.4 ; v1@48.52,5206.21 cw(c48.52,5183.27) 64.74,5199.49 cw(c80.96,5215.71) v1@58.02,5215.71 ; v1@48.52,5210.21 cw(c48.52,5196.93) 57.91,5206.32 cw(c67.3,5215.71) v1@54.02,5215.71 ; v1(48.52,5215.71) 66.79,5197.44 ; v1@49.52,5216.71 49.52,5243.46 51.86,5245.8 ; 49.52,5236.23 ccw(c69.04,5236.23) v1@55.24,5222.43 ; R142.2@57.78,5241.97 ccw(c51.86,5239.3) 51.86,5245.8 ; R142.2@57.78,5249.62 cw(c51.86,5252.29) 51.86,5245.8 ; R141.1@62.8,5191.14 ccw(c59.82,5197.44) 66.79,5197.44 ; R142.2@66.28,5245.8 51.86,5245.8 ; R141.1@66.79,5182.22 66.79,5197.44 ; R141.1@70.78,5191.14 cw(c73.76,5197.44) 66.79,5197.44
ATE.AUDIO.LIN_L: C6.1 J4.2 J4.10 J33.B49 R4.2 | length 4523.9
  MidLayer1 w4: v1(-74.48,2139.71) 158.48,2139.71 565,1733.18 565,855 912.5,507.5 1127.5,507.5 1158.43,476.57 J4.2@1158.43,388.03 ; J4.2@1147.56,429.31 ccw(c1129.78,451.76) 1158.43,451.76 ccw(c1187.07,451.76) J4.2@1169.29,429.31
  MidLayer2 w4: v1(-595,2345) -522.62,2345 -485,2307.38 -347.38,2307.38 -297.5,2257.5 -297.5,2170 -267.21,2139.71 v1(-74.48,2139.71)
  Bottom Layer w4: J33.B49@-711.58,2293.03 cw(c-700.79,2282.24) -700.79,2297.5 ; -702.5,2297.5 -765,2297.5 -642.5,2297.5 v1(-595,2345) ; J4.10@1148.88,242.06 ccw(c1125.84,265.1) 1158.43,265.1 ccw(c1191.01,265.1) J4.10@1167.97,242.06 ; J4.2@1148.88,350.93 cw(c1125.84,327.89) 1158.43,327.89 cw(c1191.01,327.89) J4.2@1167.97,350.93 ; J4.2@1148.88,425.13 ccw(c1125.84,448.17) 1158.43,448.17 ccw(c1191.01,448.17) J4.2@1167.97,425.13 ; J4.10@1158.43,214.8 J4.2@1158.43,388.03 1158.43,815 1195.67,852.24 C6.1@1195.67,950 R4.2@1253.83,950 ; C6.1@1191.56,945.89 cw(c1181.64,935.97) 1195.67,935.97 cw(c1209.7,935.97) 1199.78,945.89 cw(c1209.7,935.97) 1209.7,950 cw(c1209.7,964.03) C6.1@1199.78,954.11 ; R4.2@1250.07,946.24 ccw(c1240.99,937.16) 1240.99,950 ccw(c1240.99,962.84) R4.2@1250.07,953.76
ATE.AUDIO.LIN_R: C5.1 J4.3 J4.11 J33.B48 R3.2 | length 4408.3
  Top Layer w4: v1(-660,2380) -633,2353 -633,2325.62 -618.88,2311.5 -585,2311.5 -560,2286.5 -560,1770 -590,1740 -590,1520 -534.71,1464.71 -422.92,1464.71 -392.62,1495 -85,1495 285,1125 v1(285,890)
  MidLayer2 w4: v1(285,890) 610,890 640,860 v1(1275,860)
  Bottom Layer w4: J33.B48@-775,2337.9 J33.B48@-766.3,2337.9 -702.1,2337.9 v1(-660,2380) ; J33.B48@-717.08,2333.68 ccw(c-717.08,2359.67) -698.71,2341.29 ; J33.B48@-717.08,2337.68 ccw(c-717.08,2373.32) -691.88,2348.12 ; v1(1275,860) 1448.82,860 1453.82,855 ; C5.1@1395.66,950 R3.2@1453.82,950 1453.82,855 ; C5.1@1399.77,945.89 cw(c1409.69,935.97) 1409.69,950 cw(c1409.69,964.03) C5.1@1399.77,954.11 ; R3.2@1450.06,945.75 cw(c1440.98,936.67) 1453.82,936.67 cw(c1466.66,936.67) R3.2@1457.58,945.75 ; R3.2@1450.06,946.24 ccw(c1440.98,937.16) 1440.98,950 ccw(c1440.98,962.84) R3.2@1450.06,953.76 ; J4.11@1461.57,262.05 J4.3@1461.57,376.22 1461.57,565 1453.82,572.76 1453.82,855
ATE.AUDIO.LOUT_L: C110.2 J5.2 J33.A5 | length 8462.4
  Top Layer w4: J33.A5@-785.98,4109.55 -691.71,4109.55 ; J33.A5@-711.14,4104.53 cw(c-700.33,4095.4) -700.33,4109.55 cw(c-700.33,4123.71) J33.A5@-711.14,4114.57 ; J33.A5@-708.09,4101.95 cw(c-691.71,4088.12) -691.71,4109.55 ; J33.A5@-708.09,4117.16 ccw(c-691.71,4130.99) -691.71,4109.55 ; v1(-670,4145) -670,4131.27 -691.71,4109.55 ; v1(-509.81,4625.04) -445,4689.85 v1(-445,4795)
  MidLayer1 w4: v1(-265,5050) -306.98,5008.02 -306.98,4969.35 -270.14,4932.52 -270.14,4884.01 -180,4793.86 v1(-180,4460) ; v1@785,4550 v1(780,4555) 835,4555 860,4530 860,4309.75 825,4274.75 825,3280 785.04,3240.04 612.67,3240.04 555.11,3182.48 555.11,2978.61 663.72,2870 725,2870 731.02,2863.98 731.02,2662.39 798.5,2594.92 798.5,2553.48 735.02,2490 735.02,2196.84 654,2115.82 654,1559 663,1550 925,1550 1060,1415 1155,1415 1513.55,1056.45 1563.43,1006.57 J5.2@1563.43,388.03 ; J5.2@1553.88,425.13 ccw(c1530.84,448.17) 1563.43,448.17 ccw(c1596.01,448.17) J5.2@1572.97,425.13
  MidLayer2 w4: v1(-670,4145) -670,4165 -627.96,4207.04 -592.9,4207.04 -589.63,4210.31 -550.96,4210.31 -533.48,4227.78 -533.48,4601.37 v1(-509.81,4625.04) ; v1(-180,4460) -125,4460 -45,4380 -8.33,4380 41.67,4430 617.63,4430 742.63,4555 v1(780,4555)
  Bottom Layer w4: v1(-445,4795) -445,4965 -390,5020 -295,5020 v1(-265,5050) -259.92,5055.08 C110.2@-202.7,5055.08
ATE.AUDIO.LOUT_R: C109.1 J5.3 J33.B17 | length 7885.7
  Top Layer w4: v1(530,3250) 530,3249.52 410,3129.52 410,2810 630,2590 630,955.57 1055,530.57 1780,530.57 1866.57,443.99 J5.3@1866.57,376.22 ; J5.3@1859.4,418.24 ccw(c1852.65,430.42) 1866.57,430.42 ccw(c1880.5,430.42) J5.3@1873.75,418.24
  MidLayer1 w4: v1@-45,3925 v1(-50,3920) -25,3945 -25,4015 -45,4035 -45,4085 122.69,4252.69 122.69,4297.44 250,4424.75 250,4615 220,4645 220,4848.71 73.52,4995.19 v1(73.52,5025.04)
  MidLayer2 w4: v1(-380,3940) -358.29,3961.71 -138.63,3961.71 -96.92,3920 v1(-50,3920)
  Bottom Layer w4: J33.B17@-765.61,3557.69 -658.07,3557.69 -655.76,3560 ; J33.B17@-711.58,3552.87 cw(c-699.95,3541.24) -699.95,3557.69 ; v1@-380,3930 -380,3745 -507,3618 -617,3618 -617,3617.35 -655.76,3578.58 -655.76,3560 ; C109.1@62.73,5050.93 cw(c53.3,5041.28) 66.79,5041.28 cw(c80.28,5041.28) C109.1@70.85,5050.93 ; 66.79,5040.28 ccw(c83.5,5040.28) v1@74.35,5026.3 ; C109.1@66.79,5047.68 ccw(c88.35,5047.68) v1@76.54,5029.64 ; v1(73.52,5025.04) 66.79,5031.77 C109.1@66.79,5055.08 ccw(c93.2,5055.08) v1@78.73,5032.99 ; v1@529.99,3250.04 232.15,3250.04 172,3310.19 172,3448.08 161.71,3458.37 -93.65,3458.37 -111.98,3476.71 -140.97,3476.71 -150.18,3467.5 -612.5,3467.5 -645,3500 -645,3540 -655.76,3550.76 -655.76,3560
ATE.DAC#.DAC0: C117.1 J15.2 J33.A2 R149.1 | length 5707.4
  Top Layer w4: J33.A2@-785.98,4227.66 -675.96,4227.66 -665,4216.71 -553.29,4216.71 -552,4218 -552,4538.31 -598.56,4584.87 -598.69,4584.87 -625.81,4612 -625.81,4648.33 -568.14,4706 -568.14,5800.96 -450,5919.1 -450,6133.37 -425,6158.37 -242.94,6158.37 -193.83,6207.48 -82.48,6207.48 -5,6130 365,6130 406.99,6088.01 J15.2@406.99,5880 406.99,5560 290,5443.01 v1(290,5415) ; J33.A2@-711.58,4222.16 cw(c-698.3,4208.88) -698.3,4227.66 cw(c-698.3,4246.45) J33.A2@-711.58,4233.17 ; J33.A2@-708.76,4219.33 cw(c-688.65,4199.23) -688.65,4227.66 cw(c-688.65,4256.1) J33.A2@-708.76,4235.99 ; C117.1@237.67,5415 v1(290,5415) ; C117.1@241.78,5410.89 cw(c251.7,5400.97) 251.7,5415 cw(c251.7,5429.03) C117.1@241.78,5419.11 ; C117.1@244.61,5408.06 cw(c261.36,5391.31) 261.36,5415 cw(c261.36,5438.69) C117.1@244.61,5421.94 ; v1@283.28,5408.28 ccw(c267.06,5392.06) 267.06,5415 ccw(c267.06,5437.93) 283.28,5421.72 ccw(c267.06,5437.93) 290,5437.93 ccw(c312.93,5437.93) 296.72,5421.72 ccw(c312.93,5437.93) 312.93,5415 ccw(c312.93,5392.06) v1@296.72,5408.28 ; v1@286.11,5411.11 ccw(c276.72,5401.72) 276.72,5415 ccw(c276.72,5428.28) 286.11,5418.89 ccw(c276.72,5428.28) 290,5428.28 ccw(c303.28,5428.28) 293.89,5418.89 ccw(c303.28,5428.28) 303.28,5415 ccw(c303.28,5401.72) v1@293.89,5411.11 ; R149.1@327.23,5408.41 ccw(c311.32,5392.5) 311.32,5415 ccw(c311.32,5437.5) R149.1@327.23,5421.59 ; R149.1@330.06,5411.24 ccw(c320.98,5402.16) 320.98,5415 ccw(c320.98,5427.84) R149.1@330.06,5418.76 ; R149.1@333.82,5415 v1(290,5415) ; J15.2@379.17,5852.18 cw(c312.02,5785.03) 406.99,5785.03 cw(c501.96,5785.03) J15.2@434.8,5852.18 ; J15.2@379.17,5907.82 ccw(c312.02,5974.97) 406.99,5974.97 ccw(c501.96,5974.97) J15.2@434.8,5907.82 ; J15.2@382,5855.01 cw(c321.67,5794.69) 406.99,5794.69 cw(c492.3,5794.69) J15.2@431.98,5855.01 ; J15.2@382,5904.99 ccw(c321.67,5965.31) 406.99,5965.31 ccw(c492.3,5965.31) J15.2@431.98,5904.99 ; J15.2@384.83,5857.84 cw(c331.33,5804.34) 406.99,5804.34 cw(c482.65,5804.34) J15.2@429.15,5857.84 ; J15.2@384.83,5902.16 ccw(c331.33,5955.66) 406.99,5955.66 ccw(c482.65,5955.66) J15.2@429.15,5902.16 ; J15.2@387.66,5860.67 cw(c340.99,5814) 406.99,5814 cw(c472.99,5814) J15.2@426.32,5860.67 ; J15.2@387.66,5899.33 ccw(c340.99,5946) 406.99,5946 ccw(c472.99,5946) J15.2@426.32,5899.33 ; J15.2@390.49,5863.5 cw(c350.64,5823.66) 406.99,5823.66 cw(c463.33,5823.66) J15.2@423.49,5863.5 ; J15.2@390.49,5896.5 ccw(c350.64,5936.34) 406.99,5936.34 ccw(c463.33,5936.34) J15.2@423.49,5896.5 ; J15.2@393.31,5866.33 cw(c360.3,5833.31) 406.99,5833.31 cw(c453.68,5833.31) J15.2@420.66,5866.33 ; J15.2@393.31,5893.67 ccw(c360.3,5926.69) 406.99,5926.69 ccw(c453.68,5926.69) J15.2@420.66,5893.67
ATE.DAC#.DAC1: C118.1 J15.3 J33.A13 R150.1 | length 6280.2
  Top Layer w4: J33.A13@-785.98,3715.85 -709.15,3715.85 -680,3745 -556.52,3745 -534.5,3767.02 -534.5,4115 -541,4121.5 -541,4179 -528,4192 -528,4561.56 v1(-584.81,4618.37) ; J33.A13@-717.08,3715.63 ccw(c-717.08,3734.26) J33.A13@-703.91,3721.09 ; J33.A13@-717.08,3719.63 ccw(c-717.08,3747.92) -697.08,3727.92 ; J33.A13@-717.08,3723.63 ccw(c-717.08,3761.58) -690.25,3734.75 ; J33.A13@-717.08,3727.63 ccw(c-717.08,3775.23) -683.43,3741.57 ; J33.A13@-705.3,3715.85 cw(c-696.03,3715.85) -702.59,3722.41 ; v1@-584.81,4608.87 cw(c-584.81,4585.94) -568.59,4602.16 cw(c-552.37,4618.37) v1@-575.31,4618.37 ; v1@-584.81,4612.87 cw(c-584.81,4599.6) -575.42,4608.99 cw(c-566.03,4618.37) v1@-579.31,4618.37 ; J15.3@576.02,5852.18 cw(c508.87,5785.03) 603.84,5785.03 cw(c698.81,5785.03) J15.3@631.66,5852.18 ; J15.3@578.85,5855.01 cw(c518.52,5794.69) 603.84,5794.69 cw(c689.15,5794.69) J15.3@628.83,5855.01 ; J15.3@581.68,5857.84 cw(c528.18,5804.34) 603.84,5804.34 cw(c679.5,5804.34) J15.3@626,5857.84 ; J15.3@584.51,5860.67 cw(c537.84,5814) 603.84,5814 cw(c669.84,5814) J15.3@623.17,5860.67 ; J15.3@587.34,5863.5 cw(c547.49,5823.66) 603.84,5823.66 cw(c660.18,5823.66) J15.3@620.34,5863.5 ; J15.3@590.16,5866.33 cw(c557.15,5833.31) 603.84,5833.31 cw(c650.53,5833.31) J15.3@617.51,5866.33 ; v2@596.9,5463.1 ccw(c580.15,5479.85) 603.84,5479.85 ccw(c627.52,5479.85) v2@610.78,5463.1 ; v2@599.73,5460.27 ccw(c589.81,5470.19) 603.84,5470.19 ccw(c617.87,5470.19) v2@607.95,5460.27 ; v2(603.84,5456.16) J15.3@603.84,5880 ; R150.1@1070,5415 1110,5415 ; R150.1@1073.76,5411.24 cw(c1082.84,5402.16) 1082.84,5415 cw(c1082.84,5427.84) R150.1@1073.76,5418.76 ; R150.1@1076.59,5408.41 cw(c1092.5,5392.5) 1092.5,5415 cw(c1092.5,5437.5) R150.1@1076.59,5421.59 ; v1@1103.28,5386.72 ccw(c1087.06,5402.93) 1110,5402.93 ccw(c1132.93,5402.93) v1@1116.72,5386.72 ; v1@1106.11,5383.89 ccw(c1096.72,5393.28) 1110,5393.28 ccw(c1123.28,5393.28) v1@1113.89,5383.89 ; v1(1110,5380) 1110,5415 ; C118.1@1155.39,5408.06 ccw(c1138.64,5391.31) 1138.64,5415 ccw(c1138.64,5438.69) C118.1@1155.39,5421.94 ; C118.1@1158.22,5410.89 ccw(c1148.3,5400.97) 1148.3,5415 ccw(c1148.3,5429.03) C118.1@1158.22,5419.11 ; C118.1@1162.33,5415 1110,5415
  MidLayer2 w4: v1(-584.81,4618.37) -551.48,4651.71 -551.48,4693.34 -492.19,4752.62 -492.19,4767.38 -502.62,4777.81 -516.5,4777.81 -551.48,4812.79 -551.48,5800 -521.48,5830 553.84,5830 ; v1@-584.81,4623.87 ccw(c-584.81,4637.15) -575.42,4627.76 ccw(c-566.03,4618.37) v1@-579.31,4618.37 ; v1@-584.81,4627.87 ccw(c-584.81,4650.81) -568.59,4634.59 ccw(c-552.37,4618.37) v1@-575.31,4618.37 ; J15.3@565.54,5871.03 cw(c522.81,5861.03) 553.84,5830 ; J15.3@569.43,5871.94 cw(c531.05,5862.96) 558.92,5835.09 cw(c586.8,5807.21) J15.3@595.78,5845.59 ; J15.3@573.33,5872.85 cw(c539.29,5864.89) 564.01,5840.17 cw(c588.72,5815.45) J15.3@596.69,5849.49 ; J15.3@577.22,5873.77 cw(c547.53,5866.81) 569.09,5845.25 cw(c590.65,5823.69) J15.3@597.61,5853.38 ; J15.3@581.11,5874.68 cw(c555.77,5868.74) 574.18,5850.34 cw(c592.58,5831.93) J15.3@598.52,5857.28 ; J15.3@594.87,5841.7 ccw(c584.87,5798.98) 553.84,5830 ; v2@603.84,5446.35 cw(c603.84,5422.66) 620.59,5439.41 cw(c637.34,5456.16) v2@613.65,5456.16 ; v2@603.84,5450.35 cw(c603.84,5436.32) 613.76,5446.24 cw(c623.68,5456.16) v2@609.65,5456.16 ; v2(603.84,5456.16) 627.5,5432.5 1057.49,5432.5 1063.76,5426.23 v1(1110,5380) ; J15.3@603.84,5880 553.84,5830 ; v1@1100.5,5380 ccw(c1077.56,5380) 1093.78,5396.22 ccw(c1110,5412.43) v1@1110,5389.5 ; v1@1104.5,5380 ccw(c1091.22,5380) 1100.61,5389.39 ccw(c1110,5398.78) v1@1110,5385.5
ATE.DAC#.DAC2: C119.1 J15.4 J33.A6 R151.1 | length 4941
  Top Layer w4: J33.A6@-785.98,4070.18 -694.82,4070.18 ; J33.A6@-710.65,4065.81 cw(c-702.38,4060.17) -702.38,4070.18 cw(c-702.38,4080.19) J33.A6@-710.65,4074.56 ; J33.A6@-707.35,4063.56 cw(c-694.82,4055.03) -694.82,4070.18 ; J33.A6@-707.35,4076.81 ccw(c-694.82,4085.34) -694.82,4070.18 ; -659.07,4117.45 ccw(c-694.34,4152.72) v1@-644.49,4154.64 ; -652.59,4123.92 ccw(c-681.87,4153.2) v1@-640.5,4154.79 ; -646.12,4130.4 ccw(c-669.4,4153.68) v1@-636.5,4154.94 ; -639.64,4136.87 ccw(c-656.93,4154.16) v1@-632.5,4155.1 ; v1(-635,4155) -635,4141.52 -665.81,4110.71 -665.81,4099.19 -694.82,4070.18 ; J15.4@772.87,5852.18 cw(c705.72,5785.03) 800.69,5785.03 cw(c895.66,5785.03) J15.4@828.51,5852.18 ; J15.4@775.7,5855.01 cw(c715.37,5794.69) 800.69,5794.69 cw(c886,5794.69) J15.4@825.68,5855.01 ; J15.4@778.53,5857.84 cw(c725.03,5804.34) 800.69,5804.34 cw(c876.35,5804.34) J15.4@822.85,5857.84 ; J15.4@781.36,5860.67 cw(c734.69,5814) 800.69,5814 cw(c866.69,5814) J15.4@820.02,5860.67 ; J15.4@784.19,5863.5 cw(c744.34,5823.66) 800.69,5823.66 cw(c857.03,5823.66) J15.4@817.19,5863.5 ; J15.4@787.01,5866.33 cw(c754,5833.31) 800.69,5833.31 cw(c847.38,5833.31) J15.4@814.36,5866.33 ; v2@793.06,5416.94 ccw(c774.65,5435.35) 800.69,5435.35 ; v2@795.89,5414.11 ccw(c784.31,5425.69) 800.69,5425.69 ; v2@800.69,5410.69 J15.4@800.69,5880 ; 800.69,5422.37 ccw(c812.37,5422.37) v2@804.11,5414.11 ; 800.69,5432.02 ccw(c822.02,5432.02) v2@806.94,5416.94 ; v1@1063.14,5260.43 ccw(c1046.58,5276.99) R151.1@1070,5276.99 ; v1@1065.97,5257.6 ccw(c1056.23,5267.33) 1070,5267.33 ; R151.1@1066.24,5280.75 cw(c1057.16,5271.67) 1070,5271.67 cw(c1082.84,5271.67) R151.1@1073.76,5280.75 ; v1@1070,5253.71 R151.1@1070,5285 C119.1@1162.33,5285 ; 1070,5266.64 ccw(c1082.79,5266.64) v1@1073.75,5257.6 ; R151.1@1070,5276.3 ccw(c1092.45,5276.3) v1@1076.57,5260.43 ; R151.1@1073.76,5281.24 cw(c1082.84,5272.16) 1082.84,5285 cw(c1082.84,5297.84) R151.1@1073.76,5288.76 ; R151.1@1076.59,5278.41 cw(c1092.5,5262.5) 1092.5,5285 cw(c1092.5,5307.5) R151.1@1076.59,5291.59 ; C119.1@1155.39,5278.06 ccw(c1138.65,5261.31) 1138.65,5285 ccw(c1138.64,5308.69) C119.1@1155.39,5291.94 ; C119.1@1158.22,5280.89 ccw(c1148.3,5270.97) 1148.3,5285 ccw(c1148.3,5299.03) C119.1@1158.22,5289.11
  MidLayer2 w4: v1@-641.07,4162.31 ccw(c-651.83,4175.25) -635,4175.25 ; v1@-638.52,4159.23 ccw(c-644.75,4166.72) -635,4166.72 ccw(c-625.25,4166.72) v1@-631.48,4159.23 ; v1(-635,4155) -635,4175.25 ; v1@-628.93,4162.31 cw(c-618.17,4175.25) -635,4175.25 ; v2@793.06,5403.06 cw(c776.31,5386.31) 800,5386.31 cw(c823.69,5386.31) v2@806.94,5403.06 ; v2@795.89,5405.89 cw(c785.97,5395.97) 800,5395.97 cw(c814.03,5395.97) v2@804.11,5405.89 ; v2(800,5410) 800,5310 ; v1@1060.36,5253.71 ccw(c1037.42,5253.71) 1053.64,5269.93 ccw(c1069.86,5286.14) v1@1069.86,5263.21 ; v1@1064.36,5253.71 ccw(c1051.08,5253.71) 1060.47,5263.1 ccw(c1069.86,5272.49) v1@1069.86,5259.21 ; v1(1069.86,5253.71) 1053.56,5270 840,5270 800,5310 ; -635,4175.25 -620.71,4189.54 -585.65,4189.54 -582.38,4192.81 -543.71,4192.81 -515.98,4220.54 -515.98,4580.08 -465.56,4630.5 -325.6,4630.5 -281.97,4586.87 -226.26,4586.87 -195.76,4617.37 80,4617.37 160.9,4698.27 190.62,4728 426.69,4728 461.5,4762.81 461.5,4947.19 452,4956.69 452,5302 460,5310 800,5310
ATE.DAC#.DAC3: C120.1 J15.5 J33.A7 R152.1 | length 6441.9
  Top Layer w4: J33.A7@-785.98,4030.81 -691.8,4030.81 ; J33.A7@-711.13,4025.81 cw(c-700.38,4016.78) -700.38,4030.81 cw(c-700.38,4044.85) J33.A7@-711.13,4035.82 ; J33.A7@-708.07,4023.24 cw(c-691.8,4009.56) -691.8,4030.81 ; J33.A7@-708.07,4038.39 ccw(c-691.8,4052.06) -691.8,4030.81 ; -595.37,4592.87 -610.32,4607.82 -617.81,4615.31 -617.81,4645.02 -559.81,4703.02 -559.81,5797.98 -459.81,5897.98 -442,5915.79 -442,6128 -420,6150 -290,6150 -239.96,6150.04 -225,6165 -190.52,6199.48 -85.79,6199.48 -8.31,6122 293,6122 310,6105 v2(310,5905) ; -595.25,4592.87 -544,4541.63 -544,4200 -557,4187 -557,4128.5 -565,4120.5 -639,4120.5 -651,4108.5 -651,4064.87 -645,4058.87 -645,4035 -657,4023 -683.98,4023 -691.8,4030.81 ; C120.1@237.67,5285 R152.1@333.82,5285 ; C120.1@241.78,5280.89 cw(c251.7,5270.97) 251.7,5285 ; C120.1@241.78,5289.11 ccw(c251.7,5299.03) 251.7,5285 ; C120.1@244.61,5278.06 cw(c261.35,5261.31) 261.35,5285 cw(c261.36,5308.69) C120.1@244.61,5291.94 ; v1@268.28,5278.28 ccw(c252.07,5262.06) 252.06,5285 ccw(c252.06,5307.93) v1@268.28,5291.72 ; v1@271.11,5281.11 ccw(c261.72,5271.72) 261.72,5285 ccw(c261.72,5298.28) v1@271.11,5288.89 ; v1@278.89,5281.11 cw(c288.28,5271.72) 288.28,5285 cw(c288.28,5298.28) v1@278.89,5288.89 ; v1@281.72,5278.28 cw(c297.93,5262.06) 297.93,5285 cw(c297.94,5307.93) v1@281.72,5291.72 ; v2@303.06,5911.94 ccw(c286.31,5928.69) 310,5928.69 ccw(c333.69,5928.69) v2@316.94,5911.94 ; v2@305.89,5909.11 ccw(c295.97,5919.03) 310,5919.03 ccw(c324.03,5919.03) v2@314.11,5909.11 ; R152.1@327.23,5278.41 ccw(c311.32,5262.5) 311.32,5285 ccw(c311.32,5307.5) R152.1@327.23,5291.59 ; R152.1@330.06,5281.24 ccw(c320.98,5272.16) 320.98,5285 ccw(c320.98,5297.84) R152.1@330.06,5288.76
  MidLayer1 w4: v1@268.28,5291.72 ccw(c252.06,5307.93) 275,5307.93 ccw(c297.93,5307.93) v1@281.72,5291.72 ; v1@271.11,5288.89 ccw(c261.72,5298.28) 275,5298.28 ccw(c288.28,5298.28) v1@278.89,5288.89 ; v1(275,5285) 275,5355 352.5,5432.5 ; v2@303.06,5898.06 cw(c286.31,5881.31) 310,5881.31 cw(c333.69,5881.31) v2@316.94,5898.06 ; v2@305.89,5900.89 cw(c295.97,5890.97) 310,5890.97 cw(c324.03,5890.97) v2@314.11,5900.89 ; v2(310,5905) 310,5827.5 352.5,5785 352.5,5432.5 ; J15.5@969.72,5852.18 cw(c902.57,5785.03) 997.54,5785.03 cw(c1092.51,5785.03) J15.5@1025.36,5852.18 ; J15.5@972.55,5855.01 cw(c912.22,5794.69) 997.54,5794.69 cw(c1082.85,5794.69) J15.5@1022.53,5855.01 ; J15.5@975.38,5857.84 cw(c921.88,5804.34) 997.54,5804.34 cw(c1073.2,5804.34) J15.5@1019.7,5857.84 ; J15.5@978.21,5860.67 cw(c931.54,5814) 997.54,5814 cw(c1063.54,5814) J15.5@1016.87,5860.67 ; J15.5@981.04,5863.5 cw(c941.19,5823.66) 997.54,5823.66 cw(c1053.88,5823.66) J15.5@1014.04,5863.5 ; J15.5@983.86,5866.33 cw(c950.85,5833.31) 997.54,5833.31 cw(c1044.23,5833.31) J15.5@1011.21,5866.33 ; J15.5@997.54,5880 997.54,5442.54 987.5,5432.5 352.5,5432.5
ATE.HOST_ID.DATA: D7.2 R131.1 R132.2 U30.L13 | length 3452.7
  Top Layer w4: U30.L13@7187.17,1759.23 cw(c7187.17,1741.51) 7199.7,1754.04 cw(c7212.23,1766.57) U30.L13@7194.51,1766.57 ; U30.L13@7187.17,1766.57 v3(7206.85,1746.89) ; v1(8124.52,2650.04) 8209.96,2650.04 8239.19,2620.81 v1(8239.19,2518.04) ; v1@8128.41,2646.15 cw(c8137.8,2636.76) 8137.8,2650.04 cw(c8137.8,2663.32) v1@8128.41,2653.93 ; v1@8131.24,2643.32 cw(c8147.46,2627.11) 8147.46,2650.04 cw(c8147.46,2672.98) v1@8131.24,2656.76 ; v1@8232.47,2524.76 ccw(c8216.26,2540.98) 8239.19,2540.98 ccw(c8262.13,2540.98) v1@8245.91,2524.76 ; v1@8235.3,2521.93 ccw(c8225.91,2531.32) 8239.19,2531.32 ccw(c8252.47,2531.32) v1@8243.08,2521.93 ; 7194.05,1759.69 cw(c7181.24,1746.89) 7199.35,1746.89 ccw(c7181.24,1746.89) 7194.05,1759.69 ; 7194.05,1759.69 ccw(c7206.85,1772.5) 7206.85,1754.39 cw(c7206.85,1772.5) 7194.05,1759.69
  MidLayer1 w4: v3@7208.15,1739.5 cw(c7211.3,1721.67) 7221.68,1736.5 ; v3@7214.24,1748.19 ccw(c7232.07,1751.34) 7221.68,1736.5 ; 7283.66,1723.03 7269.73,1723.03 ; 7380.98,1708.52 ccw(c7402,1729.54) v2@7402,1699.81 ; 7387.02,1702.48 cw(c7374.54,1690) v2@7392.19,1690 ; 7387.81,1701.69 ccw(c7402,1715.88) v2@7402,1695.81 ; v2(7402,1690) 7399.5,1690 7366.47,1723.03 7343.85,1723.03 7269.73,1723.03 ; v1@8232.47,2511.32 cw(c8214.64,2493.5) 8239.86,2493.5 ; v1@8235.3,2514.15 cw(c8224.3,2503.15) 8239.86,2503.15 ; v1(8239.19,2518.04) 8239.86,2517.37 8239.86,2158.71 v1(8281.86,2116.71) ; 8239.86,2496.72 cw(c8260.51,2496.72) v1@8245.91,2511.32 ; 8239.86,2506.37 cw(c8250.86,2506.37) v1@8243.08,2514.15 ; v1@8272.36,2116.71 ccw(c8249.42,2116.71) 8265.64,2132.93 ccw(c8281.86,2149.14) v1@8281.86,2126.21 ; v1@8276.36,2116.71 ccw(c8263.08,2116.71) 8272.47,2126.1 ccw(c8281.86,2135.49) v1@8281.86,2122.21 ; 7221.68,1736.5 7230.26,1729.42 ccw(c7246.48,1746.8) 7246.48,1723.03 7269.73,1723.03
  MidLayer2 w4: v2(7402,1690) 7416,1676 7430.75,1676 7448.56,1693.81 7513.38,1693.81 7515,1692.19 7651,1692.19 7666.34,1707.52 7738.66,1707.52 7746,1700.19 7774,1700.19 7780.82,1707 8264.81,1707 8297.81,1740 8297.81,2100.75 ; v1(8281.86,2116.71) 8297.81,2100.75 ; v1@8281.92,2111.21 cw(c8282.07,2098.45) 8291.09,2107.47 cw(c8300.12,2116.49) v1@8287.36,2116.64 ; v1@8281.97,2107.21 cw(c8282.23,2085.17) 8297.81,2100.75 ; v1@8291.36,2116.6 ccw(c8313.39,2116.34) 8297.81,2100.75
  Bottom Layer w4: R132.2@8073.82,2620 8093.05,2639.23 8103.86,2650.04 ; R132.2@8073.82,2625.81 ccw(c8073.82,2639.83) R132.2@8083.73,2629.92 ; R132.2@8073.82,2629.81 ccw(c8073.82,2653.49) 8090.56,2636.75 ; R132.2@8079.14,2620.49 cw(c8090.8,2620.49) R132.2@8082.55,2628.74 ; R132.2@8083.14,2620.49 cw(c8104.45,2620.49) 8089.38,2635.56 ; D7.2@8083.89,2826.12 cw(c8057.06,2799.28) 8095,2799.28 cw(c8132.94,2799.29) D7.2@8106.11,2826.12 ; D7.2@8086.72,2828.94 cw(c8066.71,2808.94) 8095,2808.94 cw(c8123.29,2808.94) D7.2@8103.28,2828.94 ; D7.2@8089.54,2831.77 cw(c8076.37,2818.6) 8095,2818.6 cw(c8113.63,2818.6) D7.2@8100.46,2831.77 ; D7.2@8095,2838.21 8095,2724.62 8124.52,2695.09 v1(8124.52,2650.04) 8103.86,2650.04 ; R131.1@8116.18,2510 8150,2510 8158.04,2518.04 v1(8239.19,2518.04) ; v1@8117.31,2643.86 ccw(c8103.86,2632.31) 8103.86,2650.04 ; v1@8117.31,2656.23 cw(c8103.86,2667.77) 8103.86,2650.04 ; v1@8117.81,2656.76 ccw(c8101.59,2672.98) 8124.52,2672.98 ccw(c8147.46,2672.98) v1@8131.24,2656.76 ; R131.1@8119.94,2506.24 cw(c8129.02,2497.16) 8129.02,2510 cw(c8129.02,2522.84) R131.1@8119.94,2513.76 ; v1@8120.35,2646.46 ccw(c8112.56,2639.78) 8112.56,2650.04 ccw(c8112.56,2660.3) v1@8120.35,2653.62 ; v1@8120.64,2653.93 ccw(c8111.25,2663.32) 8124.52,2663.32 ccw(c8137.8,2663.32) v1@8128.41,2653.93 ; R131.1@8122.77,2503.41 cw(c8138.68,2487.5) 8138.68,2510 cw(c8138.68,2532.5) R131.1@8122.77,2516.59 ; v1@8232.47,2511.32 ccw(c8216.26,2495.11) 8216.26,2518.04 ccw(c8216.26,2540.98) v1@8232.47,2524.76 ; v1@8235.3,2514.15 ccw(c8225.91,2504.76) 8225.91,2518.04 ccw(c8225.91,2531.32) v1@8235.3,2521.93
ATE.HOST_ID.EXT_PROG: J33.B40 R132.1 U23.2 | length 15135.6
  Top Layer w4: U23.2@8091.37,2603.08 ccw(c8072.94,2621.51) 8099,2621.51 ; U23.2@8094.2,2600.25 ccw(c8082.6,2611.85) 8099,2611.85 ccw(c8115.4,2611.85) U23.2@8103.8,2600.25 ; U23.2@8099,2572.81 8099,2621.51 ; 8099,2624.52 8099,2621.51 ; U23.2@8106.63,2603.08 cw(c8125.06,2621.51) 8099,2621.51 ; v1@8184.99,2664.99 ccw(c8168.77,2648.77) 8168.77,2671.71 ccw(c8168.77,2694.64) v1@8184.99,2678.43 ; v1@8187.82,2667.82 ccw(c8178.43,2658.43) 8178.43,2671.71 ccw(c8178.43,2684.99) v1@8187.82,2675.6 ; v1(8191.71,2671.71) 8106.71,2671.71 8099,2664 8099,2621.51
  MidLayer1 w4: v1(695,1910) 840,1910 860,1890 860,1639.75 1067.25,1432.5 1162.25,1432.5 1202.71,1392.04 2642.96,1392.04 2698.52,1336.48 v1(2698.52,100.04) ; v1@698.89,1906.11 cw(c708.28,1896.72) 708.28,1910 cw(c708.28,1923.28) v1@698.89,1913.89 ; v1@701.72,1903.28 cw(c717.93,1887.06) 717.93,1910 cw(c717.93,1932.93) v1@701.72,1916.72 ; v1@2691.81,106.76 ccw(c2675.59,122.98) 2698.52,122.98 ccw(c2721.46,122.98) v1@2705.24,106.76 ; v1@2694.64,103.93 ccw(c2685.25,113.32) 2698.52,113.32 ccw(c2711.8,113.32) v1@2702.41,103.93 ; 5359.96,325.04 v1(5198.52,325.04) 5374.96,325.04 5390,310 5630.63,310 5655.63,335 5810,335 5900,245 6265,245 6393.29,116.71 7456.71,116.71 7477.34,137.34 7477.34,238.5 7459.5,256.34 7459.5,472.5 7504,517 7647.69,517 7662.02,531.33 7662.02,1236.79 7652.19,1246.62 7652.19,1261.38 7768,1377.19 7769,1377.19 7788.81,1397 7788.81,1398 7874.52,1483.71 8183.31,1483.71 8258,1558.39 8258,1686.69 8318,1746.69 8318,2105.56 8247.86,2175.71 8247.86,2496 8256.86,2505 8256.86,2648.14 8233.29,2671.71 v1(8191.71,2671.71) ; v1@8195.6,2667.82 cw(c8204.99,2658.43) 8204.99,2671.71 cw(c8204.99,2684.99) v1@8195.6,2675.6 ; v1@8198.43,2664.99 cw(c8214.64,2648.77) 8214.64,2671.71 cw(c8214.64,2694.64) v1@8198.43,2678.43 ; 5211.8,325.04 cw(c5211.8,338.32) 5202.41,328.93 ccw(c5211.8,338.32) 5211.8,325.04 ; 5211.8,325.04 ccw(c5211.8,311.76) 5202.41,321.15 cw(c5211.8,311.76) 5211.8,325.04 ; 5221.46,325.04 cw(c5221.46,347.98) 5205.24,331.76 ccw(c5221.46,347.98) 5221.46,325.04 ; 5221.46,325.04 ccw(c5221.46,302.11) 5205.24,318.32 cw(c5221.46,302.11) 5221.46,325.04
  MidLayer2 w4: v1@-665,2611.5 cw(c-665,2588.56) -648.78,2604.78 cw(c-632.57,2621) v1@-655.5,2621 ; v1@-665,2615.5 cw(c-665,2602.22) -655.61,2611.61 cw(c-646.22,2621) v1@-659.5,2621 ; v1(-665,2621) -595,2551 -595,2463.23 -581.48,2449.71 -568.35,2449.71 -452.02,2333.37 -328.37,2333.37 -272,2277 -272,2178.44 -257.27,2163.71 -106.61,2163.71 -88.31,2182 -55.69,2182 -30.69,2157 124.31,2157 371.31,1910 v1(695,1910) ; v1@688.28,1903.28 ccw(c672.06,1887.06) 672.06,1910 ccw(c672.06,1932.93) v1@688.28,1916.72 ; v1@691.11,1906.11 ccw(c681.72,1896.72) 681.72,1910 ccw(c681.72,1923.28) v1@691.11,1913.89
  Bottom Layer w4: J33.B40@-785.98,2652.86 -704.49,2652.86 -685,2633.37 -678.81,2633.37 -666.44,2621 v1(-665,2621) ; J33.B40@-717.1,2653.08 cw(c-715.31,2627.69) -697.31,2645.69 ; J33.B40@-716.82,2649.09 cw(c-714.5,2616.09) -691.11,2639.48 ; J33.B40@-716.54,2645.1 cw(c-713.68,2604.5) -684.91,2633.28 ; v1@2698.52,90.54 cw(c2698.52,67.61) 2714.74,83.82 cw(c2730.96,100.04) v1@2708.02,100.04 ; v1@2698.52,94.54 cw(c2698.52,81.26) 2707.91,90.65 cw(c2717.3,100.04) v1@2704.02,100.04 ; v1(2698.52,100.04) 2743.56,55 3895,55 4081.37,241.37 4601.37,241.37 4655.19,295.19 5095.19,295.19 5145,345 5178.56,345 v1(5198.52,325.04) ; v1@5189.02,325.04 ccw(c5166.09,325.04) 5182.31,341.26 ccw(c5198.52,357.48) v1@5198.52,334.54 ; v1@5193.02,325.04 ccw(c5179.75,325.04) 5189.14,334.43 ccw(c5198.52,343.82) v1@5198.52,330.54 ; R132.1@8116.18,2620 8175,2620 8191.71,2636.71 v1(8191.71,2671.71) ; R132.1@8119.94,2616.24 cw(c8129.02,2607.16) 8129.02,2620 cw(c8129.02,2632.84) R132.1@8119.94,2623.76 ; R132.1@8122.77,2613.41 cw(c8138.68,2597.5) 8138.68,2620 cw(c8138.68,2642.5) R132.1@8122.77,2626.59 ; v1@8184.99,2664.99 cw(c8168.77,2648.77) 8191.71,2648.77 cw(c8214.64,2648.77) v1@8198.43,2664.99 ; v1@8187.82,2667.82 cw(c8178.43,2658.43) 8191.71,2658.43 cw(c8204.99,2658.43) v1@8195.6,2667.82
ATE.HOST_JTAG.HARD.TCK: J25.3 J33.B1 R269.1 | length 13336.4
  Top Layer w4: J25.3@7586.08,5457.35 cw(c7610.33,5467.92) 7591.62,5486.62 ; J25.3@7586.99,5420.25 7586.99,5481.99 7616.53,5511.53 ; J25.3@7589.74,5458.95 cw(c7616.11,5470.44) 7595.77,5490.77 ; J25.3@7593.41,5460.55 cw(c7621.9,5472.96) 7599.93,5494.93 ; J25.3@7597.08,5462.15 cw(c7627.68,5475.48) 7604.08,5499.08 ; J25.3@7600.75,5463.74 cw(c7633.46,5477.99) 7608.23,5503.23 ; J25.3@7604.41,5465.34 cw(c7639.24,5480.51) 7612.38,5507.38 ; J25.3@7608.08,5466.94 cw(c7645.03,5483.03) 7616.53,5511.53 ; v1@7863.1,5836.29 ccw(c7846.88,5820.07) 7846.88,5843 ccw(c7846.88,5865.94) v1@7863.1,5849.72 ; v1@7865.93,5839.11 ccw(c7856.54,5829.73) 7856.54,5843 ccw(c7856.54,5856.28) v1@7865.93,5846.89 ; v1@7873.7,5839.11 cw(c7883.09,5829.73) 7883.09,5843 cw(c7883.09,5856.28) v1@7873.7,5846.89 ; v1@7876.53,5836.29 cw(c7892.75,5820.07) 7892.75,5843 cw(c7892.75,5865.94) v1@7876.53,5849.72 ; 7886.93,5843 ccw(c7886.93,5864.39) R269.1@7902.05,5849.27 ; 7889.36,5843 cw(c7889.36,5829.06) R269.1@7899.22,5838.92 ; R269.1@7902.82,5843 v1(7869.82,5843) 7748,5843 7734.41,5829.41 7734.41,5567.64 7678.3,5511.53 7616.53,5511.53
  MidLayer1 w4: v2@5010,6790.19 cw(c5010,6766.5) 5026.75,6783.25 cw(c5043.5,6800) v2@5019.81,6800 ; v2@5010,6794.19 cw(c5010,6780.16) 5019.92,6790.08 cw(c5029.84,6800) v2@5015.81,6800 ; v2(5010,6800) 5047,6763 6138,6763 6260,6885 6933,6885 7055,6763 7382,6763 7424,6721 7424,6439.63 7462.85,6400.78 7462.85,6269.78 7616,6116.63 7616,6057.5 7659.31,6014.19 7680.69,6014.19 7690.5,6024 7785.27,6024 7869.82,5939.46 v1(7869.82,5843) ; v1@7863.1,5849.72 ccw(c7846.88,5865.94) 7869.82,5865.94 ccw(c7892.75,5865.94) v1@7876.53,5849.72 ; v1@7865.93,5846.89 ccw(c7856.54,5856.28) 7869.82,5856.28 ccw(c7883.09,5856.28) v1@7873.7,5846.89
  Bottom Layer w4: J33.B1@-785.98,4267.03 -700,4267.03 ; J33.B1@-706.07,4262.85 cw(c-700,4260.54) -700,4267.03 ; J33.B1@-706.07,4271.22 ccw(c-700,4273.53) -700,4267.03 ; v2@5000.19,6800 cw(c4976.5,6800) 4993.25,6783.25 cw(c5010,6766.5) v2@5010,6790.19 ; v2@5004.19,6800 cw(c4990.16,6800) 5000.08,6790.08 cw(c5010,6780.16) v2@5010,6794.19 ; v2(5010,6800) 4943.04,6733.04 2856.96,6733.04 2780,6810 389.5,6810 99.5,6520 80,6520 55,6495 55,6465.19 90.52,6429.67 90.52,6278.36 -129.83,6058 -236.5,6058 -270.21,6091.71 -556.81,6091.71 -568.48,6080.04 -568.48,5806.52 -615,5760 -644.81,5760 -662,5742.81 -662,5342 -651.15,5331.15 -615,5295 -615,4616.86 -567.65,4569.5 -567.65,4229.35 -580.29,4216.71 -665.39,4216.71 -683.26,4234.57 -684.32,4234.57 -692.5,4242.75 -692.5,4259.53 -700,4267.03