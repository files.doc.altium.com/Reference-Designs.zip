# Altium PCB NB3000AL.PcbDoc (part 22 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
AUGND: (continued)
  MidLayer2 w4: -662,4160.56 cw(c-670,4145) -652.5,4145 cw(c-670,4145) -678,4160.56 -678,4165 ; -662,4161.69 -624.65,4199.04 -592.9,4199.04 ; -596.21,4215.04 -627.96,4215.04 ; -586.31,4202.31 -550.96,4202.31 ; 189.86,4880.16 cw(c250.84,4880.16) v1@207.72,4923.28 ; 189.86,4889.82 cw(c241.18,4889.82) v1@204.89,4926.11 ; 189.86,4899.48 cw(c231.52,4899.48) v1@202.06,4928.94 ; 189.86,4909.13 cw(c221.87,4909.13) v1@199.23,4931.77 ; 189.86,4918.79 cw(c212.21,4918.79) v1@196.4,4934.6 ; 753.92,453.08 753.92,851.92 ; 790.92,358.84 cw(c815.82,358.84) v1@804.98,381.26 ; 790.92,365.22 cw(c812.74,365.22) v1@803.24,384.86 ; 790.92,371.59 cw(c809.66,371.59) v1@801.5,388.46 ; 790.92,377.97 cw(c806.58,377.97) v1@799.76,392.06 ; 790.92,399.67 ccw(c803.67,399.67) v1@800.16,387.41 ; 790.92,404.98 ccw(c805.2,404.98) v1@801.26,391.25 ; 790.92,410.28 ccw(c806.72,410.28) v1@802.37,395.1 ; v1@803.47,398.94 cw(c808.24,415.59) 790.92,415.59 ; v1@1009.14,375.94 ccw(c1009.11,385.91) 1019.08,385.91 ; v1@1009.13,379.94 ccw(c1009.1,389.92) 1019.08,389.92 ; v1@1009.12,383.94 ccw(c1009.08,393.94) 1019.08,393.94 ; v1@1009.16,371.94 ccw(c1009.12,381.9) 1019.08,381.9 ; 1094.07,359.39 cw(c1109.48,359.39) v10@1108.25,374.75 ; 1094.07,363.72 cw(c1109.13,363.72) v10@1107.93,378.73 ; 1094.07,368.05 cw(c1108.79,368.05) v10@1107.61,382.72 ; 1094.07,372.39 cw(c1108.44,372.39) v10@1107.3,386.71 ; 1094.07,376.72 cw(c1108.09,376.72) v10@1106.98,390.7 ; v10@1104.81,395.41 ccw(c1100.24,415.59) 1120.93,415.59 ; v10@1105.7,391.51 ccw(c1101.37,410.58) 1120.93,410.58 ; v10@1106.58,387.61 ccw(c1102.51,405.57) 1120.93,405.57 ; v10@1107.4,374.72 cw(c1107.13,360.92) 1120.93,360.92 ; v10@1107.48,378.72 cw(c1107.21,365) 1120.93,365 ; v10@1107.46,383.71 ccw(c1103.64,400.57) 1120.93,400.57 ; v10@1107.56,382.72 cw(c1107.29,369.09) 1120.93,369.09 ; v10@1107.64,386.72 cw(c1107.37,373.17) 1120.93,373.17 ; v10@1107.73,390.72 cw(c1107.46,377.25) 1120.93,377.25 ; v10@1108.35,379.81 ccw(c1104.78,395.56) 1120.93,395.56 ; v10@1109.23,375.91 ccw(c1105.91,390.55) 1120.93,390.55 ; v1@1110.99,214.52 ccw(c1110.96,224.49) 1120.93,224.49 ; v1@1110.98,218.52 ccw(c1110.95,228.51) 1120.93,228.51 ; v1@1110.97,222.52 ccw(c1110.93,232.52) 1120.93,232.52 ; v1@1111.01,210.52 ccw(c1110.97,220.48) 1120.93,220.48 ; 1195.92,199.21 cw(c1207.92,199.21) v1@1206.5,211.12 ; 1195.92,203.71 cw(c1207.38,203.71) v1@1206.03,215.09 ; 1195.92,208.22 cw(c1206.85,208.22) v1@1205.56,219.07 ; 1195.92,358.84 cw(c1220.82,358.84) v1@1209.98,381.26 ; 1195.92,365.22 cw(c1217.74,365.22) v1@1208.24,384.86 ; 1195.92,371.59 cw(c1214.66,371.59) v1@1206.5,388.46 ; 1195.92,377.97 cw(c1211.58,377.97) v1@1204.76,392.06 ; 1195.92,399.67 ccw(c1208.67,399.67) v1@1205.16,387.41 ; 1195.92,404.98 ccw(c1210.2,404.98) v1@1206.26,391.25 ; 1195.92,410.28 ccw(c1211.72,410.28) v1@1207.37,395.1 ; v1@1208.47,398.94 cw(c1213.24,415.59) 1195.92,415.59 ; v1@1414.14,261.77 ccw(c1414.11,271.74) 1424.08,271.74 ; v1@1414.13,265.77 ccw(c1414.1,275.75) 1424.08,275.75 ; v1@1414.12,269.77 ccw(c1414.08,279.76) 1424.08,279.76 ; v1@1414.14,375.94 ccw(c1414.11,385.91) 1424.08,385.91 ; v1@1414.13,379.94 ccw(c1414.1,389.92) 1424.08,389.92 ; v1@1414.12,383.94 ccw(c1414.08,393.94) 1424.08,393.94 ; v1@1414.16,257.77 ccw(c1414.12,267.72) 1424.08,267.72 ; v1@1414.16,371.94 ccw(c1414.12,381.9) 1424.08,381.9 ; 1499.07,246.45 cw(c1511.07,246.45) v1@1509.65,258.37 ; 1499.07,250.96 cw(c1510.53,250.96) v1@1509.18,262.34 ; 1499.07,255.46 cw(c1510,255.46) v1@1508.7,266.31 ; 1499.07,359.39 cw(c1514.48,359.39) v10@1513.25,374.75 ; 1499.07,363.72 cw(c1514.13,363.72) v10@1512.93,378.73 ; 1499.07,368.05 cw(c1513.79,368.05) v10@1512.61,382.72 ; 1499.07,372.39 cw(c1513.44,372.39) v10@1512.3,386.71 ; 1499.07,376.72 cw(c1513.09,376.72) v10@1511.98,390.7 ; v10@1509.81,395.41 ccw(c1505.24,415.59) 1525.93,415.59 ; v10@1510.7,391.51 ccw(c1506.37,410.58) 1525.93,410.58 ; v10@1511.58,387.61 ccw(c1507.51,405.57) 1525.93,405.57 ; v10@1512.4,374.72 cw(c1512.13,360.92) 1525.93,360.92 ; v10@1512.48,378.72 cw(c1512.21,365) 1525.93,365 ; v10@1512.46,383.71 ccw(c1508.64,400.57) 1525.93,400.57 ; v10@1512.56,382.72 cw(c1512.29,369.09) 1525.93,369.09 ; v10@1512.64,386.72 cw(c1512.37,373.17) 1525.93,373.17 ; v10@1512.73,390.72 cw(c1512.46,377.25) 1525.93,377.25 ; v10@1513.35,379.81 ccw(c1509.78,395.56) 1525.93,395.56 ; v10@1514.23,375.91 ccw(c1510.91,390.55) 1525.93,390.55 ; 1600.92,358.84 cw(c1625.82,358.84) v1@1614.98,381.26 ; 1600.92,365.22 cw(c1622.74,365.22) v1@1613.24,384.86 ; 1600.92,371.59 cw(c1619.66,371.59) v1@1611.5,388.46 ; 1600.92,377.97 cw(c1616.58,377.97) v1@1609.76,392.06 ; 1600.92,399.67 ccw(c1613.67,399.67) v1@1610.16,387.41 ; 1600.92,404.98 ccw(c1615.2,404.98) v1@1611.26,391.25 ; 1600.92,410.28 ccw(c1616.72,410.28) v1@1612.37,395.1 ; v1@1613.47,398.94 cw(c1618.24,415.59) 1600.92,415.59 ; v1@1819.14,375.94 ccw(c1819.11,385.91) 1829.08,385.91 ; v1@1819.13,379.94 ccw(c1819.1,389.92) 1829.08,389.92 ; v1@1819.12,383.94 ccw(c1819.08,393.94) 1829.08,393.94 ; v1@1819.16,371.94 ccw(c1819.12,381.9) 1829.08,381.9 ; 1904.07,359.39 cw(c1919.48,359.39) v10@1918.25,374.75 ; 1904.07,363.72 cw(c1919.13,363.72) v10@1917.93,378.73 ; 1904.07,368.05 cw(c1918.79,368.05) v10@1917.61,382.72 ; 1904.07,372.39 cw(c1918.44,372.39) v10@1917.3,386.71 ; 1904.07,376.72 cw(c1918.09,376.72) v10@1916.98,390.7 ; v10@1914.81,395.41 ccw(c1910.24,415.59) 1930.93,415.59 ; v10@1915.7,391.51 ccw(c1911.37,410.58) 1930.93,410.58 ; v10@1916.58,387.61 ccw(c1912.51,405.57) 1930.93,405.57 ; v10@1917.4,374.72 cw(c1917.13,360.92) 1930.93,360.92 ; v10@1917.48,378.72 cw(c1917.21,365) 1930.93,365 ; v10@1917.46,383.71 ccw(c1913.64,400.57) 1930.93,400.57 ; v10@1917.56,382.72 cw(c1917.29,369.09) 1930.93,369.09 ; v10@1917.64,386.72 cw(c1917.37,373.17) 1930.93,373.17 ; v10@1917.73,390.72 cw(c1917.46,377.25) 1930.93,377.25 ; v10@1918.35,379.81 ccw(c1914.78,395.56) 1930.93,395.56 ; v10@1919.23,375.91 ccw(c1915.91,390.55) 1930.93,390.55 ; v1@1920.99,214.52 ccw(c1920.96,224.49) 1930.93,224.49 ; v1@1920.98,218.52 ccw(c1920.95,228.51) 1930.93,228.51 ; v1@1920.97,222.52 ccw(c1920.93,232.52) 1930.93,232.52 ; v1@1921.01,210.52 ccw(c1920.97,220.48) 1930.93,220.48 ; 2005.92,199.21 cw(c2017.92,199.21) v1@2016.5,211.12 ; 2005.92,203.71 cw(c2017.38,203.71) v1@2016.03,215.09 ; 2005.92,208.22 cw(c2016.85,208.22) v1@2015.56,219.07 ; 2005.92,358.84 cw(c2030.82,358.84) v1@2019.98,381.26 ; 2005.92,365.22 cw(c2027.74,365.22) v1@2018.24,384.86 ; 2005.92,371.59 cw(c2024.66,371.59) v1@2016.5,388.46 ; 2005.92,377.97 cw(c2021.58,377.97) v1@2014.76,392.06 ; 2005.92,399.67 ccw(c2018.67,399.67) v1@2015.16,387.41 ; 2005.92,404.98 ccw(c2020.2,404.98) v1@2016.26,391.25 ; 2005.92,410.28 ccw(c2021.72,410.28) v1@2017.37,395.1 ; v1@2018.47,398.94 cw(c2023.24,415.59) 2005.92,415.59 ; v1@2224.14,375.94 ccw(c2224.11,385.91) 2234.08,385.91 ; v1@2224.13,379.94 ccw(c2224.1,389.92) 2234.08,389.92 ; v1@2224.12,383.94 ccw(c2224.08,393.94) 2234.08,393.94 ; v1@2224.16,371.94 ccw(c2224.12,381.9) 2234.08,381.9 ; J7.1@2258.89,186.31 ccw(c2249.32,206.41) 2271.57,206.41 ; J7.1@2260.61,182.7 ccw(c2252.34,200.07) 2271.57,200.07 ccw(c2290.81,200.07) J7.1@2282.54,182.7 ; J7.1@2262.33,179.09 ccw(c2255.35,193.74) 2271.57,193.74 ccw(c2287.8,193.74) J7.1@2280.82,179.09 ; J7.1@2271.57,132.13 2271.57,206.41 ; 2272,206.84 2271.57,206.41 ; J7.1@2284.26,186.31 cw(c2293.83,206.41) 2271.57,206.41 ; 2309.07,360.63 cw(c2321.07,360.63) v1@2319.65,372.54 ; 2309.07,365.13 cw(c2320.53,365.13) v1@2319.18,376.51 ; 2309.07,369.63 cw(c2320,369.63) v1@2318.7,380.48 ; -738,3955 ccw(c-730,3955) -735.66,3949.34 ; -738,3955 ccw(c-730,3955) -735.66,3949.34 ; -738,3955 -738,4035 ; -738,4035 cw(c-730,4035) -735.66,4040.66 ; -738,4035 cw(c-730,4035) -735.66,4040.66 ; -735.66,3949.34 -719.53,3933.22 ; -735.66,4040.66 -720.66,4055.66 ; -731,2338 ccw(c-723,2338) -728.66,2332.34 ; -731,2338 ccw(c-723,2338) -728.66,2332.34 ; -731,2338 -731,3707 ; -731,3707 cw(c-723,3707) -728.66,3712.66 ; -731,3707 cw(c-723,3707) -728.66,3712.66 ; -728.66,2332.34 -688.66,2292.34 ; -728.66,3712.66 -698.66,3742.66 ; -720.66,4055.66 cw(c-715,4050) -715,4058 ; -720.66,4055.66 cw(c-715,4050) -715,4058 ; -719.53,3933.22 ccw(c-713.88,3938.88) -713.88,3930.88 ; -719.53,3933.22 ccw(c-713.88,3938.88) -713.88,3930.88 ; -715,4058 -690.56,4058 cw(c-675,4050) -657.5,4050 cw(c-675,4050) -690.56,4042 -711.69,4042 -722,4031.69 -722,3958.31 -710.56,3946.88 -676.12,3946.88 ; -713.88,3930.88 -679.44,3930.88 -671.94,3923.38 ; -698.66,3742.66 cw(c-693,3737) -693,3745 ; -698.66,3742.66 cw(c-693,3737) -693,3745 ; -693,3745 -591.31,3745 -533,3803.31 -533,3881.69 -572.35,3921.04 -666.29,3921.04 ; -688.66,2292.34 ccw(c-683,2298) -683,2290 ; -688.66,2292.34 ccw(c-683,2298) -683,2290 ; -683,2290 -591.31,2290 -573,2271.69 -573,1753.31 -585.66,1740.66 ; -678,4165 cw(c-670,4165) -675.66,4170.66 ; -678,4165 cw(c-670,4165) -675.66,4170.66 ; -676.12,3946.88 cw(c-676.12,3938.88) -670.47,3944.53 ; -676.12,3946.88 cw(c-676.12,3938.88) -670.47,3944.53 ; -675.66,4170.66 -633.62,4212.7 ; -671.94,3923.38 ccw(c-666.29,3929.04) -666.29,3921.04 ; -671.94,3923.38 ccw(c-666.29,3929.04) -666.29,3921.04 ; -670.47,3944.53 -662.97,3937.04 -569.04,3937.04 ; -633.62,4212.7 cw(c-627.96,4207.04) -627.96,4215.04 ; -633.62,4212.7 cw(c-627.96,4207.04) -627.96,4215.04 ; -592.9,4199.04 ccw(c-592.9,4207.04) -587.24,4201.38 cw(c-592.9,4207.04) -592.9,4199.04 ; -589.63,4218.31 ccw(c-589.63,4210.31) -595.28,4215.97 cw(c-589.63,4210.31) -589.63,4218.31 ; -589.63,4218.31 -554.27,4218.31 -541.48,4231.1 -541.48,4601.37 ; -588,1605 ccw(c-580,1605) -585.66,1599.34 ; -588,1605 ccw(c-580,1605) -585.66,1599.34 ; -588,1605 -588,1735 ; -588,1735 cw(c-580,1735) -585.66,1740.66 ; -588,1735 cw(c-580,1735) -585.66,1740.66 ; -588,2306 cw(c-588,2298) -582.34,2303.66 ; -588,2306 cw(c-588,2298) -582.34,2303.66 ; -588,2306 -679.69,2306 -715,2341.31 -715,3703.69 -689.69,3729 -588,3729 ; -588,3729 ccw(c-588,3737) -582.34,3731.34 ; -588,3729 ccw(c-588,3737) -582.34,3731.34 ; -585.66,1599.34 -562.25,1575.94 ; -582.34,2303.66 -559.34,2280.66 ; -582.34,3731.34 -519.34,3794.34 ; -569.04,3937.04 cw(c-569.04,3929.04) -563.38,3934.7 ; -569.04,3937.04 cw(c-569.04,3929.04) -563.38,3934.7 ; -563.38,3934.7 -519.34,3890.66 ; -562.25,1575.94 ccw(c-556.59,1581.59) -556.59,1573.59 ; -562.25,1575.94 ccw(c-556.59,1581.59) -556.59,1573.59 ; -559.34,1744.34 ccw(c-565,1750) -557,1750 ; -559.34,1744.34 ccw(c-565,1750) -557,1750 ; -559.34,1744.34 -572,1731.69 -572,1608.31 -553.28,1589.59 -399.97,1589.59 ; -559.34,2280.66 cw(c-565,2275) -557,2275 ; -559.34,2280.66 cw(c-565,2275) -557,2275 ; -557,1750 -557,2275 ; -556.59,1573.59 -403.29,1573.59 -314.04,1484.34 ; -550.96,4202.31 ccw(c-550.96,4210.31) -545.3,4204.65 ; -550.96,4202.31 ccw(c-550.96,4210.31) -545.3,4204.65 ; -545.3,4204.65 -527.82,4222.13 ; -541.48,4601.37 cw(c-533.48,4601.37) -539.14,4607.03 ; -541.48,4601.37 cw(c-533.48,4601.37) -539.14,4607.03 ; -539.14,4607.03 -526.47,4619.69 cw(c-509.81,4625.04) -492.31,4625.04 cw(c-509.81,4625.04) -515.16,4608.38 -525.48,4598.06 -525.48,4227.78 ; -527.82,4222.13 ccw(c-533.48,4227.78) -525.48,4227.78 ; -527.82,4222.13 ccw(c-533.48,4227.78) -525.48,4227.78 ; -522.62,2353 cw(c-522.62,2345) -516.96,2350.66 ; -522.62,2353 cw(c-522.62,2345) -516.96,2350.66 ; -522.62,2353 -579.44,2353 ccw(c-595,2345) -579.44,2337 -525.93,2337 -490.66,2301.72 ; -519.34,3794.34 ccw(c-525,3800) -517,3800 ; -519.34,3794.34 ccw(c-525,3800) -517,3800 ; -519.34,3890.66 cw(c-525,3885) -517,3885 ; -519.34,3890.66 cw(c-525,3885) -517,3885 ; -516.96,2350.66 -481.69,2315.38 -347.38,2315.38 ; -517,3800 -517,3885 ; -492.81,4540.13 cw(c-484.81,4540.13) -490.47,4545.78 ; -492.81,4540.13 cw(c-484.81,4540.13) -490.47,4545.78 ; -492.81,4540.13 -492.81,4198.5 -509.65,4181.66 ccw(c-515,4165) -497.5,4165 ccw(c-515,4165) -498.34,4170.35 -479.15,4189.53 ; -490.66,2301.72 ccw(c-485,2307.38) -485,2299.38 ; -490.66,2301.72 ccw(c-485,2307.38) -485,2299.38 ; -490.47,4545.78 -456.88,4579.37 ; -485,2299.38 -350.69,2299.38 -305.5,2254.19 -305.5,2170 ; -483,3505.68 ccw(c-475,3505.68) -480.66,3500.02 ; -483,3505.68 ccw(c-475,3505.68) -480.66,3500.02 ; -483,3505.68 -483,3669.88 ; -483,3669.88 cw(c-475,3669.88) -480.66,3675.54 ; -483,3669.88 cw(c-475,3669.88) -480.66,3675.54 ; -480.66,3500.02 -383.21,3402.58 ; -480.66,3675.54 -428,3728.2 -428,3955 ; -479.15,4189.53 ccw(c-484.81,4195.19) -476.81,4195.19 ; -479.15,4189.53 ccw(c-484.81,4195.19) -476.81,4195.19 ; -476.81,4195.19 -476.81,4536.81 -447.91,4565.71 -319.5,4565.71 -301.5,4547.72 ; -456.88,4579.37 cw(c-451.22,4573.71) -451.22,4581.71 ; -456.88,4579.37 cw(c-451.22,4573.71) -451.22,4581.71 ; -451.22,4581.71 -316.19,4581.71 ; -450,3535 ccw(c-442,3535) -447.66,3529.34 ; -450,3535 ccw(c-442,3535) -447.66,3529.34 ; -450,3535 -450,3596.18 ; -450,3596.18 cw(c-442,3596.18) -447.66,3601.84 ; -450,3596.18 cw(c-442,3596.18) -447.66,3601.84 ; -447.66,3529.34 -420.89,3502.58 ; -447.66,3601.84 -422.28,3627.21 ; -428,3955 cw(c-420,3955) -425.66,3960.66 ; -428,3955 cw(c-420,3955) -425.66,3960.66 ; -425.66,3960.66 -371.66,4014.65 cw(c-355,4020) -337.5,4020 cw(c-355,4020) -360.35,4003.34 -412,3951.69 -412,3724.88 ; -422.28,3627.21 cw(c-416.63,3621.56) -416.63,3629.56 ; -422.28,3627.21 cw(c-416.63,3621.56) -416.63,3629.56 ; -420.89,3502.58 ccw(c-415.23,3508.23) -415.23,3500.23 ; -420.89,3502.58 ccw(c-415.23,3508.23) -415.23,3500.23 ; -416.63,3629.56 -376.76,3629.56 -358,3648.31 -358,3715 ; -415.23,3500.23 41.02,3500.23 ccw(c76.12,3508.23) 112.12,3508.23 ccw(c76.12,3508.23) 41.02,3516.23 -411.92,3516.23 -434,3538.31 -434,3592.87 -413.31,3613.56 -373.44,3613.56 ; -414.34,3719.23 ccw(c-420,3724.88) -412,3724.88 ; -414.34,3719.23 ccw(c-420,3724.88) -412,3724.88 ; -414.34,3719.23 -467,3666.57 -467,3508.99 -374.24,3416.23 41.02,3416.23 cw(c76.12,3408.23) 112.12,3408.23 cw(c76.12,3408.23) 41.02,3400.23 -377.56,3400.23 ; -399.97,1589.59 cw(c-399.97,1581.59) -394.32,1587.25 ; -399.97,1589.59 cw(c-399.97,1581.59) -394.32,1587.25 ; -394.32,1587.25 -305.07,1498 -120,1498 ; -383.21,3402.58 ccw(c-377.56,3408.23) -377.56,3400.23 ; -383.21,3402.58 ccw(c-377.56,3408.23) -377.56,3400.23 ; -373.44,3613.56 ccw(c-373.44,3621.56) -367.79,3615.9 ; -373.44,3613.56 ccw(c-373.44,3621.56) -367.79,3615.9 ; -367.79,3615.9 -344.34,3639.34 ; -363.95,3967.36 cw(c-358.29,3961.71) -358.29,3969.71 ; -363.95,3967.36 cw(c-358.29,3961.71) -358.29,3969.71 ; -363.95,3967.36 -374.65,3956.66 ccw(c-380,3940) -362.5,3940 ccw(c-380,3940) -363.34,3945.35 -354.98,3953.71 -141.94,3953.71 -102.57,3914.34 ; -358.29,3969.71 -138.63,3969.71 ; -358,3715 cw(c-350,3715) -355.66,3720.66 ; -358,3715 cw(c-350,3715) -355.66,3720.66 ; -355.66,3720.66 -335.66,3740.66 ; -347.38,2315.38 cw(c-347.38,2307.38) -341.72,2313.04 ; -347.38,2315.38 cw(c-347.38,2307.38) -341.72,2313.04 ; -344.34,3639.34 ccw(c-350,3645) -342,3645 ; -344.34,3639.34 ccw(c-350,3645) -342,3645 ; -342,3645 -342,3711.69 -326.69,3727 -275,3727 ; -341.72,2313.04 -291.84,2263.16 ; -335.66,3740.66 cw(c-330,3735) -330,3743 ; -335.66,3740.66 cw(c-330,3735) -330,3743 ; -330,3743 -278.31,3743 -266.66,3754.65 cw(c-250,3760) -232.5,3760 cw(c-250,3760) -255.35,3743.34 -269.34,3729.34 ; -328,4988.5 cw(c-320,4988.5) -325.66,4994.16 ; -328,4988.5 cw(c-320,4988.5) -325.66,4994.16 ; -328,4988.5 -328,4950.56 ccw(c-320,4935) -302.5,4935 ccw(c-320,4935) -312,4950.56 -312,4985.19 -291.69,5005.5 -236.5,5005.5 ; -325.66,4994.16 -300.66,5019.16 ; -316.19,4581.71 cw(c-316.19,4573.71) -310.53,4579.37 ; -316.19,4581.71 cw(c-316.19,4573.71) -310.53,4579.37 ; -314.04,1484.34 ccw(c-308.38,1490) -308.38,1482 ; -314.04,1484.34 ccw(c-308.38,1490) -308.38,1482 ; -310.53,4579.37 -292.53,4561.37 -215.5,4561.37 -187.34,4589.53 ; -308.38,1482 -123.31,1482 117,1241.69 117,475 ; -305.5,2170 ccw(c-297.5,2170) -303.16,2164.34 ; -305.5,2170 ccw(c-297.5,2170) -303.16,2164.34 ; -303.16,2164.34 -272.86,2134.05 ; -301.5,4547.72 ccw(c-295.85,4553.37) -295.85,4545.37 ; -301.5,4547.72 ccw(c-295.85,4553.37) -295.85,4545.37 ; -300.66,5019.16 cw(c-295,5013.5) -295,5021.5 ; -300.66,5019.16 cw(c-295,5013.5) -295,5021.5 ; -295.85,4545.37 -212.19,4545.37 ; -295,5021.5 -239.81,5021.5 -218,5043.31 -218,5255 ; -291.84,2263.16 cw(c-297.5,2257.5) -289.5,2257.5 ; -291.84,2263.16 cw(c-297.5,2257.5) -289.5,2257.5 ; -289.5,2257.5 -289.5,2173.31 -263.89,2147.71 -90.04,2147.71 cw(c-74.48,2139.71) -56.98,2139.71 cw(c-74.48,2139.71) -90.04,2131.71 -267.21,2131.71 ; -275,3727 ccw(c-275,3735) -269.34,3729.34 ; -275,3727 ccw(c-275,3735) -269.34,3729.34 ; -272.86,2134.05 ccw(c-267.21,2139.71) -267.21,2131.71 ; -272.86,2134.05 ccw(c-267.21,2139.71) -267.21,2131.71 ; -236.5,5005.5 ccw(c-236.5,5013.5) -230.84,5007.84 ; -236.5,5005.5 ccw(c-236.5,5013.5) -230.84,5007.84 ; -230.84,5007.84 -204.34,5034.34 ; -218,5255 cw(c-210,5255) -215.66,5260.66 ; -218,5255 cw(c-210,5255) -215.66,5260.66 ; -215.66,5260.66 -203.62,5272.7 ; -212.19,4545.37 ccw(c-212.19,4553.37) -206.53,4547.72 ; -212.19,4545.37 ccw(c-212.19,4553.37) -206.53,4547.72 ; -206.53,4547.72 -178.37,4575.87 93.87,4575.87 ; -204.34,5034.34 ccw(c-210,5040) -202,5040 ; -204.34,5034.34 ccw(c-210,5040) -202,5040 ; -203.62,5272.7 cw(c-197.96,5267.04) -197.96,5275.04 ; -203.62,5272.7 cw(c-197.96,5267.04) -197.96,5275.04 ; -202,5040 -202,5251.69 -194.65,5259.04 -141.71,5259.04 ccw(c-126.14,5267.04) -108.64,5267.04 ccw(c-126.14,5267.04) -141.71,5275.04 -197.96,5275.04 ; -187.34,4589.53 cw(c-181.69,4583.87) -181.69,4591.87 ; -187.34,4589.53 cw(c-181.69,4583.87) -181.69,4591.87 ; -181.69,4591.87 90.56,4591.87 198.84,4700.16 ; -168.14,4900.88 ccw(c-160.14,4900.88) -165.8,4895.22 ; -168.14,4900.88 ccw(c-160.14,4900.88) -165.8,4895.22 ; -168.14,4900.88 -168.14,5183.04 ; -168.14,5183.04 cw(c-160.14,5183.04) -165.8,5188.7 ; -168.14,5183.04 cw(c-160.14,5183.04) -165.8,5188.7 ; -165.8,4895.22 -69.92,4799.34 ; -165.8,5188.7 -143.14,5211.36 cw(c-126.48,5216.71) -108.98,5216.71 cw(c-126.48,5216.71) -131.82,5200.05 -152.14,5179.73 -152.14,4904.19 -60.95,4813 156.69,4813 173.86,4830.17 173.86,4934.48 cw(c181.86,4950.04) 199.36,4950.04 cw(c181.86,4950.04) 189.86,4934.48 189.86,4826.86 ; -138.63,3969.71 cw(c-138.63,3961.71) -132.97,3967.36 ; -138.63,3969.71 cw(c-138.63,3961.71) -132.97,3967.36 ; -132.97,3967.36 -93.6,3928 -65.56,3928 cw(c-50,3920) -32.5,3920 cw(c-50,3920) -65.56,3912 -96.92,3912 ; -125,4468 cw(c-125,4460) -119.34,4465.66 ; -125,4468 cw(c-125,4460) -119.34,4465.66 ; -125,4468 -164.44,4468 ccw(c-180,4460) -164.44,4452 -128.31,4452 -50.66,4374.34 ; -120,1498 cw(c-120,1490) -114.34,1495.66 ; -120,1498 cw(c-120,1490) -114.34,1495.66 ; -119.34,4465.66 -41.69,4388 -11.65,4388 36,4435.65 ; -114.34,1495.66 130.66,1250.66 ; -102.57,3914.34 ccw(c-96.92,3920) -96.92,3912 ; -102.57,3914.34 ccw(c-96.92,3920) -96.92,3912 ; -69.92,4799.34 ccw(c-64.27,4805) -64.27,4797 ; -69.92,4799.34 ccw(c-64.27,4805) -64.27,4797 ; -64.27,4797 160,4797 ; -50.66,4374.34 ccw(c-45,4380) -45,4372 ; -50.66,4374.34 ccw(c-45,4380) -45,4372 ; -45,4372 -8.33,4372 ; -30,3662 ccw(c-30,3670) -24.34,3664.34 ; -30,3662 ccw(c-30,3670) -24.34,3664.34 ; -30,3662 -239.44,3662 cw(c-255,3670) -239.44,3678 -33.31,3678 -9.27,3702.05 -9.27,3838.73 ; -24.34,3664.34 4.39,3693.08 ; -9.27,3838.73 cw(c-1.27,3838.73) -6.92,3844.39 ; -9.27,3838.73 cw(c-1.27,3838.73) -6.92,3844.39 ; -8.33,4372 ccw(c-8.33,4380) -2.68,4374.34 ; -8.33,4372 ccw(c-8.33,4380) -2.68,4374.34 ; -6.92,3844.39 9.08,3860.39 ; -2.68,4374.34 44.98,4422 617.63,4422 ; 4.39,3693.08 ccw(c-1.27,3698.73) 6.73,3698.73 ; 4.39,3693.08 ccw(c-1.27,3698.73) 6.73,3698.73 ; 6.73,3698.73 6.73,3835.42 18.05,3846.73 790,3846.73 ; 9.08,3860.39 cw(c14.73,3854.73) 14.73,3862.73 ; 9.08,3860.39 cw(c14.73,3854.73) 14.73,3862.73 ; 14.73,3862.73 790,3862.73 ; 36.01,4435.66 cw(c41.67,4430) 41.67,4438 ; 36.02,4435.66 cw(c41.67,4430) 41.67,4438 ; 36.01,4435.66 cw(c41.67,4430) 41.67,4438 ; 41.67,4438 614.32,4438 736.98,4560.66 ; 93.87,4575.87 ccw(c93.87,4583.87) 99.53,4578.22 ; 93.87,4575.87 ccw(c93.87,4583.87) 99.53,4578.22 ; 99.53,4578.22 207.81,4686.5 307.19,4686.5 313.34,4680.35 ccw(c330,4675) 347.5,4675 ccw(c330,4675) 324.65,4691.66 316.16,4700.16 ; 117,475 ccw(c125,475) 119.34,469.34 ; 117,475 ccw(c125,475) 119.34,469.34 ; 119.34,469.34 206.31,382.37 ; 130.66,1250.66 cw(c125,1245) 133,1245 ; 130.66,1250.66 cw(c125,1245) 133,1245 ; 133,1245 133,478.31 215.28,396.03 715.93,396.03 715.93,415.59 cw(c753.43,415.59) 790.92,415.59 ; 160,4797 ccw(c160,4805) 165.66,4799.34 ; 160,4797 ccw(c160,4805) 165.66,4799.34 ; 165.66,4799.34 187.51,4821.2 ; 187.51,4821.2 ccw(c181.86,4826.86) 189.86,4826.86 ; 187.51,4821.2 ccw(c181.86,4826.86) 189.86,4826.86 ; 198.84,4700.16 cw(c204.5,4694.5) 204.5,4702.5 ; 198.84,4700.16 cw(c204.5,4694.5) 204.5,4702.5 ; 204.5,4702.5 310.5,4702.5 ; 206.31,382.37 ccw(c211.97,388.03) 211.97,380.03 ; 206.31,382.37 ccw(c211.97,388.03) 211.97,380.03 ; 211.97,380.03 715.93,380.03 715.93,360.47 ccw(c753.43,360.47) 790.92,360.47 790.92,415.59 ; 310.5,4702.5 cw(c310.5,4694.5) 316.16,4700.16 ; 310.5,4702.5 cw(c310.5,4694.5) 316.16,4700.16 ; 610,898 cw(c610,890) 615.66,895.66 ; 610,898 cw(c610,890) 615.66,895.66 ; 610,898 300.56,898 ccw(c285,890) 300.56,882 606.69,882 634.34,854.34 ; 615.66,895.66 643.31,868 1259.44,868 cw(c1275,860) 1292.5,860 cw(c1275,860) 1259.44,852 640,852 ; 617.63,4422 ccw(c617.63,4430) 623.29,4424.34 ; 617.63,4422 ccw(c617.63,4430) 623.29,4424.34 ; 623.29,4424.34 745.95,4547 764.44,4547 ccw(c780,4555) 797.5,4555 ccw(c780,4555) 764.44,4563 742.63,4563 ; 634.34,854.34 ccw(c640,860) 640,852 ; 634.34,854.34 ccw(c640,860) 640,852 ; 736.98,4560.66 cw(c742.63,4555) 742.63,4563 ; 736.98,4560.66 cw(c742.63,4555) 742.63,4563 ; 790,3846.73 855,3846.73 ; 790,3846.73 855,3846.73 ; 790,3862.73 855,3862.73 ; 790,3862.73 855,3862.73 ; 855,3846.73 1592.07,3846.73 1621.62,3817.18 1621.62,3301.28 ; 855,3862.73 1595.38,3862.73 ; 1019.08,393.94 cw(c1056.57,393.94) 1094.07,393.94 1094.07,380 1094.07,358.5 cw(c1056.57,358.5) 1019.08,358.5 1019.08,393.94 ; 1120.93,232.52 cw(c1158.43,232.52) 1195.92,232.52 1195.92,217 1195.92,197.09 cw(c1158.43,197.09) 1120.93,197.09 1120.93,232.52 ; 1120.93,415.59 cw(c1158.43,415.59) 1195.92,415.59 ; 1120.93,415.59 1120.93,360.47 ccw(c1158.43,360.47) 1195.92,360.47 1195.92,415.59 ; 1424.08,279.76 cw(c1461.57,279.76) 1499.07,279.76 1499.07,244.33 cw(c1461.57,244.33) 1424.08,244.33 1424.08,279.76 ; 1424.08,393.94 cw(c1461.57,393.94) 1499.07,393.94 1499.07,382 1499.07,358.5 cw(c1461.57,358.5) 1424.08,358.5 1424.08,393.94 ; 1525.93,415.59 cw(c1563.43,415.59) 1600.92,415.59 ; 1525.93,415.59 1525.93,382 1525.93,360.47 ccw(c1563.43,360.47) 1600.92,360.47 1600.92,415.59 ; 1595.38,3862.73 cw(c1595.38,3854.73) 1601.04,3860.39 ; 1595.38,3862.73 cw(c1595.38,3854.73) 1601.04,3860.39 ; 1601.04,3860.39 1635.28,3826.15 ; 1621.62,3301.28 ccw(c1629.62,3301.28) 1623.96,3295.62 ; 1621.62,3301.28 ccw(c1629.62,3301.28) 1623.96,3295.62 ; 1623.96,3295.62 1643.57,3276.02 ccw(c1660,3270) 1677.5,3270 ccw(c1660,3270) 1655.34,3286.87 1637.62,3304.59 1637.62,3820.5 ; 1635.28,3826.15 cw(c1629.62,3820.5) 1637.62,3820.5 ; 1635.28,3826.15 cw(c1629.62,3820.5) 1637.62,3820.5 ; 1829.08,393.94 cw(c1866.57,393.94) 1904.07,393.94 1904.07,358.5 cw(c1866.57,358.5) 1829.08,358.5 1829.08,393.94 ; 1930.93,232.52 cw(c1968.43,232.52) 2005.92,232.52 2005.92,197.09 cw(c1968.43,197.09) 1930.93,197.09 1930.93,232.52 ; 1930.93,415.59 cw(c1968.43,415.59) 2005.92,415.59 ; 1930.93,415.59 1930.93,388 1930.93,360.47 ccw(c1968.43,360.47) 2005.92,360.47 2005.92,415.59 ; 2234.08,393.94 cw(c2271.57,393.94) 2309.07,393.94 2309.07,358.5 cw(c2271.57,358.5) 2234.08,358.5 2234.08,393.94 ; -697.5,3675 cw(c-680,3675) -662.5,3675 cw(c-680,3675) -697.5,3675 ; -677.5,2380 cw(c-660,2380) -642.5,2380 cw(c-660,2380) -677.5,2380 ; -462.5,4795 cw(c-445,4795) -427.5,4795 cw(c-445,4795) -462.5,4795 ; -385.64,4308.37 cw(c-368.14,4308.37) -350.64,4308.37 cw(c-368.14,4308.37) -385.64,4308.37 ; -310.64,3265.71 cw(c-293.14,3265.71) -275.64,3265.71 cw(c-293.14,3265.71) -310.64,3265.71 ; -282.5,4980 cw(c-265,4980) -247.5,4980 cw(c-265,4980) -282.5,4980 ; -282.5,5050 cw(c-265,5050) -247.5,5050 cw(c-265,5050) -282.5,5050 ; -252.5,4925 cw(c-235,4925) -217.5,4925 cw(c-235,4925) -252.5,4925 ; -177.31,3559.86 cw(c-159.81,3559.86) -142.31,3559.86 cw(c-159.81,3559.86) -177.31,3559.86 ; -174,4095 cw(c-156.5,4095) -139,4095 cw(c-156.5,4095) -174,4095 ; -142.5,5105 cw(c-125,5105) -107.5,5105 cw(c-125,5105) -142.5,5105 ; -132.5,4135 cw(c-115,4135) -97.5,4135 cw(c-115,4135) -132.5,4135 ; -52.5,3790 cw(c-35,3790) -17.5,3790 cw(c-35,3790) -52.5,3790 ; -35.64,2901.71 cw(c-18.14,2901.71) -0.64,2901.71 cw(c-18.14,2901.71) -35.64,2901.71 ; -27.31,2658.37 cw(c-9.81,2658.37) 7.69,2658.37 cw(c-9.81,2658.37) -27.31,2658.37 ; 2.69,2368.71 cw(c20.19,2368.71) 37.69,2368.71 cw(c20.19,2368.71) 2.69,2368.71 ; 22.69,858.37 cw(c40.19,858.37) 57.69,858.37 cw(c40.19,858.37) 22.69,858.37 ; v1@56.02,5025.04 cw(c73.52,5025.04) 91.02,5025.04 cw(c73.52,5025.04) v1@56.02,5025.04 ; 143.36,2800.04 cw(c160.86,2800.04) 178.36,2800.04 cw(c160.86,2800.04) 143.36,2800.04 ; 143.36,2891.71 cw(c160.86,2891.71) 178.36,2891.71 cw(c160.86,2891.71) 143.36,2891.71 ; 212.5,1285 cw(c230,1285) 247.5,1285 cw(c230,1285) 212.5,1285 ; 222.5,5015 cw(c240,5015) 257.5,5015 cw(c240,5015) 222.5,5015 ; 302.5,4610 cw(c320,4610) 337.5,4610 cw(c320,4610) 302.5,4610 ; 337.5,1280 cw(c355,1280) 372.5,1280 cw(c355,1280) 337.5,1280 ; 512.5,3250 cw(c530,3250) 547.5,3250 cw(c530,3250) 512.5,3250 ; 672.69,2725.04 cw(c690.19,2725.04) 707.69,2725.04 cw(c690.19,2725.04) 672.69,2725.04 ; 747.5,2575 cw(c765,2575) 782.5,2575 cw(c765,2575) 747.5,2575 ; 1064.36,991.71 cw(c1081.86,991.71) 1099.36,991.71 cw(c1081.86,991.71) 1064.36,991.71 ; 1132.36,4635.71 cw(c1149.86,4635.71) 1167.36,4635.71 cw(c1149.86,4635.71) 1132.36,4635.71 ; 1339.36,991.71 cw(c1356.86,991.71) 1374.36,991.71 cw(c1356.86,991.71) 1339.36,991.71 ; 1572.5,3000 cw(c1590,3000) 1607.5,3000 cw(c1590,3000) 1572.5,3000 ; 1607.5,2940 cw(c1625,2940) 1642.5,2940 cw(c1625,2940) 1607.5,2940 ; 1697.69,3180 cw(c1715.19,3180) 1732.69,3180 cw(c1715.19,3180) 1697.69,3180 ; 2234.08,244.33 ccw(c2271.57,244.33) 2309.07,244.33 2309.07,279.76 ccw(c2271.57,279.76) 2234.08,279.76 2234.08,271 2234.08,244.33
  MidLayer2 w12: v1(-159.14,5608.37) -26.63,5608.37 v2(-10,5625) ; v1@-155.25,5604.49 cw(c-145.86,5595.1) -145.86,5608.37 cw(c-145.86,5621.65) v1@-155.25,5612.26 ; v2@-15.81,5625 cw(c-29.84,5625) -19.92,5615.08 cw(c-10,5605.16) v2@-10,5619.19 ; v1(479.86,2575.04) 539.52,2634.71 v1(720.52,2634.71) 760.29,2634.71 803.29,2591.71 v1(905.86,2591.71) ; v1@479.86,2580.54 ccw(c479.86,2593.82) 489.25,2584.43 ccw(c498.64,2575.04) v1@485.36,2575.04 ; v1@716.64,2630.82 ccw(c707.25,2621.43) 707.25,2634.71 ccw(c707.25,2647.99) v1@716.64,2638.6 ; v1@724.41,2630.82 cw(c733.8,2621.43) 733.8,2634.71 cw(c733.8,2647.99) v1@724.41,2638.6 ; v1@901.97,2587.82 ccw(c892.58,2578.43) 892.58,2591.71 ccw(c892.58,2604.99) v1@901.97,2595.6