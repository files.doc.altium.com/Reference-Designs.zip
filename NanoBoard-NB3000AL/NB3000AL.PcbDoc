# Altium PCB NB3000AL.PcbDoc (part 60 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetC339_1: C339.1 U61.50 | length 1950.2
  Top Layer w4: v1@6222.36,2416.71 ccw(c6199.42,2416.71) 6215.64,2432.93 ccw(c6231.86,2449.14) v1@6231.86,2426.21 ; v1@6226.36,2416.71 ccw(c6213.08,2416.71) 6222.47,2426.1 ccw(c6231.86,2435.49) v1@6231.86,2422.21 ; v1(6231.86,2416.71) 6215.19,2433.37 6215.19,2500.04 6223.66,2508.51 U61.50@6351.93,2508.51 ; U61.50@6335.91,2505.68 ccw(c6329.08,2498.85) 6329.08,2508.51 ccw(c6329.08,2518.17) U61.50@6335.91,2511.34
  MidLayer1 w4: v1@6269.28,2271.28 cw(c6253.06,2255.06) 6276,2255.06 cw(c6298.93,2255.06) v1@6282.72,2271.28 ; v1@6272.11,2274.11 cw(c6262.72,2264.72) 6276,2264.72 cw(c6289.28,2264.72) v1@6279.89,2274.11 ; v1@6276.48,2278 v1(6276,2278) 6276,2226 6258,2208 6258,2186.81 6298.5,2146.31 6298.5,2071.5 v2(6330,2040) ; v2@6320.19,2040 ccw(c6296.5,2040) 6313.25,2056.75 ccw(c6330,2073.5) v2@6330,2049.81 ; v2@6324.19,2040 ccw(c6310.16,2040) 6320.08,2049.92 ccw(c6330,2059.84) v2@6330,2045.81
  MidLayer2 w4: v1(5639.52,1991.71) 5781.42,1991.71 5788.13,1985 5931.75,1985 5992,1985 6166.31,1985 6193.31,2012 6246.55,2012 6274.55,2040 v2(6330,2040) ; v1@5643.41,1987.82 cw(c5652.8,1978.43) 5652.8,1991.71 cw(c5652.8,2004.99) v1@5643.41,1995.6 ; v1@5646.24,1984.99 cw(c5662.46,1968.77) 5662.46,1991.71 cw(c5662.46,2014.64) v1@5646.24,1998.43 ; v1@6225.14,2409.99 cw(c6208.92,2393.77) 6231.86,2393.77 cw(c6254.79,2393.77) v1@6238.57,2409.99 ; v1@6227.97,2412.82 cw(c6218.58,2403.43) 6231.86,2403.43 cw(c6245.14,2403.43) v1@6235.75,2412.82 ; v1(6231.86,2416.71) 6231.86,2368.14 6276,2324 v1(6276,2278) ; v1@6269.28,2284.72 ccw(c6253.06,2300.93) 6276,2300.93 ccw(c6298.93,2300.93) v1@6282.72,2284.72 ; v1@6272.11,2281.89 ccw(c6262.72,2291.28) 6276,2291.28 ccw(c6289.28,2291.28) v1@6279.89,2281.89 ; v2@6323.06,2033.06 ccw(c6306.31,2016.31) 6306.31,2040 ccw(c6306.31,2063.69) v2@6323.06,2046.94 ; v2@6325.89,2035.89 ccw(c6315.97,2025.97) 6315.97,2040 ccw(c6315.97,2054.03) v2@6325.89,2044.11
  Bottom Layer w4: C339.1@5610,1959.33 v1@5639.52,1988.85 ; C339.1@5610,1965.14 ccw(c5610,1979.17) 5619.92,1969.25 ccw(c5629.84,1959.33) C339.1@5615.81,1959.33 ; C339.1@5610,1969.14 ccw(c5610,1992.83) 5626.75,1976.08 ; C339.1@5619.81,1959.33 cw(c5643.5,1959.33) 5626.75,1976.08 ; C339.1@5621.29,1970.62 ccw(c5600.2,1991.71) v1@5630.02,1991.71 ; 5628.12,1977.45 ccw(c5613.86,1991.71) v1@5634.02,1991.71 ; 5628.18,1977.51 cw(c5639.52,1966.16) v1@5639.52,1982.21
NetD3_1: D3.1 Q4.2 RLY1.8 | length 744
  Top Layer w4: Q4.2@4825.18,5337.46 ccw(c4792.13,5378.74) D3.1@4845,5378.74 ; Q4.2@4827.68,5334.34 ccw(c4798.79,5370.41) D3.1@4845,5370.41 ; Q4.2@4830.18,5331.22 ccw(c4805.46,5362.08) D3.1@4845,5362.08 ; Q4.2@4832.68,5328.1 ccw(c4812.13,5353.75) 4845,5353.75 ; Q4.2@4835,5324.21 4845,5334.21 D3.1@4845,5378.74 ; Q4.2@4835.18,5324.98 ccw(c4818.8,5345.43) 4845,5345.43 ; D3.1@4835.81,5362.05 cw(c4813.62,5339.85) 4845,5339.85 cw(c4876.39,5339.85) D3.1@4854.19,5362.05 ; D3.1@4837.92,5397.14 ccw(c4829.44,5410.19) 4845,5410.19 ; D3.1@4838.64,5364.88 cw(c4823.27,5349.51) 4845,5349.51 cw(c4866.73,5349.51) D3.1@4851.36,5364.88 ; D3.1@4840.1,5393.79 ccw(c4834.23,5402.82) 4845,5402.82 ccw(c4855.77,5402.82) D3.1@4849.9,5393.79 ; D3.1@4852.08,5397.14 cw(c4860.56,5410.19) 4845,5410.19 ; 4937.64,5522.36 cw(c4925.38,5510.11) RLY1.8@4941.93,5504.97 ; 4939.47,5520.53 ccw(c4953.86,5534.91) RLY1.8@4954.54,5514.58 ; RLY1.8@4942.32,5517.68 cw(c4932.53,5507.89) RLY1.8@4945.75,5503.78 ; RLY1.8@4955,5481.22 4955,5505 4935,5525 4830,5525 4815,5510 4815,5440.19 4845,5410.19 ; D3.1@4845,5378.74 4845,5410.19
NetD4_1: D4.1 Q6.2 RLY2.8 | length 513.4
  Top Layer w4: Q6.2@5410.51,5324.72 5435,5349.21 ; Q6.2@5410.76,5332.88 ccw(c5412.27,5348.05) Q6.2@5423.05,5337.27 ; Q6.2@5411.16,5336.86 ccw(c5413.35,5358.91) 5429.03,5343.24 ; Q6.2@5411.56,5340.84 ccw(c5414.43,5369.78) 5435,5349.21 ; Q6.2@5421.71,5325.58 cw(c5444.83,5326.33) 5428.47,5342.69 ; D4.1@5422.76,5397.03 ccw(c5407.35,5420) 5435,5420 ; D4.1@5424.99,5393.71 ccw(c5412.38,5412.5) 5435,5412.5 ; Q6.2@5425.71,5325.71 cw(c5457.47,5326.74) 5435,5349.21 ; D4.1@5427.1,5358.57 cw(c5424.83,5348.65) 5435,5348.65 ; D4.1@5427.21,5390.39 ccw(c5417.41,5404.99) 5435,5404.99 ; D4.1@5427.99,5362.47 cw(c5425.98,5353.67) 5435,5353.67 ; 5435,5351.93 cw(c5449.31,5351.93) D4.1@5439.19,5362.05 ; D4.1@5435,5370 5435,5349.21 ; D4.1@5435,5373.74 5435,5420 ; 5435,5405.55 ccw(c5449.31,5405.55) D4.1@5439.19,5395.43 ; 5515.77,5435.77 ccw(c5508.19,5443.34) RLY2.8@5516.42,5450.21 ; 5518.86,5438.86 ccw(c5511.57,5446.16) RLY2.8@5519.49,5452.77 ; 5519.5,5439.5 cw(c5530,5429) RLY2.8@5530,5443.85 ; RLY2.8@5521.96,5441.96 ccw(c5514.94,5448.98) RLY2.8@5522.56,5455.33 ; RLY2.8@5535,5476.22 5535,5455 5510,5430 5445,5430 5435,5420
NetD5_1: D5.1 Q7.2 RLY3.8 | length 624.8
  Top Layer w4: Q7.2@6000.51,5324.72 6025,5349.21 ; Q7.2@6000.76,5332.88 ccw(c6002.27,5348.05) Q7.2@6013.05,5337.27 ; Q7.2@6001.16,5336.86 ccw(c6003.35,5358.91) 6019.03,5343.24 ; Q7.2@6001.56,5340.84 ccw(c6004.43,5369.78) 6025,5349.21 ; Q7.2@6011.71,5325.58 cw(c6034.83,5326.33) 6018.47,5342.69 ; Q7.2@6015.71,5325.71 cw(c6047.47,5326.74) 6025,5349.21 ; D5.1@6015.81,5395.43 ccw(c5993.62,5417.62) 6025,5417.62 ccw(c6056.39,5417.62) D5.1@6034.19,5395.43 ; D5.1@6018.64,5392.6 ccw(c6003.27,5407.97) 6025,5407.97 ccw(c6046.73,5407.97) D5.1@6031.36,5392.6 ; D5.1@6018.72,5359.86 cw(c6012.84,5349.21) 6025,5349.21 ; D5.1@6020.65,5363.36 cw(c6016.58,5355.99) 6025,5355.99 cw(c6033.42,5355.99) D5.1@6029.35,5363.36 ; D5.1@6025,5370 6025,5349.21 ; D5.1@6025,5373.74 6025,5420 6035,5430 6100,5430 6125,5455 RLY3.8@6125,5476.22 ; D5.1@6031.28,5359.86 ccw(c6037.16,5349.21) 6025,5349.21 ; 6100.77,5430.77 ccw(c6072.74,5458.8) RLY3.8@6112.34,5460.69 ; 6102.43,5432.43 cw(c6130,5404.86) RLY3.8@6130,5443.85 ; 6107.16,5437.16 ccw(c6084.94,5459.38) RLY3.8@6116.33,5460.88 ; 6109.26,5439.26 cw(c6130,5418.52) RLY3.8@6130,5447.85 ; 6113.55,5443.55 ccw(c6097.14,5459.97) RLY3.8@6120.33,5461.07 ; RLY3.8@6116.09,5446.09 cw(c6130,5432.18) RLY3.8@6130,5451.85
  Top Layer w12: RLY3.8@6123.82,5475.04 RLY3.8@6130,5481.22
NetD6_1: D6.1 Q8.2 RLY4.8 | length 542.4
  Top Layer w4: Q8.2@6585,5329.21 Q8.2@6586.02,5329.21 ; Q8.2@6585.51,5329.72 6610,5354.21 ; Q8.2@6585.76,5337.88 ccw(c6587.27,5353.05) Q8.2@6598.05,5342.27 ; Q8.2@6586.16,5341.86 ccw(c6588.35,5363.91) 6604.03,5348.24 ; Q8.2@6586.56,5345.84 ccw(c6589.43,5374.78) 6610,5354.21 ; Q8.2@6596.71,5330.58 cw(c6619.83,5331.33) 6603.47,5347.69 ; Q8.2@6600.71,5330.71 cw(c6632.47,5331.74) 6610,5354.21 ; D6.1@6600.81,5395.43 ccw(c6578.62,5417.62) 6610,5417.62 ccw(c6641.39,5417.62) D6.1@6619.19,5395.43 ; D6.1@6603.64,5392.6 ccw(c6588.27,5407.97) 6610,5407.97 ccw(c6631.73,5407.97) D6.1@6616.36,5392.6 ; D6.1@6606.58,5358.7 cw(c6605.35,5354.21) 6610,5354.21 ; D6.1@6610,5375 6610,5354.21 ; D6.1@6610,5378.74 6610,5425 6620,5435 6685,5435 6710,5460 RLY4.8@6710,5481.22 ; D6.1@6613.43,5358.7 ccw(c6614.65,5354.21) 6610,5354.21 ; 6691.1,5441.1 ccw(c6677.02,5455.17) RLY4.8@6696.56,5458.94 ; 6691.79,5441.79 cw(c6706.78,5426.81) RLY4.8@6708.74,5447.91 ; RLY4.8@6692.64,5458.18 cw(c6668.1,5453.44) 6685.77,5435.77 cw(c6705.75,5415.78) RLY4.8@6708.37,5443.93 ; RLY4.8@6696.42,5446.42 ccw(c6685.95,5456.89) RLY4.8@6700.49,5459.7
  Top Layer w12: RLY4.8@6707.85,5483.37 RLY4.8@6710,5481.22
NetD8_1: D8.1 R147.2 | length 201.7
  Top Layer w4: R147.2@4461.18,4265.19 cw(c4461.18,4241.5) 4477.93,4258.25 ; R147.2@4461.18,4269.19 cw(c4461.18,4255.16) R147.2@4471.1,4265.08 ; R147.2@4461.18,4275 4482.37,4253.81 4514,4253.81 4523.25,4244.57 D8.1@4564.41,4244.57 ; R147.2@4466.5,4274.51 ccw(c4478.15,4274.51) R147.2@4469.91,4266.27 ; R147.2@4470.5,4274.51 ccw(c4491.81,4274.51) 4476.74,4259.44 ; D8.1@4558.75,4238.91 ccw(c4545.1,4225.25) 4545.1,4244.57 ccw(c4545.1,4263.88) D8.1@4558.75,4250.22
NetD9_2: D9.2 R194.1 U36.1 | length 794.7
  Bottom Layer w4: R194.1@2967.23,6197.92 cw(c2951.32,6182.01) 2973.82,6182.01 cw(c2996.32,6182.01) R194.1@2980.41,6197.92 ; R194.1@2970.06,6200.75 cw(c2960.98,6191.67) 2973.82,6191.67 cw(c2986.66,6191.67) R194.1@2977.58,6200.75 ; R194.1@2973.82,6205 2973.82,5991.41 2976.49,5988.74 ; D9.2@2982.77,5984.33 ccw(c2976.49,5982.05) 2976.49,5988.74 ; D9.2@2982.77,5993.15 cw(c2976.49,5995.42) 2976.49,5988.74 ; D9.2@3001.36,5982.38 cw(c3016.73,5967.01) 3016.73,5988.74 cw(c3016.73,6010.47) D9.2@3001.36,5995.1 ; D9.2@3004.19,5979.55 cw(c3026.38,5957.36) 3026.38,5988.74 cw(c3026.39,6020.13) D9.2@3004.19,5997.93 ; U36.1@3090.33,5976.3 ccw(c3054.79,5951.87) 3054.79,5995 ; U36.1@3090.33,6013.69 cw(c3054.79,6038.13) 3054.79,5995 ; U36.1@3093.62,5978.57 ccw(c3062.39,5957.1) 3062.39,5995 ccw(c3062.39,6032.9) U36.1@3093.62,6011.43 ; U36.1@3096.92,5980.84 ccw(c3069.99,5962.33) 3069.99,5995 ccw(c3069.99,6027.67) U36.1@3096.92,6009.16 ; U36.1@3100.21,5983.1 ccw(c3077.6,5967.55) 3077.6,5995 ccw(c3077.6,6022.44) U36.1@3100.21,6006.9 ; U36.1@3122.52,5995 3054.78,5995 ; 2976.49,5988.74 D9.2@2995,5988.74 3048.52,5988.74 3054.78,5995
NetJ11_1: J11.1 T1.8 | length 1076
  Bottom Layer w12: 4597.03,524.75 cw(c4499.86,427.58) J11.1@4637.25,424.74 ; 4611.82,509.96 ccw(c4682.23,580.37) J11.1@4682.23,480.79 ; 4616.93,504.85 cw(c4538.85,426.78) J11.1@4649.25,424.49 ; 4632.31,489.47 ccw(c4682.23,539.4) J11.1@4682.23,468.79 ; 4636.83,484.95 cw(c4577.84,425.97) J11.1@4661.24,424.24 ; T1.8@4654.56,897.45 cw(c4622.13,865.01) 4668,865.01 cw(c4713.87,865.01) T1.8@4681.44,897.45 ; T1.8@4668,945.92 4668,848 4585,765 4585,536.78 J11.1@4697.98,423.8
NetJ11_2: J11.2 J11.3 J11.4 T1.5 | length 2056.1
  MidLayer2 w12: J11.3@4480.43,668.42 ccw(c4464.13,697.19) 4497.19,697.19 ; J11.3@4497.19,608.84 4497.19,697.19 ; J11.3@4513.95,668.42 cw(c4530.26,697.19) 4497.19,697.19 ; J11.4@4641.93,659.09 ccw(c4544.64,561.8) 4544.64,699.39 ccw(c4544.64,836.98) J11.4@4641.93,739.69 ; J11.4@4650.42,667.58 ccw(c4573.61,590.77) 4573.61,699.39 ccw(c4573.61,808.01) J11.4@4650.42,731.21 ; J11.4@4658.9,676.06 ccw(c4602.58,619.74) 4602.58,699.39 ccw(c4602.58,779.04) J11.4@4658.9,722.72 ; J11.4@4697.98,699.39 4499.39,699.39 4497.19,697.19
  Bottom Layer w12: J11.4@4697.98,699.39 4884.39,699.39 ; J11.4@4737.06,676.06 cw(c4793.38,619.74) 4793.38,699.39 cw(c4793.38,779.04) J11.4@4737.06,722.72 ; J11.4@4745.54,667.58 cw(c4822.35,590.77) 4822.35,699.39 cw(c4822.35,808.01) J11.4@4745.54,731.21 ; J11.4@4754.03,659.09 cw(c4851.32,561.8) 4851.32,699.39 cw(c4851.32,836.98) J11.4@4754.03,739.69 ; J11.2@4888.67,671.31 ccw(c4884.41,685.02) 4898.77,685.02 ; J11.2@4898.77,608.84 4898.77,685.02 ; J11.2@4908.86,671.31 cw(c4913.12,685.02) 4898.77,685.02 ; T1.5@4954.56,897.45 cw(c4922.13,865.01) 4968,865.01 cw(c5013.87,865.01) T1.5@4981.44,897.45 ; T1.5@4968,945.92 4968,783 4884.39,699.39 ; 4884.39,699.39 4898.77,685.02
NetJ24_2: J24.2 R264.1 | length 5243.5
  Top Layer w4: v1(6746.52,2481.37) 6765,2481.37 ; v1@6754.25,2475.85 cw(c6765,2468.16) 6765,2481.37 ; v1@6754.25,2486.9 ccw(c6765,2494.59) 6765,2481.37 ; R264.1@6781.07,2469.82 ccw(c6771.38,2463.33) 6771.38,2475 ; R264.1@6781.07,2480.18 cw(c6771.38,2486.67) 6771.38,2475 ; R264.1@6788.82,2475 6771.38,2475 ; 6765,2481.37 6771.38,2475
  MidLayer1 w4: v1@6739.81,2474.66 ccw(c6723.59,2458.44) 6723.59,2481.37 ccw(c6723.59,2504.31) v1@6739.81,2488.09 ; v1@6742.64,2477.49 ccw(c6733.25,2468.1) 6733.25,2481.37 ccw(c6733.25,2494.65) v1@6742.64,2485.26 ; v1(6746.52,2481.37) 6718.63,2481.37 6700,2500 6700,2545 6725,2570 6741.82,2570 6763.87,2592.05 6763.87,2606.8 6907.02,2749.95 6907.02,2766.62 6995.4,2855 7188.58,2855 7226.45,2892.87 7245.69,2912.11 7245.69,3030 7245.69,3072.82 7273.52,3100.65 7273.52,3847.06 7223.03,3897.56 7223.03,3962.48 7239.69,3979.15 7239.69,4049.46 7231.02,4058.13 7231.02,4072.62 7270,4111.6 7270,4305.89 7290.35,4326.24 7290.35,4570.35 7302.54,4582.54 7347.54,4582.54 7357.69,4592.69 7357.69,4607.29 7347.44,4617.54 7342.46,4617.54 7320.69,4639.31 7320.69,4698.96 7367.02,4745.28 7367.02,4780 7357.02,4790 v1(7235,4790) ; v1@7238.89,4786.11 cw(c7248.28,4776.72) 7248.28,4790 cw(c7248.28,4803.28) v1@7238.89,4793.89 ; v1@7241.72,4783.28 cw(c7257.94,4767.06) 7257.94,4790 cw(c7257.94,4812.93) v1@7241.72,4796.72 ; v1(7540,4760) 7580,4760 7600,4780 7600,5075 v1(7585,5090) ; v1@7543.89,4756.11 cw(c7553.28,4746.72) 7553.28,4760 cw(c7553.28,4773.28) v1@7543.89,4763.89 ; v1@7546.72,4753.28 cw(c7562.94,4737.06) 7562.94,4760 cw(c7562.94,4782.93) v1@7546.72,4766.72
  MidLayer2 w4: v1(7235,4790) 7345,4790 7385,4750 7430,4750 7440,4760 v1(7540,4760) ; v1@7238.89,4786.11 cw(c7248.28,4776.72) 7248.28,4790 cw(c7248.28,4803.28) v1@7238.89,4793.89 ; v1@7241.72,4783.28 cw(c7257.94,4767.06) 7257.94,4790 cw(c7257.94,4812.93) v1@7241.72,4796.72 ; v1@7533.28,4753.28 ccw(c7517.06,4737.06) 7517.06,4760 ccw(c7517.06,4782.93) v1@7533.28,4766.72 ; v1@7536.11,4756.11 ccw(c7526.72,4746.72) 7526.72,4760 ccw(c7526.72,4773.28) v1@7536.11,4763.89
  Bottom Layer w4: v1(7585,5090) 7660,5090 7740,5010 7755,4995 7872.5,4995 7887.5,5010 8059.33,5010 J24.2@8074.71,5025.38 ; v1@7588.89,5086.11 cw(c7598.28,5076.72) 7598.28,5090 cw(c7598.28,5103.28) v1@7588.89,5093.89 ; v1@7591.72,5083.28 cw(c7607.94,5067.06) 7607.94,5090 cw(c7607.94,5112.93) v1@7591.72,5096.72 ; 7971.13,5010 ccw(c7971.13,5128.96) J24.2@8055.24,5044.84 ; 7980.78,5010 ccw(c7980.78,5119.3) J24.2@8058.07,5042.01 ; 7990.44,5010 ccw(c7990.44,5109.65) J24.2@8060.9,5039.19 ; 8000.1,5010 ccw(c8000.1,5099.99) J24.2@8063.73,5036.36 ; 8009.75,5010 ccw(c8009.75,5090.33) J24.2@8066.56,5033.53 ; 8019.41,5010 ccw(c8019.41,5080.68) J24.2@8069.39,5030.7 ; 8029.07,5010 ccw(c8029.07,5071.02) J24.2@8072.21,5027.87 ; 8038.72,5010 ccw(c8038.72,5061.36) J24.2@8075.04,5025.04 ; 8045.38,5010 cw(c8045.38,4996.05) J24.2@8055.24,5005.91 ; 8048.38,5010 ccw(c8048.38,5051.71) J24.2@8077.87,5022.22
NetJ26_2: J26.2 R212.2 | length 545.6
  Bottom Layer w4: J26.2@1410.24,5665.16 cw(c1363.25,5618.16) 1429.71,5618.16 cw(c1496.16,5618.17) J26.2@1449.17,5665.16 ; J26.2@1413.07,5667.99 cw(c1372.91,5627.82) 1429.71,5627.82 cw(c1486.51,5627.82) J26.2@1446.35,5667.99 ; J26.2@1415.9,5670.81 cw(c1382.56,5637.48) 1429.71,5637.48 cw(c1476.85,5637.48) J26.2@1443.52,5670.81 ; J26.2@1418.73,5673.64 cw(c1392.22,5647.13) 1429.71,5647.13 cw(c1467.19,5647.14) J26.2@1440.69,5673.64 ; R212.2@1423.41,5527.77 ccw(c1407.5,5543.68) 1430,5543.68 ccw(c1452.5,5543.68) R212.2@1436.59,5527.77 ; R212.2@1426.24,5524.94 ccw(c1417.16,5534.02) 1430,5534.02 ccw(c1442.84,5534.02) R212.2@1433.76,5524.94 ; J26.2@1429.71,5684.62 1429.71,5600.33 1430,5600.04 R212.2@1430,5521.18
NetJ27_1: J27.1 J27.2 J27.3 J27.5 R100.1 R101.1 | length 1338.2
  Top Layer w4: J27.5@6220.54,3118.39 J27.3@6259.91,3118.39 6280,3118.39 ; J27.5@6224.69,3114.23 cw(c6234.72,3104.2) 6234.72,3118.39 cw(c6234.72,3132.57) J27.5@6224.69,3122.54 ; J27.3@6255.75,3114.23 ccw(c6245.73,3104.2) 6245.73,3118.39 ccw(c6245.73,3132.57) J27.3@6255.75,3122.54 ; J27.3@6264.06,3114.23 cw(c6274.09,3104.2) 6274.09,3118.39 cw(c6274.09,3132.57) J27.3@6264.06,3122.54 ; J27.2@6275.44,3067.89 ccw(c6265.41,3077.92) 6279.59,3077.92 ccw(c6293.77,3077.92) J27.2@6283.75,3067.89 ; J27.2@6278.56,3040.58 cw(c6297,3022.14) v1@6302.39,3047.66 ; J27.2@6283.78,3045.8 cw(c6298.82,3030.76) v1@6303.21,3051.57 ; 6289,3051.02 cw(c6300.64,3039.37) v1@6304.04,3055.49 ; J27.1@6295.12,3114.23 ccw(c6285.1,3104.2) 6285.1,3118.39 ccw(c6285.1,3132.57) J27.1@6295.12,3122.54 ; J27.1@6299.28,3118.39 6280,3118.39 ; v1(6303.52,3053.04) 6291.02,3053.04 J27.2@6279.59,3041.61 6279.59,3117.98 6280,3118.39 ; v1(6698.52,2866.71) 6723.52,2866.71 6765.23,2825 6788.33,2825 6788.57,2824.75 R100.1@6788.82,2824.51 ; v1@6702.41,2862.82 cw(c6711.8,2853.43) 6711.8,2866.71 cw(c6711.8,2879.99) v1@6702.41,2870.6 ; v1@6705.24,2859.99 cw(c6721.46,2843.77) 6721.46,2866.71 cw(c6721.46,2889.64) v1@6705.24,2873.43 ; R101.1@6782.23,2762.08 ccw(c6766.32,2777.99) 6788.82,2777.99 ccw(c6811.32,2777.99) R101.1@6795.41,2762.08 ; R100.1@6782.23,2817.92 cw(c6766.32,2802.01) 6788.82,2802.01 cw(c6811.32,2802.01) R100.1@6795.41,2817.92 ; R100.1@6782.23,2818.41 ccw(c6766.32,2802.5) 6766.32,2825 ccw(c6766.32,2847.5) R100.1@6782.23,2831.59 ; R101.1@6785.06,2759.25 ccw(c6775.98,2768.33) 6788.82,2768.33 ccw(c6801.66,2768.33) R101.1@6792.58,2759.25 ; R100.1@6785.06,2820.75 cw(c6775.98,2811.67) 6788.82,2811.67 cw(c6801.66,2811.67) R100.1@6792.58,2820.75 ; R100.1@6785.06,2821.24 ccw(c6775.98,2812.16) 6775.98,2825 ccw(c6775.98,2837.84) R100.1@6785.06,2828.76 ; R101.1@6788.82,2755 R100.1@6788.82,2824.51 ; R100.1@6788.82,2825 R100.1@6788.82,2824.51
  MidLayer2 w4: v1@6303.52,3043.54 cw(c6303.52,3020.61) 6319.74,3036.82 cw(c6335.96,3053.04) v1@6313.02,3053.04 ; v1@6303.52,3047.54 cw(c6303.52,3034.26) 6312.91,3043.65 cw(c6322.3,3053.04) v1@6309.02,3053.04 ; v1(6303.52,3053.04) 6381.86,2974.71 6435.63,2974.71 6462.44,2947.9 6472.12,2938.21 6624.35,2938.21 v1@6695.86,2866.71 ; 6677.75,2884.81 ccw(c6698.52,2905.58) v1@6698.52,2876.21 ; 6684.19,2878.37 cw(c6672.53,2866.71) v1@6689.02,2866.71 ; 6684.58,2877.98 ccw(c6698.52,2891.92) v1@6698.52,2872.21
NetJ27_4: J27.4 NT34.1 | length 79.2
  Top Layer w4: J27.4@6236.07,3015.33 cw(c6226.04,3005.31) 6240.22,3005.31 cw(c6254.4,3005.31) J27.4@6244.38,3015.33 ; NT34.1@6237.17,3007.33 ccw(c6229.81,3014.69) J27.4@6240.22,3014.69 ; NT34.1@6240,3000 6240.22,3000.22 J27.4@6240.22,3041.61 ; J27.4@6240.22,3013.62 ccw(c6249.12,3013.62) NT34.1@6242.83,3007.33
NetJ27_7: J27.7 NT39.1 | length 77.9
  Top Layer w4: J27.7@6177.01,3144.67 ccw(c6166.98,3154.69) 6181.17,3154.69 ccw(c6195.35,3154.69) J27.7@6185.32,3144.67 ; NT39.1@6177.17,3152.67 cw(c6167.52,3143.02) J27.7@6181.17,3143.02 ; J27.7@6181.17,3118.39 NT39.1@6181.17,3158.83 ; 6181.17,3148.66 cw(c6186.84,3148.66) NT39.1@6182.83,3152.67
NetJ27_14: J27.14 NT38.1 | length 74.2
  Top Layer w4: J27.14@6039.22,3015.33 cw(c6029.19,3005.31) 6043.37,3005.31 cw(c6057.55,3005.31) J27.14@6047.53,3015.33 ; NT38.1@6043.37,3001.63 J27.14@6043.37,3041.61 ; J27.14@6043.37,3017.59 ccw(c6058.59,3017.59) NT38.1@6047.83,3006.83
NetJ27_24: J27.24 NT37.1 | length 79.7
  Top Layer w4: NT37.1@5842.17,3007.33 ccw(c5831.67,3017.83) J27.24@5846.52,3017.83 ; J27.24@5842.37,3015.33 cw(c5832.34,3005.31) 5846.52,3005.31 cw(c5860.7,3005.31) J27.24@5850.68,3015.33 ; NT37.1@5845,3000 5846.52,3001.52 J27.24@5846.52,3041.61 ; NT37.1@5846.52,3010.48 ccw(c5850.98,3010.48) NT37.1@5847.83,3007.33
NetJ27_26: J27.26 NT41.1 | length 78.1
  Top Layer w4: NT41.1@5802.17,3007.33 ccw(c5790.15,3019.35) J27.26@5807.15,3019.35 ; J27.26@5803,3015.33 cw(c5792.97,3005.31) 5807.15,3005.31 cw(c5821.33,3005.31) J27.26@5811.31,3015.33 ; NT41.1@5805,3000 5807.15,3002.15 J27.26@5807.15,3041.61
NetJ27_29: J27.29 NT35.1 | length 77.4
  Top Layer w4: J27.29@5743.94,3144.67 ccw(c5733.92,3154.69) 5748.1,3154.69 ccw(c5762.28,3154.69) J27.29@5752.25,3144.67 ; J27.29@5748.1,3118.39 5748.1,3158.1 NT35.1@5750,3160 ; J27.29@5748.1,3141.25 cw(c5764.25,3141.25) NT35.1@5752.83,3152.67
NetJ27_31: J27.31 NT36.1 | length 79.6
  Top Layer w4: J27.31@5704.57,3144.67 ccw(c5694.55,3154.69) 5708.73,3154.69 ccw(c5722.91,3154.69) J27.31@5712.88,3144.67 ; NT36.1@5707.17,3152.67 cw(c5703.42,3148.92) 5708.73,3148.92 ; J27.31@5708.73,3118.39 5708.73,3158.73 NT36.1@5710,3160 ; J27.31@5708.73,3142.77 cw(c5722.73,3142.77) NT36.1@5712.83,3152.67
NetJ27_33: J27.33 NT40.1 | length 79.3
  Top Layer w4: J27.33@5665.2,3144.67 ccw(c5655.18,3154.69) 5669.36,3154.69 ccw(c5683.54,3154.69) J27.33@5673.51,3144.67 ; NT40.1@5667.17,3152.67 cw(c5661.9,3147.4) J27.33@5669.36,3147.4 ; J27.33@5669.36,3118.39 5669.36,3159.36 NT40.1@5670,3160 ; J27.33@5669.36,3144.29 cw(c5681.21,3144.29) NT40.1@5672.83,3152.67
NetJ27_40: J27.40 Q11.2 R100.2 R101.2 | length 2710.5
  Top Layer w4: v2@5477,2969.81 ccw(c5477,2981.72) 5485.42,2973.3 ; v2@5477.74,2965.62 5492.12,2980 5518,2980 5531.56,2993.56 J27.40@5531.56,3041.61 ; v2@5482.7,2961.13 cw(c5497.47,2964.05) 5486.82,2974.7 ; v2@5486.62,2961.91 cw(c5506.32,2965.8) 5492.12,2980 ; J27.40@5527.41,3015.33 cw(c5517.38,3005.31) 5531.56,3005.31 cw(c5545.74,3005.31) J27.40@5535.71,3015.33 ; v1(6815.19,2727.71) R101.2@6831.18,2743.7 ; v1@6815.25,2733.21 ccw(c6815.37,2746.04) 6824.45,2736.97 ccw(c6833.52,2727.89) v1@6820.69,2727.76 ; v1@6815.29,2737.21 ccw(c6815.51,2759.37) R101.2@6831.18,2743.7 ; R101.2@6821.56,2745.38 cw(c6830.77,2736.17) R101.2@6831.06,2749.19 ; R101.2@6822.45,2746.27 ccw(c6814.21,2754.51) R101.2@6825.86,2754.51 ; R101.2@6824.59,2762.08 ccw(c6808.68,2777.99) 6831.18,2777.99 ccw(c6853.68,2777.99) R101.2@6837.77,2762.08 ; R100.2@6824.59,2817.92 cw(c6808.68,2802.01) 6831.18,2802.01 cw(c6853.68,2802.01) R100.2@6837.77,2817.92 ; v1@6824.69,2727.8 cw(c6846.85,2728.03) R101.2@6831.18,2743.7 ; R101.2@6827.42,2759.25 ccw(c6818.34,2768.33) 6831.18,2768.33 ccw(c6844.02,2768.33) R101.2@6834.94,2759.25 ; R100.2@6827.42,2820.75 cw(c6818.34,2811.67) 6831.18,2811.67 cw(c6844.02,2811.67) R100.2@6834.94,2820.75 ; R101.2@6831.18,2766.03 R100.2@6831.18,2825 ; R101.2@6834.94,2751.24 cw(c6844.02,2742.16) 6844.02,2755 cw(c6844.02,2767.84) R101.2@6834.94,2758.76 ; R101.2@6837.77,2748.41 cw(c6853.68,2732.5) 6853.68,2755 cw(c6853.68,2777.5) R101.2@6837.77,2761.59 ; 7021.5,2747.5 cw(c7021.5,2701.69) Q11.2@7053.89,2734.08 ; 7031.15,2747.5 cw(c7031.15,2711.35) Q11.2@7056.72,2736.91 ; 7032.62,2747.5 ccw(c7032.62,2777.58) Q11.2@7053.89,2756.31 ; 7040.81,2747.5 cw(c7040.81,2721.01) Q11.2@7059.54,2739.74 ; 7042.27,2747.5 ccw(c7042.27,2767.92) Q11.2@7056.72,2753.48 ; Q11.2@7065,2744.21 7065,2741.71 7059.21,2747.5 6952.75,2747.5 6946.96,2741.71 6880,2741.71 6866.71,2755 R101.2@6831.18,2755 R101.2@6831.18,2743.7
  MidLayer2 w4: v2@5477,2950.19 cw(c5477,2926.5) 5493.75,2943.25 cw(c5510.5,2960) v2@5486.81,2960 ; v2@5477,2954.19 cw(c5477,2940.16) 5486.92,2950.08 cw(c5496.84,2960) v2@5482.81,2960 ; v2(5477,2960) 5521.38,2915.62 5521.38,2889.81 5536.56,2874.63 5561.29,2874.63 5611.29,2824.63 5635.37,2824.63 5715.01,2824.63 5761.77,2777.86 5761.77,2739.79 5803.85,2697.72 5813.56,2688 v1(5854,2688) ; v1@5847.28,2681.28 ccw(c5831.06,2665.06) 5831.06,2688 ccw(c5831.06,2710.93) v1@5847.28,2694.72 ; v1@5850.11,2684.11 ccw(c5840.72,2674.72) 5840.72,2688 ccw(c5840.72,2701.28) v1@5850.11,2691.89
  Bottom Layer w4: v1@5847.28,2681.28 cw(c5831.06,2665.06) 5854,2665.06 cw(c5876.93,2665.06) v1@5860.72,2681.28 ; v1@5850.11,2684.11 cw(c5840.72,2674.72) 5854,2674.72 cw(c5867.28,2674.72) v1@5857.89,2684.11 ; v1(5854,2688) 5854,2656 5867.96,2642.04 6048.59,2642.04 ; 6048.75,2642.21 6360.27,2642.21 6423.5,2705.44 6423.5,2722.35 6432.65,2731.5 6464.48,2731.5 6465.77,2730.21 6658.32,2730.21 6667.15,2739.04 6719.33,2739.04 6735.29,2755 6787.9,2755 v1(6815.19,2727.71) ; v1@6805.69,2727.71 ccw(c6782.76,2727.71) 6798.97,2743.93 ccw(c6815.19,2760.14) v1@6815.19,2737.21 ; v1@6809.69,2727.71 ccw(c6796.41,2727.71) 6805.8,2737.1 ccw(c6815.19,2746.49) v1@6815.19,2733.21
NetJ28_7: J28.7 NT28.1 | length 87
  Top Layer w4: NT28.1@4205,4020 NT28.1@4212.08,4020 ; NT28.1@4216.58,4016.49 cw(c4225.06,4008.01) J28.7@4225.06,4020 ; NT28.1@4216.98,4020 cw(c4216.98,4014.21) J28.7@4222.65,4015.37 ; NT28.1@4218.73,4014.57 ccw(c4212.08,4013.21) NT28.1@4212.08,4020 ; NT28.1@4219.41,4013.66 cw(c4234.71,3998.35) J28.7@4234.71,4020 ; J28.7@4246.61,4015.75 4242.36,4020 NT28.1@4212.08,4020
NetJ28_14: J28.14 NT29.1 | length 88.9
  Top Layer w4: J28.14@4323.39,3877.95 4325.43,3880 NT29.1@4365,3880 ; J28.14@4346.84,3876.63 cw(c4354.98,3868.49) NT29.1@4354.98,3880 ; J28.14@4349.67,3873.8 cw(c4364.63,3858.83) NT29.1@4364.63,3880 ; J28.14@4349.67,3882.11 ccw(c4354.75,3887.19) NT29.1@4354.75,3880 ; NT29.1@4357.67,3877.17 ccw(c4350.84,3870.34) 4350.84,3880 ccw(c4350.84,3889.66) NT29.1@4357.67,3882.83
NetJ28_24: J28.24 NT33.1 | length 87.2
  Top Layer w4: J28.24@4323.39,3681.1 4327.28,3685 NT33.1@4365,3685 ccw(c4365,3666.56) J28.24@4350.22,3677.59 ; J28.24@4347.01,3679.98 cw(c4357.02,3672.51) NT33.1@4357.02,3685 ; NT33.1@4357.67,3682.17 ccw(c4350.84,3675.34) 4350.84,3685 ccw(c4350.84,3694.66) NT33.1@4357.67,3687.83
NetJ28_26: J28.26 NT30.1 | length 86.1
  Top Layer w4: J28.26@4323.39,3641.73 4326.65,3645 NT30.1@4365,3645 ccw(c4365,3625.53) J28.26@4350.03,3637.98 ; J28.26@4346.95,3640.53 cw(c4356.47,3632.62) NT30.1@4356.47,3645 ; NT30.1@4357.67,3642.17 ccw(c4350.84,3635.34) 4350.84,3645 ccw(c4350.84,3654.66) NT30.1@4357.67,3647.83
NetJ28_29: J28.29 NT26.1 | length 89.3
  Top Layer w4: NT26.1@4212.33,3582.17 cw(c4219.16,3575.34) 4219.16,3585 cw(c4219.16,3594.66) NT26.1@4212.33,3587.83 ; NT26.1@4214.51,3585 cw(c4214.51,3572.92) J28.29@4223.15,3581.37 ; 4215.91,3585 ccw(c4215.91,3591.25) J28.29@4220.33,3586.83 ; J28.29@4220.29,3578.57 ccw(c4205,3563.61) NT26.1@4205,3585 4244.29,3585 J28.29@4246.61,3582.68
NetJ28_31: J28.31 NT27.1 | length 86.1
  Top Layer w4: NT27.1@4212.33,3537.17 cw(c4219.16,3530.34) 4219.16,3540 cw(c4219.16,3549.66) NT27.1@4212.33,3542.83 ; NT27.1@4213.49,3540 ccw(c4213.49,3552.39) J28.31@4223.04,3544.5 ; J28.31@4219.96,3547.05 cw(c4205,3559.4) NT27.1@4205,3540 4243.31,3540 J28.31@4246.61,3543.31
NetJ28_33: J28.33 NT31.1 | length 79.5
  Top Layer w4: NT31.1@4205,3505 4245.55,3505 J28.33@4246.61,3503.94 ; NT31.1@4207.74,3505 cw(c4207.74,3487.19) J28.33@4220.33,3499.78 ; NT31.1@4212.33,3502.17 cw(c4219.16,3495.34) 4219.16,3505 cw(c4219.16,3514.66) NT31.1@4212.33,3507.83 ; NT31.1@4212.87,3505 ccw(c4212.87,3515.55) J28.33@4220.33,3508.09
NetJ29_CD: J29.CD R253.2 U66.2 | length 2789.9
  MidLayer1 w4: v2(6492,1258) 6496.61,1262.61 6589.63,1262.61 6596.05,1256.19 6655,1256.19 6678.19,1256.19 v1(6698,1276) ; v1@6688.5,1276 cw(c6665.56,1276) 6681.78,1259.78 cw(c6698,1243.56) v1@6698,1266.5 ; v1@6692.5,1276 cw(c6679.22,1276) 6688.61,1266.61 cw(c6698,1257.22) v1@6698,1270.5
  MidLayer2 w4: v1(5173.52,1591.71) 5354.54,1591.71 5462.57,1483.68 5501.34,1444.9 5667.78,1444.9 5697.99,1414.69 5699.21,1413.48 5773.73,1413.48 5790.52,1396.69 5790.52,1300.52 5770,1280 5770,1253.56 5783.35,1240.21 5884.75,1240.21 5984.54,1340 6090,1340 6149.19,1280.81 6244.19,1280.81 v2(6260,1265) ; v1@5177.41,1587.82 cw(c5186.8,1578.43) 5186.8,1591.71 cw(c5186.8,1604.99) v1@5177.41,1595.6 ; v1@5180.24,1584.99 cw(c5196.46,1568.77) 5196.46,1591.71 cw(c5196.46,1614.64) v1@5180.24,1598.43
  Bottom Layer w4: v1(5173.52,1591.71) 5271.71,1591.71 5280,1600 ; v1@5177.41,1587.82 cw(c5186.8,1578.43) 5186.8,1591.71 cw(c5186.8,1604.99) v1@5177.41,1595.6 ; v1@5180.24,1584.99 cw(c5196.46,1568.77) 5196.46,1591.71 cw(c5196.46,1614.64) v1@5180.24,1598.43 ; U66.2@5273.68,1613.6 cw(c5262.21,1600) 5280,1600 ; U66.2@5276.25,1616.66 cw(c5269.47,1608.6) 5280,1608.6 cw(c5290.53,1608.6) U66.2@5283.75,1616.66 ; U66.2@5280,1634.88 5280,1600 ; U66.2@5286.32,1613.6 ccw(c5297.79,1600) 5280,1600 ; v2(6260,1265) 6338.19,1265 6345,1258.19 6426.68,1258.19 6434.68,1250.19 6470.19,1250.19 6478,1258 v2(6492,1258) ; v2@6264.11,1260.89 cw(c6274.03,1250.97) 6274.03,1265 cw(c6274.03,1279.03) v2@6264.11,1269.11 ; v2@6266.94,1258.06 cw(c6283.69,1241.31) 6283.69,1265 cw(c6283.69,1288.69) v2@6266.94,1271.94 ; J29.CD@6619.3,1363.54 cw(c6583.73,1327.98) 6634.03,1327.98 cw(c6684.33,1327.98) J29.CD@6648.76,1363.54 ; J29.CD@6622.13,1366.37 cw(c6593.39,1337.63) 6634.03,1337.63 cw(c6674.67,1337.63) J29.CD@6645.94,1366.37 ; J29.CD@6624.96,1369.2 cw(c6603.05,1347.29) 6634.03,1347.29 cw(c6665.02,1347.29) J29.CD@6643.11,1369.2 ; J29.CD@6634.03,1404.65 6634.03,1320.78 6664,1290.81 6664,1276 ; R253.2@6639.44,1248.72 ccw(c6635.57,1256) 6643.82,1256 ; R253.2@6643.82,1240 6643.82,1256 ; R253.2@6648.19,1248.72 cw(c6652.07,1256) 6643.82,1256 ; 6658.63,1270.82 6663.82,1276 6664,1276 ; 6660.52,1272.71 6643.82,1256 ; v1@6691.28,1269.28 ccw(c6675.06,1253.06) 6675.06,1276 ccw(c6675.06,1298.93) v1@6691.28,1282.72 ; v1@6694.11,1272.11 ccw(c6684.72,1262.72) 6684.72,1276 ccw(c6684.72,1289.28) v1@6694.11,1279.89 ; v1(6698,1276) 6664,1276
NetJ29_WP: J29.WP R254.2 U65.2 | length 2066.9
  MidLayer2 w4: v1(5148.19,1408.37) 5262.21,1408.37 5439.38,1231.21 5550.7,1231.21 5580.78,1261.29 5690.26,1261.29 5727.33,1224.21 5891.38,1224.21 5916.37,1249.21 6056.02,1249.21 v1(6056.86,1250.04) ; v1@5152.08,1404.49 cw(c5161.47,1395.1) 5161.47,1408.37 cw(c5161.47,1421.65) v1@5152.08,1412.26 ; v1@5154.91,1401.66 cw(c5171.13,1385.44) 5171.13,1408.37 cw(c5171.13,1431.31) v1@5154.91,1415.09
  Bottom Layer w4: v1@5141.47,1415.09 ccw(c5125.26,1431.31) 5148.19,1431.31 ccw(c5171.13,1431.31) v1@5154.91,1415.09 ; v1@5144.3,1412.26 ccw(c5134.91,1421.65) 5148.19,1421.65 ccw(c5161.47,1421.65) v1@5152.08,1412.26 ; v1(5148.19,1408.37) 5148.19,1498.19 5155,1505 5205,1505 5215,1495 5215,1425 5220,1420 5270,1420 5280,1410 U65.2@5280,1364.88 ; U65.2@5273.06,1385.6 ccw(c5256.31,1402.35) 5280,1402.35 ccw(c5303.69,1402.35) U65.2@5286.94,1385.6 ; U65.2@5275.89,1382.77 ccw(c5265.97,1392.69) 5280,1392.69 ccw(c5294.03,1392.69) U65.2@5284.11,1382.77 ; J29.WP@6010.8,1357.44 cw(c6010.8,1333.89) 6027.46,1350.54 ; J29.WP@6010.8,1361.44 cw(c6010.8,1347.54) J29.WP@6020.63,1357.37 ; J29.WP@6010.8,1404.65 6010.8,1367.2 6056.86,1321.14 v1(6056.86,1250.04) 6066.9,1240 ; J29.WP@6015.63,1378.06 ccw(c6049.79,1376.56) 6025.61,1352.39 ; J29.WP@6019.63,1377.89 ccw(c6062.1,1376.02) 6032.04,1345.96 ; J29.WP@6023.63,1377.71 ccw(c6074.41,1375.48) 6038.46,1339.54 ; J29.WP@6027.62,1377.54 ccw(c6086.72,1374.94) 6044.89,1333.11 ; J29.WP@6031.62,1377.36 ccw(c6099.03,1374.4) 6051.32,1326.68 ; v1@6050.14,1256.76 ccw(c6033.92,1272.98) 6056.86,1272.98 ccw(c6079.79,1272.98) v1@6063.57,1256.76 ; v1@6052.97,1253.93 ccw(c6043.58,1263.32) 6056.86,1263.32 ccw(c6070.14,1263.32) v1@6060.75,1253.93 ; R254.2@6075.94,1235.02 ccw(c6066.9,1229.3) 6066.9,1240 ; R254.2@6075.94,1244.98 cw(c6066.9,1250.7) 6066.9,1240 ; R254.2@6083.82,1240 6066.9,1240
NetJ30_CD: J30.CD R255.2 U68.2 | length 1676.9
  Bottom Layer w4: U68.2@5515,1611.29 cw(c5515,1566.47) 5546.69,1598.16 ; U68.2@5515,1615.29 cw(c5515,1580.13) 5539.86,1604.99 ; U68.2@5515,1619.29 cw(c5515,1593.79) 5533.03,1611.82 ; U68.2@5515,1634.88 5515,1629.86 5636.86,1508 5815.56,1508 6015.19,1308.37 6015.19,1214.34 6021.82,1207.71 6373.89,1207.71 R255.2@6406.18,1240 ; 6389.43,1223.25 cw(c6406.18,1206.5) R255.2@6406.18,1230.19 ; 6390.62,1224.44 ccw(c6375.55,1239.51) R255.2@6396.86,1239.51 ; R255.2@6396.26,1230.08 cw(c6406.18,1220.16) R255.2@6406.18,1234.19 ; R255.2@6397.45,1231.27 ccw(c6389.21,1239.51) R255.2@6400.86,1239.51 ; R255.2@6409.83,1236.35 6413.48,1240 6435,1240 6436.82,1240 6445,1240 6453.82,1231.18 J30.CD@6453.82,1128.35 ; R255.2@6409.94,1236.24 cw(c6419.02,1227.16) 6419.02,1240 cw(c6419.02,1252.84) R255.2@6409.94,1243.76 ; R255.2@6412.77,1233.41 cw(c6428.68,1217.5) 6428.68,1240 cw(c6428.68,1262.5) R255.2@6412.77,1246.59 ; J30.CD@6439.08,1169.46 ccw(c6403.52,1205.02) 6453.82,1205.02 ccw(c6504.12,1205.02) J30.CD@6468.55,1169.46 ; J30.CD@6441.91,1166.63 ccw(c6413.17,1195.37) 6453.82,1195.37 ccw(c6494.46,1195.37) J30.CD@6465.72,1166.63 ; J30.CD@6444.74,1163.8 ccw(c6422.83,1185.71) 6453.82,1185.71 ccw(c6484.8,1185.71) J30.CD@6462.89,1163.8
NetJ30_WP: J30.WP R256.2 U67.2 | length 2791.7
  Bottom Layer w4: U67.2@5508.06,1344.16 cw(c5491.31,1327.42) 5515,1327.42 cw(c5538.69,1327.42) U67.2@5521.94,1344.16 ; U67.2@5510.89,1346.99 cw(c5500.97,1337.07) 5515,1337.07 cw(c5529.03,1337.07) U67.2@5519.11,1346.99 ; U67.2@5515,1364.88 5515,1266.9 5637.2,1144.69 5679.95,1144.69 5710.75,1175.5 5752.5,1175.5 5857,1071 5989.51,1071 6085.8,974.71 6460.54,974.71 6485.54,999.71 6635,999.71 6645,1009.71 6645,1169.25 6667.46,1191.71 6696.29,1191.71 6714,1174 6714,1051.23 6731.86,1033.37 7043.37,1033.37 7077.05,1067.05 ; R256.2@6966.18,1240 6966.48,1240.3 6989.51,1240.3 6997.31,1232.5 7007.31,1232.5 7007.62,1232.81 7061,1232.81 7077.05,1216.77 J30.WP@7077.05,1128.35 7077.05,1067.05 ; R256.2@6969.94,1236.73 cw(c6978.56,1228.11) 6978.56,1240.3 ; R256.2@6969.94,1244.25 ccw(c6979.49,1253.8) 6979.49,1240.3 ; R256.2@6972.77,1233.9 cw(c6988.22,1218.46) 6988.22,1240.3 ; R256.2@6972.77,1247.08 ccw(c6989.14,1263.45) 6989.14,1240.3 ; J30.WP@7062.31,1169.46 ccw(c7026.75,1205.02) 7077.05,1205.02 ccw(c7127.34,1205.02) J30.WP@7091.78,1169.46 ; J30.WP@7065.14,1166.63 ccw(c7036.4,1195.37) 7077.05,1195.37 ccw(c7117.69,1195.37) J30.WP@7088.95,1166.63 ; J30.WP@7067.15,1083.63 cw(c7058.2,1067.05) 7077.05,1067.05 ; J30.WP@7067.97,1163.8 ccw(c7046.06,1185.71) 7077.05,1185.71 ccw(c7108.03,1185.71) J30.WP@7086.12,1163.8 ; J30.WP@7069.05,1087.15 cw(c7061.81,1073.75) 7077.05,1073.75 cw(c7092.28,1073.75) J30.WP@7085.04,1087.15 ; J30.WP@7086.94,1083.63 ccw(c7095.9,1067.05) 7077.05,1067.05
NetLED4_1: LED4.1 R62.2 | length 285.9
  Top Layer w4: v1@2876.93,5968.2 cw(c2861.96,5952.68) 2883.52,5952.68 ; v1@2879.71,5971.08 cw(c2871.04,5962.1) 2883.52,5962.1 cw(c2896.01,5962.1) v1@2887.34,5971.08 ; v1(2883.52,5975.04) 2883.52,5952.68 ; LED4.1@2888.95,5933.9 ccw(c2869.21,5938.37) 2883.52,5952.68 ; v1@2890.12,5968.2 ccw(c2905.08,5952.68) 2883.52,5952.68 ; LED4.1@2892.86,5933.02 ccw(c2877.58,5936.48) 2888.65,5947.55 ccw(c2899.73,5958.63) LED4.1@2903.18,5943.35 ; LED4.1@2902.3,5947.25 cw(c2897.84,5966.99) 2883.52,5952.68 ; LED4.1@2906.2,5930 2883.52,5952.68
  Bottom Layer w4: R62.2@2856.18,5975 2883.48,5975 v1(2883.52,5975.04) ; R62.2@2859.94,5971.24 cw(c2869.02,5962.16) 2869.02,5975 cw(c2869.02,5987.84) R62.2@2859.94,5978.76 ; R62.2@2860.49,5975 ccw(c2860.49,5998.07) v1@2876.81,5981.76 ; R62.2@2860.69,5975 cw(c2860.69,5952.2) v1@2876.81,5968.32 ; 2870.15,5975 ccw(c2870.15,5988.42) v1@2879.64,5978.93 ; 2870.34,5975 cw(c2870.34,5961.86) v1@2879.64,5971.15
NetLED5_1: LED5.1 R63.2 | length 1204.7
  Top Layer w4: v1(2883.52,5100.04) 3062.23,5100.04 3082.19,5120 3082.19,5617.81 3066.74,5633.26 LED5.1@2909.01,5633.26 ; v1@2887.41,5096.15 cw(c2896.8,5086.76) 2896.8,5100.04 cw(c2896.8,5113.32) v1@2887.41,5103.93 ; v1@2890.24,5093.32 cw(c2906.46,5077.11) 2906.46,5100.04 cw(c2906.46,5122.98) v1@2890.24,5106.76 ; LED5.1@2915.86,5626.41 cw(c2932.39,5609.88) 2932.39,5633.26 cw(c2932.39,5656.64) LED5.1@2915.86,5640.11 ; LED5.1@2918.69,5623.59 cw(c2942.05,5600.22) 2942.05,5633.26 cw(c2942.05,5666.3) LED5.1@2918.69,5642.94 ; LED5.1@2921.52,5620.76 cw(c2951.71,5590.57) 2951.71,5633.26 cw(c2951.71,5675.96) LED5.1@2921.52,5645.77
  Bottom Layer w4: R63.2@2859.97,5091.26 cw(c2868.91,5082.43) 2868.91,5095 cw(c2868.91,5107.57) R63.2@2859.97,5098.74 ; R63.2@2863.7,5095 ccw(c2863.7,5113.4) v1@2878.96,5103.12 ; 2871.22,5095 ccw(c2871.22,5108.33) v1@2882.28,5100.88 ; 2872.76,5095 cw(c2872.76,5089.28) v1@2876.81,5093.32 ; v1@2875.65,5105.35 cw(c2856.18,5118.48) R63.2@2856.18,5095 2878.48,5095 v1(2883.52,5100.04)
NetLED7_1: LED7.1 R67.2 | length 343.6
  Top Layer w4: v1@2885.81,5266.76 ccw(c2869.59,5282.98) 2892.52,5282.98 ccw(c2915.46,5282.98) v1@2899.24,5266.76 ; v1@2888.64,5263.93 ccw(c2879.25,5273.32) 2892.52,5273.32 ccw(c2905.8,5273.32) v1@2896.41,5263.93 ; v1(2892.52,5260.04) 2892.52,5288.29 2909.07,5304.83 ; LED7.1@2901.03,5317.96 cw(c2894.33,5304.83) 2909.07,5304.83 ; LED7.1@2902.85,5321.52 cw(c2897.66,5311.36) 2909.07,5311.36 cw(c2920.47,5311.36) LED7.1@2915.29,5321.52 ; LED7.1@2909.07,5333.71 2909.07,5304.83 ; LED7.1@2917.11,5317.96 ccw(c2923.81,5304.83) 2909.07,5304.83
  Bottom Layer w4: R67.2@2856.18,5260 2892.48,5260 v1(2892.52,5260.04) ; R67.2@2859.94,5256.24 cw(c2869.02,5247.16) 2869.02,5260 cw(c2869.02,5272.84) R67.2@2859.94,5263.76 ; R67.2@2862.77,5253.41 cw(c2878.68,5237.5) 2878.68,5260 cw(c2878.68,5282.5) R67.2@2862.77,5266.59 ; 2869.49,5260 ccw(c2869.49,5283.07) v1@2885.81,5266.76 ; 2869.69,5260 cw(c2869.69,5237.2) v1@2885.81,5253.32 ; 2879.15,5260 ccw(c2879.15,5273.42) v1@2888.64,5263.93 ; 2879.34,5260 cw(c2879.34,5246.86) v1@2888.64,5256.15
NetLED8_2: LED8.2 R91.2 | length 1174.5
  Top Layer w4: R91.2@4266.18,5391.67 4390.19,5391.67 4415.15,5366.71 4602.57,5366.71 4615.52,5379.67 4615.52,5482.43 4595.96,5502 4438.48,5502 4354.02,5586.46 4354.02,5600.96 4377.97,5624.9 LED8.2@4520.49,5624.9 ; R91.2@4269.94,5387.91 cw(c4279.02,5378.83) 4279.02,5391.67 cw(c4279.02,5404.51) R91.2@4269.94,5395.43 ; R91.2@4272.77,5385.08 cw(c4288.68,5369.17) 4288.68,5391.67 cw(c4288.68,5414.16) R91.2@4272.77,5398.26 ; LED8.2@4507.98,5612.4 ccw(c4477.79,5582.21) 4477.79,5624.9 ccw(c4477.79,5667.6) LED8.2@4507.98,5637.41 ; LED8.2@4510.81,5615.23 ccw(c4487.45,5591.87) 4487.45,5624.9 ccw(c4487.45,5657.94) LED8.2@4510.81,5634.58 ; LED8.2@4513.64,5618.06 ccw(c4497.1,5601.52) 4497.1,5624.9 ccw(c4497.1,5648.29) LED8.2@4513.64,5631.75
NetLED9_2: LED9.2 R93.2 | length 677
  Top Layer w4: R93.2@4266.18,5323.33 4390.86,5323.33 4392.57,5325.04 v1(4406.86,5325.04) ; R93.2@4269.94,5319.57 cw(c4279.02,5310.49) 4279.02,5323.33 cw(c4279.02,5336.18) R93.2@4269.94,5327.09 ; R93.2@4272.77,5316.74 cw(c4288.68,5300.84) 4288.68,5323.33 cw(c4288.68,5345.83) R93.2@4272.77,5329.92 ; v1(4490.19,5408.37) 4490.19,5424.22 LED9.2@4520.49,5454.52 ; LED9.2@4502.8,5454.52 cw(c4460.1,5454.52) 4490.29,5424.33 cw(c4520.49,5394.14) LED9.2@4520.49,5436.83 ; LED9.2@4506.8,5454.52 cw(c4473.76,5454.52) 4497.12,5431.15 cw(c4520.49,5407.79) LED9.2@4520.49,5440.83 ; LED9.2@4510.8,5454.52 cw(c4487.42,5454.52) 4503.95,5437.98 cw(c4520.49,5421.45) LED9.2@4520.49,5444.83
  MidLayer1 w4: v1(4406.86,5325.04) 4465.04,5325.04 4490.19,5350.19 v1(4490.19,5408.37) ; v1@4410.75,5321.15 cw(c4420.14,5311.76) 4420.14,5325.04 cw(c4420.14,5338.32) v1@4410.75,5328.93 ; v1@4413.57,5318.32 cw(c4429.79,5302.11) 4429.79,5325.04 cw(c4429.79,5347.98) v1@4413.57,5331.76 ; v1@4483.47,5401.66 cw(c4467.26,5385.44) 4490.19,5385.44 cw(c4513.13,5385.44) v1@4496.91,5401.66 ; v1@4486.3,5404.49 cw(c4476.91,5395.1) 4490.19,5395.1 cw(c4503.47,5395.1) v1@4494.08,5404.49
NetLED10_2: LED10.2 R95.2 | length 477.6
  Top Layer w4: R95.2@4266.18,5255 4373.52,5255 4402.65,5284.13 LED10.2@4520.49,5284.13 ; R95.2@4269.94,5251.24 cw(c4279.02,5242.16) 4279.02,5255 cw(c4279.02,5267.84) R95.2@4269.94,5258.76 ; R95.2@4272.77,5248.41 cw(c4288.68,5232.5) 4288.68,5255 cw(c4288.68,5277.5) R95.2@4272.77,5261.59 ; LED10.2@4507.98,5271.63 ccw(c4477.79,5241.44) 4477.79,5284.13 ccw(c4477.79,5326.83) LED10.2@4507.98,5296.64 ; LED10.2@4510.81,5274.45 ccw(c4487.45,5251.09) 4487.45,5284.13 ccw(c4487.45,5317.17) LED10.2@4510.81,5293.81 ; LED10.2@4513.64,5277.28 ccw(c4497.1,5260.75) 4497.1,5284.13 ccw(c4497.1,5307.51) LED10.2@4513.64,5290.98
NetLED11_2: LED11.2 R97.2 | length 3566.2
  Top Layer w4: R97.2@4732.23,5417.08 ccw(c4713.01,5436.3) 4740.19,5436.3 ; v1@4733.47,5652.66 cw(c4717.26,5636.44) 4740.19,5636.44 cw(c4763.13,5636.44) v1@4746.91,5652.66 ; R97.2@4735.06,5414.25 ccw(c4722.67,5426.64) 4740.19,5426.64 ; v1@4736.3,5655.49 cw(c4726.91,5646.1) 4740.19,5646.1 cw(c4753.47,5646.1) v1@4744.08,5655.49 ; R97.2@4738.82,5410 4740.19,5411.37 v1(4740.19,5659.37) ; 4740.19,5429.68 ccw(c4758.01,5429.68) R97.2@4745.41,5417.08 ; LED11.2@7159.69,5782.78 cw(c7129.5,5752.59) 7172.19,5752.59 cw(c7214.89,5752.59) LED11.2@7184.7,5782.78 ; LED11.2@7162.52,5785.61 cw(c7139.15,5762.25) 7172.19,5762.25 cw(c7205.23,5762.25) LED11.2@7181.87,5785.61 ; LED11.2@7165.34,5788.44 cw(c7148.81,5771.9) 7172.19,5771.9 cw(c7195.57,5771.9) LED11.2@7179.04,5788.44 ; LED11.2@7172.19,5795.28 7172.19,5726.33 7198.52,5700 7198.52,5513.37 v1(7176.86,5491.71) ; v1@7176.86,5497.21 ccw(c7176.86,5510.49) 7186.25,5501.1 ccw(c7195.64,5491.71) v1@7182.36,5491.71 ; v1@7176.86,5501.21 ccw(c7176.86,5524.14) 7193.07,5507.93 ccw(c7209.29,5491.71) v1@7186.36,5491.71
  MidLayer2 w4: v1(4740.19,5659.37) 4775.41,5694.59 ; v1@4740.19,5664.87 ccw(c4740.19,5678.15) 4749.58,5668.76 ccw(c4758.97,5659.37) v1@4745.69,5659.37 ; v1@4740.19,5668.87 ccw(c4740.19,5691.81) 4756.41,5675.59 ccw(c4772.63,5659.37) v1@4749.69,5659.37 ; 4775,5695 4804.71,5724.71 4875,5724.71 5315.52,5724.71 5340.19,5700.04 6617.58,5700.04 6784.87,5532.75 6800.58,5517.04 7151.52,5517.04 v1(7176.86,5491.71) ; v1@7167.36,5491.71 ccw(c7144.42,5491.71) 7160.64,5507.93 ccw(c7176.86,5524.14) v1@7176.86,5501.21 ; v1@7171.36,5491.71 ccw(c7158.08,5491.71) 7167.47,5501.1 ccw(c7176.86,5510.49) v1@7176.86,5497.21
NetLED12_2: LED12.2 R124.2 | length 1040
  Top Layer w4: R124.2@4266.18,5460 4328.15,5460 v1(4348.52,5480.37) ; R124.2@4269.94,5456.24 cw(c4279.02,5447.16) 4279.02,5460 cw(c4279.02,5472.84) R124.2@4269.94,5463.76 ; R124.2@4272.77,5453.41 cw(c4288.68,5437.5) 4288.68,5460 cw(c4288.68,5482.5) R124.2@4272.77,5466.59 ; v1@4339.02,5480.37 cw(c4316.09,5480.37) 4332.31,5464.16 cw(c4348.52,5447.94) v1@4348.52,5470.87 ; v1@4343.02,5480.37 cw(c4329.75,5480.37) 4339.14,5470.99 cw(c4348.52,5461.6) v1@4348.52,5474.87 ; LED12.2@4510.81,5804.97 ccw(c4486.47,5829.3) 4520.89,5829.3 ; v1@4513.28,5843.28 cw(c4494.92,5824.92) 4520.89,5824.92 ; LED12.2@4513.64,5802.14 ccw(c4496.13,5819.65) 4520.89,5819.65 ; v1@4516.11,5846.11 cw(c4504.58,5834.58) 4520.89,5834.58 ; v1(4520,5850) 4520.89,5849.11 4520.89,5789.18 4520.49,5789.18 LED12.2@4520.49,5795.29 ; 4520.89,5817.7 ccw(c4542.89,5817.7) LED12.2@4527.33,5802.14 ; 4520.89,5827.35 ccw(c4552.55,5827.35) LED12.2@4530.16,5804.97 ; 4520.89,5829.21 cw(c4540.79,5829.21) v1@4526.72,5843.28
  Bottom Layer w4: v1(4348.52,5480.37) 4420.41,5480.37 4435.04,5495 4435.04,5825.04 4460,5850 v1(4520,5850) ; v1@4352.41,5476.49 cw(c4361.8,5467.1) 4361.8,5480.37 cw(c4361.8,5493.65) v1@4352.41,5484.26 ; v1@4355.24,5473.66 cw(c4371.46,5457.44) 4371.46,5480.37 cw(c4371.46,5503.31) v1@4355.24,5487.09 ; v1@4513.28,5843.28 ccw(c4497.06,5827.06) 4497.06,5850 ccw(c4497.06,5872.93) v1@4513.28,5856.72 ; v1@4516.11,5846.11 ccw(c4506.72,5836.72) 4506.72,5850 ccw(c4506.72,5863.28) v1@4516.11,5853.89
NetLED13_2: LED13.2 R126.2 | length 2359.2
  Top Layer w4: v1@5358.47,5365.09 ccw(c5342.26,5381.31) 5365.19,5381.31 ccw(c5388.13,5381.31) v1@5371.91,5365.09 ; v1@5361.3,5362.26 ccw(c5351.91,5371.65) 5365.19,5371.65 ccw(c5378.47,5371.65) v1@5369.08,5362.26 ; R126.2@5364.98,5402.56 cw(c5352.61,5388.7) 5371.18,5388.7 ; v1(5365.19,5358.37) 5365.19,5382.71 5371.18,5388.7 ; R126.2@5367.64,5405.54 cw(c5360.58,5397.63) 5371.18,5397.63 cw(c5381.78,5397.63) R126.2@5374.72,5405.54 ; R126.2@5371.18,5410 5371.18,5388.7 ; R126.2@5377.39,5402.56 ccw(c5389.76,5388.7) 5371.18,5388.7 ; v1@7160.64,5659.37 cw(c7156.47,5651.71) 7165.19,5651.71 ; v1(7165.19,5667.71) 7165.19,5651.71 ; 7165.44,5651.46 cw(c7152.53,5638.55) LED13.2@7167.52,5628.14 ; 7168.82,5648.08 cw(c7156.52,5635.78) LED13.2@7170.81,5625.86 ; v1@7169.74,5659.37 ccw(c7173.91,5651.71) 7165.19,5651.71 ; LED13.2@7170.2,5642.47 ccw(c7169.94,5644.71) 7172.19,5644.71 ; LED13.2@7172.19,5624.9 7172.19,5644.71 ; 7172.21,5644.69 cw(c7160.52,5633.01) LED13.2@7174.09,5623.58 ; LED13.2@7174.19,5642.47 cw(c7174.44,5644.71) 7172.19,5644.71 ; 7165.19,5651.71 7172.19,5644.71
  Bottom Layer w4: v1(5365.19,5358.37) 5381.86,5375.04 5881.86,5375.04 5916.19,5409.37 6144.37,5409.37 6419.04,5684.04 6825,5684.04 7148.86,5684.04 v1(7165.19,5667.71) ; v1@5365.19,5363.87 ccw(c5365.19,5377.15) 5374.58,5367.76 ccw(c5383.97,5358.37) v1@5370.69,5358.37 ; v1@5365.19,5367.87 ccw(c5365.19,5390.81) 5381.41,5374.59 ccw(c5397.63,5358.37) v1@5374.69,5358.37 ; v1@7155.69,5667.71 ccw(c7132.76,5667.71) 7148.97,5683.93 ccw(c7165.19,5700.14) v1@7165.19,5677.21 ; v1@7159.69,5667.71 ccw(c7146.41,5667.71) 7155.8,5677.1 ccw(c7165.19,5686.49) v1@7165.19,5673.21
NetLED14_2: LED14.2 R128.2 | length 1713.2
  Top Layer w4: R128.2@5913.82,5400.19 cw(c5913.82,5357) 5944.36,5387.54 ; R128.2@5913.82,5404.19 cw(c5913.82,5370.65) 5937.53,5394.37 ; R128.2@5913.82,5408.19 cw(c5913.82,5384.31) 5930.7,5401.19 ; R128.2@5913.82,5410 5921.9,5410 5956.86,5375.04 ; v1@5969.9,5368.95 ccw(c5956.86,5358.03) 5956.86,5375.04 ; v1@5969.9,5381.14 cw(c5956.86,5392.05) 5956.86,5375.04 ; v1@5972.97,5371.51 ccw(c5965.42,5365.19) 5965.42,5375.04 ccw(c5965.42,5384.89) v1@5972.97,5378.57 ; v1(5977.19,5375.04) 5956.86,5375.04 ; LED14.2@7163.87,5438.91 cw(c7156.48,5425.04) 7172.19,5425.04 ; LED14.2@7165.75,5442.44 cw(c7160.03,5431.71) 7172.19,5431.71 cw(c7184.35,5431.71) LED14.2@7178.63,5442.44 ; LED14.2@7172.19,5454.51 7172.19,5425.04 ; v1@7179.36,5408.37 ccw(c7156.42,5408.37) 7172.64,5424.59 ccw(c7188.86,5440.81) v1@7188.86,5417.87 ; LED14.2@7180.51,5438.91 ccw(c7187.91,5425.04) 7172.19,5425.04 ; v1@7183.36,5408.37 ccw(c7170.08,5408.37) 7179.47,5417.76 ccw(c7188.86,5427.15) v1@7188.86,5413.87 ; v1(7188.86,5408.37) 7172.19,5425.04
  MidLayer2 w4: v1(5977.19,5375.04) 6010.52,5408.37 v1(7188.86,5408.37) ; v1@5977.19,5380.54 ccw(c5977.19,5393.82) 5986.58,5384.43 ccw(c5995.97,5375.04) v1@5982.69,5375.04 ; v1@5977.19,5384.54 ccw(c5977.19,5407.48) 5993.41,5391.26 ccw(c6009.63,5375.04) v1@5986.69,5375.04 ; v1@7182.14,5401.66 ccw(c7165.92,5385.44) 7165.92,5408.37 ccw(c7165.92,5431.31) v1@7182.14,5415.09 ; v1@7184.97,5404.49 ccw(c7175.58,5395.1) 7175.58,5408.37 ccw(c7175.58,5421.65) v1@7184.97,5412.26
NetLED15_2: LED15.2 R130.2 | length 1013.8
  Top Layer w4: R130.2@6499.48,5401.26 cw(c6495.71,5394.08) 6503.82,5394.08 ; R130.2@6503.82,5410 6503.82,5394.08 ; R130.2@6508.16,5401.26 ccw(c6511.93,5394.08) 6503.82,5394.08 ; v1(6515.86,5382.04) 6503.82,5394.08 ; v1@7158.47,5327.99 cw(c7142.26,5311.77) 7165.19,5311.77 cw(c7188.13,5311.77) v1@7171.91,5327.99 ; LED15.2@7159.69,5296.63 ccw(c7146.4,5309.91) 7165.19,5309.91 ; v1@7161.3,5330.82 cw(c7151.91,5321.43) 7165.19,5321.43 cw(c7178.47,5321.43) v1@7169.08,5330.82 ; 7165.19,5310.12 ccw(c7192.48,5310.12) LED15.2@7175.69,5288.61 ; 7165.19,5318.31 ccw(c7198.87,5318.31) LED15.2@7178.15,5291.76 ; v1(7165.19,5334.71) 7165.19,5291.13 LED15.2@7172.19,5284.12
  MidLayer2 w4: v1(6515.86,5382.04) 7117.86,5382.04 v1(7165.19,5334.71) ; v1@6519.75,5378.15 cw(c6529.14,5368.76) 6529.14,5382.04 cw(c6529.14,5395.32) v1@6519.75,5385.93 ; v1@6522.57,5375.32 cw(c6538.79,5359.11) 6538.79,5382.04 cw(c6538.79,5404.98) v1@6522.57,5388.76 ; v1@7155.69,5334.71 ccw(c7132.76,5334.71) 7148.97,5350.93 ccw(c7165.19,5367.14) v1@7165.19,5344.21 ; v1@7159.69,5334.71 ccw(c7146.41,5334.71) 7155.8,5344.1 ccw(c7165.19,5353.49) v1@7165.19,5340.21
NetLED16_1: LED16.1 R164.1 | length 1102.3
  Top Layer w4: R164.1@-303.82,4715 -224.77,4715 v1(-209.81,4700.04) ; R164.1@-300.06,4711.24 cw(c-290.98,4702.16) -290.98,4715 cw(c-290.98,4727.84) R164.1@-300.06,4718.76 ; R164.1@-297.23,4708.41 cw(c-281.32,4692.5) -281.32,4715 cw(c-281.32,4737.5) R164.1@-297.23,4721.59 ; LED16.1@240.6,4861.8 248.63,4853.78 270.86,4853.78 278.86,4861.78 ; v1@272.21,4877.59 cw(c256.74,4861.78) 278.86,4861.78 ; v1@275.01,4880.44 cw(c266.05,4871.29) 278.86,4871.29 cw(c291.66,4871.29) v1@282.7,4880.44 ; v1(278.86,4884.37) 278.86,4861.78 ; v1@285.5,4877.59 ccw(c300.98,4861.78) 278.86,4861.78
  Bottom Layer w4: v1(-209.81,4700.04) -164,4700.04 -150,4714.04 304.19,4714.04 315.19,4725.04 315.19,4848.04 v1(278.86,4884.37) ; v1@-205.92,4696.15 cw(c-196.53,4686.76) -196.53,4700.04 cw(c-196.53,4713.32) v1@-205.92,4703.93 ; v1@-203.09,4693.32 cw(c-186.87,4677.11) -186.87,4700.04 cw(c-186.87,4722.98) v1@-203.09,4706.76 ; v1@278.86,4874.87 cw(c278.86,4851.94) 295.07,4868.16 cw(c311.29,4884.37) v1@288.36,4884.37 ; v1@278.86,4878.87 cw(c278.86,4865.6) 288.25,4874.99 cw(c297.64,4884.37) v1@284.36,4884.37