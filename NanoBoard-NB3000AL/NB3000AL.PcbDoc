# Altium PCB NB3000AL.PcbDoc (part 65 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
PBCTRL.JTAG.HARD.TMS: R218.1 R222.1 U30.P9 | length 8457.5
  Top Layer w4: v1@3189.02,1340 ccw(c3166.09,1340) 3182.31,1356.22 ccw(c3198.52,1372.43) v1@3198.52,1349.5 ; v1@3189.02,2725.04 cw(c3166.09,2725.04) 3182.31,2708.82 cw(c3198.52,2692.61) v1@3198.52,2715.54 ; v1@3193.02,1340 ccw(c3179.75,1340) 3189.14,1349.39 ccw(c3198.52,1358.78) v1@3198.52,1345.5 ; v1@3193.02,2725.04 cw(c3179.75,2725.04) 3189.14,2715.65 cw(c3198.52,2706.26) v1@3198.52,2719.54 ; v1(3198.52,1340) 3181.19,1357.33 3181.19,2062.72 3181.3,2062.83 3181.3,2136.7 3181,2137 3181,2149.88 3181.19,2150.07 3181.19,2707.71 v1(3198.52,2725.04) ; U30.P9@7029.69,1641.12 cw(c7029.69,1623.4) 7042.22,1635.93 cw(c7054.75,1648.46) U30.P9@7037.03,1648.46 ; U30.P9@7029.69,1648.46 v3(7049.37,1628.78) ; 7036.57,1641.58 cw(c7023.76,1628.78) 7041.87,1628.78 ccw(c7023.76,1628.78) 7036.57,1641.58 ; 7036.57,1641.58 ccw(c7049.37,1654.39) 7049.37,1636.28 cw(c7049.37,1654.39) 7036.57,1641.58
  MidLayer1 w4: v1@3191.81,1273.43 ccw(c3175.59,1289.64) 3198.52,1289.64 ccw(c3221.46,1289.64) v1@3205.24,1273.43 ; v1@3191.81,1333.28 cw(c3175.59,1317.06) 3198.52,1317.06 cw(c3221.46,1317.06) v1@3205.24,1333.28 ; v1@3194.64,1270.6 ccw(c3185.25,1279.99) 3198.52,1279.99 ccw(c3211.8,1279.99) v1@3202.41,1270.6 ; v1@3194.64,1336.11 cw(c3185.25,1326.72) 3198.52,1326.72 cw(c3211.8,1326.72) v1@3202.41,1336.11 ; v1(3198.52,1266.71) v1(3198.52,1340) ; v1@6378.28,1008.28 cw(c6362.06,992.06) 6385,992.06 cw(c6407.93,992.06) v1@6391.72,1008.28 ; v1@6381.11,1011.11 cw(c6371.72,1001.72) 6385,1001.72 cw(c6398.28,1001.72) v1@6388.89,1011.11 ; v1(6385,1015) 6385,985 6435,935 v1(6435,910) ; v1@6428.28,916.72 ccw(c6412.06,932.93) 6435,932.93 ccw(c6457.93,932.93) v1@6441.72,916.72 ; v1@6431.11,913.89 ccw(c6421.72,923.28) 6435,923.28 ccw(c6448.28,923.28) v1@6438.89,913.89 ; v3@7048.07,1621.39 cw(c7044.92,1603.56) 7059.76,1613.95 ; v3@7056.76,1627.48 ccw(c7074.59,1624.33) 7059.76,1613.95 ; v1@7058.41,1389.03 ccw(c7042.19,1405.25) 7065.12,1405.25 ccw(c7088.06,1405.25) v1@7071.84,1389.03 ; v1@7061.24,1386.2 ccw(c7051.85,1395.59) 7065.12,1395.59 ccw(c7078.4,1395.59) v1@7069.01,1386.2 ; v1(7065.12,1382.31) 7065.12,1418.06 7069.81,1422.75 7069.81,1484.62 7069.81,1502.78 7064.88,1507.71 7064.88,1511.73 7064.88,1596.1 ccw(c7031.75,1596.27) 7059.79,1613.92
  MidLayer2 w4: v1@3198.52,1257.21 cw(c3198.52,1234.27) 3214.74,1250.49 cw(c3230.96,1266.71) v1@3208.02,1266.71 ; v1@3198.52,1261.21 cw(c3198.52,1247.93) 3207.91,1257.32 cw(c3217.3,1266.71) v1@3204.02,1266.71 ; v1(3198.52,1266.71) 3232.19,1233.04 4086.96,1233.04 4125.65,1271.73 4234.1,1271.73 4514.64,1552.26 4514.64,1607.57 4540.44,1633.37 4853.88,1633.37 5222.69,1264.56 5222.69,1209.46 5232.94,1199.21 5563.95,1199.21 5594.03,1229.29 5677,1229.29 5714.08,1192.21 5904.63,1192.21 5929.63,1217.21 6029.11,1217.21 6105.36,1140.96 6105.36,1003.91 6184.39,924.88 6420.12,924.88 v1(6435,910) ; v1@6385,1005.5 cw(c6385,982.56) 6401.22,998.78 cw(c6417.43,1015) v1@6394.5,1015 ; v1@6385,1009.5 cw(c6385,996.22) 6394.39,1005.61 cw(c6403.78,1015) v1@6390.5,1015 ; v1(6385,1015) 6417,983 6487,983 6552.5,917.5 6553.96,916.04 6958.22,916.04 6959.68,917.5 7185.18,1143 7348,1143 7465,1260 7465,1328.65 7388.15,1405.5 7269.25,1405.5 7230.94,1443.81 7184.62,1443.81 7163,1422.19 7160.19,1422.19 7120.31,1382.31 v1(7065.12,1382.31) ; v1@7069.01,1378.42 cw(c7078.4,1369.03) 7078.4,1382.31 cw(c7078.4,1395.59) v1@7069.01,1386.2 ; v1@7071.84,1375.59 cw(c7088.06,1359.38) 7088.06,1382.31 cw(c7088.06,1405.25) v1@7071.84,1389.03
  Bottom Layer w4: R222.1@3146.18,2740 3183.86,2740 v1@3198.52,2725.33 ; R222.1@3149.94,2736.24 cw(c3159.02,2727.16) 3159.02,2740 cw(c3159.02,2752.84) R222.1@3149.94,2743.76 ; R222.1@3152.77,2733.41 cw(c3168.68,2717.5) 3168.68,2740 cw(c3168.68,2762.5) R222.1@3152.77,2746.59 ; v1(3198.52,2725.04) 3213.86,2725.04 R218.1@3228.82,2740 ; R218.1@3219.5,2739.35 cw(c3199.4,2739.01) 3213.62,2724.8 cw(c3226.81,2711.6) R218.1@3228.15,2730.21 ; R218.1@3219.8,2730.99 cw(c3227.64,2723.15) R218.1@3228.44,2734.2 ; R218.1@3220.28,2731.47 ccw(c3212.52,2739.23) R218.1@3223.5,2739.42
PBCTRL.JTAG.SOFT.TCK: R227.1 R231.1 U30.L1 | length 4712.2
  Top Layer w4: v2@6581.06,1803.06 cw(c6564.31,1786.31) 6588,1786.31 cw(c6611.69,1786.31) v2@6594.94,1803.06 ; v2@6583.89,1805.89 cw(c6573.97,1795.97) 6588,1795.97 cw(c6602.03,1795.97) v2@6592.11,1805.89 ; v2(6588,1810) 6588,1772 6597.81,1762.19 6626.19,1762.19 6630.57,1766.57 U30.L1@6714.72,1766.57 ; U30.L1@6709.53,1761.38 ccw(c6697,1748.85) 6697,1766.57 ccw(c6697,1784.3) U30.L1@6709.53,1771.77
  Bottom Layer w4: 3140.19,2557.88 cw(c3182.33,2557.88) R231.1@3152.73,2587.88 ; 3140.19,2567.45 cw(c3172.89,2567.45) R231.1@3149.92,2590.72 ; 3140.19,2577.02 cw(c3163.44,2577.02) R231.1@3147.11,2593.57 ; R231.1@3149.94,2591.24 cw(c3159.02,2582.16) 3159.02,2595 cw(c3159.02,2607.84) R231.1@3149.94,2598.76 ; R231.1@3152.77,2588.41 cw(c3168.68,2572.5) 3168.68,2595 cw(c3168.68,2617.5) R231.1@3152.77,2601.59 ; R227.1@3222.23,2588.41 ccw(c3206.32,2572.5) 3206.32,2595 ccw(c3206.32,2617.5) R227.1@3222.23,2601.59 ; R227.1@3225.06,2591.24 ccw(c3215.98,2582.16) 3215.98,2595 ccw(c3215.98,2607.84) R227.1@3225.06,2598.76 ; R227.1@3228.82,2595 R231.1@3146.18,2595 3140.19,2589.01 3140.19,2558.37 3123.52,2541.71 3123.52,2508.37 3140.19,2491.71 3298.52,2491.71 3316.76,2509.94 3340.06,2509.94 3350,2500 3350,2415 3364.96,2400.04 3512.21,2400.04 3512.7,2400.54 4337.32,2400.54 4348.54,2389.32 4401.4,2336.45 4414.52,2323.34 4414.52,2036.48 4426,2025 4715,2025 5102.23,2025.04 5144.9,1982.37 5294.52,1982.37 5419.19,1857.71 5752.23,1857.71 5762.75,1847.19 5792.38,1847.19 5795.38,1850.19 5894.01,1850.19 5932.01,1812.19 6017.38,1812.19 6030.19,1825 6084.88,1825 6110.17,1799.71 6240,1799.71 6304.71,1799.71 6336.5,1831.5 6467.31,1831.5 6472.62,1826.19 6487.38,1826.19 6490,1826.19 6515.69,1826.19 6517.31,1827.81 6538.69,1827.81 6556.5,1810 v2(6588,1810) ; v2@6581.06,1803.06 ccw(c6564.31,1786.31) 6564.31,1810 ccw(c6564.31,1833.69) v2@6581.06,1816.94 ; v2@6583.89,1805.89 ccw(c6573.97,1795.97) 6573.97,1810 ccw(c6573.97,1824.03) v2@6583.89,1814.11
PBCTRL.JTAG.SOFT.TDI: R224.1 R228.1 U30.J1 | length 5468.4
  Top Layer w4: v2@6625.81,1849.81 6657.38,1849.81 6661.87,1845.31 U30.J1@6714.72,1845.31 ; U30.J1@6709.53,1840.12 ccw(c6697,1827.59) 6697,1845.31 ccw(c6697,1863.04) U30.J1@6709.53,1850.51
  MidLayer1 w4: v1@2970,2405 2973.37,2408.37 3117.56,2408.37 3260,2550.81 3260,2750.23 v1(3193.52,2816.71) ; v1@2973.89,2404.49 cw(c2983.28,2395.1) 2983.28,2408.37 cw(c2983.28,2421.65) v1@2973.89,2412.26 ; v1@2976.72,2401.66 cw(c2992.93,2385.44) 2992.93,2408.37 cw(c2992.93,2431.31) v1@2976.72,2415.09 ; v1@3193.52,2807.21 cw(c3193.52,2784.27) 3209.74,2800.49 cw(c3225.96,2816.71) v1@3203.02,2816.71 ; v1@3193.52,2811.21 cw(c3193.52,2797.93) 3202.91,2807.32 cw(c3212.3,2816.71) v1@3199.02,2816.71
  MidLayer2 w4: v1@5049.52,1973.87 cw(c5049.52,1950.94) 5065.74,1967.16 cw(c5081.96,1983.37) v1@5059.02,1983.37 ; v1@5049.52,1977.87 cw(c5049.52,1964.6) 5058.91,1973.99 cw(c5068.3,1983.37) v1@5055.02,1983.37 ; v1(5049.52,1983.37) 5192.19,1840.71 5222.27,1840.71 5231.43,1849.87 5700.66,1849.87 5721.03,1829.5 5893.4,1829.5 5918.71,1804.19 6020.69,1804.19 6037.71,1821.21 6059.03,1821.21 6060.82,1823 ; 6061.17,1823 6285.17,1823 6318.17,1856 6442.81,1856 6472.62,1826.19 6487.38,1826.19 6497.38,1836.19 6557.38,1836.19 6565,1843.81 6601.77,1843.81 6604,1846.04 ; 6605.04,1846.04 cw(c6605.04,1829.04) v2@6617.06,1841.06 ; 6610.8,1846.04 ccw(c6610.8,1855.33) v2@6618.92,1850.82 ; v2@6615.42,1852.76 cw(c6604,1859.11) 6604,1846.04 ; v2@6622.04,1846.04 6604,1846.04
  Bottom Layer w4: v1@2970,2398.87 cw(c2970,2375.94) 2986.22,2392.16 cw(c3002.43,2408.37) v1@2979.5,2408.37 ; v1@2970,2402.87 cw(c2970,2389.6) 2979.39,2398.99 cw(c2988.78,2408.37) v1@2975.5,2408.37 ; v1(2970,2408.37) 3054.87,2323.5 3282.02,2323.5 3311.02,2294.5 3375.5,2294.5 3379,2291 3666.15,2291 ; R228.1@3146.18,2812.5 3189.52,2812.5 3193.52,2816.5 v1(3193.52,2816.71) 3224.61,2816.71 R224.1@3228.82,2812.5 ; R228.1@3149.94,2808.74 cw(c3159.02,2799.66) 3159.02,2812.5 cw(c3159.02,2825.34) R228.1@3149.94,2816.26 ; R228.1@3152.77,2805.91 cw(c3168.68,2790) 3168.68,2812.5 cw(c3168.68,2835) R228.1@3152.77,2819.09 ; 3160.43,2812.5 ccw(c3160.43,2849.8) v1@3186.81,2823.43 ; 3170.09,2812.5 ccw(c3170.09,2840.14) v1@3189.64,2820.6 ; 3179.74,2812.5 ccw(c3179.74,2830.49) v1@3192.46,2817.77 ; 3180.75,2812.5 cw(c3180.75,2803.93) v1@3186.81,2809.99 ; v1@3197.41,2812.82 cw(c3206.8,2803.43) 3206.8,2816.71 cw(c3206.8,2829.99) v1@3197.41,2820.6 ; v1@3200.24,2809.99 cw(c3216.46,2793.77) 3216.46,2816.71 cw(c3216.46,2839.64) v1@3200.24,2823.43 ; 3215.29,2816.71 ccw(c3215.29,2826.52) R224.1@3222.23,2819.58 ; 3216.66,2816.71 cw(c3216.66,2800.84) R224.1@3227.89,2812.06 ; 3666.28,2290.87 4357.69,2290.87 4369.13,2290.87 4390.52,2269.48 4390.52,2026.54 4416.69,2000.37 4934.5,2000.37 4951.5,1983.37 v1(5049.52,1983.37) ; v1@5042.81,1976.66 ccw(c5026.59,1960.44) 5026.59,1983.37 ccw(c5026.59,2006.31) v1@5042.81,1990.09 ; v1@5045.64,1979.49 ccw(c5036.25,1970.1) 5036.25,1983.37 ccw(c5036.25,1996.65) v1@5045.64,1987.26
  other v2: 6624,1848
PBCTRL.JTAG.SOFT.TDO: R225.1 R229.1 U30.J2 | length 5343.8
  Top Layer w4: v1@3222.36,2635.04 cw(c3199.42,2635.04) 3215.64,2618.82 cw(c3231.86,2602.61) v1@3231.86,2625.54 ; v1@3226.36,2635.04 cw(c3213.08,2635.04) 3222.47,2625.65 cw(c3231.86,2616.26) v1@3231.86,2629.54 ; v1(3231.86,2635.04) 3197.19,2600.37 3197.19,2435.98 3264.86,2368.31 3264.86,2337.14 3355,2247 v1(3355,2245) ; 3337.37,2264.63 cw(c3317.74,2245) v1@3345.5,2245 ; 3342.2,2259.8 ccw(c3355,2272.61) v1@3355,2254.5 ; 3344.2,2257.8 cw(c3331.39,2245) v1@3349.5,2245 ; v1@6041.81,1805.76 ccw(c6025.59,1821.98) 6048.52,1821.98 ccw(c6071.46,1821.98) v1@6055.24,1805.76 ; v1@6041.81,1839.99 cw(c6025.59,1823.77) 6048.52,1823.77 cw(c6071.46,1823.77) v1@6055.24,1839.99 ; v1@6044.64,1802.93 ccw(c6035.25,1812.32) 6048.52,1812.32 ccw(c6061.8,1812.32) v1@6052.41,1802.93 ; v1@6044.64,1842.82 cw(c6035.25,1833.43) 6048.52,1833.43 cw(c6061.8,1833.43) v1@6052.41,1842.82 ; v1(6048.52,1799.04) v1(6048.52,1846.71) ; v2@6648,1830 v2@6648.19,1829.81 ; v2(6650,1832) 6652.53,1829.47 6734.05,1829.47 6734.38,1829.81 ; v2@6654.11,1836.11 ccw(c6670.13,1852.13) 6670.13,1829.47 ; v2@6656.94,1825.06 cw(c6667.58,1814.42) 6667.58,1829.47 ; v2@6656.94,1838.94 ccw(c6679.79,1861.79) 6679.79,1829.47 ; 6734.38,1829.81 ccw(c6734.38,1839.96) 6741.56,1832.78 ; 6734.38,1829.81 ccw(c6734.38,1839.96) 6741.56,1832.78 ; 6741.56,1832.78 ccw(c6729.03,1845.31) 6746.75,1845.31 cw(c6729.03,1845.31) 6741.56,1832.78 ; 6741.56,1832.78 cw(c6754.09,1820.25) 6754.09,1837.97 ccw(c6754.09,1820.25) 6741.56,1832.78
  MidLayer2 w4: v1(3355,2245) 3368.43,2245 ; 6022.93,1847.81 cw(c6022.93,1821.11) v1@6041.81,1839.99 ; 6028.25,1847.81 ccw(c6028.25,1866.98) v1@6041.81,1853.43 ; 6032.58,1847.81 cw(c6032.58,1830.77) v1@6044.64,1842.82 ; v1(6048.52,1799.04) 6057.86,1808.37 6064.48,1815 6288.48,1815 6321.48,1848 6439.5,1848 6469.31,1818.19 6490.69,1818.19 6500.69,1828.19 6560.69,1828.19 6568.31,1835.81 6604.69,1835.81 ; v1(6048.52,1846.71) 6047.42,1847.81 5793,1847.81 5792.38,1847.19 5725.96,1847.19 5707.28,1865.87 5273.75,1865.87 4972.62,2167 4740,2167 ; v1@6048.59,1804.54 ccw(c6048.73,1817.31) 6057.76,1808.28 ccw(c6066.79,1799.25) v1@6054.02,1799.1 ; v1@6048.63,1808.54 ccw(c6048.88,1830.6) 6064.48,1815 ccw(c6080.08,1799.4) v1@6058.02,1799.15 ; v2(6650,1832) 6648,1830 6636.5,1830 6636.31,1830.19 ; 3368.43,2245 3431.43,2182 ; 3368.43,2245 3431.43,2182 ; 3431.43,2182 4640,2182 ; 4640,2182 4680,2182 ; 4640,2182 4680,2182 ; 4680,2182 4685.77,2182 4700.77,2167 ; 4700.77,2167 4740,2167 ; 4700.77,2167 4740,2167 ; 6604.69,1835.81 6610.31,1830.19 ; 6604.69,1835.81 6610.31,1830.19 ; 6610.31,1830.19 6610.88,1830.19 ; 6610.88,1830.19 6636.31,1830.19 ; 6610.88,1830.19 6636.31,1830.19 ; v1@3355,2235.5 cw(c3355,2180.13) 3394.15,2219.28 ccw(c3355,2180.13) v1@3355,2235.5 ; v1@3355,2239.5 cw(c3355,2193.79) 3387.32,2226.11 ccw(c3355,2193.79) v1@3355,2239.5 ; v1@3355,2243.5 cw(c3355,2207.44) 3380.5,2232.94 ccw(c3355,2207.44) v1@3355,2243.5 ; v1@3355,2247.5 cw(c3355,2221.1) 3373.67,2239.77 ccw(c3355,2221.1) v1@3355,2247.5 ; v1@3355,2251.5 cw(c3355,2234.76) 3366.84,2246.6 ccw(c3355,2234.76) v1@3355,2251.5
  Bottom Layer w4: R229.1@3146.18,2667.5 R225.1@3228.82,2667.5 3228.82,2646.41 3231.86,2643.37 v1(3231.86,2635.04) ; R229.1@3149.94,2663.74 cw(c3159.02,2654.66) 3159.02,2667.5 cw(c3159.02,2680.34) R229.1@3149.94,2671.26 ; R229.1@3152.77,2660.91 cw(c3168.68,2645) 3168.68,2667.5 cw(c3168.68,2690) R229.1@3152.77,2674.09 ; R225.1@3222.23,2660.91 ccw(c3206.32,2645) 3206.32,2667.5 ccw(c3206.32,2690) R225.1@3222.23,2674.09 ; R225.1@3225.06,2663.74 ccw(c3215.98,2654.66) 3215.98,2667.5 ccw(c3215.98,2680.34) R225.1@3225.06,2671.26 ; v1@3225.14,2641.76 ccw(c3216.26,2650.64) 3228.82,2650.64 ; R225.1@3225.31,2663.01 cw(c3218.49,2655.25) 3228.82,2655.25 cw(c3239.15,2655.25) R225.1@3232.33,2663.01 ; 3228.82,2655.65 ccw(c3252.47,2655.65) v1@3235.75,2638.93 ; R225.1@3228.82,2665.31 ccw(c3262.13,2665.31) v1@3238.57,2641.76
PBCTRL.JTAG.SOFT.TMS: R226.1 R230.1 U30.R8 | length 7044.5
  Top Layer w4: v2(5506,1522) 5520,1536 5520,1665 5545,1690 5605,1690 5636.04,1721.04 5732.67,1721.04 5736.19,1724.56 5736.19,1725.5 5763,1752.31 5763,1878.77 v2(5786.19,1901.96) ; v2@5776.38,1901.96 cw(c5752.69,1901.96) 5769.44,1885.21 cw(c5786.19,1868.46) v2@5786.19,1892.15 ; v2@5780.38,1901.96 cw(c5766.35,1901.96) 5776.27,1892.04 cw(c5786.19,1882.12) v2@5786.19,1896.15 ; 6974.47,1471.53 6974.47,1475.66 6989.81,1491 6989.81,1506.38 6974.81,1521.38 6974.81,1589.38 ; 6974.81,1471.19 6974.81,1445.19 v2(6988,1432) ; 6974.81,1589.38 cw(c6984.96,1589.38) 6977.78,1596.56 ; 6974.81,1589.38 cw(c6984.96,1589.38) 6977.78,1596.56 ; 6977.78,1596.56 cw(c6990.31,1584.03) 6990.31,1601.75 ccw(c6990.31,1584.03) 6977.78,1596.56 ; 6977.78,1596.56 ccw(c6965.25,1609.09) 6982.97,1609.09 cw(c6965.25,1609.09) 6977.78,1596.56
  MidLayer1 w4: v2@6981.67,1424.5 cw(c6970.17,1410.88) 6988,1410.88 ; v2@6984.25,1427.56 cw(c6977.44,1419.49) 6988,1419.49 cw(c6998.56,1419.49) v2@6991.75,1427.56 ; v2(6988,1432) 6988,1410.88 ; v2@6994.33,1424.5 ccw(c7005.83,1410.88) 6988,1410.88 ; v2@7005.19,1215 ccw(c6981.5,1215) 6998.25,1231.75 ccw(c7015,1248.5) v2@7015,1224.81 ; v2@7009.19,1215 ccw(c6995.16,1215) 7005.08,1224.92 ccw(c7015,1234.84) v2@7015,1220.81 ; v2(7015,1215) 6990,1240 6987.19,1240 6982.19,1245 6982.19,1269.06 6993.81,1280.68 6993.81,1323 7001.1,1330.29 7001.1,1358.7 6982.47,1377.34 6982.47,1405.35 6988,1410.88
  MidLayer2 w4: v2@5510,1526 v2(5506,1522) 5575.87,1522 5608.37,1489.5 5756.13,1489.5 5768.17,1501.54 5817.33,1501.54 5938.87,1380 6182.69,1380 6217.88,1344.81 6290.88,1344.81 6327.5,1308.19 6388,1308.19 6464,1232.19 6574.8,1232.19 6588.5,1218.49 6588.5,1185.5 6631.5,1142.5 6825.5,1142.5 6829.5,1138.5 6932,1138.5 6994.31,1200.81 7000.81,1200.81 v2(7015,1215) ; v2@5510.11,1517.89 cw(c5520.03,1507.97) 5520.03,1522 cw(c5520.03,1536.03) v2@5510.11,1526.11 ; v2@5512.94,1515.06 cw(c5529.69,1498.31) 5529.69,1522 cw(c5529.69,1545.69) v2@5512.94,1528.94
  Bottom Layer w4: R230.1@3142.6,2513.4 cw(c3140.37,2508.04) 3146.18,2508.04 ; R230.1@3146.18,2522.5 3146.18,2508.04 ; R230.1@3149.76,2513.4 ccw(c3151.99,2508.04) 3146.18,2508.04 ; R226.1@3267.8,2513.32 cw(c3265.87,2508.38) 3271.18,2508.38 ; R226.1@3274.56,2513.32 ccw(c3276.49,2508.38) 3271.18,2508.38 ; R226.1@3274.94,2519.23 cw(c3288.97,2505.21) 3288.97,2525.04 ; R226.1@3277.77,2516.4 cw(c3298.62,2495.55) 3298.62,2525.04 ; R226.1@3277.77,2529.58 ccw(c3288.73,2540.54) 3288.73,2525.04 ; v2@5779.25,1895.02 ccw(c5762.5,1878.27) 5762.5,1901.96 ccw(c5762.5,1925.64) v2@5779.25,1908.89 ; v2@5782.08,1897.85 ccw(c5772.16,1887.93) 5772.16,1901.96 ccw(c5772.16,1915.99) v2@5782.08,1906.07 ; v2(5786.19,1901.96) 5761.38,1901.96 5725.13,1865.71 5422.5,1865.71 5297.84,1990.37 5148.21,1990.37 5105.54,2033.04 ; 3146.18,2508.04 3154.18,2500.04 3262.85,2500.04 3271.18,2508.37 ; 3271.18,2508.37 R226.1@3271.18,2522.5 3273.72,2525.04 3340,2525.04 3358,2507.04 3358,2418.31 3368.27,2408.04 3508.9,2408.04 3509.39,2408.54 4340.64,2408.54 4422.52,2326.65 4422.52,2039.79 4428.94,2033.37 ; 4428.94,2033.37 4429.32,2033 4711.65,2033 4711.69,2033.04 5105.54,2033.04 ; 4428.94,2033.37 5105.21,2033.37 5105.54,2033.04
PBCTRL.SPARE1: EXTHDR1.39 U30.T8 | length 7817.5
  Top Layer w4: v1@1526.18,2978.82 ccw(c1509.96,2995.04) 1532.9,2995.04 ccw(c1555.83,2995.04) v1@1539.61,2978.82 ; EXTHDR1.39@1527.24,3021.07 cw(c1513.58,3007.42) 1532.9,3007.42 cw(c1552.21,3007.42) EXTHDR1.39@1538.55,3021.07 ; v1@1529.01,2975.99 ccw(c1519.62,2985.38) 1532.9,2985.38 ccw(c1546.18,2985.38) v1@1536.79,2975.99 ; v1(1532.9,2972.1) EXTHDR1.39@1532.9,3071.85 ; U30.T8@6985.12,1564.53 cw(c6972.59,1552) 6990.31,1552 ; U30.T8@6990.32,1569.72 U30.T8@6993.81,1566.23 ; U30.T8@6995.51,1564.53 ccw(c7008.04,1552) 6990.31,1552 ; v2@7014,1451.31 7014,1482 6998.24,1497.76 6998.24,1509.26 6990.31,1517.19 6990.31,1552
  MidLayer1 w4: v1@1526.9,2964.74 cw(c1516.6,2952.1) 1532.9,2952.1 ; v1@1529.42,2967.84 cw(c1523.46,2960.52) 1532.9,2960.52 cw(c1542.33,2960.52) v1@1536.37,2967.84 ; v1(1532.9,2972.1) 1532.9,2952.1 ; v1@1538.9,2964.74 ccw(c1549.2,2952.1) 1532.9,2952.1 ; v1@1938.28,2261.72 ccw(c1915.97,2284.03) 1947.52,2284.03 ; v1@1941.11,2258.89 ccw(c1925.63,2274.37) 1947.52,2274.37 ; v1(1945,2255) 1945.37,2255 1947.52,2257.15 1947.52,2564.73 1603.54,2908.71 1576.29,2908.71 1532.9,2952.1 ; 1947.52,2271.84 ccw(c1961.84,2271.84) v1@1951.72,2261.72 ; v2@5785,1855.19 cw(c5785,1831.5) 5801.75,1848.25 cw(c5818.5,1865) v2@5794.81,1865 ; v2@5785,1859.19 cw(c5785,1845.16) 5794.92,1855.08 cw(c5804.84,1865) v2@5790.81,1865 ; v2(5785,1865) 5817,1833 5817,1681.69 5820.19,1678.5 5820.19,1678.12 6014.19,1484.12 6014.19,1470.62 v2(6049.45,1435.36) ; v2@6039.64,1435.36 ccw(c6015.95,1435.36) 6032.7,1452.11 ccw(c6049.45,1468.86) v2@6049.45,1445.17 ; v2@6043.64,1435.36 ccw(c6029.61,1435.36) 6039.53,1445.28 ccw(c6049.45,1455.2) v2@6049.45,1441.17 ; 6962,1226 ccw(c6975.47,1239.47) v2@6977.9,1220.58 ; 6963.82,1224.18 cw(c6950.49,1210.85) v2@6969.34,1210.85 ; 6967.76,1220.24 ccw(c6976.78,1229.27) v2@6978.41,1216.61 ; v2@6978.15,1209.85 6961,1227 6961,1250.12 6974.19,1263.31 6974.19,1272.37 6985.81,1284 6985.81,1319.7 6965.48,1340.03 6965.48,1382.67 6970.19,1387.38 6970.19,1439.38 6982.13,1451.31 v2(7014.38,1451.31) ; v2@7007.44,1444.38 ccw(c6990.69,1427.63) 6990.69,1451.31 ccw(c6990.69,1475) v2@7007.44,1458.25 ; v2@7010.27,1447.21 ccw(c7000.35,1437.29) 7000.35,1451.31 ccw(c7000.35,1465.34) v2@7010.27,1455.42
  MidLayer2 w4: v1@1945,2245.5 cw(c1945,2222.56) 1961.22,2238.78 cw(c1977.43,2255) v1@1954.5,2255 ; v1@1945,2249.5 cw(c1945,2236.22) 1954.39,2245.61 cw(c1963.78,2255) v1@1950.5,2255 ; v1(1945,2255) 1970,2230 2045.44,2230 2083.44,2268 2213.31,2268 2222.81,2258.5 2257.19,2258.5 2269.19,2270.5 3365.56,2270.5 3380.5,2255.56 3438.06,2198 4692.39,2198 4707.19,2183.21 4735,2183.21 4770.73,2183.21 4979.04,2183.21 5012.21,2150.04 5074.96,2150.04 5155,2070 5155,2000 5281.13,1873.87 5710.6,1873.87 5719.47,1865 v2(5785,1865) ; v2@5778.06,1858.06 ccw(c5761.31,1841.31) 5761.31,1865 ccw(c5761.31,1888.69) v2@5778.06,1871.94 ; v2@5780.89,1860.89 ccw(c5770.97,1850.97) 5770.97,1865 ccw(c5770.97,1879.03) v2@5780.89,1869.11 ; v2@5782.5,1857.5 v2@5793,1868 ; v2(6049.45,1435.36) 6095.36,1435.36 6102.21,1442.21 6186.6,1442.21 6276,1352.81 6294.19,1352.81 6330.81,1316.19 6391.31,1316.19 6467.31,1240.19 6585.24,1240.19 6605.93,1219.5 6645.5,1219.5 6714.5,1150.5 6828.81,1150.5 6832.81,1146.5 6914.81,1146.5 v2(6979.15,1210.85) ; v2@6053.56,1431.25 cw(c6063.48,1421.33) 6063.48,1435.36 cw(c6063.48,1449.39) v2@6053.56,1439.47 ; v2@6056.39,1428.43 cw(c6073.13,1411.68) 6073.13,1435.36 cw(c6073.13,1459.05) v2@6056.39,1442.3 ; v2@6969.34,1210.85 cw(c6945.66,1210.85) 6962.41,1194.1 cw(c6979.15,1177.35) v2@6979.15,1201.03 ; v2@6973.34,1210.85 cw(c6959.31,1210.85) 6969.23,1200.93 cw(c6979.15,1191.01) v2@6979.15,1205.03
PBCTRL.SPARE2: EXTHDR1.41 U30.T6 | length 7679.6
  Top Layer w4: EXTHDR1.41@1495.75,3122.63 ccw(c1482.16,3136.25) 1501.4,3136.25 ; EXTHDR1.41@1501.4,3071.85 1501.4,3136.25 ; EXTHDR1.41@1507.05,3122.63 cw(c1520.64,3136.25) 1501.4,3136.25 ; v1(1515.19,3150.04) 1501.4,3136.25 ; v2(6895.26,1497.62) 6895.62,1497.62 6911.57,1513.57 ; v2@6895.52,1503.43 ccw(c6896.11,1516.22) 6905.16,1507.16 ; v2@6895.71,1507.42 ccw(c6896.67,1528.48) 6911.57,1513.57 ; v2@6901.07,1497.67 cw(c6913.87,1497.76) 6904.82,1506.82 ; v2@6905.07,1497.7 cw(c6927.29,1497.86) 6911.57,1513.57 ; U30.T6@6906.38,1564.53 cw(c6893.85,1552) 6911.57,1552 cw(c6929.3,1552) U30.T6@6916.77,1564.53 ; U30.T6@6911.57,1569.72 6911.57,1513.57
  MidLayer1 w4: v1(1515.19,3150.04) 1614.58,3150.04 1727,3037.62 1727,2824.55 2090.19,2461.36 v1(2090.19,2250) ; v1@1519.08,3146.15 cw(c1528.47,3136.76) 1528.47,3150.04 cw(c1528.47,3163.32) v1@1519.08,3153.93 ; v1@1521.91,3143.32 cw(c1538.13,3127.11) 1538.13,3150.04 cw(c1538.13,3172.98) v1@1521.91,3156.76 ; v1@2083.47,2256.72 ccw(c2067.26,2272.93) 2090.19,2272.93 ccw(c2113.13,2272.93) v1@2096.91,2256.72 ; v1@2086.3,2253.89 ccw(c2076.91,2263.28) 2090.19,2263.28 ccw(c2103.47,2263.28) v1@2094.08,2253.89 ; v2@5537.06,1933.06 cw(c5520.31,1916.31) 5544,1916.31 cw(c5567.69,1916.31) v2@5550.94,1933.06 ; v2@5539.89,1935.89 cw(c5529.97,1925.97) 5544,1925.97 cw(c5558.03,1925.97) v2@5548.11,1935.89 ; v2(5544,1940) 5544,1874.98 5545,1873.98 5651.81,1767.17 5651.81,1719.84 5779.11,1592.54 5790,1592.54 5797.44,1592.54 5830.07,1592.54 5870,1552.61 5870,1519.98 v2(5870,1510) ; v2@5863.06,1516.94 ccw(c5846.31,1533.69) 5870,1533.69 ccw(c5893.69,1533.69) v2@5876.94,1516.94 ; v2@5865.89,1514.11 ccw(c5855.97,1524.03) 5870,1524.03 ccw(c5884.03,1524.03) v2@5874.11,1514.11 ; v2(6895.26,1497.62) 6913.81,1479.07 6913.81,1462.62 6907.81,1456.62 6907.81,1361 6886,1339.19 6880.19,1333.38 6880.19,1318.62 6899,1299.81 ; v2@6925.91,1276.19 ccw(c6921.39,1284.31) 6930.69,1284.31 ; v2(6930.69,1267.62) 6930.69,1284.31 ; v2@6935.46,1276.19 cw(c6939.98,1284.31) 6930.69,1284.31 ; 6899,1299.81 6912.38,1299.81 ; 6899,1299.81 6912.38,1299.81 ; 6912.38,1299.81 6915.19,1299.81 6930.69,1284.31
  MidLayer2 w4: v1(2090.19,2250) 2100.19,2260 2210,2260 2219.5,2250.5 2260.5,2250.5 2272.5,2262.5 3362.25,2262.5 3372.5,2252.25 3434.75,2190 4689.08,2190 4704.08,2175 4975.94,2175 5014.94,2136 5070.9,2136 5125.52,2081.37 v1(5125.52,2055.37) ; v1@5118.81,2062.09 ccw(c5102.59,2078.31) 5125.52,2078.31 ccw(c5148.46,2078.31) v1@5132.24,2062.09 ; v1@5121.64,2059.26 ccw(c5112.25,2068.65) 5125.52,2068.65 ccw(c5138.8,2068.65) v1@5129.41,2059.26 ; v2@5870.8,1509.04 6011.77,1509.04 6022.62,1498.19 6037,1498.19 6063.19,1472 6090.69,1472 6104.48,1458.21 6193.23,1458.21 6201.23,1450.21 6226.04,1450.21 6251.43,1424.81 6269.01,1424.81 6325.62,1368.2 6354.23,1368.2 ; 6354.85,1368.81 6388.22,1368.81 6439.16,1317.88 6478.75,1317.88 6496.81,1299.81 6530.88,1299.81 6552.19,1278.5 6592.19,1278.5 6619.19,1251.5 6673.12,1251.5 6688.62,1236 6737.5,1236 6749.31,1224.19 6810.69,1224.19 6818.31,1231.81 6837.38,1231.81 6864.69,1204.5 6891.25,1204.5 6901.72,1214.97 6901.72,1238.66 v2(6930.69,1267.62)
  Bottom Layer w4: v1(5125.52,2055.37) 5155.37,2055.37 5167.04,2067.04 5553.54,2067.04 5556,2064.59 5556,2052.17 5559.31,2048.86 5559.31,1955.31 v2(5544,1940) ; v1@5129.41,2051.49 cw(c5138.8,2042.1) 5138.8,2055.37 cw(c5138.8,2068.65) v1@5129.41,2059.26 ; v1@5132.24,2048.66 cw(c5148.46,2032.44) 5148.46,2055.37 cw(c5148.46,2078.31) v1@5132.24,2062.09
PBCTRL.SPARE3: EXTHDR1.43 U30.K2 | length 7111.8
  Top Layer w4: EXTHDR1.43@1466.36,3019.56 cw(c1460.65,3008.02) 1473.52,3008.02 ; EXTHDR1.43@1468.13,3023.14 cw(c1463.84,3014.46) 1473.52,3014.46 ; EXTHDR1.43@1469.9,3071.85 1469.91,3075.04 1473.52,3075.04 1473.52,3071.85 1473.52,3008.37 v1(1490.19,2991.71) ; 1473.52,3016.16 cw(c1480.48,3016.16) EXTHDR1.43@1475.56,3021.07 ; v1@1480.69,2991.71 ccw(c1457.76,2991.71) 1473.97,3007.93 ccw(c1490.19,3024.14) v1@1490.19,3001.21 ; v1@1484.69,2991.71 ccw(c1471.41,2991.71) 1480.8,3001.1 ccw(c1490.19,3010.49) v1@1490.19,2997.21 ; v2(6609,1780) 6634,1780 6644.44,1790.44 6734.38,1790.44 ; v2@6613.11,1775.89 cw(c6623.03,1765.97) 6623.03,1780 cw(c6623.03,1794.03) v2@6613.11,1784.11 ; v2@6615.94,1773.06 cw(c6632.69,1756.31) 6632.69,1780 cw(c6632.69,1803.69) v2@6615.94,1786.94 ; 6734.38,1790.44 ccw(c6734.38,1800.59) 6741.56,1793.41 ; 6734.38,1790.44 ccw(c6734.38,1800.59) 6741.56,1793.41 ; 6741.56,1793.41 ccw(c6729.03,1805.94) 6746.75,1805.94 cw(c6729.03,1805.94) 6741.56,1793.41 ; 6741.56,1793.41 cw(c6754.09,1780.88) 6754.09,1798.6 ccw(c6754.09,1780.88) 6741.56,1793.41
  MidLayer1 w4: v1@1483.47,2998.43 ccw(c1467.26,3014.64) 1490.19,3014.64 ccw(c1513.13,3014.64) v1@1496.91,2998.43 ; v1@1486.3,2995.6 ccw(c1476.91,3004.99) 1490.19,3004.99 ccw(c1503.47,3004.99) v1@1494.08,2995.6 ; v1(1490.19,2991.71) 1490.19,3019 1513.19,3042 1600.6,3042 1627.39,3015.22 1627.39,2991.9 1589.19,2953.71 1589.19,2925 1597.48,2916.71 1606.86,2916.71 1965.19,2558.37 v1(1965.19,1950.04) ; v1@1958.47,1956.76 ccw(c1942.26,1972.98) 1965.19,1972.98 ccw(c1988.13,1972.98) v1@1971.91,1956.76 ; v1@1961.3,1953.93 ccw(c1951.91,1963.32) 1965.19,1963.32 ccw(c1978.47,1963.32) v1@1969.08,1953.93
  MidLayer2 w4: v1(1965.19,1950.04) 1977.15,1962 2685.13,1962 2854.13,2131 2995.31,2131 3046.81,2079.5 3098.42,2079.5 3107.36,2070.56 3181.11,1996.81 4974.77,1996.81 5143.74,1827.85 5163.7,1807.88 5234.7,1807.88 5243.53,1816.71 5687.21,1816.71 5750.84,1753.08 ; v1@6039.02,1735.04 cw(c6016.09,1735.04) 6032.31,1718.82 cw(c6048.52,1702.61) v1@6048.52,1725.54 ; v1@6043.02,1735.04 cw(c6029.75,1735.04) 6039.13,1725.65 cw(c6048.52,1716.26) v1@6048.52,1729.54 ; v1(6048.52,1735.04) 6030.19,1716.71 6029.69,1716.21 5976.39,1716.21 5967.06,1725.54 ; 5750.84,1753.08 5778.38,1725.54 ; 5750.84,1753.08 5778.38,1725.54 ; 5778.38,1725.54 5929.63,1725.54 ; 5929.63,1725.54 5967.06,1725.54 ; 5929.63,1725.54 5967.06,1725.54
  Bottom Layer w4: v1(6048.52,1735.04) 6096.98,1783.5 6295.88,1783.5 6297.19,1782.19 6550,1782.19 6551.76,1780.43 v2@6607.57,1780.43 ; v1@6048.52,1740.54 ccw(c6048.52,1753.82) 6057.91,1744.43 ccw(c6067.3,1735.04) v1@6054.02,1735.04 ; v1@6048.52,1744.54 ccw(c6048.52,1767.48) 6064.74,1751.26 ccw(c6080.96,1735.04) v1@6058.02,1735.04 ; v2@6602.19,1782.19 v2@6603.37,1783.37 ; v2@6604,1784 v2@6607.57,1780.43 ; v2@6607.57,1780.43 6608,1780 v2(6609,1780) 6608.57,1780.43 v2@6607.57,1780.43
PBCTRL.SPARE4: EXTHDR1.65 U30.L7 | length 8687.3
  Top Layer w4: v1@1108.47,2965.09 ccw(c1092.26,2981.31) 1115.19,2981.31 ccw(c1138.13,2981.31) v1@1121.91,2965.09 ; v1@1111.3,2962.26 ccw(c1101.91,2971.65) 1115.19,2971.65 ccw(c1128.47,2971.65) v1@1119.08,2962.26 ; v1(1115.19,2958.37) 1115.19,2990.37 1123.45,2998.63 EXTHDR1.65@1123.45,3071.85 ; EXTHDR1.65@1117.79,3021.07 cw(c1104.13,3007.42) 1123.45,3007.42 cw(c1142.76,3007.42) EXTHDR1.65@1129.1,3021.07 ; v1(1260.86,2171.04) 1294.73,2171.04 1336.69,2213 1543,2213 1669,2339 2111,2339 2128.68,2321.32 2294,2156 3071.75,2156 3099.5,2128.25 3099.5,2073.75 ; v1@1264.75,2167.15 cw(c1274.14,2157.76) 1274.14,2171.04 cw(c1274.14,2184.32) v1@1264.75,2174.93 ; v1@1267.57,2164.32 cw(c1283.79,2148.11) 1283.79,2171.04 cw(c1283.79,2193.98) v1@1267.57,2177.76 ; v1(3082,2054) 3082,2056.25 3099.5,2073.75 ; v1@3082,2063.5 ccw(c3082,2081) 3094.37,2068.63 ; v1@3087.5,2054.06 cw(c3105.54,2054.28) 3092.78,2067.03 ; v1@3091.5,2054.11 cw(c3118.82,2054.43) 3099.5,2073.75 ; v2@6753.06,1296.94 ccw(c6736.31,1313.69) 6760,1313.69 ccw(c6783.69,1313.69) v2@6766.94,1296.94 ; v2@6755.89,1294.11 ccw(c6745.97,1304.03) 6760,1304.03 ccw(c6774.03,1304.03) v2@6764.11,1294.11 ; v2(6758,1396) 6746.52,1384.52 6746.52,1340.7 6746.52,1340.15 6746.52,1330.29 6760,1316.81 v2(6760,1290) ; v3(6931.26,1746.89) U30.L7@6950.94,1766.57 ; U30.L7@6943.6,1766.57 cw(c6925.88,1766.57) 6938.41,1754.04 cw(c6950.94,1741.51) U30.L7@6950.94,1759.23 ; 6944.06,1759.69 cw(c6931.26,1772.5) 6931.26,1754.39 ccw(c6931.26,1772.5) 6944.06,1759.69 ; 6944.06,1759.69 ccw(c6956.87,1746.89) 6938.76,1746.89 cw(c6956.87,1746.89) 6944.06,1759.69
  MidLayer1 w4: v1@1115.19,2948.87 cw(c1115.19,2925.94) 1131.41,2942.16 cw(c1147.63,2958.37) v1@1124.69,2958.37 ; v1@1115.19,2952.87 cw(c1115.19,2939.6) 1124.58,2948.99 cw(c1133.97,2958.37) v1@1120.69,2958.37 ; v1(1115.19,2958.37) 1156.86,2916.71 1156.86,2275.04 v1(1260.86,2171.04) ; v1@1251.36,2171.04 ccw(c1228.42,2171.04) 1244.64,2187.26 ccw(c1260.86,2203.48) v1@1260.86,2180.54 ; v1@1255.36,2171.04 ccw(c1242.08,2171.04) 1251.47,2180.43 ccw(c1260.86,2189.82) v1@1260.86,2176.54 ; v2(6628,1488) 6568,1488 6554,1474 6554,1296 6563.5,1286.5 6570,1280 6610.81,1280 6617.31,1286.5 6656.62,1325.81 6670,1325.81 6684.25,1325.81 6719.87,1290.19 6759.81,1290.19 v2(6760,1290) ; 6735.86,1290.19 cw(c6735.86,1265.86) v2@6753.06,1283.06 ; 6736.77,1290.19 ccw(c6736.77,1313.23) v2@6753.06,1296.94 ; 6745.51,1290.19 cw(c6745.51,1275.51) v2@6755.89,1285.89 ; 6746.43,1290.19 ccw(c6746.43,1303.57) v2@6755.89,1294.11
  MidLayer2 w4: v1@3082,2044.5 cw(c3082,2021.56) 3098.22,2037.78 cw(c3114.43,2054) v1@3091.5,2054 ; v1@3082,2048.5 cw(c3082,2035.22) 3091.39,2044.61 cw(c3100.78,2054) v1@3087.5,2054 ; v1(3082,2054) 3155.19,1980.81 4725.76,1980.81 5014.76,1691.81 5473.95,1691.81 5628.26,1537.5 5736.25,1537.5 5748.29,1549.54 5880.28,1549.54 5896.44,1533.37 5999.56,1533.37 6016,1549.81 6044,1549.81 6060,1533.81 6160,1533.81 6165,1538.81 6195,1538.81 6200,1533.81 6214.63,1533.81 6231.86,1551.04 6234.82,1554 6317.9,1554 6322.71,1558.81 6332.9,1569 6413.71,1569 6460,1522.71 6481.29,1522.71 6512,1492 6624,1492 v2(6628,1488) ; 6594.66,1492 cw(c6594.66,1454.66) v2@6621.06,1481.06 ; 6604.31,1492 cw(c6604.31,1464.31) v2@6623.89,1483.89 ; v2@6621.06,1494.94 cw(c6613.97,1502.03) 6613.97,1492 cw(c6613.97,1473.97) v2@6626.72,1486.72 ; v2@6758,1401.81 ccw(c6758,1418.32) 6769.67,1406.65 ; v2@6758,1405.81 ccw(c6758,1431.97) 6776.5,1413.47 ; v2@6758.51,1395.49 6803.22,1440.19 6850.19,1440.19 6875,1465 6875,1502.55 6907.4,1534.95 6907.4,1590.47 6907.4,1609.89 6907.4,1684.01 6907.4,1703.51 cw(c6949.13,1703.51) 6919.62,1733.02 ; v2@6763.81,1396 cw(c6775.36,1396) 6767.19,1404.17 ; v2@6767.81,1396 cw(c6789.02,1396) 6774.02,1411 ; v3@6923.79,1746.24 cw(c6905.75,1744.66) 6919.62,1733.02 ; v3@6931.91,1739.42 ccw(c6933.49,1721.38) 6919.62,1733.02
  Bottom Layer w4: v2@6759.88,1289.88 v2(6760,1290) v2@6760.81,1290.81
PBCTRL.SPI_CS_N0: EXTHDR1.59 U30.N5 | length 8685.9
  Top Layer w4: v1@1200.14,2948.43 ccw(c1183.92,2964.64) 1206.86,2964.64 ccw(c1229.79,2964.64) v1@1213.57,2948.43 ; v1@1202.97,2945.6 ccw(c1193.58,2954.99) 1206.86,2954.99 ccw(c1220.14,2954.99) v1@1210.75,2945.6 ; v1(1206.86,2941.71) 1206.86,2970 1217.94,2981.08 EXTHDR1.59@1217.94,3071.85 ; EXTHDR1.59@1212.28,3021.07 cw(c1198.62,3007.42) 1217.94,3007.42 cw(c1237.25,3007.42) EXTHDR1.59@1223.59,3021.07 ; v1@6191.81,1055.76 ccw(c6175.59,1071.98) 6198.52,1071.98 ccw(c6221.46,1071.98) v1@6205.24,1055.76 ; v1@6194.64,1052.93 ccw(c6185.25,1062.32) 6198.52,1062.32 ccw(c6211.8,1062.32) v1@6202.41,1052.93 ; v1(6198.52,1049.04) 6198.52,1083.37 6395,1279.85 6395,1367.74 6324,1438.74 v1(6324,1488) ; v1@6317.28,1481.28 cw(c6301.06,1465.06) 6324,1465.06 cw(c6346.93,1465.06) v1@6330.72,1481.28 ; v1@6320.11,1484.11 cw(c6310.72,1474.72) 6324,1474.72 cw(c6337.28,1474.72) v1@6327.89,1484.11 ; v3(6852.52,1668.15) U30.N5@6872.2,1687.83 ; U30.N5@6864.86,1687.83 cw(c6847.14,1687.83) 6859.67,1675.3 cw(c6872.2,1662.77) U30.N5@6872.2,1680.49 ; 6865.32,1680.95 cw(c6852.52,1693.76) 6852.52,1675.65 ccw(c6852.52,1693.76) 6865.32,1680.95 ; 6865.32,1680.95 ccw(c6878.13,1668.15) 6860.02,1668.15 cw(c6878.13,1668.15) 6865.32,1680.95
  MidLayer1 w4: v1@1197.36,2941.71 cw(c1174.42,2941.71) 1190.64,2925.49 cw(c1206.86,2909.27) v1@1206.86,2932.21 ; v1@1201.36,2941.71 cw(c1188.08,2941.71) 1197.47,2932.32 cw(c1206.86,2922.93) v1@1206.86,2936.21 ; v1(1206.86,2941.71) 1164.86,2899.71 1164.86,2278.35 1230,2213.21 1258.65,2213.21 1281.86,2190 1281.86,1916.71 1283.26,1915.3 1325.57,1873 1908.31,1873 1948.31,1833 1990.02,1833 2056.31,1766.71 v1(2123.52,1766.71) ; v1@2116.81,1759.99 ccw(c2100.59,1743.77) 2100.59,1766.71 ccw(c2100.59,1789.64) v1@2116.81,1773.43 ; v1@2119.64,1762.82 ccw(c2110.25,1753.43) 2110.25,1766.71 ccw(c2110.25,1779.99) v1@2119.64,1770.6 ; v2(6812,1488) 6818,1488 6828.66,1498.66 ; v2@6814.65,1493.17 ccw(c6818.61,1500.93) 6824.77,1494.77 ; v2@6816.47,1496.74 ccw(c6821.24,1506.07) 6828.66,1498.66 ; v2@6821.81,1488 cw(c6831.01,1488) 6824.51,1494.51 ; 6828.66,1591.34 6828.66,1605.27 ; v3@6845.13,1666.85 cw(c6827.3,1663.7) 6842.13,1653.32 ; v3@6853.82,1660.76 ccw(c6856.97,1642.93) 6842.13,1653.32 ; 6828.66,1498.66 6828.66,1531.15 6828.66,1605.27 ; 6828.66,1605.27 6828.66,1628.52 cw(c6852.43,1628.52) 6835.05,1644.74 6842.13,1653.32
  MidLayer2 w4: v1@2123.52,1757.21 cw(c2123.52,1734.27) 2139.74,1750.49 cw(c2155.96,1766.71) v1@2133.02,1766.71 ; v1@2123.52,1761.21 cw(c2123.52,1747.93) 2132.91,1757.32 cw(c2142.3,1766.71) v1@2129.02,1766.71 ; v1(2123.52,1766.71) 2160.23,1730 2813.69,1730 2893.69,1650 4238.29,1650 4280,1691.71 4818.17,1691.71 4884.84,1625.04 4929.96,1625.04 4979.38,1575.62 4979.38,1557.16 5106.54,1430 5251.9,1430 5270.69,1411.21 5442.69,1239.21 5547.38,1239.21 5577.46,1269.29 5693.57,1269.29 5730.65,1232.21 5888.06,1232.21 5913.06,1257.21 6030.69,1257.21 6048.52,1275.04 6065.19,1275.04 6131.86,1208.37 6198.52,1141.71 v1(6198.52,1049.04) ; v1@6191.81,1055.76 ccw(c6175.59,1071.98) 6198.52,1071.98 ccw(c6221.46,1071.98) v1@6205.24,1055.76 ; v1@6194.64,1052.93 ccw(c6185.25,1062.32) 6198.52,1062.32 ccw(c6211.8,1062.32) v1@6202.41,1052.93 ; v1@6324,1478.5 cw(c6324,1455.56) 6340.22,1471.78 cw(c6356.43,1488) v1@6333.5,1488 ; v1@6324,1482.5 cw(c6324,1469.22) 6333.39,1478.61 cw(c6342.78,1488) v1@6329.5,1488 ; v1(6324,1488) 6375.19,1436.81 6730,1436.81 6736.62,1430.19 6750,1430.19 6751.38,1430.19 6766.88,1430.19 6792.88,1456.19 6803.19,1456.19 6812,1465 ; v2@6805.21,1480.92 cw(c6789.95,1465) 6812,1465 ; v2@6807.98,1483.81 cw(c6798.94,1474.38) 6812,1474.38 cw(c6825.06,1474.38) v2@6816.02,1483.81 ; v2(6812,1488) 6812,1465 ; v2@6818.79,1480.92 ccw(c6834.05,1465) 6812,1465
PBCTRL.SPI_CS_N1: EXTHDR1.63 U30.M7 | length 8962.9
  Top Layer w4: v1@1150.14,3006.76 ccw(c1133.92,3022.98) 1156.86,3022.98 ccw(c1179.79,3022.98) v1@1163.57,3006.76 ; v1@1152.97,3003.93 ccw(c1143.58,3013.32) 1156.86,3013.32 ccw(c1170.14,3013.32) v1@1160.75,3003.93 ; EXTHDR1.63@1154.94,3071.85 1154.94,3075.04 EXTHDR1.63@1156.86,3075.04 ; v1(1156.86,3000.04) EXTHDR1.63@1156.86,3071.85 ; v3(6931.26,1707.52) U30.M7@6950.94,1727.2 ; U30.M7@6943.6,1727.2 cw(c6925.88,1727.2) 6938.41,1714.67 cw(c6950.94,1702.14) U30.M7@6950.94,1719.86 ; 6944.06,1720.32 cw(c6931.26,1733.13) 6931.26,1715.02 ccw(c6931.26,1733.13) 6944.06,1720.32 ; 6944.06,1720.32 ccw(c6956.87,1707.52) 6938.76,1707.52 cw(c6956.87,1707.52) 6944.06,1720.32
  MidLayer1 w4: v1(1156.86,3000.04) 1198.52,3000.04 1230,2968.57 1230,2935 1172.86,2877.86 1172.86,2432.14 1195,2410 1365,2410 1385,2390 1385,1908.21 1404.21,1889 1914.94,1889 1954.94,1849 1996.65,1849 2005.65,1840 v1(2070,1840) ; v1@1160.75,2996.15 cw(c1170.14,2986.76) 1170.14,3000.04 cw(c1170.14,3013.32) v1@1160.75,3003.93 ; v1@1163.57,2993.32 cw(c1179.79,2977.11) 1179.79,3000.04 cw(c1179.79,3022.98) v1@1163.57,3006.76 ; v1@2063.28,1833.28 ccw(c2047.06,1817.06) 2047.06,1840 ccw(c2047.06,1862.93) v1@2063.28,1846.72 ; v1@2066.11,1836.11 ccw(c2056.72,1826.72) 2056.72,1840 ccw(c2056.72,1853.28) v1@2066.11,1843.89 ; v2@5548.06,1787.06 cw(c5531.31,1770.31) 5555,1770.31 cw(c5578.69,1770.31) v2@5561.94,1787.06 ; v2@5550.89,1789.89 cw(c5540.97,1779.97) 5555,1779.97 cw(c5569.03,1779.97) v2@5559.11,1789.89 ; v2@5556.52,1792.48 v2(5555,1794) 5555,1726.81 5555,1689.19 5587.19,1657 v2@5624.81,1657 ; v2@5620.06,1650.06 ccw(c5603.31,1633.31) 5603.31,1657 ccw(c5603.31,1680.69) v2@5620.06,1663.94 ; v2@5622.89,1652.89 ccw(c5612.97,1642.97) 5612.97,1657 ccw(c5612.97,1671.03) v2@5622.89,1661.11 ; v2@5624.81,1657 v2(5627,1657) v2@5624.81,1657
  MidLayer2 w4: v1@2063.28,1833.28 cw(c2047.06,1817.06) 2070,1817.06 cw(c2092.93,1817.06) v1@2076.72,1833.28 ; v1@2066.11,1836.11 cw(c2056.72,1826.72) 2070,1826.72 cw(c2083.28,1826.72) v1@2073.89,1836.11 ; v1(2070,1840) 2070,1786.9 2137.81,1719.09 2813.28,1719.09 2890.66,1641.71 4256.86,1641.71 v1(4281.86,1666.71) ; v1@4272.36,1666.71 cw(c4249.42,1666.71) 4265.64,1650.49 cw(c4281.86,1634.27) v1@4281.86,1657.21 ; v1@4276.36,1666.71 cw(c4263.08,1666.71) 4272.47,1657.32 cw(c4281.86,1647.93) v1@4281.86,1661.21 ; v2(6463.1,1375.69) 6457.56,1375.69 6437.5,1395.75 6437.5,1410.25 6447.75,1420.5 6708.31,1420.5 6758.81,1370 6800,1370 ; 6806.53,1370 6800,1370 ; 6919.87,1693.94 ccw(c6929.8,1684.01) 6915.75,1684.01 6915.75,1590.47 6915.75,1504.94 6914.19,1503.38 6914.19,1488.62 6922.19,1480.62 6922.19,1451.38 6892.41,1421.59 6862.42,1421.59 6810.83,1370 6800,1370 ; v3@6923.79,1706.87 cw(c6905.75,1705.29) 6919.62,1693.65 cw(c6933.49,1682.01) v3@6931.91,1700.05
  Bottom Layer w4: v1@4272.36,1666.71 ccw(c4249.42,1666.71) 4265.64,1682.93 ccw(c4281.86,1699.14) v1@4281.86,1676.21 ; v1@4276.36,1666.71 ccw(c4263.08,1666.71) 4272.47,1676.1 ccw(c4281.86,1685.49) v1@4281.86,1672.21 ; v1(4281.86,1666.71) 4256.86,1691.71 4256.86,1725.04 4273.52,1741.71 4290.19,1741.71 4340.19,1691.71 4870.54,1691.71 4995.54,1816.71 5485,1816.71 5532.29,1816.71 v2(5555,1794) ; v2@5545.19,1794 ccw(c5521.5,1794) 5538.25,1810.75 ccw(c5555,1827.5) v2@5555,1803.81 ; v2@5549.19,1794 ccw(c5535.16,1794) 5545.08,1803.92 ccw(c5555,1813.84) v2@5555,1799.81 ; v2@5617.19,1657 cw(c5593.5,1657) 5610.25,1640.25 cw(c5627,1623.5) v2@5627,1647.19 ; v2@5621.19,1657 cw(c5607.16,1657) 5617.08,1647.08 cw(c5627,1637.16) v2@5627,1651.19 ; v2(5627,1657) 5610,1640 5610,1549 5610,1546.17 5640.17,1516 5810.17,1516 5818.88,1516 5842.69,1492.19 5877.38,1492.19 5883.19,1498 6037.19,1498 6053.19,1482 6067,1482 6112,1437 6112,1361.5 6124.06,1349.44 6161.32,1349.44 6172,1360.12 6172,1440.88 6191.62,1460.5 6423.25,1460.5 6472.5,1411.25 6472.5,1385.09 v2(6463.1,1375.69)
PBIO.D0: EXTHDR1.2 U8.AA13 | length 4425.6
  Top Layer w4: EXTHDR1.2@2125.66,2910.03 ccw(c2112.01,2923.68) 2131.32,2923.68 ccw(c2150.64,2923.68) EXTHDR1.2@2136.98,2910.03 ; EXTHDR1.2@2131.32,2859.25 2131.32,2926.32 2138.37,2933.37 v1(2165.19,2933.37) ; v1@2158.47,2926.66 ccw(c2142.26,2910.44) 2142.26,2933.37 ccw(c2142.26,2956.31) v1@2158.47,2940.09 ; v1@2161.3,2929.49 ccw(c2151.91,2920.1) 2151.91,2933.37 ccw(c2151.91,2946.65) v1@2161.3,2937.26 ; v3(5311.26,3914.41) U8.AA13@5330.94,3934.09 ; U8.AA13@5323.6,3934.09 cw(c5305.88,3934.09) 5318.41,3921.56 cw(c5330.94,3909.03) U8.AA13@5330.95,3926.75 ; 5324.06,3927.21 cw(c5311.26,3940.02) 5311.26,3921.91 ccw(c5311.26,3940.02) 5324.06,3927.21 ; 5324.06,3927.21 ccw(c5336.87,3914.41) 5318.76,3914.41 cw(c5336.87,3914.41) 5324.06,3927.21
  MidLayer2 w4: v1@2163.42,2931.61 ccw(c2179.27,2947.46) 2179.27,2925.04 ; v1(2165.19,2933.37) 2173.52,2925.04 2245,2925.04 2253.67,2916.37 4218.63,2916.37 4260.63,2958.37 4429.25,2958.37 4436.12,2951.5 4501.98,2951.5 4573.71,3023.23 4574.48,3024 4669.21,3024 4856.82,3024 4981.86,3149.04 4981.86,3178.14 4974.5,3185.5 4974.5,3187.45 4974.5,3230 4974.5,3320 4974.5,3330.5 4974.5,3342.68 4997.52,3365.71 5090.19,3365.71 5094.52,3370.04 5094.52,3491.71 5090.19,3496.04 5089.7,3496.54 5089.7,3556.7 5121,3588 5177,3588 5195,3570 5258.62,3570 5287.4,3598.77 5287.4,3630.82 5287.4,3638.82 5287.4,3757.99 5287.4,3777.41 5287.4,3851.53 5287.4,3871.03 cw(c5329.13,3871.03) 5299.62,3900.54 ; v1@2166.25,2934.44 ccw(c2188.93,2957.12) 2188.93,2925.04 ; v1@2169.08,2937.26 ccw(c2198.59,2966.77) 2198.59,2925.04 ; v1@2171.91,2940.09 ccw(c2208.25,2976.43) 2208.25,2925.04 ; v3@5303.79,3913.76 cw(c5285.75,3912.18) 5299.62,3900.54 ; v3@5311.91,3906.94 ccw(c5313.49,3888.9) 5299.62,3900.54
PBIO.D1: EXTHDR1.4 U8.AH10 | length 4133.3
  Top Layer w4: v1(2090.19,2933.37) 2099.83,2923.74 EXTHDR1.4@2099.83,2859.25 ; EXTHDR1.4@2094.17,2910.03 ccw(c2080.51,2923.68) 2099.83,2923.68 ccw(c2119.14,2923.68) EXTHDR1.4@2105.48,2910.03 ; v1@5183.47,3473.43 ccw(c5167.26,3489.64) 5190.19,3489.64 ccw(c5213.13,3489.64) v1@5196.91,3473.43 ; v1@5186.3,3470.6 ccw(c5176.91,3479.99) 5190.19,3479.99 ccw(c5203.47,3479.99) v1@5194.08,3470.6 ; v1(5190.19,3466.71) 5190.19,3495.06 5205.33,3510.2 5205.33,3526.2 5209.81,3530.68 5209.81,3565.32 5209.02,3566.11 5209.02,3609.02 5212.83,3612.83 5212.83,3630.82 5212.83,3638.82 ; 5212.83,3638.82 U8.AH10@5212.83,3658.5 5212.83,3638.82 ; 5212.83,3640.78 cw(c5230.56,3640.78) 5218.03,3653.31 ccw(c5230.56,3640.78) 5212.83,3640.78 ; 5212.83,3640.78 ccw(c5195.11,3640.78) 5207.64,3653.31 cw(c5195.11,3640.78) 5212.83,3640.78
  MidLayer2 w4: v1@2090.19,2923.87 cw(c2090.19,2900.94) 2106.41,2917.16 cw(c2122.63,2933.37) v1@2099.69,2933.37 ; v1@2090.19,2927.87 cw(c2090.19,2914.6) 2099.58,2923.99 cw(c2108.97,2933.37) v1@2095.69,2933.37 ; v1(2090.19,2933.37) 2115.19,2908.37 4670.54,2908.37 4695.54,2933.37 4999.52,2933.37 5108,3041.85 5108,3087.06 5232.02,3211.09 5232.02,3274.15 5232.02,3387.9 5231.86,3388.07 5231.86,3425.04 v1(5190.19,3466.71) ; v1@5190.19,3457.21 cw(c5190.19,3434.27) 5206.41,3450.49 cw(c5222.63,3466.71) v1@5199.69,3466.71 ; v1@5190.19,3461.21 cw(c5190.19,3447.93) 5199.58,3457.32 cw(c5208.97,3466.71) v1@5195.69,3466.71
PBIO.D2: EXTHDR1.6 U8.AF9 | length 4264.7
  Top Layer w4: EXTHDR1.6@2068.33,2806.13 cw(c2068.33,2788.18) 2081.02,2800.87 ; EXTHDR1.6@2068.33,2859.25 2068.33,2813.57 2090.19,2791.71 2190.19,2791.71 v1(2215.19,2816.71) ; EXTHDR1.6@2072.33,2814.13 ccw(c2083.35,2814.13) EXTHDR1.6@2075.56,2806.34 ; EXTHDR1.6@2076.33,2814.13 ccw(c2097.01,2814.13) 2082.39,2799.51 ; v1@2205.69,2816.71 cw(c2182.76,2816.71) 2198.97,2800.49 cw(c2215.19,2784.27) v1@2215.19,2807.21 ; v1@2209.69,2816.71 cw(c2196.41,2816.71) 2205.8,2807.32 cw(c2215.19,2797.93) v1@2215.19,2811.21 ; v1(5068.52,3450.37) 5112.5,3494.35 5112.5,3517.25 5122.75,3527.5 5133.04,3527.5 5145.77,3540.23 ; v1@5068.52,3455.87 ccw(c5068.52,3469.15) 5077.91,3459.76 ccw(c5087.3,3450.37) v1@5074.02,3450.37 ; v1@5068.52,3459.87 ccw(c5068.52,3482.81) 5084.74,3466.59 ccw(c5100.96,3450.37) v1@5078.02,3450.37 ; 5146,3540 5146,3540.46 5149.6,3544.06 5149.6,3630.4 5149.6,3638.82 5149.6,3697.36 cw(c5188.28,3697.36) 5160.93,3724.71 ; U8.AF9@5166.12,3737.24 cw(c5148.4,3737.24) 5160.93,3724.71 ; U8.AF9@5173.46,3729.9 ccw(c5173.46,3712.18) 5160.93,3724.71
  MidLayer1 w4: v1(2215.19,2816.71) 2548.52,2816.71 v1(2723.52,2991.71) ; v1@2219.08,2812.82 cw(c2228.47,2803.43) 2228.47,2816.71 cw(c2228.47,2829.99) v1@2219.08,2820.6 ; v1@2221.91,2809.99 cw(c2238.13,2793.77) 2238.13,2816.71 cw(c2238.13,2839.64) v1@2221.91,2823.43 ; v1@2714.02,2991.71 cw(c2691.09,2991.71) 2707.31,2975.49 cw(c2723.52,2959.27) v1@2723.52,2982.21 ; v1@2718.02,2991.71 cw(c2704.75,2991.71) 2714.14,2982.32 cw(c2723.52,2972.93) v1@2723.52,2986.21
  MidLayer2 w4: v1(2723.52,2991.71) 2742.71,2991.71 ; v1@2731.08,2985.95 cw(c2742.71,2977.09) 2742.71,2991.71 ; v1@2731.08,2997.47 ccw(c2742.71,3006.32) 2742.71,2991.71 ; v1@5059.02,3450.37 cw(c5036.09,3450.37) 5052.31,3434.16 cw(c5068.52,3417.94) v1@5068.52,3440.87 ; v1@5063.02,3450.37 cw(c5049.75,3450.37) 5059.14,3440.99 cw(c5068.52,3431.6) v1@5068.52,3444.87 ; v1(5068.52,3450.37) 5051.52,3433.37 5012.44,3433.37 ; 2742.71,2991.71 2759.71,2974.71 3279.71,2974.71 3288.04,2983.04 3353.54,2983.04 3462.7,3092.2 3467.68,3092.2 3468.17,3091.71 4629.21,3091.71 4654.21,3116.71 4716.19,3116.71 4732.86,3100.04 4816.1,3100.04 4950.5,3234.44 4950.5,3275 ; 4950.5,3275 4950.5,3320.56 ; 4950.5,3275 4950.5,3320.56 ; 4950.5,3320.56 4950.5,3371.44 ; 4950.5,3371.44 5012.44,3433.37 ; 4950.5,3371.44 5012.44,3433.37
PBIO.D3: EXTHDR1.8 U8.AG10 | length 4951.5
  Top Layer w4: EXTHDR1.8@2031.18,2808.48 cw(c2017.52,2794.82) 2036.83,2794.82 cw(c2056.15,2794.82) EXTHDR1.8@2042.49,2808.48 ; EXTHDR1.8@2036.83,2859.25 2036.83,2661.73 v1(2081.86,2616.71) ; v1@2072.36,2616.71 ccw(c2049.42,2616.71) 2065.64,2632.93 ccw(c2081.86,2649.14) v1@2081.86,2626.21 ; v1@2076.36,2616.71 ccw(c2063.08,2616.71) 2072.47,2626.1 ccw(c2081.86,2635.49) v1@2081.86,2622.21 ; v1(5114.19,3450.04) 5133.86,3450.04 ; v1@5121.63,3444.14 cw(c5133.86,3434.44) 5133.86,3450.04 ; v1@5121.63,3455.95 ccw(c5133.86,3465.65) 5133.86,3450.04 ; 5133.86,3450.04 5197.33,3513.51 5197.33,3529.51 5201.81,3534 5201.81,3562 5197.33,3566.49 5197.33,3630.82 5197.33,3638.82 5197.33,3678.16 ; 5197.33,3678.16 cw(c5207.48,3678.16) 5200.3,3685.34 ; 5197.33,3678.16 cw(c5207.48,3678.16) 5200.3,3685.34 ; 5200.3,3685.34 ccw(c5187.77,3697.87) 5205.49,3697.87 cw(c5187.77,3697.87) 5200.3,3685.34 ; 5200.3,3685.34 cw(c5212.83,3672.8) 5212.83,3690.53 ccw(c5212.83,3672.8) 5200.3,3685.34
  MidLayer1 w4: 5056.98,2750.37 cw(c5056.98,2725.16) v1@5074.81,2742.99 ; 5060.2,2750.37 ccw(c5060.2,2771.03) v1@5074.81,2756.43 ; 5066.64,2750.37 cw(c5066.64,2734.82) v1@5077.64,2745.82 ; 5069.86,2750.37 ccw(c5069.86,2761.38) v1@5077.64,2753.6 ; v1(5081.52,2749.71) 5081.52,2750.37 5045.82,2750.37 4987.5,2808.69 4987.5,3105 4987.5,3122.31 4987.5,3143.68 4990.19,3146.37 4997.19,3153.37 4997.19,3175 4997.19,3180 4997.19,3368.37 5049.32,3420.5 5069.23,3420.5 5109.69,3420.5 5114.19,3425 v1(5114.19,3450.04) ; v1@5107.47,3443.32 cw(c5091.26,3427.11) 5114.19,3427.11 cw(c5137.13,3427.11) v1@5120.91,3443.32 ; v1@5110.3,3446.15 cw(c5100.91,3436.76) 5114.19,3436.76 cw(c5127.47,3436.76) v1@5118.08,3446.15
  MidLayer2 w4: v1@2081.86,2607.21 cw(c2081.86,2584.27) 2098.07,2600.49 cw(c2114.29,2616.71) v1@2091.36,2616.71 ; v1@2081.86,2611.21 cw(c2081.86,2597.93) 2091.25,2607.32 cw(c2100.64,2616.71) v1@2087.36,2616.71 ; v1(2081.86,2616.71) 2122.56,2576 3049.65,2576 3090.35,2616.71 3559.84,2616.71 3701.84,2758.71 4078,2758.71 4152.21,2684.5 4841.32,2684.5 4906.52,2749.71 v1(5081.52,2749.71) ; v1@5074.81,2742.99 ccw(c5058.59,2726.77) 5058.59,2749.71 ccw(c5058.59,2772.64) v1@5074.81,2756.43 ; v1@5077.64,2745.82 ccw(c5068.25,2736.43) 5068.25,2749.71 ccw(c5068.25,2762.99) v1@5077.64,2753.6
PBIO.D4: EXTHDR1.10 U8.AH8 | length 3964.4
  Top Layer w4: EXTHDR1.10@1999.72,2910.06 ccw(c1986.41,2923.52) 2005.34,2923.52 ; EXTHDR1.10@2005.34,2904.36 EXTHDR1.10@2005.34,2859.25 2005.34,2923.52 ; EXTHDR1.10@2010.96,2910.06 cw(c2024.27,2923.52) 2005.34,2923.52 ; v1@2023.68,2928.53 ccw(c2015.19,2923.51) 2015.19,2933.37 ; v1@2023.68,2938.22 cw(c2015.19,2943.24) 2015.19,2933.37 ; v1(2031.86,2933.37) 2015.19,2933.37 ; v1@5073.02,3483.37 cw(c5091.49,3483.37) 5078.43,3496.43 ; v1(5075.52,3483.37) 5075.52,3493.52 5118.87,3536.87 5131.11,3536.87 5141.36,3547.13 5141.36,3564.64 5135.76,3570.24 5135.76,3616.24 5134.09,3617.91 5134.09,3630.82 5134.09,3638.82 U8.AH8@5134.09,3658.5 ; v1@5077.02,3483.37 cw(c5105.15,3483.37) 5085.26,3503.26 ; v1@5081.02,3483.37 cw(c5118.81,3483.37) 5092.09,3510.09 ; v1@5085.02,3483.37 cw(c5132.46,3483.37) 5098.92,3516.92 ; U8.AH8@5128.9,3653.31 cw(c5116.37,3640.78) 5134.09,3640.78 cw(c5151.82,3640.78) U8.AH8@5139.29,3653.31 ; 2005.34,2923.52 2015.19,2933.37 ; 2005.34,2923.52 2015.19,2933.37
  MidLayer2 w4: v1(2031.86,2933.37) 2045.19,2933.37 2078.52,2966.71 3283.29,2966.71 3291.63,2975.04 3356.86,2975.04 3465.19,3083.37 4632.19,3083.37 4657.19,3108.37 4712.52,3108.37 4729.19,3091.71 4819.08,3091.71 4958.5,3231.12 4958.5,3270 4958.5,3323.88 4958.5,3368.12 5015.42,3425.04 5067.94,3425.04 5086.02,3443.13 5086.02,3455 ; v1(5075.52,3483.37) 5086.02,3472.87 5086.02,3467.21 ; 5086.02,3455 5086.02,3467.21 ; 5086.02,3455 5086.02,3467.21