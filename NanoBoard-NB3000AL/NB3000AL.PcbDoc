# Altium PCB NB3000AL.PcbDoc (part 8 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
3V3: C20.1 C21.1 C35.1 C36.1 C37.2 C39.2 C49.1 C50.2 C51.2 C52.2 C54.2 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C63.1 C64.1 C65.1 C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C90.2 C91.2 C92.2 C93.1 C94.1 C95.1 C96.1 C126.1 C127.1 C136.1 C137.1 C153.1 C154.1 C155.1 C156.1 C158.1 C159.2 C160.1 C161.2 C162.1 C163.2 C164.1 C165.2 C168.1 C172.2 C173.2 C174.2 C175.1 C176.1 C177.1 C185.1 C200.1 C201.1 C202.1 C203.1 C215.1 C216.1 C217.1 C218.1 C227.1 C228.1 C229.1 C231.1 C232.1 C233.1 C234.1 C243.1 C244.1 C245.1 C246.1 C247.1 C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C257.1 C258.1 C259.1 C276.1 C277.1 C278.1 C279.1 C291.1 C292.1 C293.1 C294.1 C303.1 C304.1 C305.1 C307.1 C308.1 C309.1 C310.1 C319.1 C320.1 C321.1 C322.1 C323.1 C324.1 C325.1 C326.1 C327.1 C328.1 C329.1 C330.1 C331.1 C332.1 C333.1 C334.1 C335.1 C367.1 C368.1 D1.3 EXTHDR1.85 EXTHDR1.87 J8.12 J29.4 J30.4 JP1.3 JP2.3 L2.1 LED2.1 LED3.1 NT4.2 NT10.1 NT34.2 NT35.2 NT36.2 NT37.2 NT45.1 PROTOTYPE1.28 R21.1 R39.1 R50.2 R57.2 R59.2 R70.2 R73.2 R76.2 R77.2 R98.2 R99.2 R102.1 R103.1 R104.2 R105.1 R106.2 R107.1 R113.1 R114.1 R115.2 R131.2 R147.1 R154.2 R156.2 R158.2 R159.2 R161.1 R162.1 R163.1 R195.2 R205.2 R215.1 R216.2 R217.2 R218.2 R219.2 R224.2 R225.2 R226.2 R227.2 R232.2 R234.2 R235.2 R236.2 R237.2 R238.2 R239.2 R240.2 R241.2 R242.2 R243.2 R248.2 R250.1 R251.1 R252.2 R253.1 R254.1 R255.1 R256.1 R260.2 R264.2 R265.2 R271.2 R272.2 R273.2 R277.1 R278.2 R279.1 R280.1 R281.1 R282.1 R283.1 TP4.1 U1.5 U1.8 U2.3 U2.13 U3.14 U4.5 U5.14 U5.37 U5.38 U5.39 U5.41 U5.44 U5.48 U6.19 U6.20 U7.D8 U7.F1 U7.F7 U7.G5 U8.A2 U8.A5 U8.A9 U8.A13 U8.A16 U8.A20 U8.A24 U8.A27 U8.AA1 U8.AA11 U8.AA18 U8.AA28 U8.AB10 U8.AD6 U8.AD9 U8.AD13 U8.AD16 U8.AD20 U8.AD23 U8.AG1 U8.AG28 U8.AH2 U8.AH5 U8.AH9 U8.AH13 U8.AH16 U8.AH20 U8.AH24 U8.AH27 U8.B1 U8.B28 U8.E6 U8.E9 U8.E13 U8.E16 U8.E20 U8.E23 U8.H1 U8.H11 U8.H18 U8.H28 U8.J13 U8.J15 U8.K5 U8.K8 U8.K24 U8.L21 U8.N1 U8.N5 U8.N24 U8.N28 U8.T1 U8.T5 U8.T24 U8.T28 U8.U21 U8.W5 U8.W7 U8.W24 U8.Y16 U12.1 U12.3 U12.9 U12.14 U12.27 U12.43 U12.49 U13.1 U13.3 U13.9 U13.14 U13.27 U13.43 U13.49 U14.11 U14.33 U15.11 U15.33 U16.11 U16.33 U17.11 U17.33 U19.7 U19.11 U19.17 U19.27 U19.32 U19.43 U19.55 U21.12 U21.23 U21.24 U23.4 U30.A1 U30.A16 U30.C4 U30.C7 U30.C10 U30.C13 U30.E3 U30.E14 U30.G3 U30.G14 U30.H12 U30.K3 U30.K14 U30.M3 U30.M14 U30.P4 U30.P7 U30.P10 U30.P13 U30.T1 U30.T16 U36.6 U37.5 U38.5 U39.3 U41.2 U45.4 U47.11 U47.33 U49.4 U50.3 U50.7 U50.8 U51.3 U51.7 U51.8 U52.3 U52.7 U52.8 U53.3 U53.7 U53.8 U54.5 U56.7 U56.11 U56.17 U56.27 U56.32 U56.43 U56.55 U60.4 U61.10 U61.13 U61.40 U61.48 U61.59 U61.67 U61.75 U61.83 U61.94 U61.104 U61.115 U61.126 U65.5 U66.5 U67.5 U68.5 U69.5 U70.6 | length 65765.7
  Top Layer w4: R147.1@4415.19,4271.37 R147.1@4418.82,4275 ; v1@4694,4134.5 ccw(c4694,4147.78) 4703.39,4138.39 ccw(c4712.78,4129) v1@4699.5,4129 ; v1@4694,4138.5 ccw(c4694,4161.43) 4710.22,4145.22 ccw(c4726.44,4129) v1@4703.5,4129 ; v1@4695,4129 4695,4130 4715,4150 4728.31,4150 4741.81,4136.5 4784.5,4136.5 4790,4131 4829.94,4131 ; v1(4725,4480.09) 4734.36,4480.09 4760.69,4453.77 4823.91,4453.77 4831.77,4445.91 U8.H1@4858.5,4445.91 ; v2@4771.49,4263.97 cw(c4784.91,4254.67) 4784.91,4271 ; v2@4773,4267 4777,4271 4800.19,4271 ; v1@4773.89,3938.89 ccw(c4785.46,3950.46) 4785.46,3934.09 ; v2@4774.78,4261.69 cw(c4792.55,4249.38) 4792.55,4271 ; v1@4776.72,3928.28 cw(c4790.75,3914.25) 4790.75,3934.09 ; v1@4776.72,3941.72 ccw(c4795.12,3960.12) 4795.12,3934.09 ; v2@4778.06,4259.41 cw(c4800.19,4244.09) 4800.19,4271 ; v1@4780,3934 4780.09,3934.09 4820,3934.09 ; v2@4807,3619.32 ccw(c4796,3611.51) 4796,3625 ; v2@4807,3630.68 cw(c4796,3638.49) 4796,3625 ; v2@4815.55,3625.55 v2(4815,3625) ; v2@4828.19,4804 cw(c4804.5,4804) 4821.25,4787.25 cw(c4838,4770.5) v2@4838,4794.19 ; 4829.91,3934.09 4820,3934.09 ; 4830,4130.94 4829.94,4131 ; 4830.87,3697.87 4831.83,3697.87 ; v2@4832.19,4804 cw(c4818.16,4804) 4828.08,4794.08 cw(c4838,4784.16) v2@4838,4798.19 ; 4840,4131 4829.94,4131 ; v2@4842.49,4800.31 cw(c4850.29,4793.91) 4850.29,4804 cw(c4850.29,4814.09) v2@4842.49,4807.69 ; v2@4845.58,4797.77 cw(c4858.75,4786.97) 4858.75,4804 cw(c4858.75,4821.03) v2@4845.58,4810.23 ; U8.AG1@4853.31,3692.68 ccw(c4840.78,3680.15) 4840.78,3697.87 ; U8.AG1@4853.31,3703.07 cw(c4840.78,3715.6) 4840.78,3697.87 ; U8.AA1@4853.31,3928.9 ccw(c4840.78,3916.37) 4840.78,3934.09 ccw(c4840.78,3951.82) U8.AA1@4853.31,3939.29 ; U8.T1@4853.31,4125.75 ccw(c4840.78,4113.22) 4840.78,4130.94 ccw(c4840.78,4148.67) U8.T1@4853.31,4136.14 ; U8.N1@4853.31,4243.86 ccw(c4840.78,4231.33) 4840.78,4249.05 ccw(c4840.78,4266.78) U8.N1@4853.31,4254.25 ; U8.H1@4853.31,4440.71 ccw(c4840.78,4428.18) 4840.78,4445.91 ccw(c4840.78,4463.63) U8.H1@4853.31,4451.1 ; U8.B1@4853.31,4676.93 ccw(c4840.78,4664.4) 4840.78,4682.13 ccw(c4840.78,4699.85) U8.B1@4853.31,4687.32 ; U8.AA1@4858.5,3934.09 4820,3934.09 ; U8.N1@4858.5,4249.05 4822.13,4249.05 4800.19,4271 ; U8.B1@4858.5,4682.13 4813.87,4682.13 4808,4688 4808,4774 v2(4838,4804) 4858.75,4804 4897.87,4764.87 U8.A2@4897.87,4721.5 ; U8.AH2@4892.68,3653.31 cw(c4880.15,3640.78) 4897.87,3640.78 cw(c4915.6,3640.78) U8.AH2@4903.07,3653.31 ; U8.A2@4892.68,4726.69 ccw(c4880.15,4739.22) 4897.87,4739.22 ccw(c4915.6,4739.22) U8.A2@4903.07,4726.69 ; U8.AH2@4897.87,3658.5 4897,3657.63 4897,3653 4898,3652 4898,3627 4887.5,3616.5 4886.5,3615.5 4882.99,3615.5 4856.81,3615.5 4854.31,3613 4840,3613 ; v2@4946.28,3566.28 ccw(c4956.61,3576.61) 4956.61,3562 ; v2@4949.11,3569.11 ccw(c4966.27,3586.27) 4966.27,3562 ; v2@4951.94,3558.06 cw(c4961.44,3548.56) 4961.44,3562 ; v2@4951.94,3571.94 ccw(c4975.93,3595.93) 4975.93,3562 ; v2@4952,3562 4976.09,3562 5015.98,3601.89 U8.AH5@5015.98,3658.5 ; v1(4955,4850) 4992,4850 5015.98,4826.02 U8.A5@5015.98,4721.5 ; v1@4958.89,4846.11 cw(c4968.28,4836.72) 4968.28,4850 cw(c4968.28,4863.28) v1@4958.89,4853.89 ; v1@4961.72,4843.28 cw(c4977.93,4827.06) 4977.93,4850 cw(c4977.93,4872.93) v1@4961.72,4856.72 ; v3(4996.3,3993.15) U8.W5@5015.98,4012.83 ; v3(4996.3,4111.26) U8.T5@5015.98,4130.94 ; v3(4996.3,4268.74) U8.N5@5015.98,4249.05 ; v3(4996.3,4386.85) U8.K5@5015.98,4367.17 ; U8.W5@5008.64,4012.83 cw(c4990.92,4012.83) 5003.45,4000.3 cw(c5015.98,3987.77) U8.W5@5015.98,4005.49 ; U8.T5@5008.64,4130.94 cw(c4990.92,4130.94) 5003.45,4118.41 cw(c5015.98,4105.88) U8.T5@5015.98,4123.6 ; U8.N5@5008.64,4249.05 ccw(c4990.92,4249.05) 5003.45,4261.59 ccw(c5015.98,4274.12) U8.N5@5015.98,4256.4 ; U8.K5@5008.64,4367.17 ccw(c4990.92,4367.17) 5003.45,4379.7 ccw(c5015.98,4392.23) U8.K5@5015.98,4374.51 ; U8.AH5@5010.79,3653.31 cw(c4998.26,3640.78) 5015.98,3640.78 cw(c5033.71,3640.78) U8.AH5@5021.18,3653.31 ; U8.A5@5010.79,4726.69 ccw(c4998.26,4739.22) 5015.98,4739.22 ccw(c5033.71,4739.22) U8.A5@5021.18,4726.69 ; 5016,4750 5016,4826 ; v3(5035.67,3796.3) U8.AD6@5055.35,3815.98 ; v3(5035.67,4583.7) U8.E6@5055.35,4564.02 ; U8.AD6@5048.01,3815.98 cw(c5030.29,3815.98) 5042.82,3803.45 cw(c5055.35,3790.92) U8.AD6@5055.35,3808.64 ; U8.E6@5048.01,4564.02 ccw(c5030.29,4564.02) 5042.82,4576.55 ccw(c5055.35,4589.08) U8.E6@5055.35,4571.36 ; v3(5075.04,3993.15) U8.W7@5094.72,4012.83 ; U8.W7@5087.38,4012.83 cw(c5069.66,4012.83) 5082.19,4000.3 cw(c5094.72,3987.77) U8.W7@5094.72,4005.49 ; v3(5114.41,4386.85) U8.K8@5134.09,4367.17 ; U8.K8@5126.75,4367.17 ccw(c5109.03,4367.17) 5121.56,4379.7 ccw(c5134.09,4392.23) U8.K8@5134.09,4374.51 ; v1@5130,3509 5130.5,3509.5 5150,3529 5174.19,3529 5185.81,3540.62 5185.81,3555.38 5173.46,3567.72 5173.46,3625 ; v3(5153.78,3796.3) U8.AD9@5173.46,3815.98 ; v3(5153.78,4583.7) U8.E9@5173.46,4564.02 ; v1@5158,4878.5 cw(c5158,4855.56) 5174.22,4871.78 cw(c5190.43,4888) v1@5167.5,4888 ; v1@5158,4882.5 cw(c5158,4869.22) 5167.39,4878.61 cw(c5176.78,4888) v1@5163.5,4888 ; v1(5158,4888) 5186,4860 5186,4787.3 5173.46,4774.77 U8.A9@5173.46,4721.5 ; U8.AD9@5166.12,3815.98 cw(c5148.4,3815.98) 5160.93,3803.45 cw(c5173.46,3790.92) U8.AD9@5173.46,3808.64 ; U8.E9@5166.12,4564.02 ccw(c5148.4,4564.02) 5160.93,4576.55 ccw(c5173.46,4589.08) U8.E9@5173.46,4571.36 ; U8.AH9@5168.27,3653.31 cw(c5155.74,3640.78) 5173.46,3640.78 ; U8.A9@5168.27,4726.69 ccw(c5155.74,4739.22) 5173.46,4739.22 ccw(c5191.19,4739.22) U8.A9@5178.66,4726.69 ; 5173.46,3630 5173.46,3625 ; U8.AH9@5178.66,3653.31 ccw(c5191.19,3640.78) 5173.46,3640.78 ; v3(5193.15,3875.04) U8.AB10@5212.83,3894.72 ; U8.AB10@5205.49,3894.72 cw(c5187.77,3894.72) 5200.3,3882.19 cw(c5212.83,3869.66) U8.AB10@5212.83,3887.38 ; v3(5232.52,3914.41) U8.AA11@5252.2,3934.09 ; v3(5232.52,4465.59) U8.H11@5252.2,4445.91 ; U8.AA11@5244.86,3934.09 cw(c5227.14,3934.09) 5239.67,3921.56 cw(c5252.2,3909.03) U8.AA11@5252.2,3926.75 ; U8.H11@5244.86,4445.91 ccw(c5227.14,4445.91) 5239.67,4458.44 ccw(c5252.2,4470.97) U8.H11@5252.2,4453.25 ; v3(5311.26,3796.3) U8.AD13@5330.94,3815.98 ; v3(5311.26,4426.22) U8.J13@5330.94,4406.54 ; v3(5311.26,4583.7) U8.E13@5330.94,4564.02 ; U8.AD13@5323.6,3815.98 cw(c5305.88,3815.98) 5318.41,3803.45 cw(c5330.94,3790.92) U8.AD13@5330.95,3808.64 ; U8.J13@5323.6,4406.54 ccw(c5305.88,4406.53) 5318.41,4419.07 ccw(c5330.94,4431.6) U8.J13@5330.95,4413.88 ; U8.E13@5323.6,4564.02 ccw(c5305.88,4564.02) 5318.41,4576.55 ccw(c5330.94,4589.08) U8.E13@5330.95,4571.36 ; U8.AH13@5325.75,3653.31 cw(c5313.22,3640.78) 5330.95,3640.78 cw(c5348.67,3640.78) U8.AH13@5336.14,3653.31 ; U8.A13@5325.75,4726.69 ccw(c5313.22,4739.22) 5330.95,4739.22 ccw(c5348.67,4739.22) U8.A13@5336.14,4726.69 ; v1@5329.95,4825.78 cw(c5313.73,4809.56) 5336.67,4809.56 cw(c5359.6,4809.56) v1@5343.39,4825.78 ; v1@5330.89,3562.98 ccw(c5324.98,3580) 5343,3580 ; U8.AH13@5330.94,3658.5 5330.95,3592.05 5343,3580 v1@5343,3557 ; U8.A13@5330.94,4721.5 5330.95,4788.95 5336.67,4794.67 v1(5336.67,4832.5) ; v1@5332.2,3559.2 ccw(c5326.93,3574.38) 5343,3574.38 ; v1@5332.78,4828.61 cw(c5323.39,4819.22) 5336.67,4819.22 cw(c5349.95,4819.22) v1@5340.56,4828.61 ; v1@5333.51,3555.42 ccw(c5328.88,3568.76) 5343,3568.76 ; v1@5334.82,3551.64 ccw(c5330.83,3563.13) 5343,3563.13 ; v2@5403.06,3551.94 ccw(c5386.31,3568.69) 5410,3568.69 ccw(c5433.69,3568.69) v2@5416.94,3551.94 ; v2@5405.89,3549.11 ccw(c5395.97,3559.03) 5410,3559.03 ccw(c5424.03,3559.03) v2@5414.11,3549.11 ; U8.J15@5409.68,4406.54 v3(5429.37,4426.22) ; U8.J15@5409.69,4413.88 ccw(c5409.69,4431.6) 5422.22,4419.07 ccw(c5434.75,4406.54) U8.J15@5417.03,4406.54 ; v2(5410,3545) 5410,3575.38 5449.05,3614.43 U8.AH16@5449.06,3658.5 ; U8.AH16@5443.86,3653.31 cw(c5431.33,3640.78) 5449.05,3640.78 cw(c5466.78,3640.78) U8.AH16@5454.25,3653.31 ; U8.A16@5443.86,4726.69 ccw(c5431.33,4739.22) 5449.05,4739.22 ccw(c5466.78,4739.22) U8.A16@5454.25,4726.69 ; v2(5444,4788) 5449.05,4782.95 U8.A16@5449.06,4721.5 ; U8.AD16@5449.05,3808.64 cw(c5449.05,3790.92) 5461.59,3803.45 cw(c5474.12,3815.98) U8.AD16@5456.4,3815.98 ; U8.AD16@5449.06,3815.98 v3(5468.74,3796.3) ; U8.Y16@5449.05,3966.12 cw(c5449.05,3948.4) 5461.59,3960.93 cw(c5474.12,3973.46) U8.Y16@5456.4,3973.46 ; U8.Y16@5449.06,3973.46 v3(5468.74,3953.78) ; U8.E16@5449.06,4564.02 v3(5468.74,4583.7) ; U8.E16@5449.05,4571.36 ccw(c5449.05,4589.08) 5461.59,4576.55 ccw(c5474.12,4564.02) U8.E16@5456.4,4564.02 ; U8.AA18@5527.8,3926.75 cw(c5527.8,3909.03) 5540.33,3921.56 cw(c5552.86,3934.09) U8.AA18@5535.14,3934.09 ; U8.AA18@5527.8,3934.09 v3(5547.48,3914.41) ; U8.H18@5527.8,4445.91 v3(5547.48,4465.59) ; U8.H18@5527.8,4453.25 ccw(c5527.8,4470.97) 5540.33,4458.44 ccw(c5552.86,4445.91) U8.H18@5535.14,4445.91 ; v2(5562.63,3452.99) 5563.99,3452.99 5580.19,3469.19 ; v2@5562.99,3458.79 ccw(c5563.88,3472.96) 5573.92,3462.92 ; v2@5563.24,3462.79 ccw(c5564.63,3484.75) 5580.19,3469.19 ; v2@5572.44,3452.99 cw(c5592.83,3452.99) 5578.41,3467.41 ; 5591.38,3486.57 5580.19,3475.38 5580.19,3469.19 ; 5591.57,3486.57 5591.57,3486.67 5603.11,3498.21 5603.11,3595 ; U8.AH20@5601.34,3653.31 cw(c5588.81,3640.78) 5606.54,3640.78 cw(c5624.26,3640.78) U8.AH20@5611.73,3653.31 ; U8.A20@5601.34,4726.69 ccw(c5588.81,4739.22) 5606.54,4739.22 ; 5603.11,3596 5603.11,3595 ; U8.AH20@5606.54,3658.5 5606.54,3620.54 5603.11,3617.11 5603.11,3595 ; U8.AD20@5606.54,3808.64 cw(c5606.54,3790.92) 5619.07,3803.45 cw(c5631.6,3815.98) U8.AD20@5613.88,3815.98 ; U8.AD20@5606.54,3815.98 v3(5626.22,3796.3) ; U8.E20@5606.54,4564.02 v3(5626.22,4583.7) ; U8.E20@5606.54,4571.36 ccw(c5606.54,4589.08) 5619.07,4576.55 ccw(c5631.6,4564.02) U8.E20@5613.88,4564.02 ; U8.A20@5606.54,4721.5 5606.54,4739.22 ; 5606.54,4741.18 5606.54,4739.22 ; U8.A20@5611.73,4726.69 cw(c5624.26,4739.22) 5606.54,4739.22 ; v1@5625.38,4814.32 ccw(c5614.06,4805.88) 5614.06,4820 ; v1@5625.38,4825.68 cw(c5614.06,4834.12) 5614.06,4820 ; v1(5633,4820) 5614.06,4820 ; U8.U21@5645.91,4084.23 cw(c5645.91,4066.51) 5658.44,4079.04 cw(c5670.97,4091.57) U8.U21@5653.25,4091.57 ; U8.U21@5645.91,4091.57 v3(5665.59,4071.89) ; U8.L21@5645.91,4327.8 v3(5665.59,4347.48) ; U8.L21@5645.91,4335.14 ccw(c5645.91,4352.86) 5658.44,4340.33 ccw(c5670.97,4327.8) U8.L21@5653.25,4327.8 ; v1@5717.28,1691.28 cw(c5700.27,1674.27) C158.1@5724.33,1674.27 ; v1@5720.11,1694.11 cw(c5709.92,1683.92) 5724.33,1683.92 ; v1(5724,1698) 5724.33,1697.67 C158.1@5724.33,1670 ; C158.1@5724.33,1675.86 cw(c5746.14,1675.86) v1@5730.72,1691.28 ; 5724.33,1685.52 cw(c5736.48,1685.52) v1@5727.89,1694.11 ; U8.AD23@5724.65,3808.64 cw(c5724.65,3790.92) 5737.18,3803.45 cw(c5749.71,3815.98) U8.AD23@5731.99,3815.98 ; U8.AD23@5724.65,3815.98 v3(5744.33,3796.3) ; U8.E23@5724.65,4564.02 v3(5744.33,4583.7) ; U8.E23@5724.65,4571.36 ccw(c5724.65,4589.08) 5737.18,4576.55 ccw(c5749.71,4564.02) U8.E23@5731.99,4564.02 ; U8.AH24@5758.82,3653.31 cw(c5746.29,3640.78) 5764.02,3640.78 ; U8.A24@5758.82,4726.69 ccw(c5746.29,4739.22) 5764.02,4739.22 ; U8.W24@5764.02,4005.49 cw(c5764.02,3987.77) 5776.55,4000.3 cw(c5789.08,4012.83) U8.W24@5771.36,4012.83 ; U8.W24@5764.02,4012.83 v3(5783.7,3993.15) ; U8.T24@5764.02,4123.6 cw(c5764.02,4105.88) 5776.55,4118.41 cw(c5789.08,4130.94) U8.T24@5771.36,4130.94 ; U8.T24@5764.02,4130.94 v3(5783.7,4111.26) ; U8.N24@5764.02,4249.05 v3(5783.7,4268.74) ; U8.N24@5764.02,4256.4 ccw(c5764.02,4274.12) 5776.55,4261.59 ccw(c5789.08,4249.05) U8.N24@5771.36,4249.05 ; U8.K24@5764.02,4367.17 v3(5783.7,4386.85) ; U8.K24@5764.02,4374.51 ccw(c5764.02,4392.23) 5776.55,4379.7 ccw(c5789.08,4367.17) U8.K24@5771.36,4367.17 ; U8.A24@5764.02,4721.5 5764.02,4739.22 ; 5764.02,4741.18 5764.02,4739.22 ; v2@5769.21,3523.08 ccw(c5753.95,3539) 5776,3539 ccw(c5798.05,3539) v2@5782.79,3523.08 ; U8.AH24@5769.21,3653.31 ccw(c5781.74,3640.78) 5764.02,3640.78 ; U8.A24@5769.21,4726.69 cw(c5781.74,4739.22) 5764.02,4739.22 ; v2@5771.98,3520.19 ccw(c5762.94,3529.62) 5776,3529.62 ccw(c5789.06,3529.62) v2@5780.02,3520.19 ; v2@5772,3519.42 5773.42,3519.42 5774,3520 v2@5776,3518 ; v1@5780.5,4805 cw(c5757.56,4805) 5773.78,4788.78 cw(c5790,4772.56) v1@5790,4795.5 ; v1@5784.5,4805 cw(c5771.22,4805) 5780.61,4795.61 cw(c5790,4786.22) v1@5790,4799.5 ; v1(5790,4805) 5764.02,4779.02 5764.02,4739.22 ; U8.AH27@5876.93,3653.31 cw(c5864.4,3640.78) 5882.13,3640.78 ; U8.A27@5876.93,4726.69 ccw(c5864.4,4739.22) 5882.13,4739.22 ; 5882.13,3643.01 U8.AH27@5882.13,3658.5 ; U8.AH27@5887.32,3653.31 ccw(c5899.85,3640.78) 5882.13,3640.78 ; U8.A27@5887.32,4726.69 cw(c5899.85,4739.22) 5882.13,4739.22 ; v2@5914.56,4728.43 ccw(c5897.81,4745.18) 5921.5,4745.18 ccw(c5945.18,4745.18) v2@5928.43,4728.43 ; v2@5917.39,4725.61 ccw(c5907.47,4735.53) 5921.5,4735.53 ccw(c5935.53,4735.53) v2@5925.61,4725.61 ; U8.AG28@5921.5,3697.87 5939.22,3697.87 ; U8.AA28@5921.5,3934.09 5921.99,3933.6 5998.9,3933.6 6015.31,3917.19 v2@6048.11,3917.19 ; U8.T28@5921.5,4130.94 5967.74,4130.94 5991.15,4107.54 6030.35,4107.54 6048.61,4125.79 ; U8.N28@5921.5,4249.05 5939.22,4249.05 ; U8.H28@5921.5,4445.91 5974.09,4445.91 5988.72,4431.28 6002.5,4417.5 6030.82,4417.5 6038.31,4410.01 6062.01,4410.01 v1(6073,4421) ; U8.B28@5921.5,4682.13 5978.13,4682.13 5992,4696 v2(5992,4724) ; v2(5921.5,4721.5) 5921.5,4751.5 5935,4765 5980,4765 5992,4777 5992,4798 5980,4810 5934.81,4810 5882.13,4757.31 5882.13,4739.22 ; U8.AG28@5926.69,3692.68 cw(c5939.22,3680.15) 5939.22,3697.87 ; U8.AG28@5926.69,3703.07 ccw(c5939.22,3715.6) 5939.22,3697.87 ; U8.AA28@5926.69,3928.9 cw(c5939.22,3916.37) 5939.22,3934.09 cw(c5939.22,3951.82) U8.AA28@5926.69,3939.29 ; U8.T28@5926.69,4125.75 cw(c5939.22,4113.22) 5939.22,4130.94 cw(c5939.22,4148.67) U8.T28@5926.69,4136.14 ; U8.N28@5926.69,4243.86 cw(c5939.22,4231.33) 5939.22,4249.05 ; U8.N28@5926.69,4254.25 ccw(c5939.22,4266.78) 5939.22,4249.05 ; U8.H28@5926.69,4440.71 cw(c5939.22,4428.18) 5939.22,4445.91 cw(c5939.22,4463.63) U8.H28@5926.69,4451.1 ; U8.B28@5926.69,4676.93 cw(c5939.22,4664.4) 5939.22,4682.13 cw(c5939.22,4699.85) U8.B28@5926.69,4687.32 ; 5936.17,3588.97 ccw(c5959.62,3612.42) v2@5965.39,3579.76 ; 5941.18,4249.05 5939.22,4249.05 ; 5941.6,3583.54 ccw(c5961.25,3603.19) v2@5966.09,3575.82 ; 5947.03,3578.11 ccw(c5962.88,3593.96) v2@5966.78,3571.88 ; 5952.46,3572.68 ccw(c5964.51,3584.73) v2@5967.48,3567.94 ; v2@5962.21,3578.61 ccw(c5956.67,3588.26) 5967.8,3588.26 ; v2@5972.96,3577.97 cw(c5980.64,3588.26) 5967.8,3588.26 ; v2@5985.06,4717.06 cw(c5968.31,4700.31) 5992,4700.31 cw(c6015.69,4700.31) v2@5998.94,4717.06 ; v2@5987.89,4719.89 cw(c5977.97,4709.97) 5992,4709.97 cw(c6006.03,4709.97) v2@5996.11,4719.89 ; 6006.44,4217.5 ccw(c6006.44,4245.56) v1@6026.28,4225.72 ; 6013.69,4217.5 cw(c6013.69,4199.69) v1@6026.28,4212.28 ; 6016.1,4217.5 ccw(c6016.1,4235.9) v1@6029.11,4222.89 ; v1(6033,4219) 6031.5,4217.5 5982.75,4217.5 5951.2,4249.05 5939.22,4249.05 ; 6054.15,4125.79 ccw(c6054.15,4135.94) v1@6063.78,4132.74 ; 6058.63,4125.79 cw(c6058.63,4120.63) v1@6062.28,4124.28 ; v1@6059.99,4134 cw(c6048.61,4137.79) 6048.61,4125.79 ; v1(6069,4131) 6063.79,4125.79 6048.61,4125.79 ; v3(6695.04,1550.04) U30.T1@6714.72,1569.72 ; v3@6695.04,1557.54 ccw(c6695.04,1575.65) 6707.84,1562.84 ccw(c6720.65,1550.04) v3@6702.54,1550.04 ; v3@6695.04,2172.46 cw(c6695.04,2154.35) 6707.84,2167.16 cw(c6720.65,2179.96) v3@6702.54,2179.96 ; v3(6695.04,2179.96) U30.A1@6714.72,2160.28 ; v3(6773.78,1707.52) U30.M3@6793.46,1727.2 ; v3(6773.78,1786.26) U30.K3@6793.46,1805.94 ; v3(6773.78,1943.74) U30.G3@6793.46,1924.05 ; v3(6773.78,2022.48) U30.E3@6793.46,2002.8 ; U30.M3@6786.12,1727.2 cw(c6768.4,1727.2) 6780.93,1714.67 cw(c6793.46,1702.14) U30.M3@6793.46,1719.86 ; U30.K3@6786.12,1805.94 cw(c6768.4,1805.94) 6780.93,1793.41 cw(c6793.46,1780.88) U30.K3@6793.46,1798.6 ; U30.G3@6786.12,1924.05 ccw(c6768.4,1924.05) 6780.93,1936.59 ccw(c6793.46,1949.12) U30.G3@6793.46,1931.4 ; U30.E3@6786.12,2002.8 ccw(c6768.4,2002.8) 6780.93,2015.33 ccw(c6793.46,2027.86) U30.E3@6793.46,2010.14 ; v3(6813.15,1628.78) U30.P4@6832.83,1648.46 ; v3(6813.15,2101.22) U30.C4@6832.83,2081.54 ; U30.P4@6825.49,1648.46 cw(c6807.77,1648.46) 6820.3,1635.93 cw(c6832.83,1623.4) U30.P4@6832.83,1641.12 ; U30.C4@6825.49,2081.54 ccw(c6807.77,2081.54) 6820.3,2094.07 ccw(c6832.83,2106.6) U30.C4@6832.83,2088.88 ; v3(6931.26,1628.78) U30.P7@6950.94,1648.46 ; v3(6931.26,2101.22) U30.C7@6950.94,2081.54 ; U30.P7@6943.6,1648.46 cw(c6925.88,1648.46) 6938.41,1635.93 cw(c6950.94,1623.4) U30.P7@6950.94,1641.12 ; U30.C7@6943.6,2081.54 ccw(c6925.88,2081.54) 6938.41,2094.07 ccw(c6950.94,2106.6) U30.C7@6950.94,2088.88 ; U30.P10@7069.06,1641.12 cw(c7069.06,1623.4) 7081.59,1635.93 cw(c7094.12,1648.46) U30.P10@7076.4,1648.46 ; U30.P10@7069.06,1648.46 v3(7088.74,1628.78) ; U30.C10@7069.06,2081.54 v3(7088.74,2101.22) ; U30.C10@7069.06,2088.88 ccw(c7069.06,2106.6) 7081.59,2094.07 ccw(c7094.12,2081.54) U30.C10@7076.4,2081.54 ; U30.H12@7147.8,1884.68 v3(7167.48,1904.37) ; U30.H12@7147.8,1892.03 ccw(c7147.8,1909.75) 7160.33,1897.22 ccw(c7172.86,1884.68) U30.H12@7155.14,1884.68 ; U30.P13@7187.17,1641.12 cw(c7187.17,1623.4) 7199.7,1635.93 cw(c7212.23,1648.46) U30.P13@7194.51,1648.46 ; U30.P13@7187.17,1648.46 v3(7206.85,1628.78) ; U30.C13@7187.17,2081.54 v3(7206.85,2101.22) ; U30.C13@7187.17,2088.88 ccw(c7187.17,2106.6) 7199.7,2094.07 ccw(c7212.23,2081.54) U30.C13@7194.51,2081.54 ; U30.M14@7226.54,1719.86 cw(c7226.54,1702.14) 7239.07,1714.67 cw(c7251.6,1727.2) U30.M14@7233.88,1727.2 ; U30.M14@7226.54,1727.2 v3(7246.22,1707.52) ; U30.K14@7226.54,1798.6 cw(c7226.54,1780.88) 7239.07,1793.41 cw(c7251.6,1805.94) U30.K14@7233.88,1805.94 ; U30.K14@7226.54,1805.94 v3(7246.22,1786.26) ; U30.G14@7226.54,1924.05 v3(7246.22,1943.74) ; U30.G14@7226.54,1931.4 ccw(c7226.54,1949.12) 7239.07,1936.59 ccw(c7251.6,1924.05) U30.G14@7233.88,1924.05 ; U30.E14@7226.54,2002.8 v3(7246.22,2022.48) ; U30.E14@7226.54,2010.14 ccw(c7226.54,2027.86) 7239.07,2015.33 ccw(c7251.6,2002.8) U30.E14@7233.88,2002.8 ; U30.T16@7305.28,1562.22 cw(c7305.28,1544.12) 7318.08,1556.92 cw(c7330.88,1569.72) U30.T16@7312.78,1569.72 ; U30.T16@7305.28,1569.72 v3(7324.96,1550.04) ; U30.A16@7305.28,2160.28 v3(7324.96,2179.96) ; U30.A16@7305.28,2167.78 ccw(c7305.28,2185.88) 7318.08,2173.08 ccw(c7330.88,2160.28) U30.A16@7312.78,2160.28 ; C216.1@7359.28,1363.41 ccw(c7353.93,1372.33) 7364.33,1372.33 ; C216.1@7364.33,1355 7364.33,1372.33 ; C216.1@7369.38,1363.41 cw(c7374.73,1372.33) 7364.33,1372.33 ; v1(7380,1388) 7364.33,1372.33 ; C217.1@7520,1504.86 cw(c7520,1468.79) 7545.51,1494.29 ; C217.1@7520,1508.86 cw(c7520,1482.44) 7538.68,1501.12 ; C217.1@7520,1510.67 7529.13,1510.67 7555.8,1484 v2(7556,1484) ; C217.1@7520,1512.86 cw(c7520,1496.1) 7531.85,1507.95 ; 7538.91,1500.89 ccw(c7556,1517.98) v2@7556,1493.81 ; 7539.39,1500.41 cw(c7522.99,1484) v2@7546.19,1484 ; 7545.74,1494.06 ccw(c7556,1504.32) v2@7556,1489.81 ; 7546.22,1493.58 cw(c7536.64,1484) v2@7550.19,1484 ; 4796,3625 v2(4815,3625) ; 4796,3625 4789.19,3631.81 4789.19,3668.94 4793.75,3673.5 4796.44,3676.19 4804,3676.19 4807,3679.18 4825.69,3697.87 4831.83,3697.87 ; v2(4815,3625) 4827,3613 4839.5,3613 ; 4831.83,3697.87 4840.78,3697.87 ; 4839.5,3613 4840,3613 ; 4839.5,3613 4840,3613 ; 5009.1,4005.95 cw(c4996.3,4018.76) 4996.3,4000.65 ccw(c4996.3,4018.76) 5009.1,4005.95 ; 5009.1,4005.95 ccw(c5021.91,3993.15) 5003.8,3993.15 cw(c5021.91,3993.15) 5009.1,4005.95 ; 5009.1,4124.06 cw(c4996.3,4136.87) 4996.3,4118.76 ccw(c4996.3,4136.87) 5009.1,4124.06 ; 5009.1,4124.06 ccw(c5021.91,4111.26) 5003.8,4111.26 cw(c5021.91,4111.26) 5009.1,4124.06 ; 5009.1,4255.94 cw(c5021.91,4268.74) 5003.8,4268.74 ccw(c5021.91,4268.74) 5009.1,4255.94 ; 5009.1,4255.94 ccw(c4996.3,4243.13) 4996.3,4261.24 cw(c4996.3,4243.13) 5009.1,4255.94 ; 5009.1,4374.05 cw(c5021.91,4386.85) 5003.8,4386.85 ccw(c5021.91,4386.85) 5009.1,4374.05 ; 5009.1,4374.05 ccw(c4996.3,4361.24) 4996.3,4379.35 cw(c4996.3,4361.24) 5009.1,4374.05 ; 5048.47,3809.1 cw(c5035.67,3821.91) 5035.67,3803.8 ccw(c5035.67,3821.91) 5048.47,3809.1 ; 5048.47,3809.1 ccw(c5061.28,3796.3) 5043.17,3796.3 cw(c5061.28,3796.3) 5048.47,3809.1 ; 5048.47,4570.9 cw(c5061.28,4583.7) 5043.17,4583.7 ccw(c5061.28,4583.7) 5048.47,4570.9 ; 5048.47,4570.9 ccw(c5035.67,4558.09) 5035.67,4576.2 cw(c5035.67,4558.09) 5048.47,4570.9 ; 5087.84,4005.95 cw(c5075.04,4018.76) 5075.04,4000.65 ccw(c5075.04,4018.76) 5087.84,4005.95 ; 5087.84,4005.95 ccw(c5100.65,3993.15) 5082.54,3993.15 cw(c5100.65,3993.15) 5087.84,4005.95 ; 5127.21,4374.05 cw(c5140.02,4386.85) 5121.91,4386.85 ccw(c5140.02,4386.85) 5127.21,4374.05 ; 5127.21,4374.05 ccw(c5114.41,4361.24) 5114.41,4379.35 cw(c5114.41,4361.24) 5127.21,4374.05 ; 5166.58,3809.1 cw(c5153.78,3821.91) 5153.78,3803.8 ccw(c5153.78,3821.91) 5166.58,3809.1 ; 5166.58,3809.1 ccw(c5179.39,3796.3) 5161.28,3796.3 cw(c5179.39,3796.3) 5166.58,3809.1 ; 5166.58,4570.9 cw(c5179.39,4583.7) 5161.28,4583.7 ccw(c5179.39,4583.7) 5166.58,4570.9 ; 5166.58,4570.9 ccw(c5153.78,4558.09) 5153.78,4576.2 cw(c5153.78,4558.09) 5166.58,4570.9 ; 5173.46,3625 5173.46,3640.78 ; 5205.95,3887.84 cw(c5193.15,3900.65) 5193.15,3882.54 ccw(c5193.15,3900.65) 5205.95,3887.84 ; 5205.95,3887.84 ccw(c5218.76,3875.04) 5200.65,3875.04 cw(c5218.76,3875.04) 5205.95,3887.84 ; 5245.32,3927.21 cw(c5232.52,3940.02) 5232.52,3921.91 ccw(c5232.52,3940.02) 5245.32,3927.21 ; 5245.32,3927.21 ccw(c5258.13,3914.41) 5240.02,3914.41 cw(c5258.13,3914.41) 5245.32,3927.21 ; 5245.32,4452.79 cw(c5258.13,4465.59) 5240.02,4465.59 ccw(c5258.13,4465.59) 5245.32,4452.79 ; 5245.32,4452.79 ccw(c5232.52,4439.98) 5232.52,4458.09 cw(c5232.52,4439.98) 5245.32,4452.79 ; 5324.06,3809.1 cw(c5311.26,3821.91) 5311.26,3803.8 ccw(c5311.26,3821.91) 5324.06,3809.1 ; 5324.06,3809.1 ccw(c5336.87,3796.3) 5318.76,3796.3 cw(c5336.87,3796.3) 5324.06,3809.1 ; 5324.06,4413.42 cw(c5336.87,4426.22) 5318.76,4426.22 ccw(c5336.87,4426.22) 5324.06,4413.42 ; 5324.06,4413.42 ccw(c5311.26,4400.61) 5311.26,4418.72 cw(c5311.26,4400.61) 5324.06,4413.42 ; 5324.06,4570.9 cw(c5336.87,4583.7) 5318.76,4583.7 ccw(c5336.87,4583.7) 5324.06,4570.9 ; 5324.06,4570.9 ccw(c5311.26,4558.09) 5311.26,4576.2 cw(c5311.26,4558.09) 5324.06,4570.9 ; 5416.57,4413.42 cw(c5429.37,4400.61) 5429.37,4418.72 ccw(c5429.37,4400.61) 5416.57,4413.42 ; 5416.57,4413.42 ccw(c5403.76,4426.22) 5421.87,4426.22 cw(c5403.76,4426.22) 5416.57,4413.42 ; 5455.94,3809.1 cw(c5443.13,3796.3) 5461.24,3796.3 ccw(c5443.13,3796.3) 5455.94,3809.1 ; 5455.94,3809.1 ccw(c5468.74,3821.91) 5468.74,3803.8 cw(c5468.74,3821.91) 5455.94,3809.1 ; 5455.94,3966.58 cw(c5443.13,3953.78) 5461.24,3953.78 ccw(c5443.13,3953.78) 5455.94,3966.58 ; 5455.94,3966.58 ccw(c5468.74,3979.39) 5468.74,3961.28 cw(c5468.74,3979.39) 5455.94,3966.58 ; 5455.94,4570.9 cw(c5468.74,4558.09) 5468.74,4576.2 ccw(c5468.74,4558.09) 5455.94,4570.9 ; 5455.94,4570.9 ccw(c5443.13,4583.7) 5461.24,4583.7 cw(c5443.13,4583.7) 5455.94,4570.9 ; 5534.68,3927.21 cw(c5521.87,3914.41) 5539.98,3914.41 ccw(c5521.87,3914.41) 5534.68,3927.21 ; 5534.68,3927.21 ccw(c5547.48,3940.02) 5547.48,3921.91 cw(c5547.48,3940.02) 5534.68,3927.21 ; 5534.68,4452.79 cw(c5547.48,4439.98) 5547.48,4458.09 ccw(c5547.48,4439.98) 5534.68,4452.79 ; 5534.68,4452.79 ccw(c5521.87,4465.59) 5539.98,4465.59 cw(c5521.87,4465.59) 5534.68,4452.79 ; 5606.54,4739.22 5606.54,4812.47 5614.06,4820 ; 5613.42,3809.1 cw(c5600.61,3796.3) 5618.72,3796.3 ccw(c5600.61,3796.3) 5613.42,3809.1 ; 5613.42,3809.1 ccw(c5626.22,3821.91) 5626.22,3803.8 cw(c5626.22,3821.91) 5613.42,3809.1 ; 5613.42,4570.9 cw(c5626.22,4558.09) 5626.22,4576.2 ccw(c5626.22,4558.09) 5613.42,4570.9 ; 5613.42,4570.9 ccw(c5600.61,4583.7) 5618.72,4583.7 cw(c5600.61,4583.7) 5613.42,4570.9 ; 5652.79,4084.69 cw(c5639.98,4071.89) 5658.09,4071.89 ccw(c5639.98,4071.89) 5652.79,4084.69 ; 5652.79,4084.69 ccw(c5665.59,4097.5) 5665.59,4079.39 cw(c5665.59,4097.5) 5652.79,4084.69 ; 5652.79,4334.68 cw(c5665.59,4321.87) 5665.59,4339.98 ccw(c5665.59,4321.87) 5652.79,4334.68 ; 5652.79,4334.68 ccw(c5639.98,4347.48) 5658.09,4347.48 cw(c5639.98,4347.48) 5652.79,4334.68 ; 5731.53,3809.1 cw(c5718.72,3796.3) 5736.83,3796.3 ccw(c5718.72,3796.3) 5731.53,3809.1 ; 5731.53,3809.1 ccw(c5744.33,3821.91) 5744.33,3803.8 cw(c5744.33,3821.91) 5731.53,3809.1 ; 5731.53,4570.9 cw(c5744.33,4558.09) 5744.33,4576.2 ccw(c5744.33,4558.09) 5731.53,4570.9 ; 5731.53,4570.9 ccw(c5718.72,4583.7) 5736.83,4583.7 cw(c5718.72,4583.7) 5731.53,4570.9 ; 5764.02,3640.78 5764.02,3626.02 5760.5,3622.5 5760.5,3577.06 5763.9,3573.66 5763.9,3551.1 5776,3539 v2@5776,3518 ; 5770.9,4005.95 cw(c5758.09,3993.15) 5776.2,3993.15 ccw(c5758.09,3993.15) 5770.9,4005.95 ; 5770.9,4005.95 ccw(c5783.7,4018.76) 5783.7,4000.65 cw(c5783.7,4018.76) 5770.9,4005.95 ; 5770.9,4124.06 cw(c5758.09,4111.26) 5776.2,4111.26 ccw(c5758.09,4111.26) 5770.9,4124.06 ; 5770.9,4124.06 ccw(c5783.7,4136.87) 5783.7,4118.76 cw(c5783.7,4136.87) 5770.9,4124.06 ; 5770.9,4255.94 cw(c5783.7,4243.13) 5783.7,4261.24 ccw(c5783.7,4243.13) 5770.9,4255.94 ; 5770.9,4255.94 ccw(c5758.09,4268.74) 5776.2,4268.74 cw(c5758.09,4268.74) 5770.9,4255.94 ; 5770.9,4374.05 cw(c5783.7,4361.24) 5783.7,4379.35 ccw(c5783.7,4361.24) 5770.9,4374.05 ; 5770.9,4374.05 ccw(c5758.09,4386.85) 5776.2,4386.85 cw(c5758.09,4386.85) 5770.9,4374.05 ; v2@5776,3518 v2(5776,3516) v2@5776,3518 ; 5882.13,3640.78 5882.13,3619.19 5906.31,3595 5930.14,3595 5955.04,3570.1 v2(5967.1,3570.1) 5967.8,3570.8 5967.8,3588.26 ; 5939.22,3697.87 5941.18,3697.87 5953.18,3697.87 5961.12,3689.94 5961.12,3594.94 5967.8,3588.26 ; 6786.58,1720.32 cw(c6773.78,1733.13) 6773.78,1715.02 ccw(c6773.78,1733.13) 6786.58,1720.32 ; 6786.58,1720.32 ccw(c6799.39,1707.52) 6781.28,1707.52 cw(c6799.39,1707.52) 6786.58,1720.32 ; 6786.58,1799.06 cw(c6773.78,1811.87) 6773.78,1793.76 ccw(c6773.78,1811.87) 6786.58,1799.06 ; 6786.58,1799.06 ccw(c6799.39,1786.26) 6781.28,1786.26 cw(c6799.39,1786.26) 6786.58,1799.06 ; 6786.58,1930.94 cw(c6799.39,1943.74) 6781.28,1943.74 ccw(c6799.39,1943.74) 6786.58,1930.94 ; 6786.58,1930.94 ccw(c6773.78,1918.13) 6773.78,1936.24 cw(c6773.78,1918.13) 6786.58,1930.94 ; 6786.58,2009.68 cw(c6799.39,2022.48) 6781.28,2022.48 ccw(c6799.39,2022.48) 6786.58,2009.68 ; 6786.58,2009.68 ccw(c6773.78,1996.87) 6773.78,2014.98 cw(c6773.78,1996.87) 6786.58,2009.68 ; 6825.95,1641.58 cw(c6813.15,1654.39) 6813.15,1636.28 ccw(c6813.15,1654.39) 6825.95,1641.58 ; 6825.95,1641.58 ccw(c6838.76,1628.78) 6820.65,1628.78 cw(c6838.76,1628.78) 6825.95,1641.58 ; 6825.95,2088.42 cw(c6838.76,2101.22) 6820.65,2101.22 ccw(c6838.76,2101.22) 6825.95,2088.42 ; 6825.95,2088.42 ccw(c6813.15,2075.61) 6813.15,2093.72 cw(c6813.15,2075.61) 6825.95,2088.42 ; 6944.06,1641.58 cw(c6931.26,1654.39) 6931.26,1636.28 ccw(c6931.26,1654.39) 6944.06,1641.58 ; 6944.06,1641.58 ccw(c6956.87,1628.78) 6938.76,1628.78 cw(c6956.87,1628.78) 6944.06,1641.58 ; 6944.06,2088.42 cw(c6956.87,2101.22) 6938.76,2101.22 ccw(c6956.87,2101.22) 6944.06,2088.42 ; 6944.06,2088.42 ccw(c6931.26,2075.61) 6931.26,2093.72 cw(c6931.26,2075.61) 6944.06,2088.42 ; 7075.94,1641.58 cw(c7063.13,1628.78) 7081.24,1628.78 ccw(c7063.13,1628.78) 7075.94,1641.58 ; 7075.94,1641.58 ccw(c7088.74,1654.39) 7088.74,1636.28 cw(c7088.74,1654.39) 7075.94,1641.58 ; 7075.94,2088.42 cw(c7088.74,2075.61) 7088.74,2093.72 ccw(c7088.74,2075.61) 7075.94,2088.42 ; 7075.94,2088.42 ccw(c7063.13,2101.22) 7081.24,2101.22 cw(c7063.13,2101.22) 7075.94,2088.42 ; 7154.68,1891.57 cw(c7167.48,1878.76) 7167.48,1896.87 ccw(c7167.48,1878.76) 7154.68,1891.57 ; 7154.68,1891.57 ccw(c7141.87,1904.37) 7159.98,1904.37 cw(c7141.87,1904.37) 7154.68,1891.57 ; 7194.05,1641.58 cw(c7181.24,1628.78) 7199.35,1628.78 ccw(c7181.24,1628.78) 7194.05,1641.58 ; 7194.05,1641.58 ccw(c7206.85,1654.39) 7206.85,1636.28 cw(c7206.85,1654.39) 7194.05,1641.58 ; 7194.05,2088.42 cw(c7206.85,2075.61) 7206.85,2093.72 ccw(c7206.85,2075.61) 7194.05,2088.42 ; 7194.05,2088.42 ccw(c7181.24,2101.22) 7199.35,2101.22 cw(c7181.24,2101.22) 7194.05,2088.42 ; 7233.42,1720.32 cw(c7220.61,1707.52) 7238.72,1707.52 ccw(c7220.61,1707.52) 7233.42,1720.32 ; 7233.42,1720.32 ccw(c7246.22,1733.13) 7246.22,1715.02 cw(c7246.22,1733.13) 7233.42,1720.32 ; 7233.42,1799.06 cw(c7220.61,1786.26) 7238.72,1786.26 ccw(c7220.61,1786.26) 7233.42,1799.06 ; 7233.42,1799.06 ccw(c7246.22,1811.87) 7246.22,1793.76 cw(c7246.22,1811.87) 7233.42,1799.06 ; 7233.42,1930.94 cw(c7246.22,1918.13) 7246.22,1936.24 ccw(c7246.22,1918.13) 7233.42,1930.94 ; 7233.42,1930.94 ccw(c7220.61,1943.74) 7238.72,1943.74 cw(c7220.61,1943.74) 7233.42,1930.94 ; 7233.42,2009.68 cw(c7246.22,1996.87) 7246.22,2014.98 ccw(c7246.22,1996.87) 7233.42,2009.68 ; 7233.42,2009.68 ccw(c7220.61,2022.48) 7238.72,2022.48 cw(c7220.61,2022.48) 7233.42,2009.68 ; 7312.16,1562.84 cw(c7299.35,1550.04) 7317.46,1550.04 ccw(c7299.35,1550.04) 7312.16,1562.84 ; 7312.16,1562.84 ccw(c7324.96,1575.65) 7324.96,1557.54 cw(c7324.96,1575.65) 7312.16,1562.84 ; 7312.16,2167.16 cw(c7324.96,2154.35) 7324.96,2172.46 ccw(c7324.96,2154.35) 7312.16,2167.16 ; 7312.16,2167.16 ccw(c7299.35,2179.96) 7317.46,2179.96 cw(c7299.35,2179.96) 7312.16,2167.16
  Top Layer w8: v2@5414,2747 ccw(c5421.19,2754.18) v2@5425.6,2745.03 ; v2(5416,2750) 5411,2750 5423,2738 v2(5429,2738) ; v5(7731.89,4445.63) U7.G5@7751.58,4465.32 ; v5@7731.89,4454.63 ccw(c7731.89,4476.36) 7747.25,4460.99 ccw(c7762.62,4445.63) v5@7740.89,4445.63 ; v5(7771.26,4366.89) U7.F7@7790.95,4386.57 ; v5@7771.26,4375.89 ccw(c7771.26,4397.62) 7786.62,4382.25 ccw(c7801.99,4366.89) v5@7780.26,4366.89 ; v5@7771.26,4633.48 cw(c7771.26,4611.75) 7786.62,4627.12 cw(c7801.99,4642.48) v5@7780.26,4642.48 ; v5(7771.26,4642.48) U7.F1@7790.95,4622.8 ; U7.D8@7869.69,4347.2 v5(7889.37,4327.52) ; v5@7880.37,4327.52 ccw(c7858.64,4327.52) 7874.01,4342.88 ccw(c7889.37,4358.25) v5@7889.37,4336.52
  Top Layer w10: NT37.2@5845,2980 5858,2980 5868,2970 v1(5876,2970) ; 5862,2976 ccw(c5867.52,2981.52) v1@5872.15,2975.23