# Altium PCB NB3000AL.PcbDoc (part 3 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment) (continued)
R182 "150R 1%" RESC1005-STAR#1 4400,3540 r0 bottom locked (schematic designator R1)
R183 "150R 1%" RESC1005-STAR#1 4400,3426.25 r0 bottom locked (schematic designator R2)
R184 "150R 1%" RESC1005-STAR#1 4400,3483.12 r0 bottom locked (schematic designator R3)
R185 "150R 1%" RESC1005-STAR#1 4635,3198.75 r0 bottom locked (schematic designator R4)
R186 "150R 1%" RESC1005-STAR#1 4635,3085 r0 bottom locked (schematic designator R5)
R187 "150R 1%" RESC1005-STAR#1 4635,3141.88 r0 bottom locked (schematic designator R6)
R188 "150R 1%" RESC1005-STAR#1 4635,3369.38 r0 bottom locked (schematic designator R1)
R189 "150R 1%" RESC1005-STAR#1 4635,3255.62 r0 bottom locked (schematic designator R2)
R190 "150R 1%" RESC1005-STAR#1 4635,3312.5 r0 bottom locked (schematic designator R3)
R191 "150R 1%" RESC1005-STAR#1 4635,3540 r0 bottom locked (schematic designator R4)
R192 "150R 1%" RESC1005-STAR#1 4635,3426.25 r0 bottom locked (schematic designator R5)
R193 "150R 1%" RESC1005-STAR#1 4635,3483.12 r0 bottom locked (schematic designator R6)
R194 "220R 1%" RESC1005-STAR#1 2995,6205 r0 bottom locked (schematic designator R2)
R195 "270R 1%" RESC1005-STAR#1 3737.5,6155 r0 bottom locked (schematic designator R1)
R196 "5R6 1%" RESC1005-STAR#1 3595,6155 r180 bottom locked (schematic designator R3)
R197 "220R 1%" RESC1005-STAR#1 3880,6155 r0 bottom (schematic designator R5)
R198 "220R 1%" RESC1005-STAR#1 3880,6010 r0 bottom
R199 "220R 1%" RESC1005-STAR#1 4880,6160 r0 bottom locked (schematic designator R7)
R200 "220R 1%" RESC1005-STAR#1 4515,5900 r0 bottom
R201 "120R 1%" RESC1005-STAR#1 2890,1625 r180 bottom locked (schematic designator R1)
R202 "56R 1%" RESC1005-STAR#2 3025,1625 r0 bottom locked (schematic designator R2)
R203 "120R 1%" RESC1005-STAR#1 1805,1625 r180 bottom locked (schematic designator R1)
R204 "120R 1%" RESC1005-STAR#2 1940,1625 r0 bottom locked (schematic designator R2)
R205 "120R 1%" RESC1005-STAR#1 720,1625 r180 bottom locked (schematic designator R1)
R206 "200R 1%" RESC1005-STAR#2 855,1625 r0 bottom locked (schematic designator R2)
R207 "0R 5%" RESC1005-STAR#1 3325,1635 r180 bottom locked (schematic designator R1)
R208 "10K 1%" RESC1005-STAR#2 3460,1635 r0 bottom locked (schematic designator R2)
R209 "100R 1%" RESC1005-STAR#1 517.11,5565.08 r0 bottom locked (schematic designator R1)
R210 "100R 1%" RESC1005-STAR#1 517.11,5420.08 r0 bottom locked (schematic designator R2)
R211 "100R 1%" RESC1005-STAR#1 1840,5670 r180 bottom locked (schematic designator R1)
R212 "120R 1%" RESC1005-STAR#1 1430,5500 r90 bottom locked (schematic designator R2)
R213 "5R6 1%" RESC1005-STAR#1 7999.06,3945 r180 bottom
R214 "120R 1%" RESC1005-STAR#1 6810,2615 r180 top locked
R215 "47K 1%" RESC1005-STAR#1 6810,2685 r0 top locked (schematic designator R2)
R216 "4K7 1%" RESC1005-STAR#1 3250,3030 r0 bottom locked (schematic designator R1)
R217 "4K7 1%" RESC1005-STAR#1 3250,2957.5 r0 bottom locked (schematic designator R2)
R218 "4K7 1%" RESC1005-STAR#1 3250,2740 r0 bottom locked (schematic designator R3)
R219 "4K7 1%" RESC1005-STAR#1 3250,2885 r0 bottom locked (schematic designator R4)
R220 "100R 1%" RESC1005-STAR#1 3125,3030 r180 bottom locked (schematic designator R5)
R221 "100R 1%" RESC1005-STAR#1 3125,2957.5 r180 bottom locked (schematic designator R6)
R222 "100R 1%" RESC1005-STAR#1 3125,2740 r180 bottom locked (schematic designator R7)
R223 "100R 1%" RESC1005-STAR#1 3125,2885 r180 bottom locked (schematic designator R8)
R224 "4K7 1%" RESC1005-STAR#1 3250,2812.5 r0 bottom locked (schematic designator R9)
R225 "4K7 1%" RESC1005-STAR#1 3250,2667.5 r0 bottom locked (schematic designator R10)
R226 "4K7 1%" RESC1005-STAR#1 3250,2522.5 r180 bottom locked (schematic designator R11)
R227 "4K7 1%" RESC1005-STAR#1 3250,2595 r0 bottom locked (schematic designator R12)
R228 "100R 1%" RESC1005-STAR#1 3125,2812.5 r180 bottom locked (schematic designator R13)
R229 "100R 1%" RESC1005-STAR#1 3125,2667.5 r180 bottom locked (schematic designator R14)
R230 "100R 1%" RESC1005-STAR#1 3125,2522.5 r180 bottom locked (schematic designator R15)
R231 "100R 1%" RESC1005-STAR#1 3125,2595 r180 bottom locked (schematic designator R16)
R232 "4K7 1%" RESC1005-STAR#1 3250,2450 r0 bottom locked (schematic designator R17)
R233 "100R 1%" RESC1005-STAR#1 3125,2450 r180 bottom locked (schematic designator R18)
R234 "2K2 1%" RESC1005-STAR#1 1165,3160 r180 top locked (schematic designator R1)
R235 "2K2 1%" RESC1005-STAR#1 7530,3474.85 r270 top locked (schematic designator R275)
R236 "4K7 1%" RESC1005-STAR#1 5040,2719.09 r180 bottom (schematic designator R8)
R237 "4K7 1%" RESC1005-STAR#1 5040,2663.18 r180 bottom locked (schematic designator R7)
R238 "4K7 1%" RESC1005-STAR#1 5040,2607.27 r180 bottom locked (schematic designator R6)
R239 "4K7 1%" RESC1005-STAR#1 5040,2551.36 r180 bottom locked (schematic designator R5)
R240 "4K7 1%" RESC1005-STAR#1 5040,2495.45 r180 bottom (schematic designator R4)
R241 "4K7 1%" RESC1005-STAR#1 5040,2439.55 r180 bottom locked (schematic designator R3)
R242 "4K7 1%" RESC1005-STAR#1 5040,2383.64 r180 bottom locked (schematic designator R2)
R243 "4K7 1%" RESC1005-STAR#1 5040,2327.73 r180 bottom locked (schematic designator R1)
R244 "27R 1%" RESC1005-STAR#1 6280,5915 r180 bottom locked (schematic designator R1)
R245 "2K7 1%" RESC1005-STAR#1 7080,5805 r180 bottom locked (schematic designator R2)
R246 "5K6 1%" RESC1005-STAR#2 7080,5852.5 r180 bottom locked (schematic designator R3)
R247 "10K 1%" RESC1005-STAR#1 6775,6440 r180 bottom locked (schematic designator R4)
R248 "4K7 1%" RESC1005-STAR#1 7692.5,1440 r180 bottom locked (schematic designator R1000)
R249 "27R 1%" RESC1005-STAR#1 6775,6360 r180 bottom locked (schematic designator R6)
R250 "4K7 1%" RESC1005-STAR#1 7005,6250 r180 bottom locked (schematic designator R9)
R251 "4K7 1%" RESC1005-STAR#1 7005,6130 r180 bottom locked (schematic designator R8)
R252 "4K7 1%" RESC1005-STAR#1 7005,6190 r0 bottom locked (schematic designator R7)
R253 "4K7 1%" RESC1005-STAR#1 6665,1240 r180 bottom locked (schematic designator R1)
R254 "4K7 1%" RESC1005-STAR#1 6105,1240 r180 bottom locked (schematic designator R2)
R255 "4K7 1%" RESC1005-STAR#1 6385,1240 r0 bottom locked (schematic designator R1)
R256 "4K7 1%" RESC1005-STAR#1 6945,1240 r0 bottom (schematic designator R2)
R257 "12K 1%" RESC1005-STAR#2 5937.51,2085 r0 top locked (schematic designator R1)
R258 "12K 1%" RESC1005-STAR#2 6126.25,2085 r0 top locked (schematic designator R2)
R259 "12K 1%" RESC1005-STAR#2 6315,2085 r0 top locked (schematic designator R3)
R260 "10K 1%" RESC1005-STAR#1 5040,2775 r180 bottom locked (schematic designator R4)
R261 "150R 1%" RESC1005-STAR#1 5040,2271.82 r180 bottom locked (schematic designator R5)
R262 "150R 1%" RESC1005-STAR#1 5040,2215.91 r180 bottom locked (schematic designator R6)
R263 "150R 1%" RESC1005-STAR#1 5040,2160 r180 bottom locked (schematic designator R7)
R264 "330R 1%" RESC1005-STAR#1 6810,2475 r0 top locked (schematic designator R269)
R265 "2K2 1%" RESC1005-STAR#1 6950,2475 r0 top locked (schematic designator R270)
R266 "1K 1%" RESC1005-STAR#2 7090,2475 r0 top locked (schematic designator R271)
R267 "100R 1%" RESC1005-STAR#1 7926.99,5997 r0 top locked (schematic designator R154)
R268 "100R 1%" RESC1005-STAR#1 7695,5997 r0 top locked (schematic designator R155)
R269 "100R 1%" RESC1005-STAR#1 7926.99,5846 r0 top locked (schematic designator R156)
R270 "100R 1%" RESC1005-STAR#1 7695,5846 r0 top locked (schematic designator R157)
R271 "4K7 1%" RESC1005-STAR#1 6090,5495 r180 bottom locked (schematic designator R1000)
R272 "10K 1%" RESC1005-STAR#1 5445,2482.51 r90 top locked (schematic designator R268)
R273 "10K 1%" RESC1005-STAR#1 5445,2615 r90 top locked (schematic designator R264)
R274 "10K 1%" RESC1005-STAR#1 5225,935 r270 bottom locked (schematic designator R265)
R275 "10K 1%" RESC1005-STAR#1 5475,935 r90 bottom locked (schematic designator R266)
R276 "10K 1%" RESC1005-STAR#1 5725,935 r270 bottom locked (schematic designator R267)
R277 "4K7 1%" RESC1005-STAR#1 1785.16,3160.02 r180 top locked
R278 "4K7 1%" RESC1005-STAR#1 1985.52,3160.03 r180 top locked
R279 "4K7 1%" RESC1005-STAR#1 7926.99,5946.67 r0 top locked
R280 "4K7 1%" RESC1005-STAR#1 7695,5946.67 r0 top locked
R281 "4K7 1%" RESC1005-STAR#1 7926.99,5896.33 r0 top locked
R282 "4K7 1%" RESC1005-STAR#1 7695,5896.33 r0 top locked
R283 "4K7 1%" RESC1005-STAR#1 1076.56,3160 r180 top locked
R284 "4K7 1%" RESC1005-STAR#1 5885,1905 r180 bottom
R285 "4K7 1%" RESC1005-STAR#1 5885,2285 r180 bottom
R286 "4K7 1%" RESC1005-STAR#1 4400,3028.12 r0 bottom
R287 "4K7 1%" RESC1005-STAR#1 4298.52,2439.55 r0 bottom (schematic designator R284)
R288 "4K7 1%" RESC1005-STAR#1 5885,2135 r0 bottom (schematic designator R285)
R289 "4K7 1%" RESC1005-STAR#1 4540.98,2085 r0 bottom (schematic designator R286)
R290 "4K7 1%" RESC1005-STAR#1 7085,3845 r180 bottom (schematic designator R284)
R291 "4K7 1%" RESC1005-STAR#1 7370,3205 r0 bottom (schematic designator R285)
R292 "4K7 1%" RESC1005-STAR#1 7085,3226.88 r180 bottom (schematic designator R286)
R293 "4K7 1%" RESC1005-STAR#1 7085,3078.75 r180 bottom (schematic designator R284)
R294 "4K7 1%" RESC1005-STAR#1 7370,3095 r180 bottom (schematic designator R285)
R295 "4K7 1%" RESC1005-STAR#1 7085,3177.5 r180 bottom (schematic designator R286)
R296 "4K7 1%" RESC1005-STAR#1 7085,3128.12 r180 bottom (schematic designator R284)
R297 "4K7 1%" RESC1005-STAR#1 7085,3029.38 r180 bottom (schematic designator R285)
R298 "4K7 1%" RESC1005-STAR#1 7085,2980 r180 bottom (schematic designator R286)
R299 "4K7 1%" RESC1005-STAR#1 7085,3325.62 r180 bottom (schematic designator R284)
R300 "4K7 1%" RESC1005-STAR#1 7085,3375 r180 bottom (schematic designator R285)
R301 "4K7 1%" RESC1005-STAR#1 7085,3276.25 r180 bottom (schematic designator R286)
R302 "4K7 1%" RESC1005-STAR#1 5526.06,3075 r180 bottom (schematic designator R284)
R303 "4K7 1%" RESC1005-STAR#1 4298.52,2663.18 r0 bottom (schematic designator R285)
R304 "4K7 1%" RESC1005-STAR#1 4298.52,2495.45 r0 bottom (schematic designator R286)
R305 "4K7 1%" RESC1005-STAR#1 4298.52,2607.27 r0 bottom (schematic designator R284)
R306 "4K7 1%" RESC1005-STAR#1 4298.52,2719.09 r0 bottom (schematic designator R285)
R307 "4K7 1%" RESC1005-STAR#1 4298.52,2551.36 r0 bottom (schematic designator R286)
R308 "4K7 1%" RESC1005-STAR#1 3925,3990 r0 bottom (schematic designator R284)
R309 "4K7 1%" RESC1005-STAR#1 4155,3990 r0 bottom (schematic designator R285)
R310 "4K7 1%" RESC1005-STAR#1 4155,3900 r180 bottom (schematic designator R286)
R311 "4K7 1%" RESC1005-STAR#1 3925,4170 r0 bottom (schematic designator R284)
R312 "4K7 1%" RESC1005-STAR#1 3925,3900 r0 bottom (schematic designator R285)
R313 "4K7 1%" RESC1005-STAR#1 3925,4260 r0 bottom (schematic designator R286)
R314 "5R6 1%" RESC1005-STAR#1 7999.06,4055 r0 bottom
RLY1 "IMO3 - 5VDC" IM03GR 4955,5245 r270 top locked
RLY2 "IMO3 - 5VDC" IM03GR 5530,5245 r270 top locked (schematic designator RLY1)
RLY3 "IMO3 - 5VDC" IM03GR 6130,5245 r270 top locked (schematic designator RLY1)
RLY4 "IMO3 - 5VDC" IM03GR 6710,5245 r270 top locked (schematic designator RLY1)
SW1 "SPNO" SW_DTSM-61NT/R#1 5485,985.39 r0 top locked
SW2 "SPNO" SW_DTSM-61NT/R#1 5962.5,985.39 r0 top locked
SW3 "SPNO" SW_DTSM-61NT/R#1 6440,985.39 r0 top locked
SW4 "SPNO" SW_DTSM-61NT/R#1 6917.5,985 r0 top locked
SW5 "SPNO" SW_DTSM-61NT/R#1 7395,985 r0 top locked
SW6 "SPNO" SW_DTSM-61NT/R#2 5485,255 r180 top locked (schematic designator SW1)
SW7 "SPDT SUB" T8019L-TNQ 7422,6920 r0 bottom locked (schematic designator SW1)
SW8 "219-8LPST" 219-8LPST 7140,245 r90 top locked (schematic designator SW1)
T1 "PT4812" PT4812 4668,1466 r0 bottom locked
TP1 "GND" TESTPIN#1 76.12,4108.23 r180 top locked
TP2 "5V0" TESTPIN#2 76.12,4008.23 r180 top locked
TP3 "+B" TESTPIN#2 3576.12,3908.23 r0 top locked
TP4 "3V3" TESTPIN#2 76.12,3908.23 r180 top locked
TP5 "2V5" TESTPIN#2 76.12,3808.23 r180 top locked
TP6 "1V8" TESTPIN#2 76.12,3708.23 r180 top locked
TP7 "1V2" TESTPIN#2 76.12,3608.23 r180 top locked
TP8 "GND" TESTPIN#1 3576.12,4008.23 r0 top locked
TP9 "MIXER LEFT" TESTPIN#2 76.12,3508.23 r180 top locked (schematic designator TP1)
TP10 "MIXER RIGHT" TESTPIN#2 76.12,3408.23 r180 top locked (schematic designator TP2)
TP11 "32K768HZ" TESTPIN#2 3576.12,4108.23 r0 top locked (schematic designator TP1)
TP12 "VBATT" TESTPIN#2 3576.12,3408.23 r0 top locked (schematic designator TP15)
U1 "CS4270" TSSOP-24 -320,2835 r270 top locked
U2 "ICS307-02" SOIC127P600-16#1 7986.38,3756.34 r270 top locked (schematic designator U1)
U3 "74HCU04" TSSOP14#1 4295,1200 r180 bottom locked (schematic designator U1)
U4 "SN74LVC1G04DBV" SOT95P280-5 7930,2400 r180 bottom locked (schematic designator U1)
U5 "RTL8201CL" TSQFP50P900X900-48 2360.87,5490 r90 bottom locked (schematic designator U1)
U6 "SN74LVC244ADB" SOP65P780-20 3470,5585 r270 bottom locked (schematic designator U2)
U7 "S29GL128P11FFI010" BGA100P8X8-64 7850,4485 r180 top locked (schematic designator U1)
U8 "EP3C40F780C8N" FBGA780-2 5390,4190 r0 top locked
U9 "SMF05C" SC70_6L#1 3725,5436.18 r270 top locked (schematic designator U2)
U10 "SMF05C" SC70_6L#1 3725,5300 r270 top locked (schematic designator U2)
U11 "SMF05C" SC70_6L#1 3880,5300 r270 top locked (schematic designator U2)
U12 "SDRAM-16Mx16" TSOP80P1176-54 7070,3765 r270 top locked (schematic designator U1)
U13 "SDRAM-16Mx16" TSOP80P1176-54 6395,3765 r270 top locked (schematic designator U2)
U14 "SRAM-256Kx16" TSOP80P1176-44 6395,4640 r270 bottom locked (schematic designator U1_SM)
U15 "SRAM-256Kx16" TSOP80P1176-44 7070,4640 r270 bottom locked (schematic designator U1_SM)
U16 "SRAM-256Kx16" TSOP80P1176-44 7070,4640 r270 top locked (schematic designator U1)
U17 "SRAM-256Kx16" TSOP80P1176-44 6395,4640 r270 top locked (schematic designator U2)
U18 "NUP2201MR6T1G" TSOP95P275-6 7400,495 r90 bottom locked (schematic designator U2)
U19 "CY7C68001-56LFC" QFN50P800X800_HS-57 7420,750 r180 bottom locked (schematic designator U3)
U20 "SMF05C" SC70_6L#1 5792.17,6170 r270 bottom locked (schematic designator U1)
U21 "THS8134BCPHP" TSQFP50P900X900_HS-48 5145,5570 r180 bottom locked (schematic designator U1)
U22 "SMF05C" SC70_6L#1 3880,5436.18 r270 top locked (schematic designator U2)
U23 "DS2502P" DSO-C6-D4 8099,2498.01 r180 top locked (schematic designator U1)
U24 "ADC084S021" TSSOP50P490-10AN 1905,5345 r180 top locked (schematic designator U1)
U25 "SMF05C" SC70_6L#2 2235,5370 r270 top locked (schematic designator U2)
U26 "PT2300-S" SOIC127P1030-16N -210,5025 r0 top locked (schematic designator U1)
U27 "PCF2123TS" TSOP65P640-14AN 3705,4310 r0 top locked (schematic designator U5)
U28 "DAC084S085CIMM" TSSOP50P490-10AN 590,5360 r0 top locked (schematic designator U1)
U29 "SMF05C" SC70_6L#2 795,5380 r270 top locked (schematic designator U2)
U30 "EP3C10F256C8" FBGA256-2 7010,1865 r0 top locked
U31 "74VHC04" TSSOP14#2 3920,3475 r0 top locked (schematic designator U1)
U32 "74VHC04" TSSOP14#2 3920,4020 r0 top locked (schematic designator U1)
U33 "74VHC04" TSSOP14#2 5125,3165 r0 top locked (schematic designator U1)
U34 "74VHC04" TSSOP14#2 6820,3170 r0 top locked (schematic designator U1)
U35 "74VHC04" TSSOP14#2 7130,3170 r0 top locked (schematic designator U1)
U36 "PC900V0NSZXF" H11L1SR2VM 3305,6095 r90 bottom locked (schematic designator U1)
U37 "SN74LVC1G04DBV" SOT95P280-5 3670,6020 r90 bottom locked (schematic designator U2)
U38 "SN74LVC1G04DBV" SOT95P280-5 4285.84,6100 r0 bottom locked (schematic designator U3)
U39 "AP1084KL" TO254P-3N 2580,1775 r90 bottom locked (schematic designator U1)
U40 "AP1084KL" TO254P-3N 1495,1775 r90 bottom locked (schematic designator U1)
U41 "AP1084KL" TO254P-3N 410,1775 r90 bottom locked (schematic designator U1)
U42 "NCP630A" TO-263-2 3770,1525 r180 bottom locked (schematic designator U1)
U43 "TC1017R-3.3VLTTR" SOT65P210X80-5N 4540,2500 r270 bottom locked (schematic designator U1)
U44 "TC1017R-3.3VLTTR" SOT65P210X80-5N 560,2568.37 r270 bottom locked (schematic designator U1)
U45 "MAX6315US26D1" SOT143 -165.45,2020 r180 bottom locked (schematic designator U2000)
U46 "ISL8491IB" SOIC127P600-14N 1637.05,5570.08 r180 bottom locked (schematic designator U1)
U47 "SRAM-256Kx16" TSOP80P1176-44 7780,3035 r270 top locked (schematic designator U1_SM)
U48 "XPT2046" TSOP65P640-16AN 6610,3080 r0 top locked (schematic designator U1)
U49 "MAX6315US26D1" SOT143 7689.55,1550 r180 bottom locked (schematic designator U1000)
U50 "M25P32-VMW6TG 32Mbit Serial Flash" SOIC8-200-BODY 5655,1920 r270 top locked (schematic designator U1)
U51 "M25P32-VMW6TG 32Mbit Serial Flash" SOIC8-200-BODY 6130,1580 r270 top locked (schematic designator U1)
U52 "M25P32-VMW6TG 32Mbit Serial Flash" SOIC8-200-BODY 6130,1920 r270 top locked (schematic designator U1)
U53 "M25P32-VMW6TG 32Mbit Serial Flash" SOIC8-200-BODY 5655,1580 r270 top locked (schematic designator U2)
U54 "SN74LVC1G04DBV" SOT95P280-5 6165,6045 r0 bottom locked (schematic designator U1)
U55 "NUP2201MR6T1G" TSOP95P275-6 6610,6425 r270 bottom locked (schematic designator U2)
U56 "CY7C68001-56LFC" QFN50P800X800_HS-57 6610,6135 r0 bottom locked (schematic designator U3)
U58 "TC1017R-3.3VLTTR" SOT65P210X80-5N 1435,5205 r270 bottom locked (schematic designator U1)
U59 "HIN232ACBNZ-T" SOIC127P600-16#2 816.8,5545.08 r270 bottom locked (schematic designator U45)
U60 "MAX6315US26D1" SOT143 6087.05,5610 r180 bottom locked (schematic designator U1000)
U61 "ISP1760" SOT425-1 5570,2240 r0 top locked (schematic designator U59)
U62 "NUP2201MR6T1G" TSOP95P275-6 5345,935 r270 bottom locked (schematic designator U60)
U63 "NUP2201MR6T1G" TSOP95P275-6 5595,935 r270 bottom locked (schematic designator U61)
U64 "NUP2201MR6T1G" TSOP95P275-6 5845,935 r270 bottom locked (schematic designator U62)
U65 "SN74LVC1G04DBV" SOT95P280-5 5280,1420 r180 bottom locked
U66 "SN74LVC1G04DBV" SOT95P280-5 5280,1690 r180 bottom locked
U67 "SN74LVC1G04DBV" SOT95P280-5 5515,1420 r180 bottom locked (schematic designator U65)
U68 "SN74LVC1G04DBV" SOT95P280-5 5515,1690 r180 bottom locked (schematic designator U66)
U69 "FSA4157" SC70_6L#3 8098.58,4755.7 r180 bottom locked
U70 "CY2305 Zero-delay Buffer" SOIC127P600-8 7999.06,3808.67 r270 bottom
U71 "SN74LVC1G04DBV" SOT95P280-5 4490.84,6100 r0 bottom
U72 "SN74LVC1G04DBV" SOT95P280-5 4080.84,6100 r0 bottom
UH1 "2x10 HEADER" HDR2X10 976.12,4713.23 r0 top locked
UH2 "2x10 HEADER" HDR2X10 2373.76,4713.23 r0 top locked
VR1 "2x5K linear" POT-R0911G-A1 440,555 r180 bottom locked
Y1 "20MHZ" XTAL-200X126-4 7986.38,4110 r0 top locked
Y2 "25MHz" XTAL-200X126-4 2660,5530 r270 bottom locked (schematic designator Y1)
Y3 "32.768 kHz 7pF" ECS-71 3595,4605 r90 top locked (schematic designator Y1)
Y4 "24MHz" XTAL-200X126-4 6325,6075 r270 bottom locked (schematic designator Y1)
Y5 "12MHz XTAL" XTAL-200X126-4 5510,1935 r270 top locked (schematic designator Y1)

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
219-8LPST [mm] "Surface Mount DIP Switch, 8-way, Gull Wing Leads"
  rrect50% 2.44x1.13 smd mask+0: 1(-4.3,8.89) 2(-4.3,6.35) 3(-4.3,3.81) 4(-4.3,1.27) 5(-4.3,-1.27) 6(-4.3,-3.81) 7(-4.3,-6.35) 8(-4.3,-8.89)
  rrect50% 2.44x1.13 smd: 9(4.3,-8.89) 10(4.3,-6.35) 11(4.3,-3.81) 12(4.3,-1.27) 13(4.3,1.27) 14(4.3,3.81) 15(4.3,6.35) 16(4.3,8.89)
  silkscreen extent -4.42,-11.04 2.68,11.04, body extent -5.1,-11.4 5.08,11.4, height 3.37
0603LED_GREEN [mm]
  rect 1x1 smd paste+0 mask+0: 1(0.85,0) 2(-0.85,0)
  silkscreen extent -1.97,-0.85 1.6,0.85, body extent -0.92,-0.53 1.09,0.53, height 0.46
0603LED_ORANGE [mm]
  rect 1x1 smd paste+0 mask+0: 1(0.85,0) 2(-0.85,0)
  silkscreen extent -1.97,-0.85 1.6,0.85, body extent -0.92,-0.53 1.09,0.53, height 0.46
0603LED_RED [mm]
  rect 1x1 smd paste+0 mask+0: 1(0.85,0) 2(-0.85,0)
  silkscreen extent -1.97,-0.85 1.6,0.85, body extent -0.92,-0.53 1.09,0.53, height 0.46
0603LED_YELLOW [mm]
  rect 1x1 smd paste+0 mask+0: 1(0.85,0) 2(-0.85,0)
  silkscreen extent -1.97,-0.85 1.6,0.85, body extent -0.92,-0.53 1.09,0.53, height 0.46
53751 [mm]
  rrect50% 0.508x2.8 smd mask+0: 1(-19.6,-2.7) 3(-18.8,-2.7) 5(-18,-2.7) 95(18,-2.7) 97(18.8,-2.7) 99(19.6,-2.7)
  rrect50% 0.508x2.8 smd: 2(-19.6,2.7) 4(-18.8,2.7) 6(-18,2.7) 7(-17.2,-2.7) 8(-17.2,2.7) 9(-16.4,-2.7) 10(-16.4,2.7) 11(-15.6,-2.7) 12(-15.6,2.7) 13(-14.8,-2.7) 14(-14.8,2.7) 15(-14,-2.7) 16(-14,2.7) 17(-13.2,-2.7) 18(-13.2,2.7) 19(-12.4,-2.7) 20(-12.4,2.7) 21(-11.6,-2.7) 22(-11.6,2.7) 23(-10.8,-2.7) 24(-10.8,2.7) 25(-10,-2.7) 26(-10,2.7) 27(-9.2,-2.7) 28(-9.2,2.7) 29(-8.4,-2.7) 30(-8.4,2.7) 31(-7.6,-2.7) 32(-7.6,2.7) 33(-6.8,-2.7) 34(-6.8,2.7) 35(-6,-2.7) 36(-6,2.7) 37(-5.2,-2.7) 38(-5.2,2.7) 39(-4.4,-2.7) 40(-4.4,2.7) 41(-3.6,-2.7) 42(-3.6,2.7) 43(-2.8,-2.7) 44(-2.8,2.7) 45(-2,-2.7) 46(-2,2.7) 47(-1.2,-2.7) 48(-1.2,2.7) 49(-0.4,-2.7) 50(-0.4,2.7) 51(0.4,-2.7) 52(0.4,2.7) 53(1.2,-2.7) 54(1.2,2.7) 55(2,-2.7) 56(2,2.7) 57(2.8,-2.7) 58(2.8,2.7) 59(3.6,-2.7) 60(3.6,2.7) 61(4.4,-2.7) 62(4.4,2.7) 63(5.2,-2.7) 64(5.2,2.7) 65(6,-2.7) 66(6,2.7) 67(6.8,-2.7) 68(6.8,2.7) 69(7.6,-2.7) 70(7.6,2.7) 71(8.4,-2.7) 72(8.4,2.7) 73(9.2,-2.7) 74(9.2,2.7) 75(10,-2.7) 76(10,2.7) 77(10.8,-2.7) 78(10.8,2.7) 79(11.6,-2.7) 80(11.6,2.7) 81(12.4,-2.7) 82(12.4,2.7) 83(13.2,-2.7) 84(13.2,2.7) 85(14,-2.7) 86(14,2.7) 87(14.8,-2.7) 88(14.8,2.7) 89(15.6,-2.7) 90(15.6,2.7) 91(16.4,-2.7) 92(16.4,2.7) 93(17.2,-2.7) 94(17.2,2.7) 96(18,2.7) 98(18.8,2.7) 100(19.6,2.7)
  round 1.35 hole 0.8 mask+0: MH1(-22.283,-2.9) MH3(22.317,-2.9)
  oval 1.8x1 hole 0.6 slot 1.4 at 0 deg mask+0: MH2(-22.283,2.9) MH4(22.317,2.9)
  silkscreen extent -30,-4.77 30.05,4.5, body extent -30.33,-4.4 30.37,4.4, height 11.7
482040001 [mm] "USB A Type Up-Right Reverse Connector, Pb-Free version"
  rrect50% 1.52x1.52 hole 0.9: 1(0,7.73)
  round 1.52 hole 0.9: 2(0,9.73) 3(0,11.73)
  round 1.52 hole 0.9 mask+0: 4(0,13.73)
  rrect50% 1.727x2.5 hole 1.1 slot 1.5 at 90 deg: MH1(-2.735,7) MH2(2.735,7) MH3(-2.735,14) MH4(2.735,14)
  silkscreen extent -3.6,-4.64 3.6,15.75, body extent -3.61,-4.71 3.59,14.54, height 14.68
955012881 [mm] "Connector; PCB Jack, Thru-Hole; 1-Port, 8 Positions, 8 Loaded; Shielded without Lightpipes; Vertical"
  rect 1.5x1.5 hole 0.9: 1(-4.445,3.43)
  round 1.5 hole 0.9: 2(-3.175,5.97) 3(-1.905,3.43) 4(-0.635,5.97) 5(0.635,3.43) 6(1.905,5.97) 7(3.175,3.43) 8(4.445,5.97)
  round 3.15 hole 3.15 unplated: MH1(-5.715,-2.92) MH2(5.715,-2.92)
  silkscreen extent -7.62,-10.8 7.62,7.3, body extent -7.53,-145.72 7.51,7.04, height 23.16
BGA100P8X8-64 [mil] "AMD 64-Ball Fortfied Ball grid Array (FBGA)"
  round 20 smd: A1(-137.8,-137.8) A2(-137.8,-98.43) A3(-137.8,-59.06) A4(-137.8,-19.68) A5(-137.8,19.68) A6(-137.8,59.06) A7(-137.8,98.43) A8(-137.8,137.8) B1(-98.43,-137.8) B2(-98.43,-98.43) B3(-98.43,-59.06) B4(-98.43,-19.69) B5(-98.43,19.68) B6(-98.43,59.06) B7(-98.43,98.43) B8(-98.43,137.8) C1(-59.06,-137.8) C2(-59.06,-98.43) C3(-59.06,-59.06) C4(-59.06,-19.69) C5(-59.06,19.68) C6(-59.06,59.06) C7(-59.06,98.43) C8(-59.06,137.8) D1(-19.69,-137.8) D2(-19.69,-98.43) D3(-19.69,-59.06) D4(-19.69,-19.69) D5(-19.69,19.68) D6(-19.69,59.06) D7(-19.69,98.43) D8(-19.69,137.8) E1(19.68,-137.8) E2(19.68,-98.43) E3(19.68,-59.06) E4(19.68,-19.69) E5(19.68,19.68) E6(19.68,59.06) E7(19.68,98.43) F1(59.05,-137.8) F2(59.05,-98.43) F3(59.05,-59.06) F4(59.05,-19.69) F5(59.05,19.68) F6(59.05,59.06) F7(59.05,98.43) F8(59.05,137.8) G1(98.42,-137.8) G2(98.42,-98.43) G3(98.42,-59.06) G4(98.42,-19.69) G5(98.42,19.68) G6(98.42,59.06) G7(98.43,98.43) G8(98.42,137.8) H1(137.8,-137.8) H3(137.8,-59.06) H4(137.8,-19.69) H5(137.8,19.68) H6(137.8,59.06) H8(137.8,137.8)
  round 20 smd mask+0: E8(19.68,137.8) H2(137.8,-98.43) H7(137.8,98.43)
  silkscreen extent -256,-250 256,217, body extent -250,-213 252,211, height 39
CAPC1005-STAR#1 [mm] "Chip Capacitor 1005"
  rect 0.6x0.6 smd: 1(-0.525,0) 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.57,-0.3 0.57,0.3, height 0.4
CAPC1005-STAR#2 [mm] "Chip Capacitor 1005"
  rect 0.6x0.6 smd: 1(-0.525,0)
  rect 0.6x0.6 smd mask+0: 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.57,-0.3 0.57,0.3, height 0.4
CAPC1005-STAR#3 [mm] "Chip Capacitor 1005"
  rect 0.6x0.6 smd mask+0: 1(-0.525,0)
  rect 0.6x0.6 smd: 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.57,-0.3 0.57,0.3, height 0.4
CAPC1005-STAR#4 [mm] "Chip Capacitor 1005"
  rect 0.6x0.6 smd mask+0.038: 1(-0.525,0)
  rect 0.6x0.6 smd mask+0: 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.57,-0.3 0.57,0.3, height 0.2
CAPC1005-STAR#5 [mm] "Chip Capacitor 1005"
  rect 0.6x0.6 smd mask+0.038: 1(-0.525,0)
  rect 0.6x0.584 smd mask+0: 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.57,-0.3 0.57,0.3, height 0.2
CAPC1005-STAR#6 [mm] "Chip Capacitor 1005"
  rect 0.6x0.6 smd paste+0.038: 1(-0.525,0)
  rect 0.6x0.6 smd paste+0.038 mask+0: 2(0.525,0)
  silkscreen extent -0.05,-0.38 0.05,0.38, body extent -0.57,-0.3 0.57,0.3, height 0.2
CAPC2012-STAR#1 [mm] "0805 Capacitor SMD - Startronics"
  rect 1x1.25 smd: 1(-1,0) 2(1,0)
  silkscreen extent -0.4,-1 0.4,1, body extent -0.98,-0.64 0.87,0.6, height 0.8
CAPC2012-STAR#2 [mm] "0805 Capacitor SMD - Startronics"
  rect 1x1.25 smd: 1(-1,0)
  rect 1x1.25 smd mask+0: 2(1,0)
  silkscreen extent -0.4,-1 0.4,1, body extent -0.98,-0.64 0.87,0.6, height 0.8
CAPC2012-STAR#3 [mm] "0805 Capacitor SMD - Startronics"
  rect 1x1.25 smd mask+0: 1(-1,0)
  rect 1x1.25 smd: 2(1,0)
  silkscreen extent -0.4,-1 0.4,1, body extent -0.98,-0.64 0.87,0.6, height 0.8
CAPC3216-STAR [mm] "Capacitor 1206 (3216) for Startronics"
  rect 1x1.6 smd: 1(-1.45,0)
  rect 1x1.6 smd mask+0: 2(1.45,0)
  silkscreen extent -0.62,-1.1 0.62,1.1, body extent -1.64,-0.89 1.63,0.86, height 0.9
CAPC3528-STAR#1 [mm] "Capacitor 3.5x2.8mm (B-Case)"
  rect 2x2.2 smd: 1(-1.6,0)
  rect 2x2.2 smd mask+0: 2(1.6,0)
  silkscreen extent -3,-1.7 3.05,1.7, body extent -1.79,-1.54 1.8,1.54, height 1
CAPC3528-STAR#2 [mm] "Capacitor 3.5x2.8mm (B-Case)"
  rect 2x2.2 smd: 1(-1.6,0) 2(1.6,0)
  silkscreen extent -3,-1.7 3.05,1.7, body extent -1.79,-1.54 1.8,1.54, height 1
CAPC3528-STAR#3 [mm] "Capacitor 3.5x2.8mm (B-Case)"
  rect 2x2.2 smd: 1(-1.6,0)
  rect 1.956x2.2 smd: 2(1.6,0)
  silkscreen extent -3,-1.7 3.05,1.7, body extent -1.79,-1.54 1.8,1.54, height 1
CAPC7343-STAR#1 [mm] "Capcacitor SMD 7.3 x 4.3mm (D-Case)"
  rect 2.6x2.4 smd: 1(-3.202,0.007)
  rect 2.6x2.4 smd mask+0: 2(3.198,0.007)
  silkscreen extent -5.33,-2.39 5.08,2.41, body extent -3.49,-2.03 3.51,2.04, height 4.05
CAPC7343-STAR#2 [mm] "Capcacitor SMD 7.3 x 4.3mm (D-Case)"
  rect 2.6x2.4 smd: 1(-3.202,0.007) 2(3.198,0.007)
  silkscreen extent -5.33,-2.39 5.08,2.41, body extent -3.49,-2.03 3.51,2.04, height 4.05
CAPM7163 [mm]
  rect 2.35x3.1 smd: 1(-2.875,0)
  rect 2.35x3.1 smd mask+0: 2(2.875,0)
  silkscreen extent -3.5,-3.15 3.5,3.15, body extent -3.1,-2.64 3.2,2.81, height 1.5
CELL_HOLDER [mm] "Lithium Battery Holder for CR2032 3V Cell"
  round 2 hole 1: 1(12.275,0)
  round 2 hole 1 mask+0: 2(-7.95,0)
  Top Layer region: 10.802,3.591 9.577,3.591 9.577,-3.609 10.802,-3.609
  Top Layer region: 9.577,-1.534 9.577,-3.609 12.302,-3.609 12.302,-1.534
  Top Layer region: 12.298,1.534 12.298,3.609 9.573,3.609 9.573,1.534
  Top Layer region: -8.109,-1.527 -8.109,-3.602 -3.959,-3.602 -3.959,-1.527
  Top Layer region: -3.94,1.527 -3.94,3.602 -8.09,3.602 -8.09,1.527
  Top Layer region: -6.475,-3.6 -3.95,-3.6 -3.95,3.6 -6.475,3.6
  silkscreen extent -10.6,-10.6 13.47,10.6, body extent -10.62,-10.59 13.17,10.63, height 10
CON_RJ45_RA_LEDS [mm]
  rect 1.5x1.5 hole 0.9: 1(-4.445,6.35)
  round 1.5 hole 0.9: 2(-3.175,8.89) 3(-1.905,6.35) 4(-0.635,8.89) 5(0.635,6.35) 6(1.905,8.89) 7(3.175,6.35)
  round 1.5 hole 0.9 mask+0: 8(4.445,8.89)
  round 1.62 hole 1: 9(-6.325,-5.08) 11(3.785,-5.08) 12(6.325,-3.38)
  round 1.62 hole 1 mask+0: 10(-3.785,-3.38)
  round 2.23 hole 1.6: MH1(-7.875,3.3) MH2(7.875,3.3)
  round 3.3 hole 3.3 unplated: MH3(-5.715,0) MH4(5.715,0)
  silkscreen extent -8,-10.7 8,10.6, body extent -7.9,-145.27 7.97,10.6, height 24.58
DB9_MALE [mm]
  rect 1.69x1.69 hole 0.9: 1(1.385,-2.84)
  round 1.69 hole 0.9: 2(-1.385,-2.84) 3(-4.155,-2.84) 4(-6.925,-2.84) 6(0,0) 7(-2.77,0) 8(-5.54,0) 9(-8.31,0)
  round 1.69 hole 0.9 mask+0: 5(-9.695,-2.84)
  round 4.76 hole 3.3: 10(-16.65,-1.42) 11(8.34,-1.42)
  silkscreen extent -19.56,-4.32 11.24,15.6, body extent -19.85,-4.33 11.47,16.38, height 12.66
DB15-VGA-FEMALE [mm]
  rect 1.4x1.4 hole 0.9: 1(0,0)
  round 1.4 hole 0.9: 2(2.29,0) 3(4.58,0) 4(6.87,0) 9(5.47,2.54) 11(0,5.08) 12(2.29,5.08) 13(4.58,5.08) 14(6.87,5.08) 15(9.16,5.08)
  round 1.4 hole 0.9 mask+0: 5(9.16,0) 6(-1.4,2.54) 7(0.89,2.54) 8(3.18,2.54) 10(7.76,2.54)
  round 5 hole 3.3: 16(-7.915,2.54) 17(17.075,2.54)
  silkscreen extent -10.83,-2.65 20.01,19.61, body extent -12.27,-1.67 21.42,60.12, height 14.3
DIOM8059 [mm] "DO-214-AB/SMC; 2 C-Bend Leads; Body 7.9 x 5.9 mm, inc. leads (LxW)"
  rect 2.4x3.3 smd mask+0: 1(-3.475,0)
  rect 2.4x3.3 smd: 2(3.475,0)
  silkscreen extent -5.07,-2.05 5.43,2.05, body extent -4.06,-2.92 4.19,2.92, height 1.42
DSO-C6-D4 [mm] "Small Outline; 6 C-Bend Leads; Body Width 3.8 mm; Pitch 1.27 mm"
  rrect50% 0.65x1.8 smd mask+0: 1(-1.27,-1.9)
  rrect50% 0.65x1.8 smd: 2(0,-1.9) 3(1.27,-1.9) 4(1.27,1.9) 5(0,1.9) 6(-1.27,1.9)
  silkscreen extent -2.27,-2.02 2,1.95, body extent -1.86,-1.52 1.86,1.7, height 1.02
ECS-71 [mm] "SMD TUNING FORK CRYSTAL"
  rrect50% 1.2x0.6 smd: 1(-3.15,-0.45) 4(-3.15,0.45)
  rrect50% 1.2x0.6 smd mask+0: 2(3.15,-0.45) 3(3.15,0.45)
  silkscreen extent -2.15,-0.75 2.15,0.75, body extent -3.59,-0.75 3.55,0.74, height 1.41
EDGE-PCIE-X8 [mm] "PCIe X8 PCB Edge Connector"
  rrect50% 0.7x3.2 smd paste-3.2: A1(0,-4)
  rrect50% 0.7x4.2 smd paste-4.2: A2(-1,-3.5) A3(-2,-3.5) A4(-3,-3.5) A5(-4,-3.5) A6(-5,-3.5) A7(-6,-3.5) A8(-7,-3.5) A9(-8,-3.5) A10(-9,-3.5) A11(-10,-3.5) A12(-13,-3.5) A13(-14,-3.5) A14(-15,-3.5) A15(-16,-3.5) A16(-17,-3.5) A17(-18,-3.5) A18(-19,-3.5) A19(-20,-3.5) A20(-21,-3.5) A21(-22,-3.5) A22(-23,-3.5) A23(-24,-3.5) A24(-25,-3.5) A25(-26,-3.5) A26(-27,-3.5) A27(-28,-3.5) A28(-29,-3.5) A29(-30,-3.5) A30(-31,-3.5) A31(-32,-3.5) A32(-33,-3.5) A33(-34,-3.5) A34(-35,-3.5) A35(-36,-3.5) A36(-37,-3.5) A37(-38,-3.5) A41(-42,-3.5) A42(-43,-3.5) A43(-44,-3.5) A44(-45,-3.5) A45(-46,-3.5) A46(-47,-3.5) A47(-48,-3.5) A48(-49,-3.5) A49(-50,-3.5)
  rrect50% 0.7x4.2 smd paste-4.2 mask+0: A38(-39,-3.5) A39(-40,-3.5) A40(-41,-3.5)
  rrect50% 0.7x4.2 smd far side paste-4.2: B1(0,-3.5) B2(-1,-3.5) B3(-2,-3.5) B4(-3,-3.5) B5(-4,-3.5) B6(-5,-3.5) B7(-6,-3.5) B8(-7,-3.5) B9(-8,-3.5) B10(-9,-3.5) B11(-10,-3.5) B12(-13,-3.5) B13(-14,-3.5) B14(-15,-3.5) B15(-16,-3.5) B16(-17,-3.5) B18(-19,-3.5) B19(-20,-3.5) B20(-21,-3.5) B21(-22,-3.5) B22(-23,-3.5) B23(-24,-3.5) B24(-25,-3.5) B25(-26,-3.5) B26(-27,-3.5) B27(-28,-3.5) B28(-29,-3.5) B29(-30,-3.5) B30(-31,-3.5) B32(-33,-3.5) B33(-34,-3.5) B34(-35,-3.5) B35(-36,-3.5) B36(-37,-3.5) B37(-38,-3.5) B39(-40,-3.5) B40(-41,-3.5) B41(-42,-3.5) B42(-43,-3.5) B43(-44,-3.5) B44(-45,-3.5) B45(-46,-3.5) B46(-47,-3.5) B47(-48,-3.5) B49(-50,-3.5)
  rrect50% 0.7x3.2 smd far side paste-3.2: B17(-18,-4) B31(-32,-4) B48(-49,-4)
  rrect50% 0.7x4.2 smd far side paste-4.2 mask+0: B38(-39,-3.5)
FBGA256-2 [mil] "BGA, 256-Leads, Body 17x17mm, Pitch 1mm"
  round 19 smd: A1(-295.28,295.28) A2(-255.91,295.28) A3(-216.54,295.28) A4(-177.17,295.28) A5(-137.8,295.28) A6(-98.43,295.28) A7(-59.06,295.28) A8(-19.69,295.28) A9(19.68,295.28) A10(59.06,295.28) A11(98.43,295.28) A12(137.8,295.28) A13(177.17,295.28) A14(216.54,295.28) A15(255.91,295.28) A16(295.28,295.28) B1(-295.28,255.91) B3(-216.54,255.91) B4(-177.17,255.91) B5(-137.8,255.91) B6(-98.43,255.91) B7(-59.06,255.91) B8(-19.69,255.91) B9(19.68,255.91) B10(59.06,255.91) B11(98.43,255.91) B12(137.8,255.91) B13(177.17,255.91) B14(216.54,255.91) B16(295.28,255.91) C1(-295.28,216.54) C2(-255.91,216.54) C3(-216.54,216.54) C4(-177.17,216.54) C6(-98.43,216.54) C7(-59.06,216.54) C8(-19.69,216.54) C9(19.68,216.54) C10(59.06,216.54) C11(98.43,216.54) C13(177.17,216.54) C14(216.54,216.54) C15(255.91,216.54) C16(295.28,216.54) D1(-295.28,177.17) D2(-255.91,177.17) D3(-216.54,177.17) D4(-177.17,177.17) D5(-137.8,177.17) D6(-98.43,177.17) D8(-19.69,177.17) D9(19.68,177.17) D11(98.43,177.17) D12(137.8,177.17) D13(177.17,177.17) D14(216.54,177.17) D15(255.91,177.17) D16(295.28,177.17) E1(-295.28,137.8) E2(-255.91,137.8) E3(-216.54,137.8) E5(-137.8,137.8) E6(-98.43,137.8) E7(-59.06,137.8) E8(-19.69,137.8) E9(19.68,137.8) E10(59.06,137.8) E11(98.43,137.8) E14(216.54,137.8) E15(255.91,137.8) E16(295.28,137.8) F1(-295.28,98.43) F2(-255.91,98.43) F3(-216.54,98.43) F4(-177.17,98.43) F5(-137.8,98.43) F6(-98.43,98.43) F7(-59.06,98.43) F8(-19.69,98.43) F9(19.68,98.43) F10(59.06,98.43) F11(98.43,98.43) F12(137.8,98.43) F13(177.17,98.43) F14(216.54,98.43) F15(255.91,98.43) F16(295.28,98.43) G1(-295.28,59.06) G2(-255.91,59.06) G3(-216.54,59.06) G5(-137.8,59.06) G6(-98.43,59.06) G7(-59.06,59.06) G8(-19.69,59.06) G9(19.68,59.06) G10(59.06,59.06) G11(98.43,59.06) G14(216.54,59.06) G15(255.91,59.06) G16(295.28,59.06) H1(-295.28,19.68) H2(-255.91,19.68) H3(-216.54,19.68) H4(-177.17,19.68) H5(-137.8,19.68) H6(-98.43,19.68) H11(98.43,19.68) H12(137.8,19.68) H14(216.54,19.68) H15(255.91,19.68) H16(295.28,19.68) J1(-295.28,-19.68) J2(-255.91,-19.68) J4(-177.17,-19.68) J5(-137.8,-19.68) J6(-98.43,-19.68) J11(98.43,-19.68) J12(137.8,-19.68) J13(177.17,-19.68) J14(216.54,-19.68) J15(255.91,-19.68) J16(295.28,-19.68) K1(-295.28,-59.06) K2(-255.91,-59.06) K3(-216.54,-59.06) K5(-137.8,-59.06) K6(-98.43,-59.06) K7(-59.06,-59.06) K8(-19.69,-59.06) K9(19.68,-59.06) K10(59.06,-59.06) K11(98.43,-59.06) K12(137.8,-59.06) K14(216.54,-59.06) K15(255.91,-59.06) K16(295.28,-59.06) L1(-295.28,-98.43) L2(-255.91,-98.43) L3(-216.54,-98.43) L4(-177.17,-98.43) L5(-137.8,-98.43) L6(-98.43,-98.43) L7(-59.06,-98.43) L8(-19.69,-98.43) L9(19.68,-98.43) L10(59.06,-98.43) L11(98.43,-98.43) L12(137.8,-98.43) L13(177.17,-98.43) L14(216.54,-98.43) L15(255.91,-98.43) L16(295.28,-98.43) M1(-295.28,-137.8) M2(-255.91,-137.8) M3(-216.54,-137.8) M6(-98.43,-137.8) M7(-59.06,-137.8) M8(-19.69,-137.8) M9(19.68,-137.8) M10(59.06,-137.8) M11(98.43,-137.8) M12(137.8,-137.8) M14(216.54,-137.8) M15(255.91,-137.8) M16(295.28,-137.8) N1(-295.28,-177.17) N2(-255.91,-177.17) N3(-216.54,-177.17) N4(-177.17,-177.17) N5(-137.8,-177.17) N6(-98.43,-177.17) N8(-19.69,-177.17) N9(19.68,-177.17) N11(98.43,-177.17) N12(137.8,-177.17) N13(177.17,-177.17) N14(216.54,-177.17) N15(255.91,-177.17) N16(295.28,-177.17) P1(-295.28,-216.54) P2(-255.91,-216.54) P3(-216.54,-216.54) P4(-177.17,-216.54) P6(-98.43,-216.54) P7(-59.06,-216.54) P8(-19.69,-216.54) P9(19.68,-216.54) P10(59.06,-216.54) P11(98.43,-216.54) P13(177.17,-216.54) P14(216.54,-216.54) P15(255.91,-216.54) P16(295.28,-216.54) R1(-295.28,-255.91) R3(-216.54,-255.91) R4(-177.17,-255.91) R5(-137.8,-255.91) R6(-98.43,-255.91) R7(-59.06,-255.91) R8(-19.69,-255.91) R9(19.68,-255.91) R10(59.06,-255.91) R11(98.43,-255.91) R12(137.8,-255.91) R13(177.17,-255.91) R14(216.54,-255.91) R16(295.28,-255.91) T1(-295.28,-295.28) T2(-255.91,-295.28) T3(-216.54,-295.28) T4(-177.17,-295.28) T5(-137.8,-295.28) T6(-98.43,-295.28) T7(-59.06,-295.28) T8(-19.69,-295.28) T9(19.68,-295.28) T10(59.06,-295.28) T11(98.43,-295.28) T12(137.8,-295.28) T13(177.17,-295.28) T14(216.54,-295.28) T15(255.91,-295.28) T16(295.28,-295.28)
  round 19 smd mask+0: B2(-255.91,255.91) B15(255.91,255.91) C5(-137.8,216.54) C12(137.8,216.54) D7(-59.06,177.17) D10(59.06,177.17) E4(-177.17,137.8) E12(137.8,137.8) E13(177.17,137.8) G4(-177.17,59.06) G12(137.8,59.06) G13(177.17,59.06) H7(-59.06,19.68) H8(-19.69,19.68) H9(19.68,19.68) H10(59.06,19.68) H13(177.17,19.68) J3(-216.54,-19.68) J7(-59.06,-19.68) J8(-19.69,-19.68) J9(19.68,-19.68) J10(59.06,-19.68) K4(-177.17,-59.06) K13(177.17,-59.06) M4(-177.17,-137.8) M5(-137.8,-137.8) M13(177.17,-137.8) N7(-59.06,-177.17) N10(59.06,-177.17) P5(-137.8,-216.54) P12(137.8,-216.54) R2(-255.91,-255.91) R15(255.91,-255.91)
  silkscreen extent -365,-335 335,335, body extent -335,-335 335,335, height 61