# Altium PCB NB3000AL.PcbDoc (part 40 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DBUSB.D7: U8.AH22 U19.25 | length 4495.4
  Top Layer w4: U8.AH22@5685.28,3658.5 5685.28,3612.85 5658.02,3585.6 5658.02,3556.04 5690.86,3523.21 5690.86,3495.46 5699.19,3487.12 5699.19,3444.79 5756.86,3387.12 5756.86,3375 5748.52,3366.67 ; v1@5742.44,3353.67 ccw(c5731.6,3366.67) 5748.52,3366.67 ; v1@5745,3350.6 ccw(c5738.73,3358.12) 5748.52,3358.12 ccw(c5758.32,3358.12) v1@5752.05,3350.6 ; v1(5748.52,3346.37) 5748.52,3366.67 ; v1@5754.61,3353.67 cw(c5765.44,3366.67) 5748.52,3366.67 ; v1@6415.1,2226.37 cw(c6392.17,2226.37) 6408.38,2210.15 cw(c6424.6,2193.93) v1@6424.6,2216.87 ; v1@6419.1,2226.37 cw(c6405.82,2226.37) 6415.21,2216.98 cw(c6424.6,2207.59) v1@6424.6,2220.87 ; v1(6424.6,2226.37) 6406.86,2208.63 6406.86,2093.33 6407.81,2092.38 6407.81,2034.19 6432.02,2009.98 6432.02,1955.1 6454.9,1932.23 6454.9,1857.77 6454.19,1857.06 6454.19,1833.31 6454.9,1832.6 6454.9,1757.77 6429.5,1732.37 6429.5,1682.15 6456.79,1654.86 6456.79,1590.71 6489.69,1557.81 6499.38,1557.81 6511.81,1545.38 6511.81,1530.97 6524.5,1518.28 6524.5,1060.12 6601.25,983.37 6798.52,983.37 6956.86,825.04 6963,818.9 v4(7234.34,818.9) ; v4@7228.68,813.24 ccw(c7215.02,799.58) 7215.02,818.9 ccw(c7215.02,838.21) v4@7228.68,824.55 ; 5685.28,3640.78 cw(c5703,3640.78) 5690.47,3653.31 ccw(c5703,3640.78) 5685.28,3640.78 ; 5685.28,3640.78 ccw(c5667.55,3640.78) 5680.08,3653.31 cw(c5667.55,3640.78) 5685.28,3640.78
  MidLayer1 w4: v1@5741.81,3339.66 cw(c5725.59,3323.44) 5748.52,3323.44 cw(c5771.46,3323.44) v1@5755.24,3339.66 ; v1@5744.64,3342.49 cw(c5735.25,3333.1) 5748.52,3333.1 cw(c5761.8,3333.1) v1@5752.41,3342.49 ; v1(5748.52,3346.37) 5748.52,3314.79 5732.69,3298.96 5732.69,3284.46 5751.5,3265.65 5751.5,3247.75 5732.02,3228.28 5732.02,3090 5732.02,3060.54 5756.35,3036.21 5756.35,3008.65 5756.35,2995 5756.35,2987.73 5742.5,2973.88 5742.5,2934.65 5753.59,2923.56 5753.59,2884.66 5753.59,2860 5753.59,2831.3 5765,2819.89 5765,2780 5765,2745.25 5765,2718.19 5772.19,2711 5799.25,2711 ; v1@5812.81,2704.79 ccw(c5799.25,2693.09) 5799.25,2711 ; v1@5812.81,2717.21 cw(c5799.25,2728.91) 5799.25,2711 ; v1@5815.84,2707.41 ccw(c5807.99,2700.63) 5807.99,2711 ccw(c5807.99,2721.37) v1@5815.84,2714.59 ; v1(5820,2711) 5799.25,2711
  MidLayer2 w4: v1(5820,2711) 5837.69,2711 ; v1@5827.92,2705.75 cw(c5837.69,2699.29) 5837.69,2711 ; v1@5827.92,2716.25 ccw(c5837.69,2722.71) 5837.69,2711 ; 6364.69,2404 6364.69,2445 6364.69,2458.87 6364.69,2511.6 6298.29,2578 6055.69,2578 5924.5,2709.19 5839.5,2709.19 ; 6364.69,2404.89 6364.69,2303.31 6367.96,2300.04 6411.81,2256.19 6424.6,2243.4 v1(6424.6,2226.37) ; v1@6419.61,2234.45 ccw(c6414.09,2243.4) 6424.6,2243.4 ccw(c6435.12,2243.4) v1@6429.59,2234.45 ; 5837.69,2711 5839.5,2709.19 ; 5837.69,2711 5839.5,2709.19
  Bottom Layer w8: v4(7234.34,818.9) U19.25@7265.67,818.9 ; v4@7238.58,814.66 cw(c7248.82,804.41) 7248.82,818.9 cw(c7248.82,833.38) v4@7238.58,823.14
DBUSB.D8: U19.45 | length 54.1
  Bottom Layer w8: U19.45@7574.33,838.58 v4(7605.66,838.58) ; v4@7601.42,834.34 ccw(c7591.18,824.1) 7591.18,838.58 ccw(c7591.18,853.07) v4@7601.42,842.83
DBUSB.D9: U19.46 | length 54.1
  Bottom Layer w8: v4(7543,818.9) U19.46@7574.33,818.9 ; v4@7547.24,814.65 cw(c7557.48,804.41) 7557.48,818.9 cw(c7557.49,833.38) v4@7547.24,823.14
DBUSB.D10: U19.47 | length 54.1
  Bottom Layer w8: U19.47@7574.33,799.21 v4(7605.66,799.21) ; v4@7601.42,794.97 ccw(c7591.18,784.73) 7591.18,799.21 ccw(c7591.18,813.7) v4@7601.42,803.46
DBUSB.D11: U19.48 | length 54.1
  Bottom Layer w8: v4(7543,779.53) U19.48@7574.33,779.53 ; v4@7547.24,775.28 cw(c7557.48,765.04) 7557.48,779.53 cw(c7557.49,794.01) v4@7547.24,783.77
DBUSB.D12: U19.49 | length 54.1
  Bottom Layer w8: U19.49@7574.33,759.84 v4(7605.66,759.84) ; v4@7601.42,755.6 ccw(c7591.18,745.36) 7591.18,759.84 ccw(c7591.18,774.33) v4@7601.42,764.09
DBUSB.D13: U19.50 | length 54.1
  Bottom Layer w8: v4(7543,740.16) U19.50@7574.33,740.16 ; v4@7547.24,735.91 cw(c7557.48,725.67) 7557.48,740.16 cw(c7557.49,754.64) v4@7547.24,744.4
DBUSB.D14: U19.51 | length 54.1
  Bottom Layer w8: U19.51@7574.33,720.47 v4(7605.66,720.47) ; v4@7601.42,716.23 ccw(c7591.18,705.99) 7591.18,720.47 ccw(c7591.18,734.96) v4@7601.42,724.72
DBUSB.D15: U19.52 | length 54.1
  Bottom Layer w8: v4(7543,700.79) U19.52@7574.33,700.79 ; v4@7547.24,696.54 cw(c7557.48,686.3) 7557.48,700.79 cw(c7557.49,715.27) v4@7547.24,705.03
DBUSB.FIFOADR0: U8.AC18 U19.37 | length 4889.9
  Top Layer w4: U8.AC18@5527.8,3848.01 cw(c5527.8,3830.29) 5540.33,3842.82 cw(c5552.86,3855.35) U8.AC18@5535.14,3855.35 ; U8.AC18@5527.8,3855.35 v3(5547.48,3835.67) ; 5534.68,3848.47 cw(c5521.87,3835.67) 5539.98,3835.67 ccw(c5521.87,3835.67) 5534.68,3848.47 ; 5534.68,3848.47 ccw(c5547.48,3861.28) 5547.48,3843.17 cw(c5547.48,3861.28) 5534.68,3848.47
  MidLayer1 w4: v3@5546.83,3828.2 cw(c5545.25,3810.16) 5559.12,3821.8 ; v3@5554.95,3835.02 ccw(c5572.99,3833.44) 5559.12,3821.8 ; 5571.34,3758.86 5571.34,3772.79 ; v1@6522.36,900.04 cw(c6499.42,900.04) 6515.64,883.82 cw(c6531.86,867.61) v1@6531.86,890.54 ; v1@6526.36,900.04 cw(c6513.08,900.04) 6522.47,890.65 cw(c6531.86,881.26) v1@6531.86,894.54 ; v1(6531.86,900.04) 6513.92,882.1 6418.8,882.1 6296.7,1004.2 6296.7,1137.23 5833.39,1600.54 5782.42,1600.54 5659.81,1723.15 5659.81,1805.42 5656.86,1808.37 5615.19,1850.04 5615.19,2016.71 5590.19,2041.71 5590.19,2263.69 5597.81,2271.31 5597.81,2430.4 5531.35,2496.86 5531.35,2674.54 5640.69,2783.88 5640.69,2816.46 5589.36,2867.79 5589.36,2885.87 5648.48,2945 5648.48,3128.77 5617.19,3160.06 5617.19,3265 5617.19,3280.81 5617.19,3293.69 5623.5,3300 5623.5,3382.36 5608.5,3397.36 5608.5,3453.31 5615.81,3460.62 5615.81,3476.44 5587.11,3505.14 5587.11,3556.89 5571.34,3572.66 5571.34,3679.25 5571.34,3698.67 5571.34,3772.79 ; 5559.12,3821.8 cw(c5529.61,3792.29) 5571.34,3792.29 5571.34,3772.79
  MidLayer2 w4: v1(6531.86,900.04) 6964.85,900.04 7040.69,975.87 7136.13,975.87 7195.29,916.71 7431.86,916.71 7449.52,934.37 v4(7449.53,935.66) ; 7434.96,919.81 ccw(c7419.12,935.66) v4@7441.53,935.66 ; 7438.06,922.91 cw(c7449.53,911.45) v4@7449.53,927.66 ; 7441.79,926.64 ccw(c7432.77,935.66) v4@7445.53,935.66
  Bottom Layer w8: v4@7445.28,931.42 cw(c7435.04,921.18) 7449.53,921.18 cw(c7464.01,921.18) v4@7453.77,931.42 ; U19.37@7449.53,904.33 v4(7449.53,935.66)
DBUSB.FIFOADR1: U8.AC25 U19.38 | length 6938.4
  Top Layer w4: v2@5443.04,1614.25 ccw(c5426.29,1631) 5449.98,1631 ccw(c5473.66,1631) v2@5456.91,1614.25 ; v2@5445.87,1611.42 ccw(c5435.95,1621.34) 5449.98,1621.34 ccw(c5464.01,1621.34) v2@5454.09,1611.42 ; v2(5449.98,1607.31) 5449.98,1646.14 5548.88,1745.04 5721.79,1745.04 5739,1762.25 5739,1902.58 5754.19,1917.77 5754.19,1944.12 5748.31,1950.01 5748.31,1996.92 v2(5774.12,2022.73) ; v2@5764.31,2022.73 cw(c5740.62,2022.73) 5757.37,2005.98 cw(c5774.12,1989.23) v2@5774.12,2012.92 ; v2@5768.31,2022.73 cw(c5754.28,2022.73) 5764.2,2012.81 cw(c5774.12,2002.89) v2@5774.12,2016.92 ; U8.AC25@5803.39,3848.01 cw(c5803.39,3830.29) 5815.92,3842.82 cw(c5828.45,3855.35) U8.AC25@5810.73,3855.35 ; U8.AC25@5803.39,3855.35 v3(5823.07,3835.67) ; v1(7228.52,1200.04) 7374.96,1200.04 7469.21,1105.79 v4(7469.21,873) ; v1@7232.41,1196.15 cw(c7241.8,1186.76) 7241.8,1200.04 cw(c7241.8,1213.32) v1@7232.41,1203.93 ; v1@7235.24,1193.32 cw(c7251.46,1177.11) 7251.46,1200.04 cw(c7251.46,1222.98) v1@7235.24,1206.76 ; v4@7463.56,878.66 ccw(c7449.9,892.31) 7469.21,892.31 ccw(c7488.53,892.31) v4@7474.87,878.66 ; 5810.27,3848.47 cw(c5797.46,3835.67) 5815.57,3835.67 ccw(c5797.46,3835.67) 5810.27,3848.47 ; 5810.27,3848.47 ccw(c5823.07,3861.28) 5823.07,3843.17 cw(c5823.07,3861.28) 5810.27,3848.47
  MidLayer1 w4: v3(5823.07,3835.67) 5900.75,3835.67 5964.33,3835.67 5976,3824 5976,3693 5991.1,3677.9 6044.75,3677.9 6057.86,3664.79 6057.86,3625.04 6032.19,3599.37 6032.19,3407.19 6021.31,3396.31 6021.31,3368.92 ; v3@5828.26,3830.48 cw(c5840.8,3817.94) 5840.8,3835.67 cw(c5840.8,3853.4) v3@5828.26,3840.86 ; 6001.36,3173.39 6001.36,3187.89 6013.51,3200.04 6045.61,3200.04 6088.54,3157.1 6117.92,3157.1 6152.5,3191.68 6152.5,3252.25 6095.95,3308.8 6095.95,3329.05 6061,3364 6026.23,3364 6021.23,3369 ; 6001.5,3173.25 6045.81,3128.94 6045.81,2970.69 6051.81,2964.69 6051.81,2919.9 6017.19,2885.27 6017.19,2814.71 6031.86,2800.04 6031.86,2733.37 5998.52,2700.04 5998.52,2641.71 6211.92,2428.31 6211.92,2163.33 6266.69,2108.56 v2(6266.69,2093.25) ; 5841.18,3835.67 cw(c5841.18,3853.78) 5828.37,3840.97 ccw(c5841.18,3853.78) 5841.18,3835.67 ; 5841.18,3835.67 ccw(c5841.18,3817.56) 5828.37,3830.37 cw(c5841.18,3817.56) 5841.18,3835.67
  MidLayer2 w4: v2(5449.98,1607.31) 5449.98,1606.02 5464,1592 5464,1576 5454,1566 5454,1526.18 5511.28,1468.9 5788,1468.9 5798.98,1457.92 5827.01,1457.92 5928.93,1356 6096.63,1356 6155.82,1296.81 6277.19,1296.81 6580.79,993.21 6923.21,993.21 7130.04,1200.04 v1(7228.52,1200.04) ; v2@5774.12,2012.92 cw(c5774.12,1989.23) 5790.87,2005.98 cw(c5807.61,2022.73) v2@5783.93,2022.73 ; v2@5774.12,2016.92 cw(c5774.12,2002.89) 5784.04,2012.81 cw(c5793.96,2022.73) v2@5779.93,2022.73 ; v2(5774.12,2022.73) 5801.85,1995 6165,1995 6190,2020 6238.75,2020 6266.75,2048 v2@6266.75,2093.19 ; v2@6259.75,2086.31 cw(c6242.86,2069.42) 6266.75,2069.42 ; v2@6262.58,2089.14 cw(c6252.51,2079.07) 6266.75,2079.07 ; 6266.75,2069.71 cw(c6290.23,2069.71) v2@6273.63,2086.31 ; 6266.75,2079.36 cw(c6280.57,2079.36) v2@6270.8,2089.14 ; v1@7221.81,1193.32 ccw(c7205.59,1177.11) 7205.59,1200.04 ccw(c7205.59,1222.98) v1@7221.81,1206.76 ; v1@7224.64,1196.15 ccw(c7215.25,1186.76) 7215.25,1200.04 ccw(c7215.25,1213.32) v1@7224.64,1203.93
  Bottom Layer w8: v4@7464.97,877.24 ccw(c7454.73,887.49) 7469.21,887.49 ccw(c7483.7,887.48) v4@7473.46,877.24 ; v4(7469.21,873) U19.38@7469.21,904.33
DBUSB.FIFOADR2: U8.AC19 U19.36 | length 5040.8
  Top Layer w4: U8.AC19@5567.17,3848.01 cw(c5567.17,3830.29) 5579.7,3842.82 cw(c5592.23,3855.35) U8.AC19@5574.51,3855.35 ; U8.AC19@5567.17,3855.35 v3(5586.85,3835.67) ; 5574.05,3848.47 cw(c5561.24,3835.67) 5579.35,3835.67 ccw(c5561.24,3835.67) 5574.05,3848.47 ; 5574.05,3848.47 ccw(c5586.85,3861.28) 5586.85,3843.17 cw(c5586.85,3861.28) 5574.05,3848.47
  MidLayer1 w4: v3@5586.2,3828.2 cw(c5584.62,3810.16) 5598.49,3821.8 ; v3@5594.32,3835.02 ccw(c5612.36,3833.44) 5598.49,3821.8 ; 5610.71,3758.86 5610.71,3772.79 ; v1@5642.28,3299.28 cw(c5626.06,3283.06) 5649,3283.06 cw(c5671.93,3283.06) v1@5655.72,3299.28 ; v1@5645.11,3302.11 cw(c5635.72,3292.72) 5649,3292.72 cw(c5662.28,3292.72) v1@5652.89,3302.11 ; v1(5649,3306) 5649,3279 5638.29,3268.29 5633.19,3263.19 5633.19,3235.71 5633.19,3225 5633.19,3218.1 5665.69,3185.6 5665.69,2934.87 5633.71,2902.9 5633.71,2864.85 5686.31,2812.26 5686.31,2791.64 5699.36,2778.59 5699.36,2685 5699.36,2662.19 5699.36,2409.21 5698.52,2408.37 ; 5656.38,3471.18 cw(c5639.2,3454) v1@5663.5,3454 ; 5657.75,3469.82 ccw(c5673,3485.07) v1@5673,3463.5 ; 5663.21,3464.35 cw(c5652.86,3454) v1@5667.5,3454 ; 5664.58,3462.99 ccw(c5673,3471.41) v1@5673,3459.5 ; v1(5673,3454) 5673,3454.56 5614.86,3512.71 5614.86,3563.09 5610.71,3567.23 5610.71,3638.82 5610.71,3679.25 5610.71,3698.67 5610.71,3772.79 ; v4@7421.84,873 ccw(c7402.52,873) 7416.18,886.66 ccw(c7429.84,900.31) v4@7429.84,881 ; v4@7429.84,875.04 v4(7429.84,873) 7411.14,891.71 7223.52,891.71 7190.19,858.37 7181.52,849.71 6657.73,849.71 6649.07,858.37 6510.19,997.25 6510.19,997.32 6364.52,1142.98 6364.52,1249.15 6385.81,1270.44 6385.81,1285 6385.81,1300.69 6385.81,1361.24 6382.81,1364.24 ; 5598.49,3821.8 cw(c5568.98,3792.29) 5610.71,3792.29 5610.71,3772.79 ; 5690.19,2400.04 5698.52,2408.37 ; 5690.19,2400.04 5698.52,2408.37 ; 5690.19,2400.04 5689.69,2399.54 5689.69,2185.56 5700.55,2174.71 5954.79,2174.71 5959.31,2170.19 5980.69,2170.19 6051.5,2170.19 6065.02,2183.71 6092.79,2183.71 6124,2152.5 6124,2044.13 6108,2028.13 6108,1862.94 6220.73,1750.21 6240.36,1730.58 6240.36,1704.51 6266.37,1678.5 6278.88,1678.5 6298.5,1658.88 6349,1608.38 6349,1595.87 6381.5,1563.37 6381.5,1555 6381.5,1365.56 ; 6381.5,1365.56 6382.81,1364.24 ; 6381.5,1365.56 6382.81,1364.24
  MidLayer2 w4: v1@5642.28,3312.72 ccw(c5626.06,3328.93) 5649,3328.93 ccw(c5671.93,3328.93) v1@5655.72,3312.72 ; v1@5645.11,3309.89 ccw(c5635.72,3319.28) 5649,3319.28 ccw(c5662.28,3319.28) v1@5652.89,3309.89 ; v1(5649,3306) 5649,3397.48 5673,3421.48 v1(5673,3454) ; v1@5666.28,3447.28 cw(c5650.06,3431.06) 5673,3431.06 cw(c5695.93,3431.06) v1@5679.72,3447.28 ; v1@5669.11,3450.11 cw(c5659.72,3440.72) 5673,3440.72 cw(c5686.28,3440.72) v1@5676.89,3450.11
  Bottom Layer w8: v4@7425.6,877.24 ccw(c7415.36,887.49) 7429.84,887.49 ccw(c7444.33,887.48) v4@7434.09,877.24 ; v4(7429.84,873) U19.36@7429.84,904.33
DBUSB.FLAGA: U8.AE18 U19.29 | length 4850.5
  Top Layer w4: U8.AE18@5527.8,3769.27 cw(c5527.8,3751.55) 5540.33,3764.08 cw(c5552.86,3776.61) U8.AE18@5535.14,3776.61 ; U8.AE18@5527.8,3776.61 v3(5547.48,3756.93) ; v1@5589.29,3303.28 cw(c5573.1,3287.08) 5596,3287.08 ; v1@5592.11,3306.11 cw(c5582.74,3296.73) 5596,3296.73 cw(c5609.26,3296.73) v1@5599.89,3306.11 ; v1(5596,3310) 5596,3287.08 ; v1@5602.71,3303.28 ccw(c5618.9,3287.08) 5596,3287.08 ; v1(5656.86,3225.04) 5656.86,3226.22 5596,3287.08 ; 5534.68,3769.73 cw(c5521.87,3756.93) 5539.98,3756.93 ccw(c5521.87,3756.93) 5534.68,3769.73 ; 5534.68,3769.73 ccw(c5547.48,3782.54) 5547.48,3764.43 cw(c5547.48,3782.54) 5534.68,3769.73
  MidLayer1 w4: v3@5542.18,3751.63 cw(c5529.37,3738.82) 5547.48,3738.82 cw(c5565.59,3738.82) v3@5552.78,3751.63 ; v3@5542.29,3751.74 cw(c5529.75,3739.2) 5547.48,3739.2 cw(c5565.21,3739.2) v3@5552.67,3751.74 ; 5544.25,3430.09 5544.25,3415.54 ; v3(5547.48,3756.93) 5547.48,3679.25 5547.48,3638.82 5547.48,3628.82 5547.48,3583.82 5551.3,3580 5551.3,3561.55 5543.49,3553.74 5543.49,3538.78 5555.89,3526.39 5555.89,3471.44 5544.82,3460.37 5544.25,3459.81 5544.25,3441.32 5544.25,3415.54 ; v1@5589.28,3316.72 ccw(c5573.06,3332.93) 5596,3332.93 ccw(c5618.93,3332.93) v1@5602.72,3316.72 ; v1@5592.11,3313.89 ccw(c5582.72,3323.28) 5596,3323.28 ccw(c5609.28,3323.28) v1@5599.89,3313.89 ; v1(5596,3310) 5596,3363.8 5590,3369.8 5583.9,3375.9 5544.25,3415.54 ; v1@5656.86,3215.54 cw(c5656.86,3192.61) 5673.08,3208.82 cw(c5689.29,3225.04) v1@5666.36,3225.04 ; v1@5656.86,3219.54 cw(c5656.86,3206.26) 5666.25,3215.65 cw(c5675.64,3225.04) v1@5662.36,3225.04 ; v1(5656.86,3225.04) 5673.52,3208.37 5673.69,3208.21 5673.69,2931.56 5641.71,2899.58 5641.71,2870.15 5694.31,2817.55 5694.31,2794.96 5707.36,2781.9 5707.36,2415 5707.36,2405.89 5697.69,2396.23 5697.69,2188.88 5703.86,2182.71 5920,2182.71 5958.1,2182.71 5962.62,2178.19 6048.19,2178.19 6061.71,2191.71 6096.11,2191.71 6132,2155.82 6132,2040.81 6116,2024.81 6116,1866.25 6248.36,1733.9 6248.36,1707.83 6269.68,1686.5 6282.19,1686.5 6306.5,1662.19 6357,1611.69 6357,1599.18 6389.5,1566.68 6389.5,1368.87 ; v1@7130.69,891.71 cw(c7107.76,891.71) 7123.97,875.49 cw(c7140.19,859.27) v1@7140.19,882.21 ; v1@7134.69,891.71 cw(c7121.41,891.71) 7130.8,882.32 cw(c7140.19,872.93) v1@7140.19,886.21 ; v1(7140.19,891.71) 7106.19,857.71 6661.05,857.71 6627.05,891.71 6518.19,1000.57 6518.19,1000.63 6372.52,1146.3 6372.52,1245.84 6393.81,1267.12 6393.81,1290 6393.81,1304 6393.81,1364.56 6390.81,1367.56 ; 6389.5,1368.87 6390.81,1367.56 ; 6389.5,1368.87 6390.81,1367.56
  Bottom Layer w4: v1(7140.19,891.71) 7156.86,908.37 7292.05,908.37 U19.29@7292.05,904.33 ccw(c7282.28,894.57) 7282.28,908.37 ; v1@7140.19,897.21 ccw(c7140.19,910.49) 7149.58,901.1 ccw(c7158.97,891.71) v1@7145.69,891.71 ; v1@7140.19,901.21 ccw(c7140.19,924.14) 7156.41,907.93 ccw(c7172.63,891.71) v1@7149.69,891.71 ; 7272.63,908.37 cw(c7272.63,884.91) U19.29@7289.22,901.5
DBUSB.FLAGB: U8.AD18 U19.30 | length 4806.1
  Top Layer w4: U8.AD18@5527.8,3808.64 cw(c5527.8,3790.92) 5540.33,3803.45 cw(c5552.86,3815.98) U8.AD18@5535.14,3815.98 ; U8.AD18@5527.8,3815.98 v3(5547.48,3796.3) ; 5534.68,3809.1 cw(c5521.87,3796.3) 5539.98,3796.3 ccw(c5521.87,3796.3) 5534.68,3809.1 ; 5534.68,3809.1 ccw(c5547.48,3821.91) 5547.48,3803.8 cw(c5547.48,3821.91) 5534.68,3809.1
  MidLayer1 w4: v3@5546.83,3788.83 cw(c5545.25,3770.79) 5559.12,3782.43 cw(c5572.99,3794.07) v3@5554.95,3795.65 ; 5558.87,3782.72 cw(c5548.94,3772.79) 5562.99,3772.79 5562.99,3679.25 5562.99,3638.82 5562.99,3630.99 5562.99,3569.7 5579.11,3553.58 5579.11,3538.82 5573.61,3533.33 5573.61,3467.2 5580.44,3460.37 5580.44,3402.79 5613.5,3369.73 5613.5,3301.31 5607.5,3295.31 5607.5,3216.94 5567.64,3177.08 5567.64,2907.64 5567.64,2822.36 5597.46,2792.54 v1@5621.77,2792.54 ; v1@5675.14,2759.99 cw(c5658.92,2743.77) 5681.86,2743.77 cw(c5704.79,2743.77) v1@5688.57,2759.99 ; v1@5677.97,2762.82 cw(c5668.58,2753.43) 5681.86,2753.43 cw(c5695.14,2753.43) v1@5685.75,2762.82 ; v1(5681.86,2766.71) 5681.86,2716.71 5690.19,2708.37 5691.36,2707.21 5691.36,2412.52 5690.19,2411.35 ; v4@7306.08,867.34 ccw(c7292.42,853.68) 7292.42,873 ccw(c7292.42,892.31) v4@7306.08,878.66 ; v4(7311.73,873) 7279.82,873 7248.52,841.71 6654.42,841.71 6502.19,993.94 6502.19,994 6356.52,1139.67 6356.52,1252.47 6377.81,1273.75 6377.81,1292.19 6346,1324 6346,1345 6349.58,1348.58 6373.5,1372.5 6373.5,1380 6373.5,1560.06 6368.81,1564.75 6341,1592.56 6341,1605.06 6290.5,1655.56 6275.56,1670.5 ; 5681.86,2403.02 5690.19,2411.35 ; 5681.86,2403.02 5690.19,2411.35 ; 5681.86,2403.02 5681.69,2402.85 5681.69,2182.25 5697.23,2166.71 5951.48,2166.71 5956,2162.19 5984,2162.19 6054.82,2162.19 6068.34,2175.71 6089.48,2175.71 6116,2149.19 6116,2047.44 6100,2031.44 6100,1859.63 6217.42,1742.21 6232.36,1727.27 6232.36,1701.2 6263.06,1670.5 6275,1670.5 ; 6275,1670.5 6275.56,1670.5 ; 6275,1670.5 6275.56,1670.5
  Bottom Layer w4: v1(5623.19,2791.13) 5657.44,2791.13 v1(5681.86,2766.71) ; v1@5627.08,2787.24 cw(c5636.47,2777.85) 5636.47,2791.13 cw(c5636.47,2804.4) v1@5627.08,2795.02 ; v1@5629.91,2784.41 cw(c5646.12,2768.19) 5646.12,2791.13 cw(c5646.12,2814.06) v1@5629.91,2797.84
  Bottom Layer w8: v4@7307.49,877.24 ccw(c7297.25,887.49) 7311.73,887.49 ccw(c7326.22,887.48) v4@7315.97,877.24 ; v4(7311.73,873) U19.30@7311.73,904.33
DBUSB.FLAGC: U8.AD22 U19.31 | length 5579.8
  Top Layer w4: U8.AD22@5685.28,3808.64 cw(c5685.28,3790.92) 5697.81,3803.45 cw(c5710.34,3815.98) U8.AD22@5692.62,3815.98 ; U8.AD22@5685.28,3815.98 v3(5704.96,3796.3) ; v2@6353.06,1675.06 cw(c6336.31,1658.31) 6360,1658.31 cw(c6383.69,1658.31) v2@6366.94,1675.06 ; v2@6355.89,1677.89 cw(c6345.97,1667.97) 6360,1667.97 cw(c6374.03,1667.97) v2@6364.11,1677.89 ; v2(6360,1682) 6360,1601.19 6326.19,1567.38 6326.19,1530 6334.37,1521.81 6334.37,1502.37 6341.5,1495.25 6341.5,1432.55 6403,1371.05 6403,1235 v2(6429,1209) ; v2@6419.19,1209 ccw(c6395.5,1209) 6412.25,1225.75 ccw(c6429,1242.5) v2@6429,1218.81 ; v2@6423.19,1209 ccw(c6409.16,1209) 6419.08,1218.92 ccw(c6429,1228.84) v2@6429,1214.81 ; 5692.16,3809.1 cw(c5679.35,3796.3) 5697.46,3796.3 ccw(c5679.35,3796.3) 5692.16,3809.1 ; 5692.16,3809.1 ccw(c5704.96,3821.91) 5704.96,3803.8 cw(c5704.96,3821.91) 5692.16,3809.1
  MidLayer1 w4: v3@5704.31,3788.83 cw(c5702.73,3770.79) 5716.6,3782.43 cw(c5730.47,3794.07) v3@5712.43,3795.65 ; 5716.35,3782.72 cw(c5706.42,3772.79) 5720.47,3772.79 5720.47,3679.25 5720.47,3599.53 5742.19,3577.81 5800,3577.81 5808.69,3577.81 5868.86,3517.64 5904.5,3482 5904.5,3481.4 ; v2(6253.75,1922) 6272.56,1922 ; v2@6261.8,1916.39 cw(c6272.56,1908.88) 6272.56,1922 ; v2@6261.8,1927.61 ccw(c6272.56,1935.12) 6272.56,1922 ; v2@6360.19,1682.19 6360.19,1731.32 6365,1736.13 6365,1818.75 6365,1829.56 6272.56,1922 ; v2@6473.77,1885.7 ccw(c6457.02,1868.95) 6457.02,1892.64 ccw(c6457.02,1916.33) v2@6473.77,1899.58 ; v2@6476.6,1888.53 ccw(c6466.68,1878.61) 6466.68,1892.64 ccw(c6466.68,1906.67) v2@6476.6,1896.75 ; v2(6480.71,1892.64) 6436.05,1892.64 6432.69,1896 ; v2(7038.4,1153.02) 7143.83,1153.02 7154.81,1164 7186.62,1195.81 7201.38,1195.81 7211.81,1185.38 7217.19,1180 7368.69,1180 7448.86,1099.83 7448.86,975.37 7431.86,958.37 7431.86,933.37 7415.19,916.71 7350.37,916.71 v4(7331.42,935.66) ; v2@7042.51,1148.91 cw(c7052.43,1138.99) 7052.43,1153.02 cw(c7052.43,1167.05) v2@7042.51,1157.13 ; v2@7045.34,1146.09 cw(c7062.09,1129.34) 7062.09,1153.02 cw(c7062.09,1176.71) v2@7045.34,1159.96 ; v4@7331.42,927.66 cw(c7331.42,908.35) 7345.07,922 cw(c7358.73,935.66) v4@7339.42,935.66 ; 5904.5,3465 5904.5,3481.4 ; 5904.5,3465 5904.5,3481.4 ; 5904.5,3465 5904.5,3418.12 5916,3406.62 5916,3360.55 5970,3306.55 5970,3293.79 5956.86,3280.65 5956.86,3258.17 5922.19,3223.5 5922.19,3037.69 5942.19,3017.69 5942.19,2966.56 5916,2940.37 5916,2786.91 5914.69,2785.6 5914.69,2770.5 5906.86,2762.67 5906.86,2645.3 5981.52,2570.63 5981.52,2495.02 6073.33,2403.22 6076.51,2400.04 6096.55,2380 6119.25,2357.29 6166.02,2357.29 6203.92,2319.39 6203.92,2125.69 6203.92,2120 6203.92,2110.93 6214.35,2100.5 6228.19,2100.5 6245,2083.69 6428.07,1900.62 ; 6428.07,1900.62 6432.69,1896 ; 6428.07,1900.62 6432.69,1896
  MidLayer2 w4: v2(6253.75,1922) 6272.56,1922 ; v2@6261.8,1916.39 cw(c6272.56,1908.88) 6272.56,1922 ; v2@6261.8,1927.61 ccw(c6272.56,1935.12) 6272.56,1922 ; v2@6429,1199.19 cw(c6429,1175.5) 6445.75,1192.25 cw(c6462.5,1209) v2@6438.81,1209 ; v2@6429,1203.19 cw(c6429,1189.16) 6438.92,1199.08 cw(c6448.84,1209) v2@6434.81,1209 ; v2(6429,1209) 6588.79,1049.21 6903.21,1049.21 6999.58,1145.58 7005,1145.58 ; v2@6473.77,1885.7 ccw(c6457.02,1868.95) 6457.02,1892.64 ccw(c6457.02,1916.33) v2@6473.77,1899.58 ; v2@6476.6,1888.53 ccw(c6466.68,1878.61) 6466.68,1892.64 ccw(c6466.68,1906.67) v2@6476.6,1896.75 ; v2(6480.71,1892.64) 6317.73,1892.64 6310,1900.37 6288.37,1922 6272.56,1922 ; v2(7038.4,1153.02) 7024.02,1153.02 7019.52,1153.02 7012.09,1145.58 ; 7005,1145.58 7012.09,1145.58 ; 7005,1145.58 7012.09,1145.58
  Bottom Layer w8: v4@7327.17,931.42 cw(c7316.93,921.18) 7331.42,921.18 cw(c7345.9,921.18) v4@7335.66,931.42 ; U19.31@7331.42,904.33 v4(7331.42,935.66)
DBUSB.FLAGD_CS_N: U8.AG22 U19.40 | length 5145.4
  Top Layer w4: v1@5717.28,3452.72 ccw(c5701.06,3468.93) 5724,3468.93 ccw(c5746.93,3468.93) v1@5730.72,3452.72 ; v1@5720.11,3449.89 ccw(c5710.72,3459.28) 5724,3459.28 ccw(c5737.28,3459.28) v1@5727.89,3449.89 ; 5697.81,3685.34 ccw(c5685.28,3672.8) 5685.28,3690.53 cw(c5685.28,3672.8) 5697.81,3685.34 ; 5697.81,3685.34 cw(c5710.34,3697.87) 5692.62,3697.87 ccw(c5710.34,3697.87) 5697.81,3685.34 ; 5697.81,3685.34 cw(c5690.63,3678.16) 5700.78,3678.16 ; 5697.81,3685.34 cw(c5690.63,3678.16) 5700.78,3678.16 ; 5699.19,3499.65 5699.19,3526.19 ; 5699.19,3499.65 5699.19,3526.19 ; 5699.19,3499.65 5724,3474.84 v1@5724,3456.5 ; 5699.19,3526.19 5666.02,3559.35 5666.02,3582.29 5676.28,3592.54 5676.54,3592.54 5700.78,3616.78 5700.78,3630.82 5700.78,3638.82 ; 5700.78,3638.82 5700.78,3678.16 ; 5700.78,3638.82 5700.78,3678.16 ; v1@5724,3450.04 v1@5724,3456.5 ; v1@5724,3450.04 v1(5724,3446) v1@5724,3450.04 ; v1@5724,3450.04 v1@5724,3456.5
  MidLayer1 w4: 5885.13,2621.77 5897.39,2609.51 ; 7022.56,983.37 7060,983.37 ; v1@7172.36,958.37 ccw(c7149.42,958.37) 7165.64,974.59 ccw(c7181.86,990.81) v1@7181.86,967.87 ; v1@7176.36,958.37 ccw(c7163.08,958.37) 7172.47,967.76 ccw(c7181.86,977.15) v1@7181.86,963.87 ; v1(7181.86,958.37) 7156.86,983.37 7060,983.37 ; 5733.39,3436.61 cw(c5742.78,3446) 5729.5,3446 ccw(c5742.78,3446) 5733.39,3436.61 ; 5733.39,3436.61 ccw(c5724,3427.22) 5724,3440.5 cw(c5724,3427.22) 5733.39,3436.61 ; 5740.22,3429.78 cw(c5756.43,3446) 5733.5,3446 ccw(c5756.43,3446) 5740.22,3429.78 ; 5740.22,3429.78 ccw(c5724,3413.56) 5724,3436.5 cw(c5724,3413.56) 5740.22,3429.78 ; 5756.02,3218.33 5784.41,3246.72 ; 5756.02,3218.33 5784.41,3246.72 ; 5756.02,3218.33 5756.02,3070.48 5808.68,3017.82 5808.68,2953.43 5796.5,2941.25 5796.5,2926.75 5807.75,2915.5 5835.52,2915.5 5842.19,2908.83 5842.19,2814.13 5842.68,2813.64 5850.5,2805.81 5850.5,2765.69 5874.36,2741.83 5874.36,2695 ; 5784.41,3246.72 5784.41,3270 ; 5784.41,3270 5784.41,3385.59 ; 5784.41,3270 5784.41,3385.59 ; 5784.41,3385.59 v1(5724,3446) 5784.41,3385.59 ; 5874.36,2684.46 5874.36,2695 ; 5874.36,2684.46 5874.36,2695 ; 5874.36,2684.46 5874.36,2632.54 5897.39,2609.51 ; 5897.39,2609.51 5948.52,2558.37 5948.52,2280.37 5970.52,2258.37 6105,2258.37 ; 6105,2258.37 6139.25,2258.37 ; 6105,2258.37 6139.25,2258.37 ; 6139.25,2258.37 6179.92,2217.71 6179.92,2135.63 ; 6179.92,2100.99 6179.92,2135.63 ; 6179.92,2100.99 6179.92,2135.63 ; 6179.92,2100.99 6189.81,2091.1 6189.81,2037.32 ; 6189.81,2035 6189.81,2027.37 6366.36,1850.82 ; 6189.81,2035 6189.81,2037.32 ; 6189.81,2035 6189.81,2037.32 ; 6366.36,1850.82 6385,1832.18 ; 6366.36,1850.82 6385,1832.18 ; 6376.19,1724.69 6376.19,1703.31 6389,1690.5 6389,1613.37 6421.5,1580.87 6421.5,1385 ; 6376.19,1724.69 6385,1733.5 ; 6376.19,1724.69 6385,1733.5 ; 6385,1733.5 6385,1832.18 ; 6421.5,1382.12 6422.81,1380.81 ; 6421.5,1382.12 6421.5,1385 ; 6421.5,1382.12 6422.81,1380.81 ; 6421.5,1382.12 6421.5,1385 ; 6422.81,1380.81 6426.19,1377.43 6426.19,1316.88 ; 6426.19,1305 6426.19,1281.31 6475.31,1232.19 6502.69,1232.19 6517.11,1246.61 6583,1246.61 6589.43,1240.19 6697.56,1240.19 6727.19,1240.19 6743.57,1223.81 6778.13,1223.81 6839.44,1162.5 7018.56,983.37 7060,983.37 ; 6426.19,1305 6426.19,1316.88 ; 6426.19,1305 6426.19,1316.88
  MidLayer2 w4: v1(7181.86,958.37) 7501.63,958.37 7508.58,951.42 v4(7508.58,873) ; v1@7185.75,954.49 cw(c7195.14,945.1) 7195.14,958.37 cw(c7195.14,971.65) v1@7185.75,962.26 ; v1@7188.57,951.66 cw(c7204.79,935.44) 7204.79,958.37 cw(c7204.79,981.31) v1@7188.57,965.09 ; v4@7502.93,878.66 ccw(c7489.27,892.31) 7508.58,892.31 ccw(c7527.9,892.31) v4@7514.24,878.66 ; v4@7506.86,873 v4(7508.58,873) ; v4@7510,874.42 v4(7508.58,873)
  Bottom Layer w8: v4@7504.34,877.24 ccw(c7494.1,887.49) 7508.58,887.49 ccw(c7523.07,887.48) v4@7512.83,877.24 ; v4(7508.58,873) U19.40@7508.58,904.33
DBUSB.IFCLK: R112.1 U8.AE15 | length 4788
  Top Layer w4: U8.AE15@5409.69,3769.27 cw(c5409.69,3751.55) 5422.22,3764.08 cw(c5434.75,3776.61) U8.AE15@5417.03,3776.61 ; U8.AE15@5409.68,3776.61 v3(5429.37,3756.93) ; 5416.57,3769.73 cw(c5403.76,3756.93) 5421.87,3756.93 ccw(c5403.76,3756.93) 5416.57,3769.73 ; 5416.57,3769.73 ccw(c5429.37,3782.54) 5429.37,3764.43 cw(c5429.37,3782.54) 5416.57,3769.73
  MidLayer1 w4: v3@5424.18,3751.74 cw(c5411.64,3739.2) 5429.37,3739.2 cw(c5447.1,3739.2) v3@5434.56,3751.74 ; v3(5429.37,3756.93) 5429.37,3679.25 5429.37,3638.82 5429.4,3629.5 5429.4,3615 5392.19,3577.79 5392.19,3537.62 5397,3532.81 5397,3491.45 5394.8,3489.25 5394.8,3474.75 5408.5,3461.05 5408.5,3405 5474.39,3339.11 5474.39,3261.69 5499.35,3236.73 5499.35,3196.2 5489.68,3186.53 5484.26,3186.53 5448.5,3150.77 5448.5,3038.25 5435.5,3025.25 5435.5,2951.56 5419.5,2935.56 5419.5,2927.42 5397.52,2905.44 5397.52,2742.71 5431.19,2709.04 5431.19,1767.37 5831.86,1366.71 5831.86,1275.04 5848.52,1258.37 5857.03,1249.87 5949.05,1249.87 6523.88,675.04 6781.86,675.04 6790.19,683.37 v1(7098.52,683.37) ; v1@7091.81,676.66 ccw(c7075.59,660.44) 7075.59,683.37 ccw(c7075.59,706.31) v1@7091.81,690.09 ; v1@7094.64,679.49 ccw(c7085.25,670.1) 7085.25,683.37 ccw(c7085.25,696.65) v1@7094.64,687.26 ; 5429.37,3738.82 cw(c5447.48,3738.82) 5434.67,3751.63 ccw(c5447.48,3738.82) 5429.37,3738.82 ; 5429.37,3738.82 ccw(c5411.26,3738.82) 5424.07,3751.63 cw(c5411.26,3738.82) 5429.37,3738.82
  Bottom Layer w4: v1@7091.81,676.66 cw(c7075.59,660.44) 7098.52,660.44 cw(c7121.46,660.44) v1@7105.24,676.66 ; v1@7094.64,679.49 cw(c7085.25,670.1) 7098.52,670.1 cw(c7111.8,670.1) v1@7102.41,679.49 ; v1(7098.52,683.37) 7098.52,611.48 7115,595 R112.1@7153.82,595 ; R112.1@7147.23,588.41 ccw(c7131.32,572.5) 7131.32,595 ccw(c7131.32,617.5) R112.1@7147.23,601.59 ; R112.1@7150.06,591.24 ccw(c7140.98,582.16) 7140.98,595 ccw(c7140.98,607.84) R112.1@7150.06,598.76
DBUSB.INT_N: R115.1 U8.AF24 U19.34 | length 5076.6
  Top Layer w4: v1(5748.52,3491.71) 5776.9,3491.71 5807.81,3522.62 5807.81,3567.38 5782.5,3592.69 5782.5,3617.5 5788,3623 5788,3630 5787.88,3638.82 5787.88,3697.36 ; v1@5752.41,3487.82 cw(c5761.8,3478.43) 5761.8,3491.71 cw(c5761.8,3504.99) v1@5752.41,3495.6 ; v1@5755.24,3484.99 cw(c5771.46,3468.77) 5771.46,3491.71 cw(c5771.46,3514.64) v1@5755.24,3498.43 ; v1(7181.86,1033.37) 7375,1033.37 7390.47,1017.9 v4(7390.47,873) ; v1@7185.75,1029.49 cw(c7195.14,1020.1) 7195.14,1033.37 cw(c7195.14,1046.65) v1@7185.75,1037.26 ; v1@7188.57,1026.66 cw(c7204.79,1010.44) 7204.79,1033.37 cw(c7204.79,1056.31) v1@7188.57,1040.09 ; v4@7384.82,878.66 ccw(c7371.16,892.32) 7390.47,892.32 ccw(c7409.78,892.31) v4@7396.13,878.66 ; 5776.55,3724.71 cw(c5789.08,3737.24) 5771.36,3737.24 ccw(c5789.08,3737.24) 5776.55,3724.71 ; 5776.55,3724.71 ccw(c5764.02,3712.18) 5764.02,3729.9 cw(c5764.02,3712.18) 5776.55,3724.71 ; 5776.55,3724.71 cw(c5749.2,3697.36) 5787.88,3697.36 ; 5776.55,3724.71 cw(c5749.2,3697.36) 5787.88,3697.36
  MidLayer1 w4: v1@5742.01,3484.8 cw(c5727.76,3469.69) 5748.52,3469.69 ; v1@5744.75,3487.71 cw(c5736.5,3478.96) 5748.52,3478.96 cw(c5760.55,3478.96) v1@5752.3,3487.71 ; v1@5755.04,3484.8 ccw(c5769.29,3469.69) 5748.52,3469.69 ; 6187.92,2132.32 6187.92,2120 ; 6991.69,1062 7040,1062 ; v1@7172.36,1033.37 ccw(c7149.42,1033.37) 7165.64,1049.59 ccw(c7181.86,1065.81) v1@7181.86,1042.87 ; v1@7176.36,1033.37 ccw(c7163.08,1033.37) 7172.47,1042.76 ccw(c7181.86,1052.15) v1@7181.86,1038.87 ; v1(7181.86,1033.37) 7153.23,1062 7040,1062 ; 5748.52,3469.69 5752.4,3465.81 5766.7,3465.81 ; 5748.52,3469.69 v1@5748.52,3483.99 ; v1@5748.52,3483.99 v1(5748.52,3491.71) v1@5748.52,3483.99 ; 5766.7,3465.81 5777.92,3454.59 ; 5766.7,3465.81 5777.92,3454.59 ; 5777.92,3454.59 5796.16,3454.59 5837.81,3412.94 5837.81,3284.56 5832.5,3279.25 5832.5,3264.75 5849.02,3248.23 5849.02,3211.48 5822.69,3185.15 5822.69,3066.62 ; 5822.69,3066.62 5842.5,3046.81 ; 5822.69,3066.62 5842.5,3046.81 ; 5842.5,3046.81 5842.5,2964.25 5848.52,2958.22 5869.5,2937.25 5869.5,2922.75 ; 5850.19,2895 5850.19,2903.44 ; 5850.19,2895 5850.19,2817.44 5858.5,2809.13 5858.5,2769 5882.36,2745.15 5882.36,2681.15 5882.36,2650 ; 5850.19,2895 5850.19,2903.44 ; 5850.19,2903.44 5857.25,2910.5 ; 5857.25,2910.5 5869.5,2922.75 ; 5857.25,2910.5 5869.5,2922.75 ; 5882.36,2635.86 5887.08,2631.13 ; 5882.36,2635.86 5887.08,2631.13 ; 5882.36,2635.86 5882.36,2650 ; 5882.36,2635.86 5892.91,2625.31 ; 5882.36,2635.86 5882.36,2650 ; 5887.08,2631.13 5892.91,2625.31 ; 5892.91,2625.31 5957.35,2560.86 5957.35,2555.89 5956.86,2555.39 5956.86,2288.14 5977.8,2267.2 5978.63,2266.37 6028.44,2266.37 ; 6028.44,2266.37 6142.57,2266.37 ; 6028.44,2266.37 6142.57,2266.37 ; 6142.57,2266.37 6187.92,2221.02 ; 6142.57,2266.37 6187.92,2221.02 ; 6187.92,2104.31 6187.92,2120 ; 6187.92,2104.31 6187.92,2120 ; 6187.92,2104.31 6197.81,2094.42 6197.81,2040.63 ; 6187.92,2120 6187.92,2221.02 ; 6197.81,2033.11 6197.81,2040.63 ; 6197.81,2033.11 6384.14,1846.78 ; 6197.81,2033.11 6197.81,2040.63 ; 6384.14,1846.78 6395,1835.92 ; 6384.14,1846.78 6395,1835.92 ; 6384.19,1721.38 6384.19,1706.62 6397,1693.81 6397,1616.69 6429.5,1584.19 6429.5,1385.44 6434.19,1380.75 6434.19,1284.62 6478.62,1240.19 6499.38,1240.19 6513.8,1254.61 6586.32,1254.61 6592.74,1248.19 6694.25,1248.19 6730.5,1248.19 6746.88,1231.81 6781.44,1231.81 6842.75,1170.5 6951.25,1062 7040,1062 ; 6384.19,1721.38 6395,1732.19 ; 6384.19,1721.38 6395,1732.19 ; 6395,1732.19 6395,1835.92
  Bottom Layer w4: v1(7181.86,1033.37) 7196.18,1019.05 R115.1@7196.18,990 ; R115.1@7189.59,997.08 ccw(c7173.68,1012.99) 7196.18,1012.99 ccw(c7218.68,1012.99) R115.1@7202.77,997.08 ; R115.1@7192.42,994.25 ccw(c7183.34,1003.33) 7196.18,1003.33 ccw(c7209.02,1003.33) R115.1@7199.94,994.25
  Bottom Layer w8: v4@7386.23,877.24 ccw(c7375.99,887.49) 7390.47,887.49 ccw(c7404.96,887.48) v4@7394.72,877.24 ; v4(7390.47,873) U19.34@7390.47,904.33
DBUSB.PKTEND: U8.AH23 U19.39 | length 5565.7
  Top Layer w4: v1@5700.24,3551.76 5724.65,3576.16 5724.65,3630.82 5724.65,3638.82 U8.AH23@5724.65,3658.5 ; U8.AH23@5719.45,3653.31 cw(c5706.92,3640.78) 5724.65,3640.78 cw(c5742.37,3640.78) U8.AH23@5729.84,3653.31
  MidLayer1 w4: v4@7483.24,941.32 ccw(c7469.58,954.98) 7488.9,954.98 ccw(c7508.21,954.98) v4@7494.55,941.32 ; 7805.69,3062.5 cw(c7861.06,3062.5) v1@7821.91,3101.66 ; 7805.69,3072.16 cw(c7851.4,3072.16) v1@7819.08,3104.49 ; 7805.69,3081.82 cw(c7841.75,3081.82) v1@7816.25,3107.31 ; 7805.69,3091.48 cw(c7832.09,3091.48) v1@7813.42,3110.14 ; v1(7815.19,3108.37) 7805.69,3098.87 7805.69,2924.63 7807.81,2922.51 7807.81,2773.76 7822.5,2759.07 7822.5,2660.17 7822.5,2602.5 7816.5,2596.5 7816.5,2500 7827,2489.5 7827,2392.82 7873.36,2346.46 7873.36,2335.14 7902.5,2306 7902.5,2229.93 7872.5,2199.93 7872.5,2039 7834.19,2000.69 7834.19,1990.01 7817.81,1973.63 7817.81,1952.5 7822.5,1947.81 7822.5,1831.81 7752.5,1761.81 7751.31,1761.81 7728.62,1739.12 7728.62,1735.86 7588.04,1595.29 7582.54,1595.29 7528,1540.75 7528,1525.31 7494.69,1492 7472.69,1492 7454,1473.31 7454,1448 7474,1428 7474,1216.31 7429.19,1171.5 7429.19,1147.62 7472.19,1104.62 7472.19,1001.34 7488.9,984.63 v4@7488.9,943.33 ; v4@7488.9,943.33 v4(7488.9,935.66) 7488.9,933.37 7489.19,933.37 7490.19,934.37 7490.19,942.04 v4@7488.9,943.33
  MidLayer2 w4: v1@5693.28,3545.28 cw(c5677.06,3529.06) 5700,3529.06 cw(c5722.93,3529.06) v1@5706.72,3545.28 ; v1@5696.11,3548.11 cw(c5686.72,3538.72) 5700,3538.72 cw(c5713.28,3538.72) v1@5703.89,3548.11 ; v1(5700,3552) 5700,3525.38 5706.5,3518.88 5706.5,3438.75 5723.06,3422.19 5763.38,3422.19 5774.5,3433.31 5774.5,3441.25 5784.75,3451.5 5884.81,3451.5 5916.31,3420 5955.19,3420 5965.19,3430 ; v1@5959.18,3442.69 cw(c5948.8,3430) 5965.19,3430 ; v1@5961.71,3445.78 cw(c5955.7,3438.44) 5965.19,3438.44 cw(c5974.68,3438.44) v1@5968.67,3445.78 ; v1(5965.19,3450.04) 5965.19,3430 ; v1@5971.2,3442.69 ccw(c5981.58,3430) 5965.19,3430
  Bottom Layer w4: v1(5965.19,3450.04) 5983.65,3450.04 ; v1@5972.92,3444.52 cw(c5983.64,3436.87) 5983.64,3450.04 ; v1@5972.92,3455.56 ccw(c5983.64,3463.22) 5983.64,3450.04 ; 7798.65,3124.73 ccw(c7815.19,3141.27) v1@7815.19,3117.87 ; 7799.11,3124.27 cw(c7783.21,3108.37) v1@7805.69,3108.37 ; 7805.48,3117.9 ccw(c7815.19,3127.61) v1@7815.19,3113.87 ; 7805.94,3117.44 cw(c7796.87,3108.37) v1@7809.69,3108.37 ; v1(7815.19,3108.37) 7815,3108.37 7738.37,3185 7633.65,3185 7624.69,3193.96 7624.69,3205.27 7609.75,3220.21 7595.28,3220.21 7555,3260.48 7555,3348.31 7502.44,3400.87 7382.94,3400.87 7373.77,3391.71 7198.52,3391.71 7173.86,3416.37 6859.56,3416.37 6834.23,3441.71 6705.52,3441.71 6690.01,3457.22 6679.69,3467.54 6655.61,3467.54 6629.78,3441.71 6284.59,3441.71 6284.09,3441.21 6262.96,3441.21 6245.7,3458.47 6201.25,3458.47 6182.27,3439.5 5994.19,3439.5 5983.65,3450.04
  Bottom Layer w8: v4@7484.66,931.42 cw(c7474.41,921.18) 7488.9,921.18 cw(c7503.38,921.18) v4@7493.14,931.42 ; U19.39@7488.9,904.33 v4(7488.9,935.66)
DBUSB.RD_N: U8.AB22 U19.1 | length 10214.5
  Top Layer w4: U8.AB22@5685.28,3887.38 cw(c5685.28,3869.66) 5697.81,3882.19 cw(c5710.34,3894.72) U8.AB22@5692.62,3894.72 ; U8.AB22@5685.28,3894.72 v3(5704.96,3875.04) ; v2@5759.17,2642.2 cw(c5759.17,2618.52) 5775.92,2635.27 cw(c5792.67,2652.01) v2@5768.98,2652.01 ; v2@5759.17,2646.2 cw(c5759.17,2632.17) 5769.09,2642.09 cw(c5779.01,2652.01) v2@5764.98,2652.01 ; v2(5759.17,2652.01) 5802,2609.18 5802,2526.69 5837.81,2490.87 5889.11,2490.87 5942.73,2490.87 5972.19,2520.33 6117.09,2665.24 6117.09,2678.67 6164.92,2726.5 6186.56,2726.5 6194.56,2734.5 6255,2734.5 6281.4,2760.9 6333.5,2813 6361.69,2813 6379,2830.31 6379,2881 6329,2931 6329,2950 6348,2969 6434.69,2969 6461.15,2942.54 6731.15,2942.54 6828.69,2845 6886.9,2845 v1(6948.52,2783.37) ; v1@6939.02,2783.37 ccw(c6916.09,2783.37) 6932.31,2799.59 ccw(c6948.52,2815.81) v1@6948.52,2792.87 ; v1@6943.02,2783.37 ccw(c6929.75,2783.37) 6939.14,2792.76 ccw(c6948.52,2802.15) v1@6948.52,2788.87 ; 5692.16,3887.84 cw(c5679.35,3875.04) 5697.46,3875.04 ccw(c5679.35,3875.04) 5692.16,3887.84 ; 5692.16,3887.84 ccw(c5704.96,3900.65) 5704.96,3882.54 cw(c5704.96,3900.65) 5692.16,3887.84
  MidLayer1 w4: v2(5379,2755) 5379,2749.92 5423.19,2705.73 5423.19,1664 5437.82,1649.37 5437.82,1646.18 v2(5491,1593) ; v2@5481.19,1593 ccw(c5457.5,1593) 5474.25,1609.75 ccw(c5491,1626.5) v2@5491,1602.81 ; v2@5485.19,1593 ccw(c5471.16,1593) 5481.08,1602.92 ccw(c5491,1612.84) v2@5491,1598.81 ; v2@7000,1245.19 cw(c7000,1220.9) 7017.18,1238.07 ; v2@7000,1249.19 cw(c7000,1234.55) 7010.35,1244.9 ; v2@7000.25,1255 7022.75,1232.5 7070.31,1232.5 7084.62,1246.81 7118.69,1246.81 7127.31,1238.19 7169.35,1238.19 7190,1217.54 7280,1217.54 7342.46,1217.54 7456.86,1103.14 7456.86,1078.09 7456.86,959.04 7465.86,950.04 7465.86,925.04 7474.19,916.71 7498.52,916.71 7506.86,925.04 7506.86,985 7481.86,1010 7481.86,1083.37 7498.52,1100.04 7515.19,1100.04 7531.86,1083.37 7531.86,1016.71 7556.86,991.71 v1(7581.86,991.71) ; v2@7005.81,1255 ccw(c7019.23,1255) 7009.74,1245.51 ; v2@7009.81,1255 ccw(c7032.89,1255) 7016.57,1238.68 ; v1@7575.14,984.99 ccw(c7558.92,968.77) 7558.92,991.71 ccw(c7558.92,1014.64) v1@7575.14,998.43 ; v1@7577.97,987.82 ccw(c7568.58,978.43) 7568.58,991.71 ccw(c7568.58,1004.99) v1@7577.97,995.6
  MidLayer2 w4: 5473.32,1574.01 ccw(c5454.33,1593) v2@5481.19,1593 ; 5476.49,1577.18 cw(c5491,1562.67) v2@5491,1583.19 ; 5480.15,1580.84 ccw(c5467.99,1593) v2@5485.19,1593 ; 5483.32,1584.01 cw(c5491,1576.33) v2@5491,1587.19 ; v2@5491,1591.69 5468,1568.69 5468,1526 5503.3,1490.7 5517.1,1476.9 5754.85,1476.9 5767.28,1489.34 5771.49,1493.54 5814.02,1493.54 5935.56,1372 6179.37,1372 6214.56,1336.81 6287.56,1336.81 6324.18,1300.19 6384.68,1300.19 6460.68,1224.19 6571.49,1224.19 6580.5,1215.17 6580.5,1179.5 6655,1105 6909.81,1105 6997.62,1192.81 7026,1192.81 7031.81,1198.62 ; v1(6085,3495) 6085,3494.85 6081.86,3491.71 6198.52,3491.71 6220.09,3470.14 6281.86,3408.37 6315.19,3408.37 6373.52,3350.04 6668.5,3350.04 6710,3308.55 6710,3238.56 6948.52,3000.04 v1(6948.52,2783.37) ; v1@6086.06,3496.06 ccw(c6096.57,3506.57) 6096.57,3491.71 ; v1@6088.89,3498.89 ccw(c6106.23,3516.23) 6106.23,3491.71 ; v1@6091.72,3488.28 cw(c6099.99,3480.01) 6099.99,3491.71 ; v1@6091.72,3501.72 ccw(c6115.88,3525.88) 6115.88,3491.71 ; v1@6941.81,2790.09 ccw(c6925.59,2806.31) 6948.52,2806.31 ccw(c6971.46,2806.31) v1@6955.24,2790.09 ; v1@6944.64,2787.26 ccw(c6935.25,2796.65) 6948.52,2796.65 ccw(c6961.8,2796.65) v1@6952.41,2787.26 ; v2(7000,1255) 7025,1255 7032.81,1247.19 7032.81,1222.38 7032.81,1215 7032.81,1210 7032.81,1202.62 7032.81,1199.62 7031.81,1198.62 ; v2@7004.11,1250.89 cw(c7014.03,1240.97) 7014.03,1255 cw(c7014.03,1269.03) v2@7004.11,1259.11 ; v2@7006.94,1248.06 cw(c7023.69,1231.31) 7023.69,1255 cw(c7023.69,1278.69) v2@7006.94,1261.94 ; 7030.84,1197.65 7031.81,1198.62 ; v1@7575.14,984.99 cw(c7558.92,968.77) 7581.86,968.77 cw(c7604.79,968.77) v1@7588.57,984.99 ; v1@7577.97,987.82 cw(c7568.58,978.43) 7581.86,978.43 cw(c7595.14,978.43) v1@7585.75,987.82 ; v1(7581.86,991.71) 7581.86,618.14 7599.96,600.04 v1(7631.86,600.04) ; v1@7625.14,593.32 ccw(c7608.92,577.11) 7608.92,600.04 ccw(c7608.92,622.98) v1@7625.14,606.76 ; v1@7627.97,596.15 ccw(c7618.58,586.76) 7618.58,600.04 ccw(c7618.58,613.32) v1@7627.97,603.93
  Bottom Layer w4: v2(5379,2755) 5387.07,2755 5438.2,2806.13 5514.13,2806.13 5525,2817 5525,2851 5538,2864 5559.21,2864 5598.21,2825 5639.51,2825 5680.3,2784.21 5689.11,2784.21 5696.79,2776.52 5718.27,2776.52 5765.5,2729.3 5765.5,2685 5759.17,2678.67 v2(5759.17,2652.01) ; v2@5379,2756.81 ccw(c5379,2780.66) 5395.86,2763.8 ; v2@5379,2760.81 ccw(c5379,2794.32) 5402.69,2770.62 ; v2@5379,2764.81 ccw(c5379,2807.97) 5409.52,2777.45 ; v3@5706.26,3867.65 cw(c5709.41,3849.82) 5719.79,3864.65 ; v3@5712.35,3876.34 ccw(c5730.18,3879.49) 5719.79,3864.65 ; v2@5752.23,2658.95 ccw(c5735.48,2675.7) 5759.17,2675.7 ccw(c5782.85,2675.7) v2@5766.11,2658.95 ; v2@5755.06,2656.12 ccw(c5745.14,2666.04) 5759.17,2666.04 ccw(c5773.2,2666.04) v2@5763.28,2656.12 ; v1@6078.28,3501.72 ccw(c6062.06,3517.93) 6085,3517.93 ccw(c6107.93,3517.93) v1@6091.72,3501.72 ; v1@6081.11,3498.89 ccw(c6071.72,3508.28) 6085,3508.28 ccw(c6098.28,3508.28) v1@6088.89,3498.89 ; v1(6085,3495) 6085,3545 6071.29,3558.71 6010.88,3558.71 5981.19,3588.39 5981.19,3614.22 5993.12,3626.15 5993.12,3690.81 5978.19,3705.74 5978.19,3770.5 5976.16,3772.53 5939.59,3772.53 5881.33,3772.53 5823.07,3772.53 cw(c5823.07,3796.3) 5799.3,3796.3 ccw(c5783.7,3796.3) 5783.7,3811.9 cw(c5783.7,3835.67) 5759.93,3835.67 ccw(c5744.33,3835.67) 5744.33,3851.27 cw(c5744.33,3875.04) 5727.52,3858.23 5719.79,3864.65 ; U19.1@7550.78,592.84 cw(c7568.16,575.46) 7568.16,600.04 ; 7558.51,600.04 ccw(c7558.51,585.12) U19.1@7547.95,595.67 7547.95,600.04 v1(7631.86,600.04) ; v1@7625.14,593.32 ccw(c7608.92,577.11) 7608.92,600.04 ccw(c7608.92,622.98) v1@7625.14,606.76 ; v1@7627.97,596.15 ccw(c7618.58,586.76) 7618.58,600.04 ccw(c7618.58,613.32) v1@7627.97,603.93
DBUSB.READY: U8.R27 U19.33 | length 6608.3
  Top Layer w4: U8.R27@5882.13,4162.97 cw(c5882.13,4145.25) 5894.66,4157.78 ; U8.R27@5889.47,4170.32 ccw(c5907.19,4170.32) 5894.66,4157.78 ; v1@6035.28,4135.28 ccw(c6019.06,4119.06) 6019.06,4142 ccw(c6019.06,4164.93) v1@6035.28,4148.72 ; v1@6038.11,4138.11 ccw(c6028.72,4128.72) 6028.72,4142 ccw(c6028.72,4155.28) v1@6038.11,4145.89 ; v1(6042,4142) 6013,4142 6010,4145 5998.68,4145 5988.88,4154.81 5901.84,4154.81 cw(c5901.84,4164.96) 5894.66,4157.78
  Bottom Layer w4: v1@6035.28,4148.72 ccw(c6019.06,4164.93) 6042,4164.93 ccw(c6064.93,4164.93) v1@6048.72,4148.72 ; v1@6038.11,4145.89 ccw(c6028.72,4155.28) 6042,4155.28 ccw(c6055.28,4155.28) v1@6045.89,4145.89 ; v1(6042,4142) 6042,4183 6040.5,4184.5 6040.5,4200.25 6052.75,4212.5 6122.21,4212.5 6135,4199.71 6175.29,4199.71 6209.13,4165.87 ; 6216.28,4165.87 6209.13,4165.87 ; 6225,4165.87 6230,4165.87 ; U19.33@7367.96,918.09 ccw(c7361.13,924.92) 7370.79,924.92 ccw(c7380.44,924.92) U19.33@7373.62,918.09 ; U19.33@7370.79,904.33 7370.79,935.66 7386.84,951.71 7571.71,951.71 7640,1020 7640,1255.2 7843.17,1458.37 ; 7843.37,1458.37 7885.37,1500.37 8008.37,1500.37 8078.15,1570.15 8213.31,1570.15 8239.36,1596.19 8239.36,1759.14 8239.36,2299.98 8319,2379.63 8319,3551.7 8239.01,3631.69 8239.01,3720 8238.75,3720 ; 6209.13,4165.87 6230,4165.87 ; 6230,4165.87 6255.77,4165.87 6257.4,4167.5 6417.5,4167.5 6439.97,4189.97 6483.34,4189.97 6487.31,4186 6702.9,4186 6738.86,4150.04 6845.54,4150.04 6846.04,4149.55 6851.01,4149.55 6851.5,4150.04 6990.19,4150.04 7026.15,4186 7368.15,4186 7398.52,4216.37 7532.35,4216.37 7557.02,4191.71 7971.77,4191.71 7982.94,4180.54 8060,4180.54 8093.15,4180.54 8108.15,4180.54 8202,4086.69 8202,3757.01 8203.66,3755.35 ; 8203.66,3755.35 8203.66,3755.09 8238.75,3720 ; 8203.66,3755.35 8238.75,3720.26 8238.75,3720
DBUSB.RESET_N: U8.AG25 U49.3 | length 4994.5
  Top Layer w4: v1@5786.02,3441.38 ccw(c5775.89,3453.91) 5792,3453.91 ; v1@5788.54,3438.28 ccw(c5782.67,3445.53) 5792,3445.53 ccw(c5801.33,3445.53) v1@5795.46,3438.28 ; v1(5792,3434) 5792,3453.91 ; v1@5797.98,3441.38 cw(c5808.11,3453.91) 5792,3453.91 ; v2(6796,2528) 6908,2528 6925,2545 6990,2545 6998,2537 v2(6998,2496) v2@6991.02,2502.98 ; v2@6800.11,2523.89 cw(c6810.03,2513.97) 6810.03,2528 cw(c6810.03,2542.03) v2@6800.11,2532.11 ; v2@6802.94,2521.06 cw(c6819.69,2504.31) 6819.69,2528 cw(c6819.69,2551.69) v2@6802.94,2534.94 ; v2@6991.06,2502.94 ccw(c6974.31,2519.69) 6998,2519.69 ccw(c7021.69,2519.69) v2@7004.94,2502.94 ; v2@6993.89,2500.11 ccw(c6983.97,2510.03) 6998,2510.03 ccw(c7012.03,2510.03) v2@7002.11,2500.11 ; v2@7482,1977.81 ccw(c7482,1991.84) 7491.92,1981.92 ccw(c7501.84,1972) v2@7487.81,1972 ; v2@7482,1981.81 ccw(c7482,2005.5) 7498.75,1988.75 ccw(c7515.5,1972) v2@7491.81,1972 ; v2@7486,1976 7537.81,2027.81 7537.81,2312.38 v2@7509.19,2341 ; v2@7508,2331.19 cw(c7508,2304.63) 7526.78,2323.41 ; v2@7508,2335.19 cw(c7508,2318.29) 7519.95,2330.24 ; v2@7513.81,2341 ccw(c7524.97,2341) 7517.08,2333.11 ; v2@7517.81,2341 ccw(c7538.63,2341) 7523.91,2326.28 ; 5792,3453.91 5803.11,3465.02 5803.11,3479.78 5797.13,3485.76 5797.13,3500.62 5818.89,3522.39 5818.89,3678.16 ; 5815.92,3685.34 cw(c5808.74,3678.16) 5818.89,3678.16 ; 5815.92,3685.34 cw(c5808.74,3678.16) 5818.89,3678.16 ; 5815.92,3685.34 ccw(c5803.39,3672.8) 5803.39,3690.53 cw(c5803.39,3672.8) 5815.92,3685.34 ; 5815.92,3685.34 cw(c5828.45,3697.87) 5810.73,3697.87 ccw(c5828.45,3697.87) 5815.92,3685.34
  MidLayer1 w4: v2@6991.06,2489.06 cw(c6974.31,2472.31) 6998,2472.31 cw(c7021.69,2472.31) v2@7004.94,2489.06 ; v2@6993.89,2491.89 cw(c6983.97,2481.97) 6998,2481.97 cw(c7012.03,2481.97) v2@7002.11,2491.89 ; v2(6998,2496) 6998,2455.75 7012.87,2440.87 7041.69,2440.87 7042.62,2441.81 7065.06,2441.81 7087.06,2463.81 7162.48,2463.81 v2(7312.79,2614.12) ; v2@7302.98,2614.12 cw(c7279.29,2614.12) 7296.04,2597.37 cw(c7312.79,2580.62) v2@7312.79,2604.31 ; v2@7306.98,2614.12 cw(c7292.95,2614.12) 7302.87,2604.2 cw(c7312.79,2594.28) v2@7312.79,2608.31 ; v2@7485,2695.19 cw(c7485,2671.05) 7502.07,2688.12 ; v2@7485,2699.19 cw(c7485,2684.7) 7495.24,2694.95 ; v2(7485,2705) 7485.19,2705 7507.81,2682.38 7507.81,2637.56 7507.5,2637.25 7507.5,2584 7515.81,2575.69 7515.81,2529.87 7504.19,2518.25 7504.19,2468.62 7508,2464.81 v2(7508,2341) ; v2@7490.81,2705 ccw(c7504.38,2705) 7494.79,2695.4 ; v2@7494.81,2705 ccw(c7518.04,2705) 7501.62,2688.57 ; v2@7501.06,2347.94 ccw(c7484.31,2364.69) 7508,2364.69 ccw(c7531.69,2364.69) v2@7514.94,2347.94 ; v2@7503.89,2345.11 ccw(c7493.97,2355.03) 7508,2355.03 ccw(c7522.03,2355.03) v2@7512.11,2345.11
  MidLayer2 w4: v1@5790.19,3441.71 5792,3439.9 v1(5792,3434) 5891,3434 5982.69,3342.31 5982.69,3299.21 6056.86,3225.04 6090.94,3225.04 6099.4,3233.5 6263.99,3233.5 6297.49,3200 6395.9,3200 6464.23,3131.67 ; v1@5795.89,3430.11 cw(c5805.28,3420.72) 5805.28,3434 cw(c5805.28,3447.28) v1@5795.89,3437.89 ; v1@5798.72,3427.28 cw(c5814.93,3411.06) 5814.93,3434 cw(c5814.93,3456.93) v1@5798.72,3440.72 ; 6462.52,3133.37 6464.23,3131.67 ; v2(6796,2528) 6835.52,2567.52 6835.52,2873.35 6729.68,2979.2 6617.02,2979.2 6616.86,2979.04 6464.23,3131.67 ; v2@6796,2533.81 ccw(c6796,2547.84) 6805.92,2537.92 ccw(c6815.84,2528) v2@6801.81,2528 ; v2@6796,2537.81 ccw(c6796,2561.5) 6812.75,2544.75 ccw(c6829.5,2528) v2@6805.81,2528
  Bottom Layer w4: v2@7306,2620.91 v2(7312.79,2614.12) ; v2@7310,2608 7310,2610 7349.54,2649.54 7362.09,2649.54 7417.55,2705 v2(7485,2705) 7485,2711 7486,2712 v2@7485,2712 ; v2@7312.79,2619.93 ccw(c7312.79,2637.16) 7324.98,2624.98 ; v2@7312.79,2623.93 ccw(c7312.79,2650.82) 7331.81,2631.81 ; v2@7322.6,2614.12 cw(c7343.08,2614.12) 7328.6,2628.6 ; v2@7478.06,2698.06 ccw(c7461.31,2681.31) 7461.31,2705 ccw(c7461.31,2728.69) v2@7478.06,2711.94 ; v2@7480.89,2700.89 ccw(c7470.97,2690.97) 7470.97,2705 ccw(c7470.97,2719.03) v2@7480.89,2709.11 ; v2(7482,1972) 7472.19,1962.19 7472.19,1879.38 7472.19,1860 7472.19,1814.62 7485.66,1801.15 7485.66,1645.66 7516.31,1615 7526.69,1604.62 7636.38,1604.62 7647.69,1593.31 U49.3@7652.15,1593.31