# Altium PCB NB3000AL.PcbDoc (part 45 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Top Layer w4: 5894.66,3685.34 cw(c5887.48,3678.16) 5897.63,3678.16 ; 5894.66,3685.34 cw(c5887.48,3678.16) 5897.63,3678.16 ; 5894.66,4261.59 cw(c5901.84,4254.41) 5901.84,4264.56 5940,4264.56 ; 5894.66,4694.66 cw(c5882.13,4707.19) 5882.13,4689.47 ccw(c5882.13,4707.19) 5894.66,4694.66 ; 5894.66,4694.66 ccw(c5907.19,4682.13) 5889.47,4682.13 cw(c5907.19,4682.13) 5894.66,4694.66 ; 5894.66,4694.66 ccw(c5887.48,4701.84) 5897.63,4701.84 ; 5894.66,4694.66 ccw(c5887.48,4701.84) 5897.63,4701.84 ; 6747.21,2127.79 cw(c6760.02,2140.59) 6741.91,2140.59 ccw(c6760.02,2140.59) 6747.21,2127.79 ; 6747.21,2127.79 ccw(c6734.41,2114.98) 6734.41,2133.09 cw(c6734.41,2114.98) 6747.21,2127.79 ; 6786.58,1838.43 cw(c6773.78,1851.24) 6773.78,1833.13 ccw(c6773.78,1851.24) 6786.58,1838.43 ; 6786.58,1838.43 ccw(c6799.39,1825.63) 6781.28,1825.63 cw(c6799.39,1825.63) 6786.58,1838.43 ; 6825.95,1720.32 cw(c6813.15,1733.13) 6813.15,1715.02 ccw(c6813.15,1733.13) 6825.95,1720.32 ; 6825.95,1720.32 ccw(c6838.76,1707.52) 6820.65,1707.52 cw(c6838.76,1707.52) 6825.95,1720.32 ; 6825.95,1799.06 cw(c6813.15,1811.87) 6813.15,1793.76 ccw(c6813.15,1811.87) 6825.95,1799.06 ; 6825.95,1799.06 ccw(c6838.76,1786.26) 6820.65,1786.26 cw(c6838.76,1786.26) 6825.95,1799.06 ; 6825.95,1930.94 cw(c6838.76,1943.74) 6820.65,1943.74 ccw(c6838.76,1943.74) 6825.95,1930.94 ; 6825.95,1930.94 ccw(c6813.15,1918.13) 6813.15,1936.24 cw(c6813.15,1918.13) 6825.95,1930.94 ; 6825.95,2009.68 cw(c6838.76,2022.48) 6820.65,2022.48 ccw(c6838.76,2022.48) 6825.95,2009.68 ; 6825.95,2009.68 ccw(c6813.15,1996.87) 6813.15,2014.98 cw(c6813.15,1996.87) 6825.95,2009.68 ; 6865.32,1641.58 cw(c6852.52,1654.39) 6852.52,1636.28 ccw(c6852.52,1654.39) 6865.32,1641.58 ; 6865.32,1641.58 ccw(c6878.13,1628.78) 6860.02,1628.78 cw(c6878.13,1628.78) 6865.32,1641.58 ; 6865.32,1720.32 cw(c6852.52,1733.13) 6852.52,1715.02 ccw(c6852.52,1733.13) 6865.32,1720.32 ; 6865.32,1720.32 ccw(c6878.13,1707.52) 6860.02,1707.52 cw(c6878.13,1707.52) 6865.32,1720.32 ; 6865.32,2088.42 cw(c6878.13,2101.22) 6860.02,2101.22 ccw(c6878.13,2101.22) 6865.32,2088.42 ; 6865.32,2088.42 ccw(c6852.52,2075.61) 6852.52,2093.72 cw(c6852.52,2075.61) 6865.32,2088.42 ; 6944.06,1680.95 cw(c6931.26,1693.76) 6931.26,1675.65 ccw(c6931.26,1693.76) 6944.06,1680.95 ; 6944.06,1680.95 ccw(c6956.87,1668.15) 6938.76,1668.15 cw(c6956.87,1668.15) 6944.06,1680.95 ; 6944.06,1838.43 cw(c6931.26,1851.24) 6931.26,1833.13 ccw(c6931.26,1851.24) 6944.06,1838.43 ; 6944.06,1838.43 ccw(c6956.87,1825.63) 6938.76,1825.63 cw(c6956.87,1825.63) 6944.06,1838.43 ; 6944.06,1891.57 cw(c6956.87,1904.37) 6938.76,1904.37 ccw(c6956.87,1904.37) 6944.06,1891.57 ; 6944.06,1891.57 ccw(c6931.26,1878.76) 6931.26,1896.87 cw(c6931.26,1878.76) 6944.06,1891.57 ; 6944.06,2049.05 cw(c6956.87,2061.85) 6938.76,2061.85 ccw(c6956.87,2061.85) 6944.06,2049.05 ; 6944.06,2049.05 ccw(c6931.26,2036.24) 6931.26,2054.35 cw(c6931.26,2036.24) 6944.06,2049.05 ; 6983.43,1838.43 cw(c6970.63,1851.24) 6970.63,1833.13 ccw(c6970.63,1851.24) 6983.43,1838.43 ; 6983.43,1838.43 ccw(c6996.24,1825.63) 6978.13,1825.63 cw(c6996.24,1825.63) 6983.43,1838.43 ; 6983.43,1891.57 cw(c6996.24,1904.37) 6978.13,1904.37 ccw(c6996.24,1904.37) 6983.43,1891.57 ; 6983.43,1891.57 ccw(c6970.63,1878.76) 6970.63,1896.87 cw(c6970.63,1878.76) 6983.43,1891.57 ; 7036.57,1838.43 cw(c7023.76,1825.63) 7041.87,1825.63 ccw(c7023.76,1825.63) 7036.57,1838.43 ; 7036.57,1838.43 ccw(c7049.37,1851.24) 7049.37,1833.13 cw(c7049.37,1851.24) 7036.57,1838.43 ; 7036.57,1891.57 cw(c7049.37,1878.76) 7049.37,1896.87 ccw(c7049.37,1878.76) 7036.57,1891.57 ; 7036.57,1891.57 ccw(c7023.76,1904.37) 7041.87,1904.37 cw(c7023.76,1904.37) 7036.57,1891.57 ; 7075.94,1680.95 cw(c7063.13,1668.15) 7081.24,1668.15 ccw(c7063.13,1668.15) 7075.94,1680.95 ; 7075.94,1680.95 ccw(c7088.74,1693.76) 7088.74,1675.65 cw(c7088.74,1693.76) 7075.94,1680.95 ; 7075.94,1838.43 cw(c7063.13,1825.63) 7081.24,1825.63 ccw(c7063.13,1825.63) 7075.94,1838.43 ; 7075.94,1838.43 ccw(c7088.74,1851.24) 7088.74,1833.13 cw(c7088.74,1851.24) 7075.94,1838.43 ; 7075.94,1891.57 cw(c7088.74,1878.76) 7088.74,1896.87 ccw(c7088.74,1878.76) 7075.94,1891.57 ; 7075.94,1891.57 ccw(c7063.13,1904.37) 7081.24,1904.37 cw(c7063.13,1904.37) 7075.94,1891.57 ; 7075.94,2049.05 cw(c7088.74,2036.24) 7088.74,2054.35 ccw(c7088.74,2036.24) 7075.94,2049.05 ; 7075.94,2049.05 ccw(c7063.13,2061.85) 7081.24,2061.85 cw(c7063.13,2061.85) 7075.94,2049.05 ; 7154.68,1641.58 cw(c7141.87,1628.78) 7159.98,1628.78 ccw(c7141.87,1628.78) 7154.68,1641.58 ; 7154.68,1641.58 ccw(c7167.48,1654.39) 7167.48,1636.28 cw(c7167.48,1654.39) 7154.68,1641.58 ; 7154.68,1930.94 cw(c7167.48,1918.13) 7167.48,1936.24 ccw(c7167.48,1918.13) 7154.68,1930.94 ; 7154.68,1930.94 ccw(c7141.87,1943.74) 7159.98,1943.74 cw(c7141.87,1943.74) 7154.68,1930.94 ; 7154.68,2009.68 cw(c7167.48,1996.87) 7167.48,2014.98 ccw(c7167.48,1996.87) 7154.68,2009.68 ; 7154.68,2009.68 ccw(c7141.87,2022.48) 7159.98,2022.48 cw(c7141.87,2022.48) 7154.68,2009.68 ; 7154.68,2088.42 cw(c7167.48,2075.61) 7167.48,2093.72 ccw(c7167.48,2075.61) 7154.68,2088.42 ; 7154.68,2088.42 ccw(c7141.87,2101.22) 7159.98,2101.22 cw(c7141.87,2101.22) 7154.68,2088.42 ; 7194.05,1720.32 cw(c7181.24,1707.52) 7199.35,1707.52 ccw(c7181.24,1707.52) 7194.05,1720.32 ; 7194.05,1720.32 ccw(c7206.85,1733.13) 7206.85,1715.02 cw(c7206.85,1733.13) 7194.05,1720.32 ; 7194.05,1799.06 cw(c7181.24,1786.26) 7199.35,1786.26 ccw(c7181.24,1786.26) 7194.05,1799.06 ; 7194.05,1799.06 ccw(c7206.85,1811.87) 7206.85,1793.76 cw(c7206.85,1811.87) 7194.05,1799.06 ; 7194.05,1891.57 cw(c7206.85,1878.76) 7206.85,1896.87 ccw(c7206.85,1878.76) 7194.05,1891.57 ; 7194.05,1891.57 ccw(c7181.24,1904.37) 7199.35,1904.37 cw(c7181.24,1904.37) 7194.05,1891.57 ; 7194.05,1930.94 cw(c7206.85,1918.13) 7206.85,1936.24 ccw(c7206.85,1918.13) 7194.05,1930.94 ; 7194.05,1930.94 ccw(c7181.24,1943.74) 7199.35,1943.74 cw(c7181.24,1943.74) 7194.05,1930.94 ; 7194.05,2009.68 cw(c7206.85,1996.87) 7206.85,2014.98 ccw(c7206.85,1996.87) 7194.05,2009.68 ; 7194.05,2009.68 ccw(c7181.24,2022.48) 7199.35,2022.48 cw(c7181.24,2022.48) 7194.05,2009.68 ; 7272.79,1602.21 cw(c7259.98,1589.41) 7278.09,1589.41 ccw(c7259.98,1589.41) 7272.79,1602.21 ; 7272.79,1602.21 ccw(c7285.59,1615.02) 7285.59,1596.91 cw(c7285.59,1615.02) 7272.79,1602.21 ; 7272.79,2127.79 cw(c7285.59,2114.98) 7285.59,2133.09 ccw(c7285.59,2114.98) 7272.79,2127.79 ; 7272.79,2127.79 ccw(c7259.98,2140.59) 7278.09,2140.59 cw(c7259.98,2140.59) 7272.79,2127.79 ; v2@4745,3899.81 ccw(c4745,3916.25) 4756.63,3904.63 cw(c4745,3916.25) v2@4745,3899.81
  Top Layer w5: 5220,730 5255,765 5410,765 5457.5,812.5 5457.5,1124.16 5335.69,1245.97 5335.69,2085.51 5420.68,2170.5 5990.5,2170.5 6005,2185 6005,2208.37 ; 5490.49,746.31 cw(c5444.83,702.33) J37.4@5507.67,693.92 ; 5496.81,740.01 cw(c5457.45,700.64) J37.4@5512.63,693.26 ; 5503.96,732.86 cw(c5470.06,698.95) J37.4@5517.58,692.59 ; 5510.36,726.46 ccw(c5529.9,745.99) J37.4@5529.9,718.37 ; 5511.11,725.71 cw(c5482.67,697.26) J37.4@5522.54,691.93 ; 5518.26,718.56 cw(c5495.28,695.58) J37.4@5527.5,691.27 ; 5523.5,915 5523.5,995 ; J37.4@5529.9,690.94 5529.9,706.92 5490.5,746.32 5490.5,1137.83 5379,1249.33 5368.69,1259.65 5368.69,2071.84 5434.35,2137.5 6102.5,2137.5 6140,2175 6140,2208.37 ; 5732.65,802.5 5725,802.5 ; J38.4@5835.45,713.86 ccw(c5819.25,740) 5850,740 ccw(c5880.99,740) J38.4@5864.49,713.76 ; J38.4@5838.08,709.61 ccw(c5824.81,731.02) 5850,731.02 ; J38.4@5840.72,705.36 ccw(c5830.38,722.03) 5850,722.03 ; J38.4@5850,690.55 5850,740 5787.5,802.5 5725,802.5 ; 5850,721.9 ccw(c5869.61,721.9) J38.4@5859.17,705.3 ; 5850,730.95 ccw(c5875.3,730.95) J38.4@5861.83,709.53 ; 6251.63,2217.54 ccw(c6242.36,2226.81) U61.36@6255.47,2226.81 ; U61.36@6258.97,2240 6258.97,2224.88 6138.6,2104.5 5448.02,2104.5 5401.69,2058.17 5401.69,1273.32 5414,1261.01 5523.5,1151.5 5523.5,995 ; v2(6760,1250) 6785.69,1275.69 6785.69,1292 6805.67,1311.98 C237.2@6805.67,1355 ; v2@6760,1259.31 ccw(c6760,1281.79) 6775.89,1265.89 ccw(c6791.79,1250) v2@6769.31,1250 ; C237.2@6799.09,1348.42 cw(c6783.19,1332.52) 6805.67,1332.52 cw(c6828.15,1332.52) C237.2@6812.25,1348.42 ; v2@6873.42,1271.58 ccw(c6860.69,1284.31) 6878.69,1284.31 ; v2@6878.69,1265 6878.69,1332.58 6901.1,1355 ; 6878.69,1278.57 ccw(c6893.57,1278.57) v2@6883.05,1268.05 ; 6878.69,1290.64 ccw(c6905.64,1290.64) v2@6886.58,1271.58 ; 6892.93,1346.82 cw(c6914.33,1325.42) C198.2@6914.33,1355.69 ; 6894.49,1348.39 cw(c6901.13,1341.75) C198.2@6907.76,1348.4 ; 6898.04,1351.93 cw(c6904.67,1345.3) C198.2@6911.29,1351.95 ; 6901.46,1355.36 cw(c6914.33,1342.49) C198.2@6914.33,1360.69 ; 6901.58,1355.47 cw(c6908.2,1348.85) C198.2@6914.82,1355.49 ; C198.2@6905.57,1351.86 ccw(c6901.1,1350.26) 6901.1,1355 ; C198.2@6905.57,1358.14 cw(c6901.1,1359.74) 6901.1,1355 ; C198.2@6914.33,1355 6901.1,1355 ; 5523.5,995 5523.5,803.32 5524.32,802.5 5725,802.5
  Top Layer w6: v2@6467,1493.19 cw(c6467,1471.12) 6482.61,1486.72 ; v2(6467,1502) 6467.33,1502 6471.33,1498 C231.2@6500,1469.33 ; v2@6475.81,1502 ccw(c6496.28,1502) 6481.81,1487.52 ; C231.2@6491.19,1469.33 ccw(c6469.92,1469.33) 6484.96,1484.37 ccw(c6500,1499.41) C231.2@6500,1478.14 ; C222.2@6500,1610.52 cw(c6500,1592.46) 6512.77,1605.23 ; C222.2@6500,1619.33 6500,1618 6518.38,1599.62 v2(6518.38,1577) ; C241.2@6500,1810.67 C241.2@6501.18,1811.85 ; C222.2@6508.81,1619.33 ccw(c6533.3,1619.33) 6515.98,1602.02 ; v2@6512.15,1583.23 ccw(c6497.11,1598.27) 6518.38,1598.27 ccw(c6539.65,1598.27) v2@6524.61,1583.23
  Top Layer w8: v2@6482,1920.19 cw(c6482,1901.33) 6495.33,1914.67 cw(c6508.67,1928) C238.2@6489.81,1928 ; v2(6482,1928) 6500.52,1909.48 6500.52,1884.43 6500,1883.91 6500,1831.86 6501.18,1830.68 ; C238.2@6494.48,1913.81 cw(c6479.89,1899.22) 6500.52,1899.22 ; C241.2@6494.81,1816.51 ccw(c6482.24,1830.68) 6501.18,1830.68 ; 6500.52,1901.73 cw(c6517.6,1901.73) C238.2@6505.52,1913.81 ; C241.2@6501.18,1811.85 6501.18,1830.68 ; 6501.18,1826.67 ccw(c6516.01,1826.67) C241.2@6505.52,1816.19 ; v5(7692.52,4366.89) U7.H7@7712.2,4386.57 ; v5@7692.52,4375.89 ccw(c7692.52,4397.62) 7707.88,4382.25 ccw(c7723.25,4366.89) v5@7701.52,4366.89 ; v5@7692.52,4594.11 cw(c7692.52,4572.38) 7707.88,4587.75 cw(c7723.25,4603.11) v5@7701.52,4603.11 ; v5(7692.52,4603.11) U7.H2@7712.2,4583.43 ; v5(7810.63,4327.52) U7.E8@7830.32,4347.2 ; v5@7810.63,4336.52 ccw(c7810.63,4358.25) 7825.99,4342.88 ccw(c7841.36,4327.52) v5@7819.63,4327.52
  Top Layer w11.81: v1@7539.57,1134.42 cw(c7530.02,1124.87) 7543.52,1124.87 cw(c7557.03,1124.87) v1@7547.48,1134.42 ; SW5.3@7541.89,1085.62 ccw(c7520.35,1110) 7552.87,1110 ccw(c7585.4,1110) SW5.3@7563.86,1085.62 ; v1(7543.52,1138.37) 7543.52,1119.35 7552.87,1110 SW5.3@7552.87,1073.19