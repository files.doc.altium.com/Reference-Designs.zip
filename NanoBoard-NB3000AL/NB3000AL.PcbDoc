# Altium PCB NB3000AL.PcbDoc (part 23 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
AUGND: (continued)
  Bottom Layer w4: -697.3,2289.5 -642.5,2289.5 ; -697.3,2318.12 -697.3,2305.5 -645.81,2305.5 -611.66,2339.65 cw(c-595,2345) -577.5,2345 cw(c-595,2345) -600.35,2328.34 -636.84,2291.84 ; -697.3,2318.31 -697.3,2331.5 ; -697.3,2357.68 -697.3,2354.01 -676.66,2374.65 cw(c-660,2380) -642.5,2380 cw(c-660,2380) -665.35,2363.34 -696.44,2332.24 ; -697.3,3549.69 -668.83,3549.69 -666,3549.69 -661.42,3545.11 -653,3536.69 -653,3500 ; -697.3,3565.69 -668.83,3565.69 ccw(c-668.83,3573.69) -663.76,3567.5 -663.76,3578.58 ; -697.3,3656.7 -697.3,3667 ; -697.3,3683 -697.3,3696.26 ; -697.3,4050.4 -697.3,4060.99 -691.66,4055.35 ccw(c-675,4050) -657.5,4050 ccw(c-675,4050) -658.34,4055.35 -654.38,4059.31 -648.5,4059.31 ; -697.3,4078.18 -697.3,4089.96 ; -695.56,3667 ccw(c-680,3675) -662.5,3675 ccw(c-680,3675) -695.56,3683 ; v1@-343.94,3992.94 cw(c-327.1,3976.1) -327.1,3999.92 ; v1@-341.11,3990.11 cw(c-317.44,3966.44) -317.44,3999.92 ; -340.83,4009.73 cw(c-355,4020) -338.5,4025.83 -338.5,4035.54 -329.18,4035.54 -329.18,4055.37 -338.5,4055.37 -338.5,4090.99 -329.18,4090.99 ; -338.5,4009.73 -338.5,3999.92 -303.86,3999.92 -303.86,4035.54 -313.18,4035.54 -313.18,4055.37 -303.86,4055.37 -303.86,4090.99 -313.18,4090.99 ; -338.5,4231.55 -338.5,4221.73 -329.18,4221.73 -329.18,4201.9 -338.5,4201.9 -338.5,4166.28 -329.18,4166.28 ; v1@-338.28,3987.28 cw(c-307.78,3956.78) -307.78,3999.92 ; -261.52,3693 -261.52,3702.81 -297.14,3702.81 -297.14,3667.19 -272.27,3667.19 ccw(c-255,3670) -237.73,3667.19 -203.86,3667.19 -203.86,3702.81 -213.18,3702.81 -213.18,3722.64 -203.86,3722.64 -203.86,3758.27 -232.59,3758.27 ; -261.5,3792.34 ccw(c-249.43,3792.34) v1@-252.83,3780.76 ; -261.5,3797.69 ccw(c-247.86,3797.69) v1@-251.7,3784.6 ; -261.5,3803.03 ccw(c-246.29,3803.03) v1@-250.58,3788.44 ; -261.5,3808.38 ccw(c-244.72,3808.38) v1@-249.45,3792.28 ; v1@-248.32,3796.12 cw(c-243.15,3813.72) -261.5,3813.72 ; -232.5,3760 ccw(c-250,3760) -267.41,3758.27 -270.82,3758.27 -270.82,3778.1 -261.5,3778.1 -261.5,3813.72 ; -161.52,4065.98 -161.52,4055.37 -197.14,4055.37 -197.14,4090.99 -173.53,4090.99 cw(c-156.5,4095) -163.97,4110.82 -197.14,4110.82 -197.14,4146.45 -182.75,4146.45 -166.6,4162.6 ; -159.34,4067.52 -150.84,4076.02 ; -143.53,5118.08 -143.53,5127.89 -178.17,5127.89 -178.17,5092.27 -143.53,5092.27 -143.53,5099.45 ccw(c-136.53,5104.4) -140.46,5096.77 ; -140.55,5096.97 ccw(c-125,5105) -107.5,5105 ccw(c-125,5105) -138.15,5116.55 ; v1@-81.72,2910.28 cw(c-107.26,2884.74) -71.14,2884.74 ; v1@-78.89,2913.11 cw(c-97.6,2894.4) -71.14,2894.4 ; v1@-76.88,2915.35 ccw(c-62.99,2927.53) -62.99,2909.06 ; v1@-76.06,2915.94 cw(c-87.95,2904.05) -71.14,2904.05 ; v1@-73.87,2917.99 ccw(c-54.16,2935.28) -54.16,2909.06 ; -71.14,2903.39 cw(c-61.39,2903.39) v1@-68.28,2910.28 ; v1@-70.87,2920.63 ccw(c-45.33,2943.03) -45.33,2909.06 ; v1@-67.86,2923.27 ccw(c-36.5,2950.77) -36.5,2909.06 ; -36.5,2899.25 -36.5,2909.06 -71.14,2909.06 -71.14,2873.44 -36.5,2873.44 -36.5,2883.25 -28.6,2883.25 ; -35.47,2899.25 cw(c-18.14,2901.71) -0.64,2901.71 cw(c-18.14,2901.71) -23.53,2885.06 ; v1@39.28,5033.72 ccw(c15.87,5057.13) 48.98,5057.13 ; v1@42.11,5030.89 ccw(c25.53,5047.47) 48.98,5047.47 ; 48.98,5042.74 ccw(c61.74,5042.74) v1@52.72,5033.72 ; 58.79,5034.48 ccw(c73.52,5025.04) 91.02,5025.04 ccw(c73.52,5025.04) 84.6,5038.59 84.6,5072.89 48.98,5072.89 48.98,5037.27 58.79,5037.27 ; 148.48,2812.41 cw(c160.86,2800.04) 178.36,2800.04 cw(c160.86,2800.04) 148.48,2787.67 148.48,2777.19 112.86,2777.19 112.86,2812.81 123.18,2812.81 123.18,2827.19 113.86,2827.19 113.86,2862.81 148.5,2862.81 148.5,2827.19 139.18,2827.19 139.18,2812.81 148.48,2812.81 ; 148.48,2877.19 112.86,2877.19 112.86,2912.81 123.18,2912.81 123.18,2927.19 113.86,2927.19 113.86,2962.81 148.5,2962.81 148.5,2927.19 139.18,2927.19 139.18,2912.81 148.48,2912.81 148.48,2904.08 cw(c160.86,2891.71) 178.36,2891.71 cw(c160.86,2891.71) 148.48,2879.34 ; 199.5,4898.52 ccw(c199.5,4947.39) v1@234.11,4912.88 ; 209.13,4898.52 ccw(c209.13,4937.78) v1@236.94,4910.06 ; 218.77,4898.52 ccw(c218.77,4928.17) v1@239.77,4907.23 ; 228.41,4898.52 ccw(c228.41,4918.56) v1@242.6,4904.41 ; v1@231.27,4915.71 cw(c189.86,4957) 189.86,4898.52 ; v1@325.14,2759.99 cw(c308.92,2743.77) 331.86,2743.77 cw(c354.79,2743.77) v1@338.57,2759.99 ; v1@327.97,2762.82 cw(c318.58,2753.43) 331.86,2753.43 cw(c345.14,2753.43) v1@335.75,2762.82 ; 331.86,2723.04 v1(331.86,2766.71) ; 552,2633.37 560,2625.38 ; 721.97,2995.81 cw(c721.97,2935.97) v1@764.28,2978.28 ; 731.63,2995.81 cw(c731.63,2945.63) v1@767.11,2981.11 ; C146.2@740.78,2603.22 ccw(c701.17,2642.83) 757.19,2642.83 ; 741.29,2995.81 cw(c741.29,2955.29) v1@769.94,2983.94 ; v1@743.61,2600.39 ccw(c710.83,2633.17) 757.19,2633.17 ; v1@746.44,2597.56 ccw(c720.48,2623.52) 757.19,2623.52 ; v1@749.27,2594.73 ccw(c730.14,2613.86) 757.19,2613.86 ; 750.94,2995.81 cw(c750.94,2964.94) v1@772.77,2986.77 ; v1@752.1,2591.9 ccw(c739.8,2604.2) 757.19,2604.2 ; 760.6,2995.81 cw(c760.6,2974.6) v1@775.6,2989.6 ; 764.02,2684.87 cw(c776.88,2684.87) v1@774.86,2697.57 ; 764.02,2689.56 cw(c776.14,2689.56) v1@774.24,2701.52 ; 764.02,2694.24 cw(c775.39,2694.24) v1@773.61,2705.47 ; 764.02,2711.39 ccw(c782.39,2711.39) v1@769.4,2698.4 ; 764.02,2721.05 ccw(c792.05,2721.05) v1@772.23,2701.23 ; 764.02,2730.7 ccw(c801.7,2730.7) v1@775.06,2704.06 ; 764.02,2740.36 ccw(c811.36,2740.36) v1@777.89,2706.89 ; 764.02,2750.02 ccw(c821.02,2750.02) v1@780.72,2709.72 ; v1@771,2975.5 cw(c771,2917.35) 812.12,2958.47 ; v1@771,2979.5 cw(c771,2931.01) 805.29,2965.3 ; v1@771,2983.5 cw(c771,2944.67) 798.46,2972.13 ; v1@771,2987.5 cw(c771,2958.32) 791.63,2978.95 ; v1@771,2991.5 cw(c771,2971.98) 784.8,2985.78 ; 790.92,358.84 cw(c815.82,358.84) v1@804.98,381.26 ; 790.92,365.22 cw(c812.74,365.22) v1@803.24,384.86 ; 790.92,371.59 cw(c809.66,371.59) v1@801.5,388.46 ; 790.92,377.97 cw(c806.58,377.97) v1@799.76,392.06 ; 790.92,399.67 ccw(c803.67,399.67) v1@800.16,387.41 ; 790.92,404.98 ccw(c805.2,404.98) v1@801.26,391.25 ; 790.92,410.28 ccw(c806.72,410.28) v1@802.37,395.1 ; v1@803.47,398.94 cw(c808.24,415.59) 790.92,415.59 ; v1@1009.14,375.94 ccw(c1009.11,385.91) 1019.08,385.91 ; v1@1009.13,379.94 ccw(c1009.1,389.92) 1019.08,389.92 ; v1@1009.12,383.94 ccw(c1009.08,393.94) 1019.08,393.94 ; v1@1009.16,371.94 ccw(c1009.12,381.9) 1019.08,381.9 ; 1094.07,359.39 cw(c1109.48,359.39) v10@1108.25,374.75 ; 1094.07,363.72 cw(c1109.13,363.72) v10@1107.93,378.73 ; 1094.07,368.05 cw(c1108.79,368.05) v10@1107.61,382.72 ; 1094.07,372.39 cw(c1108.44,372.39) v10@1107.3,386.71 ; 1094.07,376.72 cw(c1108.09,376.72) v10@1106.98,390.7 ; v10@1104.81,395.41 ccw(c1100.24,415.59) 1120.93,415.59 ; v10@1105.7,391.51 ccw(c1101.37,410.58) 1120.93,410.58 ; v10@1106.58,387.61 ccw(c1102.51,405.57) 1120.93,405.57 ; v10@1107.4,374.72 cw(c1107.13,360.92) 1120.93,360.92 ; v10@1107.48,378.72 cw(c1107.21,365) 1120.93,365 ; v10@1107.46,383.71 ccw(c1103.64,400.57) 1120.93,400.57 ; v10@1107.56,382.72 cw(c1107.29,369.09) 1120.93,369.09 ; v10@1107.64,386.72 cw(c1107.37,373.17) 1120.93,373.17 ; v10@1107.73,390.72 cw(c1107.46,377.25) 1120.93,377.25 ; v10@1108.35,379.81 ccw(c1104.78,395.56) 1120.93,395.56 ; v10@1109.23,375.91 ccw(c1105.91,390.55) 1120.93,390.55 ; v1@1110.99,214.52 ccw(c1110.96,224.49) 1120.93,224.49 ; v1@1110.98,218.52 ccw(c1110.95,228.51) 1120.93,228.51 ; v1@1110.97,222.52 ccw(c1110.93,232.52) 1120.93,232.52 ; v1@1111.01,210.52 ccw(c1110.97,220.48) 1120.93,220.48 ; 1144.98,983.71 1097.42,983.71 cw(c1081.86,991.71) 1097.42,999.71 1148.29,999.71 ; 1146.33,982.36 1146.33,967.81 1136.52,967.81 1136.52,932.19 1172.14,932.19 1172.14,967.81 1162.33,967.81 1162.33,985.67 ; 1195.92,199.21 cw(c1207.92,199.21) v1@1206.5,211.12 ; 1195.92,203.71 cw(c1207.38,203.71) v1@1206.03,215.09 ; 1195.92,208.22 cw(c1206.85,208.22) v1@1205.56,219.07 ; 1195.92,358.84 cw(c1220.82,358.84) v1@1209.98,381.26 ; 1195.92,365.22 cw(c1217.74,365.22) v1@1208.24,384.86 ; 1195.92,371.59 cw(c1214.66,371.59) v1@1206.5,388.46 ; 1195.92,377.97 cw(c1211.58,377.97) v1@1204.76,392.06 ; 1195.92,399.67 ccw(c1208.67,399.67) v1@1205.16,387.41 ; 1195.92,404.98 ccw(c1210.2,404.98) v1@1206.26,391.25 ; 1195.92,410.28 ccw(c1211.72,410.28) v1@1207.37,395.1 ; v1@1208.47,398.94 cw(c1213.24,415.59) 1195.92,415.59 ; v1@1375.24,975 ccw(c1387.08,981.17) 1387.08,967.81 ; v1@1378.78,976.84 ccw(c1393.68,984.61) 1393.68,967.81 ; v1@1382.33,978.69 ccw(c1400.27,988.05) 1400.27,967.81 ; v1@1385.88,980.54 ccw(c1406.87,991.48) 1406.87,967.81 ; v1@1389.42,982.39 ccw(c1413.47,994.92) 1413.47,967.81 ; v1@1414.14,261.77 ccw(c1414.11,271.74) 1424.08,271.74 ; v1@1414.13,265.77 ccw(c1414.1,275.75) 1424.08,275.75 ; v1@1414.12,269.77 ccw(c1414.08,279.76) 1424.08,279.76 ; v1@1414.14,375.94 ccw(c1414.11,385.91) 1424.08,385.91 ; v1@1414.13,379.94 ccw(c1414.1,389.92) 1424.08,389.92 ; v1@1414.12,383.94 ccw(c1414.08,393.94) 1424.08,393.94 ; v1@1414.16,257.77 ccw(c1414.12,267.72) 1424.08,267.72 ; v1@1414.16,371.94 ccw(c1414.12,381.9) 1424.08,381.9 ; 1445.51,852 1290.56,852 cw(c1275,860) 1290.56,868 1445.82,868 1445.82,932.19 1436.5,932.19 1436.5,942 1413.47,942 1413.47,932.19 1377.85,932.19 1377.85,967.81 1413.47,967.81 ; 1445.82,851.69 1445.82,572.76 ; 1499.07,246.45 cw(c1511.07,246.45) v1@1509.65,258.37 ; 1499.07,250.96 cw(c1510.53,250.96) v1@1509.18,262.34 ; 1499.07,255.46 cw(c1510,255.46) v1@1508.7,266.31 ; 1499.07,359.39 cw(c1514.48,359.39) v10@1513.25,374.75 ; 1499.07,363.72 cw(c1514.13,363.72) v10@1512.93,378.73 ; 1499.07,368.05 cw(c1513.79,368.05) v10@1512.61,382.72 ; 1499.07,372.39 cw(c1513.44,372.39) v10@1512.3,386.71 ; 1499.07,376.72 cw(c1513.09,376.72) v10@1511.98,390.7 ; v10@1509.81,395.41 ccw(c1505.24,415.59) 1525.93,415.59 ; v10@1510.7,391.51 ccw(c1506.37,410.58) 1525.93,410.58 ; v10@1511.58,387.61 ccw(c1507.51,405.57) 1525.93,405.57 ; v10@1512.4,374.72 cw(c1512.13,360.92) 1525.93,360.92 ; v10@1512.48,378.72 cw(c1512.21,365) 1525.93,365 ; v10@1512.46,383.71 ccw(c1508.64,400.57) 1525.93,400.57 ; v10@1512.56,382.72 cw(c1512.29,369.09) 1525.93,369.09 ; v10@1512.64,386.72 cw(c1512.37,373.17) 1525.93,373.17 ; v10@1512.73,390.72 cw(c1512.46,377.25) 1525.93,377.25 ; v10@1513.35,379.81 ccw(c1509.78,395.56) 1525.93,395.56 ; v10@1514.23,375.91 ccw(c1510.91,390.55) 1525.93,390.55 ; 1573.52,942 v1(1615,950) ; 1600.92,358.84 cw(c1625.82,358.84) v1@1614.98,381.26 ; 1600.92,365.22 cw(c1622.74,365.22) v1@1613.24,384.86 ; 1600.92,371.59 cw(c1619.66,371.59) v1@1611.5,388.46 ; 1600.92,377.97 cw(c1616.58,377.97) v1@1609.76,392.06 ; 1600.92,399.67 ccw(c1613.67,399.67) v1@1610.16,387.41 ; 1600.92,404.98 ccw(c1615.2,404.98) v1@1611.26,391.25 ; 1600.92,410.28 ccw(c1616.72,410.28) v1@1612.37,395.1 ; v1@1607.13,955.32 cw(c1588.14,968.18) 1592.48,945.66 cw(c1596.82,923.14) v1@1609.68,942.13 ; v1@1610.44,953.08 cw(c1599.45,960.52) 1601.96,947.49 cw(c1604.48,934.45) v1@1611.92,945.44 ; v1@1613.47,398.94 cw(c1618.24,415.59) 1600.92,415.59 ; v1@1819.14,375.94 ccw(c1819.11,385.91) 1829.08,385.91 ; v1@1819.13,379.94 ccw(c1819.1,389.92) 1829.08,389.92 ; v1@1819.12,383.94 ccw(c1819.08,393.94) 1829.08,393.94 ; v1@1819.16,371.94 ccw(c1819.12,381.9) 1829.08,381.9 ; 1904.07,359.39 cw(c1919.48,359.39) v10@1918.25,374.75 ; 1904.07,363.72 cw(c1919.13,363.72) v10@1917.93,378.73 ; 1904.07,368.05 cw(c1918.79,368.05) v10@1917.61,382.72 ; 1904.07,372.39 cw(c1918.44,372.39) v10@1917.3,386.71 ; 1904.07,376.72 cw(c1918.09,376.72) v10@1916.98,390.7 ; v10@1914.81,395.41 ccw(c1910.24,415.59) 1930.93,415.59 ; v10@1915.7,391.51 ccw(c1911.37,410.58) 1930.93,410.58 ; v10@1916.58,387.61 ccw(c1912.51,405.57) 1930.93,405.57 ; v10@1917.4,374.72 cw(c1917.13,360.92) 1930.93,360.92 ; v10@1917.48,378.72 cw(c1917.21,365) 1930.93,365 ; v10@1917.46,383.71 ccw(c1913.64,400.57) 1930.93,400.57 ; v10@1917.56,382.72 cw(c1917.29,369.09) 1930.93,369.09 ; v10@1917.64,386.72 cw(c1917.37,373.17) 1930.93,373.17 ; v10@1917.73,390.72 cw(c1917.46,377.25) 1930.93,377.25 ; v10@1918.35,379.81 ccw(c1914.78,395.56) 1930.93,395.56 ; v10@1919.23,375.91 ccw(c1915.91,390.55) 1930.93,390.55 ; v1@1920.99,214.52 ccw(c1920.96,224.49) 1930.93,224.49 ; v1@1920.98,218.52 ccw(c1920.95,228.51) 1930.93,228.51 ; v1@1920.97,222.52 ccw(c1920.93,232.52) 1930.93,232.52 ; v1@1921.01,210.52 ccw(c1920.97,220.48) 1930.93,220.48 ; 2005.92,199.21 cw(c2017.92,199.21) v1@2016.5,211.12 ; 2005.92,203.71 cw(c2017.38,203.71) v1@2016.03,215.09 ; 2005.92,208.22 cw(c2016.85,208.22) v1@2015.56,219.07 ; 2005.92,358.84 cw(c2030.82,358.84) v1@2019.98,381.26 ; 2005.92,365.22 cw(c2027.74,365.22) v1@2018.24,384.86 ; 2005.92,371.59 cw(c2024.66,371.59) v1@2016.5,388.46 ; 2005.92,377.97 cw(c2021.58,377.97) v1@2014.76,392.06 ; 2005.92,399.67 ccw(c2018.67,399.67) v1@2015.16,387.41 ; 2005.92,404.98 ccw(c2020.2,404.98) v1@2016.26,391.25 ; 2005.92,410.28 ccw(c2021.72,410.28) v1@2017.37,395.1 ; v1@2018.47,398.94 cw(c2023.24,415.59) 2005.92,415.59 ; v1@2224.14,261.77 ccw(c2224.11,271.74) 2234.08,271.74 ; v1@2224.13,265.77 ccw(c2224.1,275.75) 2234.08,275.75 ; v1@2224.12,269.77 ccw(c2224.08,279.76) 2234.08,279.76 ; v1@2224.14,375.94 ccw(c2224.11,385.91) 2234.08,385.91 ; v1@2224.13,379.94 ccw(c2224.1,389.92) 2234.08,389.92 ; v1@2224.12,383.94 ccw(c2224.08,393.94) 2234.08,393.94 ; v1@2224.16,257.77 ccw(c2224.12,267.72) 2234.08,267.72 ; v1@2224.16,371.94 ccw(c2224.12,381.9) 2234.08,381.9 ; 2299.76,219.6 cw(c2271.57,244.33) 2234.08,244.33 2234.08,279.76 ; 2309.07,260 2309.07,279.76 ccw(c2271.57,279.76) 2279.57,316.4 2279.57,321.87 ccw(c2271.57,358.5) 2309.07,358.5 2309.07,393.94 ccw(c2271.57,393.94) 2279.57,430.57 2279.57,843.43 ; 2309.07,360.63 cw(c2321.07,360.63) v1@2319.65,372.54 ; 2309.07,365.13 cw(c2320.53,365.13) v1@2319.18,376.51 ; 2309.07,369.63 cw(c2320,369.63) v1@2318.7,380.48 ; -689.53,4075.84 ccw(c-695.18,4070.18) -695.18,4078.18 cw(c-695.18,4070.18) -689.53,4075.84 ; -689.53,4075.84 -680.35,4066.66 cw(c-675,4050) -669.65,4066.66 -663.35,4072.97 ; -663.76,3578.58 cw(c-655.76,3578.58) -661.42,3584.24 ; -663.76,3578.58 cw(c-655.76,3578.58) -661.42,3584.24 ; -663.35,4072.97 cw(c-657.69,4067.31) -657.69,4075.31 ; -663.35,4072.97 cw(c-657.69,4067.31) -657.69,4075.31 ; -661.42,3584.24 -624.22,3621.44 ; -657.69,4075.31 -648.5,4075.31 ; -653,3500 ccw(c-645,3500) -650.66,3494.34 ; -653,3500 ccw(c-645,3500) -650.66,3494.34 ; -650.66,3494.34 -618.16,3461.84 ; -648.5,4059.31 -630,4059.31 ; -648.5,4059.31 -630,4059.31 ; -648.5,4075.31 -630,4075.31 ; -648.5,4075.31 -630,4075.31 ; -642.5,2289.5 ccw(c-642.5,2297.5) -636.84,2291.84 ; -642.5,2289.5 ccw(c-642.5,2297.5) -636.84,2291.84 ; -639.34,3545.66 cw(c-645,3540) -637,3540 ; -639.34,3545.66 cw(c-645,3540) -637,3540 ; -639.34,3545.66 -647.76,3554.08 -647.76,3575.27 -613.03,3610 -507,3610 ; -637,3540 -637,3503.31 -609.19,3475.5 -153.49,3475.5 -146.63,3482.36 ; -630,4059.31 -555.31,4059.31 ; -630,4075.31 -558.63,4075.31 -484.5,4149.44 -484.5,4162 -484.5,4540 ; -624.22,3621.44 cw(c-617,3618) -617,3626 ; -624.22,3621.44 cw(c-617,3618) -617,3626 ; -618.16,3461.84 ccw(c-612.5,3467.5) -612.5,3459.5 ; -618.16,3461.84 ccw(c-612.5,3467.5) -612.5,3459.5 ; -617,3626 -510.31,3626 -388,3748.31 -388,3924.44 cw(c-380,3940) -362.5,3940 cw(c-380,3940) -372,3924.44 -372,3745 ; -612.5,3459.5 -150.18,3459.5 ; -555.31,4059.31 ccw(c-555.31,4067.31) -549.66,4061.65 ; -555.31,4059.31 ccw(c-555.31,4067.31) -549.66,4061.65 ; -549.66,4061.65 -470.84,4140.47 ; -507,3610 ccw(c-507,3618) -501.34,3612.34 ; -507,3610 ccw(c-507,3618) -501.34,3612.34 ; -501.34,3612.34 -374.34,3739.34 ; -484.5,4540 cw(c-476.5,4540) -482.16,4545.66 ; -484.5,4540 cw(c-476.5,4540) -482.16,4545.66 ; -482.16,4545.66 -436,4591.81 -436,4732 ; -470.84,4140.47 ccw(c-476.5,4146.12) -468.5,4146.12 ; -470.84,4140.47 ccw(c-476.5,4146.12) -468.5,4146.12 ; -468.5,4146.12 -468.5,4536.69 -422.34,4582.84 ; -453,4965 cw(c-445,4965) -450.66,4970.66 ; -453,4965 cw(c-445,4965) -450.66,4970.66 ; -453,4965 -453,4810.56 ccw(c-445,4795) -427.5,4795 ccw(c-445,4795) -437,4810.56 -437,4961.69 -386.69,5012 -295,5012 ; -450.66,4970.66 -395.66,5025.66 ; -436,4732 cw(c-428,4732) -433.66,4737.66 ; -436,4732 cw(c-428,4732) -433.66,4737.66 ; -433.66,4737.66 -410.66,4760.66 ; -422.34,4582.84 ccw(c-428,4588.5) -420,4588.5 ; -422.34,4582.84 ccw(c-428,4588.5) -420,4588.5 ; -420,4588.5 -420,4728.69 -401.69,4747 -255.91,4747 ; -410.66,4760.66 cw(c-405,4755) -405,4763 ; -410.66,4760.66 cw(c-405,4755) -405,4763 ; -405,4763 -259.22,4763 -253.91,4768.31 -253.91,4792.03 -303.09,4792.03 -303.09,4898.52 -243,4898.52 -243,4909.44 cw(c-235,4925) -217.5,4925 cw(c-235,4925) -227,4909.44 -227,4898.52 -188.72,4898.52 -188.72,4792.03 -237.91,4792.03 -237.91,4765 ; -395.66,5025.66 cw(c-390,5020) -390,5028 ; -395.66,5025.66 cw(c-390,5020) -390,5028 ; -390,5028 -298.31,5028 -281.66,5044.65 cw(c-265,5050) -253.38,5063.08 -220.51,5063.08 -220.51,5072.89 -184.89,5072.89 -184.89,5037.27 -220.51,5037.27 -220.51,5047.08 -247.74,5047.08 cw(c-265,5050) -270.35,5033.34 -289.34,5014.34 ; -376.14,4267.37 ccw(c-368.14,4267.37) -373.8,4261.72 ; -376.14,4267.37 ccw(c-368.14,4267.37) -373.8,4261.72 ; -376.14,4267.37 -376.14,4292.81 cw(c-368.14,4308.37) -350.64,4308.37 cw(c-368.14,4308.37) -360.14,4292.81 -360.14,4270.69 -338.5,4249.05 -338.5,4257.36 -303.86,4257.36 -303.86,4221.73 -313.18,4221.73 -313.18,4201.9 -303.86,4201.9 -303.86,4166.28 -313.18,4166.28 ; -374.34,3739.34 ccw(c-380,3745) -372,3745 ; -374.34,3739.34 ccw(c-380,3745) -372,3745 ; -373.8,4261.72 -345.97,4233.89 ; -345.97,4233.89 ccw(c-340.31,4239.55) -340.31,4231.55 cw(c-340.31,4239.55) -345.97,4233.89 ; -329.18,4090.99 -329.18,4110.82 ; -329.18,4090.99 -329.18,4110.82 ; -329.18,4090.99 -329.18,4110.82 ; -329.18,4110.82 -338.5,4110.82 -338.5,4146.45 -329.18,4146.45 ; -329.18,4146.45 -329.18,4166.28 ; -329.18,4146.45 -329.18,4166.28 ; -329.18,4146.45 -329.18,4166.28 ; -313.18,4090.99 -313.18,4110.82 ; -313.18,4090.99 -313.18,4110.82 ; -313.18,4090.99 -313.18,4110.82 ; -313.18,4110.82 -303.86,4110.82 -303.86,4146.45 -313.18,4146.45 ; -313.18,4146.45 -313.18,4166.28 ; -313.18,4146.45 -313.18,4166.28 ; -313.18,4146.45 -313.18,4166.28 ; -295,5012 ccw(c-295,5020) -289.34,5014.34 ; -295,5012 ccw(c-295,5020) -289.34,5014.34 ; -261.5,3813.72 -296.14,3813.72 -296.14,3778.1 -286.82,3778.1 -286.82,3758.27 -296.14,3758.27 -296.14,3722.64 -261.5,3722.64 -261.5,3733.71 -252.11,3733.71 ; -255.91,4747 ccw(c-255.91,4755) -250.25,4749.34 ; -255.91,4747 ccw(c-255.91,4755) -250.25,4749.34 ; -255.78,3690.66 ccw(c-261.44,3685) -261.44,3693 cw(c-261.43,3685) -255.78,3690.66 ; -255.78,3690.66 -252.43,3687.31 cw(c-255,3670) -238.5,3675.83 -238.5,3702.81 -229.18,3702.81 -229.18,3722.64 -238.5,3722.64 -238.5,3732.45 -247.81,3732.45 ; -252.11,3733.71 ccw(c-247.81,3740.45) -247.81,3732.45 ; -252.11,3733.71 ccw(c-247.81,3740.45) -247.81,3732.45 ; -250.25,4749.34 -240.25,4759.34 ; -240.25,4759.34 ccw(c-245.91,4765) -237.91,4765 ; -240.25,4759.34 ccw(c-245.91,4765) -237.91,4765 ; -228.67,3574.71 ccw(c-220.67,3574.71) -226.33,3569.05 ; -228.67,3574.71 ccw(c-220.67,3574.71) -226.33,3569.05 ; -228.67,3574.71 -228.67,3607.19 -238.48,3607.19 -238.48,3642.81 -202.86,3642.81 -202.86,3607.19 -212.67,3607.19 -212.67,3578.02 -202.51,3567.86 -175.37,3567.86 cw(c-159.81,3559.86) -142.31,3559.86 cw(c-159.81,3559.86) -175.37,3551.86 -205.82,3551.86 ; -226.33,3569.05 -211.48,3554.2 ; -211.48,3554.2 ccw(c-205.82,3559.86) -205.82,3551.86 ; -211.48,3554.2 ccw(c-205.82,3559.86) -205.82,3551.86 ; -166.6,4162.6 cw(c-160.94,4156.94) -160.94,4164.94 ; -166.6,4162.6 cw(c-160.94,4156.94) -160.94,4164.94 ; -160.94,4164.94 -136.94,4164.94 ; -150.84,4076.02 ccw(c-156.5,4081.68) -148.88,4079.25 ; -150.84,4076.02 ccw(c-156.5,4081.68) -148.88,4079.25 ; -150.18,3459.5 ccw(c-150.18,3467.5) -144.52,3461.84 ; -150.18,3459.5 ccw(c-150.18,3467.5) -144.52,3461.84 ; -148.88,4079.25 ccw(c-156.5,4095) -139,4095 ccw(c-156.5,4095) -161.52,4111.76 -161.52,4145.05 -157.63,4148.94 -140.25,4148.94 -131.66,4140.35 ccw(c-115,4135) -97.5,4135 ccw(c-115,4135) -120.35,4151.66 -131.28,4162.6 ; -146.63,3482.36 cw(c-140.97,3476.71) -140.97,3484.71 ; -146.63,3482.36 cw(c-140.97,3476.71) -140.97,3484.71 ; -144.52,3461.84 -137.66,3468.71 -115.29,3468.71 -99.3,3452.72 ; -143,4350 ccw(c-135,4350) -140.66,4344.34 ; -143,4350 ccw(c-135,4350) -140.66,4344.34 ; -143,4350 -143,4390 ; -143,4390 cw(c-135,4390) -140.66,4395.66 ; -143,4390 cw(c-135,4390) -140.66,4395.66 ; -140.97,3484.71 -111.98,3484.71 ; -140.66,4344.34 -125.66,4329.34 ; -140.66,4395.66 -125.66,4410.66 ; -138.15,5116.55 ccw(c-142.85,5110.08) -142.85,5118.08 cw(c-142.85,5110.08) -138.15,5116.55 ; -136.94,4164.94 cw(c-136.94,4156.94) -131.28,4162.6 ; -136.94,4164.94 cw(c-136.94,4156.94) -131.28,4162.6 ; -135.85,5284.75 cw(c-135.85,5276.75) -131.75,5283.62 ; -135.85,5284.75 cw(c-135.85,5276.75) -131.75,5283.62 ; -135.85,5284.75 -143.53,5284.75 -143.53,5294.56 -178.17,5294.56 -178.17,5258.94 -143.53,5258.94 -143.53,5265.05 ccw(c-126.14,5267.04) -108.64,5267.04 ccw(c-126.14,5267.04) -131.75,5283.62 ; -135.66,4969.38 ccw(c-130,4975.04) -130,4967.04 ; -135.66,4969.38 ccw(c-130,4975.04) -130,4967.04 ; -135.66,4969.38 -138.27,4972 -249.44,4972 cw(c-265,4980) -249.44,4988 -134.96,4988 ; -134.96,4988 cw(c-134.96,4980) -129.3,4985.66 ; -134.96,4988 cw(c-134.96,4980) -129.3,4985.66 ; -130,4967.04 -52,4967.04 84.71,4967.04 ; -129.3,4985.66 -126.69,4983.04 -71.2,4983.04 ; -125.66,4329.34 ccw(c-120,4335) -120,4327 ; -125.66,4329.34 ccw(c-120,4335) -120,4327 ; -125.66,4410.66 cw(c-120,4405) -120,4413 ; -125.66,4410.66 cw(c-120,4405) -120,4413 ; -120,4327 -93.27,4327 -83,4316.73 -83,4212.4 -103.31,4192.09 -161.52,4192.09 -161.52,4201.9 -197.14,4201.9 -197.14,4166.28 -161.52,4166.28 -161.52,4176.09 -100,4176.09 ; -120,4413 46.69,4413 109.84,4476.16 ; -111.98,3484.71 cw(c-111.98,3476.71) -106.32,3482.36 ; -111.98,3484.71 cw(c-111.98,3476.71) -106.32,3482.36 ; -106.32,3482.36 -90.33,3466.37 161.71,3466.37 ; -100,4176.09 ccw(c-100,4184.09) -94.34,4178.43 ; -100,4176.09 ccw(c-100,4184.09) -94.34,4178.43 ; -99.3,3452.72 ccw(c-93.65,3458.37) -93.65,3450.37 ; -99.3,3452.72 ccw(c-93.65,3458.37) -93.65,3450.37 ; -98.42,5396.42 cw(c-98.42,5388.42) -92.76,5394.07 ; -98.42,5396.42 cw(c-98.42,5388.42) -92.76,5394.07 ; -98.42,5396.42 -143.53,5396.42 -143.53,5406.23 -178.17,5406.23 -178.17,5370.6 -143.53,5370.6 -143.53,5380.42 -101.73,5380.42 -72.81,5351.5 -72.81,4987.85 ; -95,3803.91 cw(c-95,3795.91) -89.34,3801.57 ; -95,3803.91 cw(c-95,3795.91) -89.34,3801.57 ; -95,3803.91 -161.52,3803.91 -161.52,3813.72 -197.14,3813.72 -197.14,3778.1 -161.52,3778.1 -161.52,3787.91 -98.31,3787.91 -94.75,3784.34 ; -94.75,3784.34 ccw(c-89.09,3790) -89.09,3782 ; -94.75,3784.34 ccw(c-89.09,3790) -89.09,3782 ; -94.34,4178.43 -69.34,4203.43 ; -93.65,3450.37 158.39,3450.37 164,3444.77 164,3310.19 ; -92.76,5394.07 -59.15,5360.47 ; -89.96,4343 cw(c-89.96,4335) -84.3,4340.66 ; -89.96,4343 cw(c-89.96,4335) -84.3,4340.66 ; -89.96,4343 -116.69,4343 -127,4353.31 -127,4386.69 -116.69,4397 50,4397 ; -89.34,3801.57 -85.78,3798 -50.56,3798 cw(c-35,3790) -17.5,3790 cw(c-35,3790) -50.56,3782 -89.09,3782 ; -84.3,4340.66 -69.34,4325.7 ; -72.81,4987.85 ccw(c-64.81,4987.85) -71.2,4983.04 ; -72.81,4987.85 ccw(c-64.81,4987.85) -71.2,4983.04 ; -69.34,4203.43 ccw(c-75,4209.09) -67,4209.09 ; -69.34,4203.43 ccw(c-75,4209.09) -67,4209.09 ; -69.34,4325.7 cw(c-75,4320.04) -67,4320.04 ; -69.34,4325.7 cw(c-75,4320.04) -67,4320.04 ; -67,4209.09 -67,4320.04 ; -59.15,5360.47 cw(c-64.81,5354.81) -56.81,5354.81 ; -59.15,5360.47 cw(c-64.81,5354.81) -56.81,5354.81 ; -56.81,5354.81 -56.81,4991.16 -48.69,4983.04 88,4983.04 ; -28.6,2883.25 ccw(c-28.6,2891.25) -23.53,2885.06 ; -28.6,2883.25 ccw(c-28.6,2891.25) -23.53,2885.06 ; -28.18,2632 ccw(c-28.18,2640) -22.53,2634.34 ; -28.18,2632 ccw(c-28.18,2640) -22.53,2634.34 ; -28.18,2632 -36.5,2632 -36.5,2622.19 -71.14,2622.19 -71.14,2657.81 -36.5,2657.81 -36.5,2648 -31.5,2648 -26.47,2653.03 cw(c-9.81,2658.37) 7.69,2658.37 cw(c-9.81,2658.37) -15.16,2641.71 -22.53,2634.34 ; 37.72,2339.87 ccw(c43.37,2345.52) 43.37,2337.52 ; 37.72,2339.87 ccw(c43.37,2345.52) 43.37,2337.52 ; 37.72,2339.87 25.54,2352.05 cw(c20.19,2368.71) 37.69,2368.71 cw(c20.19,2368.71) 36.85,2363.36 46.69,2353.52 722.21,2353.52 732,2363.31 732,2495 ; 43.37,2337.52 725.52,2337.52 ; 50,4397 ccw(c50,4405) 55.66,4399.34 ; 50,4397 ccw(c50,4405) 55.66,4399.34 ; 55.66,4399.34 118.81,4462.5 695.5,4462.5 ; 84.71,4967.04 ccw(c90,4973.04) 90,4965.04 ; 84.71,4967.04 ccw(c90,4973.04) 90,4965.04 ; 88,4983.04 cw(c88,4975.04) 93.29,4981.04 ; 88,4983.04 cw(c88,4975.04) 93.29,4981.04 ; 90,4965.04 126.01,4965.04 ; 93.29,4981.04 122.69,4981.04 162.31,5020.66 ; 109.84,4476.16 cw(c115.5,4470.5) 115.5,4478.5 ; 109.84,4476.16 cw(c115.5,4470.5) 115.5,4478.5 ; 115.5,4478.5 692.19,4478.5 713.41,4499.72 ; 126.01,4965.04 ccw(c126.01,4973.04) 131.66,4967.38 ; 126.01,4965.04 ccw(c126.01,4973.04) 131.66,4967.38 ; 131.66,4967.38 171.28,5007 224.44,5007 ccw(c240,5015) 257.5,5015 ccw(c240,5015) 224.44,5023 167.97,5023 ; 161.71,3466.37 cw(c161.71,3458.37) 167.36,3464.03 ; 161.71,3466.37 cw(c161.71,3458.37) 167.36,3464.03 ; 162.31,5020.66 cw(c167.97,5015) 167.97,5023 ; 162.31,5020.66 cw(c167.97,5015) 167.97,5023 ; 164,3310.19 ccw(c172,3310.19) 166.34,3304.53 ; 164,3310.19 ccw(c172,3310.19) 166.34,3304.53 ; 166.34,3304.53 226.49,3244.38 ; 167.36,3464.03 177.66,3453.74 ; 177.66,3453.74 cw(c172,3448.08) 180,3448.08 ; 177.66,3453.74 cw(c172,3448.08) 180,3448.08 ; 180,3448.08 180,3313.5 235.46,3258.04 514.46,3258.04 cw(c530,3250) 547.5,3250 cw(c530,3250) 514.41,3242.04 232.15,3242.04 ; 189.86,4898.52 251.28,4898.52 251.28,4792.03 136.91,4792.03 136.91,4898.52 173.86,4898.52 173.86,4934.48 cw(c181.86,4950.04) 199.36,4950.04 cw(c181.86,4950.04) 189.86,4934.48 189.86,4898.52 ; 200,866.37 cw(c200,858.37) 205.66,864.03 ; 200,866.37 cw(c200,858.37) 205.66,864.03 ; 200,866.37 55.75,866.37 ccw(c40.19,858.37) 55.75,850.37 196.69,850.37 294.34,752.72 ; 205.66,864.03 303.31,766.37 1010,766.37 ; 226.49,3244.38 ccw(c232.15,3250.04) 232.15,3242.04 ; 226.49,3244.38 ccw(c232.15,3250.04) 232.15,3242.04 ; 274.34,1340.66 cw(c280,1335) 280,1343 ; 274.34,1340.66 cw(c280,1335) 280,1343 ; 274.34,1340.66 235.35,1301.66 ccw(c230,1285) 247.5,1285 ccw(c230,1285) 246.66,1290.35 283.31,1327 861.69,1327 959.34,1229.34 ; 280,1343 865,1343 ; 294.34,752.72 ccw(c300,758.37) 300,750.37 ; 294.34,752.72 ccw(c300,758.37) 300,750.37 ; 300,750.37 1006.69,750.37 1048.57,708.49 1048.57,430.57 ccw(c1056.57,393.94) 1019.08,393.94 ; 366.14,1305.61 cw(c371.8,1299.95) 371.8,1307.95 ; 366.14,1305.61 cw(c371.8,1299.95) 371.8,1307.95 ; 366.14,1305.61 357.81,1297.27 ccw(c355,1280) 372.5,1280 ccw(c355,1280) 370.76,1287.6 375.11,1291.95 751.74,1291.95 879.34,1164.34 ; 371.8,1307.95 755.05,1307.95 ; 576.52,2905.67 ccw(c584.52,2905.67) 578.87,2900.01 ; 576.52,2905.67 ccw(c584.52,2905.67) 578.87,2900.01 ; 576.52,2905.67 576.52,3005 ; 576.52,3005 cw(c584.52,3005) 578.87,3010.66 ; 576.52,3005 cw(c584.52,3005) 578.87,3010.66 ; 578.87,2900.01 682.19,2796.69 682.19,2740.61 ccw(c690.19,2725.04) 707.69,2725.04 ccw(c690.19,2725.04) 698.19,2740.61 698.19,2800 ; 578.87,3010.66 604.68,3036.46 ; 603.52,2916.85 ccw(c611.52,2916.85) 605.87,2911.19 ; 603.52,2916.85 ccw(c611.52,2916.85) 605.87,2911.19 ; 603.52,2916.85 603.52,2993.82 ; 603.52,2993.82 cw(c611.52,2993.82) 605.87,2999.47 ; 603.52,2993.82 cw(c611.52,2993.82) 605.87,2999.47 ; 604.68,3036.46 cw(c610.33,3030.81) 610.33,3038.81 ; 604.68,3036.46 cw(c610.33,3030.81) 610.33,3038.81 ; 605.87,2911.19 748.02,2769.04 748.02,2679.17 ; 605.87,2999.47 615.86,3009.46 ; 610.33,3038.81 1559.19,3038.81 ; 615.86,3009.46 cw(c621.52,3003.81) 621.52,3011.81 ; 615.86,3009.46 cw(c621.52,3003.81) 621.52,3011.81 ; 621.52,3011.81 778.09,3011.81 ; 695.5,4462.5 ccw(c695.5,4470.5) 701.16,4464.84 ; 695.5,4462.5 ccw(c695.5,4470.5) 701.16,4464.84 ; 695.85,2805.66 cw(c690.19,2800) 698.19,2800 ; 695.85,2805.66 cw(c690.19,2800) 698.19,2800 ; 695.85,2805.66 592.52,2908.98 592.52,3001.69 613.65,3022.81 1555.88,3022.81 1573.34,3005.35 ccw(c1590,3000) 1607.5,3000 ccw(c1590,3000) 1584.65,3016.66 1564.85,3036.46 ; 701.16,4464.84 722.38,4486.06 794.06,4486.06 ; 713.41,4499.72 cw(c719.06,4494.06) 719.06,4502.06 ; 713.41,4499.72 cw(c719.06,4494.06) 719.06,4502.06 ; 719.06,4502.06 790.75,4502.06 827,4538.31 827,4610 ; 725.52,2337.52 ccw(c725.52,2345.52) 731.18,2339.87 ; 725.52,2337.52 ccw(c725.52,2345.52) 731.18,2339.87 ; 731.18,2339.87 745.66,2354.34 ; 732,2495 cw(c740,2495) 734.34,2500.66 ; 732,2495 cw(c740,2495) 734.34,2500.66 ; 734.34,2500.66 757.19,2523.5 757.19,2559.34 cw(c765,2575) 757.19,2590.66 757.19,2666.69 750.37,2673.51 ; 745.66,2354.34 ccw(c740,2360) 748,2360 ; 745.66,2354.34 ccw(c740,2360) 748,2360 ; 748,2360 748,2491.69 770.85,2514.53 ; 748.02,2679.17 ccw(c756.02,2679.17) 750.37,2673.51 ; 748.02,2679.17 ccw(c756.02,2679.17) 750.37,2673.51 ; 755.05,1307.95 cw(c755.05,1299.95) 760.71,1305.61 ; 755.05,1307.95 cw(c755.05,1299.95) 760.71,1305.61 ; 760.71,1305.61 888.31,1178 1810,1178 ; 761.68,2778.01 cw(c756.02,2772.35) 764.02,2772.35 ; 761.68,2778.01 cw(c756.02,2772.35) 764.02,2772.35 ; 761.68,2778.01 619.52,2920.16 619.52,2990.5 624.83,2995.81 774.78,2995.81 872.15,2898.43 ; 764.02,2772.35 764.02,2682.48 770.85,2675.66 ; 770.85,2514.53 ccw(c765.19,2520.19) 773.19,2520.19 ; 770.85,2514.53 ccw(c765.19,2520.19) 773.19,2520.19 ; 770.85,2675.66 cw(c765.19,2670) 773.19,2670 ; 770.85,2675.66 cw(c765.19,2670) 773.19,2670 ; 773.19,2520.19 773.19,2559.53 ccw(c765,2575) 782.5,2575 ccw(c765,2575) 773.19,2590.47 773.19,2670 ; 778.09,3011.81 cw(c778.09,3003.81) 783.75,3009.46 ; 778.09,3011.81 cw(c778.09,3003.81) 783.75,3009.46 ; 783.75,3009.46 881.12,2912.09 1207.59,2912.09 1230.19,2934.69 1230.19,2961.22 ; 790.92,415.59 ccw(c753.43,415.59) 715.93,415.59 715.93,360.47 ccw(c753.43,360.47) 790.92,360.47 790.92,415.59 ; 794.06,4486.06 ccw(c794.06,4494.06) 799.72,4488.41 ; 794.06,4486.06 ccw(c794.06,4494.06) 799.72,4488.41 ; 799.72,4488.41 840.66,4529.34 ; 827,4610 cw(c835,4610) 829.34,4615.66 ; 827,4610 cw(c835,4610) 829.34,4615.66 ; 829.34,4615.66 864.34,4650.66 ; 840.66,4529.34 ccw(c835,4535) 843,4535 ; 840.66,4529.34 ccw(c835,4535) 843,4535 ; 843,4535 843,4606.69 873.31,4637 971.69,4637 978.64,4630.05 ; 864.34,4650.66 cw(c870,4645) 870,4653 ; 864.34,4650.66 cw(c870,4645) 870,4653 ; 865,1343 cw(c865,1335) 870.66,1340.66 ; 865,1343 cw(c865,1335) 870.66,1340.66 ; 870,4653 975,4653 ; 870.66,1340.66 968.31,1243 1880,1243 ; 872.15,2898.43 ccw(c877.81,2904.09) 877.81,2896.09 ; 872.15,2898.43 ccw(c877.81,2904.09) 877.81,2896.09 ; 877.81,2896.09 1210.91,2896.09 ; 879.34,1164.34 ccw(c885,1170) 885,1162 ; 879.34,1164.34 ccw(c885,1170) 885,1162 ; 885,1162 1806.69,1162 1960.43,1008.26 1960.43,452.22 ccw(c1968.43,415.59) 1930.93,415.59 ; 959.34,1229.34 ccw(c965,1235) 965,1227 ; 959.34,1229.34 ccw(c965,1235) 965,1227 ; 965,1227 1876.69,1227 2263.57,840.11 2263.57,430.57 ccw(c2271.57,393.94) 2234.08,393.94 ; 975,4653 cw(c975,4645) 980.66,4650.66 ; 975,4653 cw(c975,4645) 980.66,4650.66 ; 978.64,4630.05 ccw(c984.29,4635.71) 984.29,4627.71 ; 978.64,4630.05 ccw(c984.29,4635.71) 984.29,4627.71 ; 980.66,4650.66 987.61,4643.71 1134.29,4643.71 cw(c1149.86,4635.71) 1167.36,4635.71 cw(c1149.86,4635.71) 1134.29,4627.71 984.29,4627.71 ; 1010,766.37 cw(c1010,758.37) 1015.66,764.03 ; 1010,766.37 cw(c1010,758.37) 1015.66,764.03 ; 1015.66,764.03 1062.23,717.46 ; 1019.08,393.94 1019.08,358.5 ccw(c1056.57,358.5) 1094.07,358.5 1094.07,393.94 ccw(c1056.57,393.94) 1064.57,430.57 1064.57,711.8 ; 1062.23,717.46 cw(c1056.57,711.8) 1064.57,711.8 ; 1062.23,717.46 cw(c1056.57,711.8) 1064.57,711.8 ; 1120.93,232.52 cw(c1158.43,232.52) 1150.43,269.15 1150.43,323.84 cw(c1158.43,360.47) 1120.93,360.47 1120.93,415.59 ; 1120.93,232.52 1120.93,197.09 ccw(c1158.43,197.09) 1195.92,197.09 1195.92,232.52 ccw(c1158.43,232.52) 1166.43,269.15 1166.43,323.84 ccw(c1158.43,360.47) 1195.92,360.47 1195.92,415.59 ; 1120.93,415.59 cw(c1158.43,415.59) 1150.43,452.22 1150.43,815 ; 1148.29,999.71 cw(c1148.29,991.71) 1153.95,997.36 ; 1148.29,999.71 cw(c1148.29,991.71) 1153.95,997.36 ; 1150.43,815 cw(c1158.43,815) 1152.77,820.66 ; 1150.43,815 cw(c1158.43,815) 1152.77,820.66 ; 1152.77,820.66 1187.67,855.56 1187.67,932.19 1177.86,932.19 1177.86,967.81 1213.48,967.81 1213.48,958 1236.51,958 1236.51,967.81 1271.15,967.81 1271.15,932.19 1236.51,932.19 1236.51,942 1213.48,942 1213.48,932.19 1203.67,932.19 1203.67,852.24 ; 1153.95,997.36 1159.99,991.33 ; 1159.99,991.33 cw(c1154.33,985.67) 1162.33,985.67 ; 1159.99,991.33 cw(c1154.33,985.67) 1162.33,985.67 ; 1195.92,415.59 ccw(c1158.43,415.59) 1166.43,452.22 1166.43,811.69 1201.33,846.59 ; 1201.33,846.59 ccw(c1195.67,852.24) 1203.67,852.24 ; 1201.33,846.59 ccw(c1195.67,852.24) 1203.67,852.24 ; 1210.91,2896.09 ccw(c1210.91,2904.09) 1216.57,2898.43 ; 1210.91,2896.09 ccw(c1210.91,2904.09) 1216.57,2898.43 ; 1216.57,2898.43 1243.85,2925.72 ; 1230.19,2961.22 cw(c1238.19,2961.22) 1232.53,2966.88 ; 1230.19,2961.22 cw(c1238.19,2961.22) 1232.53,2966.88 ; 1232.53,2966.88 1248.35,2982.7 ; 1243.85,2925.72 ccw(c1238.19,2931.37) 1246.19,2931.37 ; 1243.85,2925.72 ccw(c1238.19,2931.37) 1246.19,2931.37 ; 1246.19,2931.37 1246.19,2957.91 1257.32,2969.04 1273.06,2969.04 1284.19,2957.91 1284.19,2928.12 ; 1248.35,2982.7 cw(c1254.01,2977.04) 1254.01,2985.04 ; 1248.35,2982.7 cw(c1254.01,2977.04) 1254.01,2985.04 ; 1254.01,2985.04 1276.37,2985.04 ; 1276.37,2985.04 cw(c1276.37,2977.04) 1282.03,2982.7 ; 1276.37,2985.04 cw(c1276.37,2977.04) 1282.03,2982.7 ; 1282.03,2982.7 1297.85,2966.88 ; 1284.19,2928.12 ccw(c1292.19,2928.12) 1286.53,2922.47 ; 1284.19,2928.12 ccw(c1292.19,2928.12) 1286.53,2922.47 ; 1286.53,2922.47 1303.23,2905.77 ; 1297.85,2966.88 cw(c1292.19,2961.22) 1300.19,2961.22 ; 1297.85,2966.88 cw(c1292.19,2961.22) 1300.19,2961.22 ; 1300.19,2961.22 1300.19,2931.44 1312.2,2919.43 1492.97,2919.43 ; 1303.23,2905.77 ccw(c1308.88,2911.43) 1308.88,2903.43 ; 1303.23,2905.77 ccw(c1308.88,2911.43) 1308.88,2903.43 ; 1308.88,2903.43 1489.66,2903.43 1503.37,2889.72 ; 1413.47,967.81 1413.47,958 1436.5,958 1436.5,967.81 1471.14,967.81 1471.14,932.19 1461.82,932.19 1461.82,855 1461.82,576.07 1467.23,570.66 ; 1424.08,279.76 cw(c1461.57,279.76) 1453.57,316.4 1453.57,321.87 cw(c1461.57,358.5) 1424.08,358.5 1424.08,393.94 ; 1424.08,279.76 1424.08,244.33 ccw(c1461.57,244.33) 1499.07,244.33 1499.07,279.76 ccw(c1461.57,279.76) 1469.57,316.4 1469.57,321.87 ccw(c1461.57,358.5) 1499.07,358.5 1499.07,393.94 ccw(c1461.57,393.94) 1469.57,430.57 1469.57,565 ; 1424.08,393.94 cw(c1461.57,393.94) 1453.57,430.57 1453.57,561.69 1448.16,567.1 ; 1445.82,572.76 ccw(c1453.82,572.76) 1448.16,567.1 ; 1445.82,572.76 ccw(c1453.82,572.76) 1448.16,567.1 ; 1467.23,570.66 cw(c1461.57,565) 1469.57,565 ; 1467.23,570.66 cw(c1461.57,565) 1469.57,565 ; 1492.97,2919.43 cw(c1492.97,2911.43) 1498.63,2917.09 ; 1492.97,2919.43 cw(c1492.97,2911.43) 1498.63,2917.09 ; 1498.63,2917.09 1512.34,2903.37 1577.06,2903.37 1608.34,2934.65 cw(c1625,2940) 1642.5,2940 cw(c1625,2940) 1619.65,2923.34 1586.03,2889.72 ; 1503.37,2889.72 ccw(c1509.03,2895.37) 1509.03,2887.37 ; 1503.37,2889.72 ccw(c1509.03,2895.37) 1509.03,2887.37 ; 1509.03,2887.37 1580.37,2887.37 ; 1525.93,415.59 cw(c1563.43,415.59) 1600.92,415.59 ; 1525.93,415.59 1525.93,360.47 ccw(c1563.43,360.47) 1600.92,360.47 1600.92,415.59 ; 1559.19,3038.81 cw(c1559.19,3030.81) 1564.85,3036.46 ; 1559.19,3038.81 cw(c1559.19,3030.81) 1564.85,3036.46 ; 1580.37,2887.37 ccw(c1580.37,2895.37) 1586.03,2889.72 ; 1580.37,2887.37 ccw(c1580.37,2895.37) 1586.03,2889.72 ; 1810,1178 cw(c1810,1170) 1815.66,1175.66 ; 1810,1178 cw(c1810,1170) 1815.66,1175.66 ; 1815.66,1175.66 1974.08,1017.23 ; 1829.08,393.94 cw(c1866.57,393.94) 1904.07,393.94 1904.07,358.5 cw(c1866.57,358.5) 1829.08,358.5 1829.08,393.94 ; 1880,1243 cw(c1880,1235) 1885.66,1240.66 ; 1880,1243 cw(c1880,1235) 1885.66,1240.66 ; 1885.66,1240.66 2277.23,849.08 ; 1930.93,232.52 cw(c1968.43,232.52) 1960.43,269.15 1960.43,323.84 cw(c1968.43,360.47) 1930.93,360.47 1930.93,415.59 ; 1930.93,232.52 1930.93,197.09 ccw(c1968.43,197.09) 2005.92,197.09 2005.92,232.52 ccw(c1968.43,232.52) 1976.43,269.15 1976.43,323.84 ccw(c1968.43,360.47) 2005.92,360.47 2005.92,415.59 ; 1974.08,1017.23 cw(c1968.43,1011.57) 1976.43,1011.57 ; 1974.08,1017.23 cw(c1968.43,1011.57) 1976.43,1011.57 ; 1976.43,1011.57 1976.43,452.22 cw(c1968.43,415.59) 2005.92,415.59 ; 2234.08,279.76 cw(c2271.57,279.76) 2263.57,316.4 2263.57,321.87 cw(c2271.57,358.5) 2234.08,358.5 2234.08,393.94 ; 2277.23,849.08 cw(c2271.57,843.43) 2279.57,843.43 ; 2277.23,849.08 cw(c2271.57,843.43) 2279.57,843.43 ; -532.5,4165 cw(c-515,4165) -497.5,4165 cw(c-515,4165) -532.5,4165 ; -527.31,4625.04 cw(c-509.81,4625.04) -492.31,4625.04 cw(c-509.81,4625.04) -527.31,4625.04 ; -337.5,4935 cw(c-320,4935) -302.5,4935 cw(c-320,4935) -337.5,4935 ; -310.64,3265.71 cw(c-293.14,3265.71) -275.64,3265.71 cw(c-293.14,3265.71) -310.64,3265.71 ; -197.5,4460 cw(c-180,4460) -162.5,4460 cw(c-180,4460) -197.5,4460 ; -178.17,5203.1 -143.53,5203.1 -143.53,5212.78 ccw(c-126.48,5216.71) -108.98,5216.71 ccw(c-126.48,5216.71) -139.01,5228.92 -143.53,5228.92 -143.53,5238.73 -178.17,5238.73 -178.17,5203.1 ; -91.98,2139.71 cw(c-74.48,2139.71) -56.98,2139.71 cw(c-74.48,2139.71) -91.98,2139.71 ; -67.5,3920 cw(c-50,3920) -32.5,3920 cw(c-50,3920) -67.5,3920 ; 40.12,3408.23 cw(c76.12,3408.23) 112.12,3408.23 cw(c76.12,3408.23) 40.12,3408.23 ; 40.12,3508.23 cw(c76.12,3508.23) 112.12,3508.23 cw(c76.12,3508.23) 40.12,3508.23 ; 267.5,890 cw(c285,890) 302.5,890 cw(c285,890) 267.5,890 ; 302.5,4610 cw(c320,4610) 337.5,4610 cw(c320,4610) 302.5,4610 ; 312.5,4675 cw(c330,4675) 347.5,4675 cw(c330,4675) 312.5,4675 ; 762.5,4555 cw(c780,4555) 797.5,4555 cw(c780,4555) 762.5,4555 ; 1336.51,932.19 1372.13,932.19 1372.13,967.81 1362.32,967.81 1362.32,975.08 ccw(c1356.86,991.71) 1374.36,991.71 ccw(c1356.86,991.71) 1346.32,977.74 1346.32,967.81 1336.51,967.81 1336.51,932.19 ; 1642.5,3270 cw(c1660,3270) 1677.5,3270 cw(c1660,3270) 1642.5,3270 ; 1697.69,3180 cw(c1715.19,3180) 1732.69,3180 cw(c1715.19,3180) 1697.69,3180
  Bottom Layer w12: v1(-243.14,5225.04) -207.34,5225.04 R139.1@-203.21,5220.92 R145.1@-203.21,5165.08 R140.1@-203.21,5110.08 ; v1(-243.14,5429.37) -228.27,5444.25 C105.1@-202.7,5444.25 -159.14,5487.8 -159.14,5500.08 v1(-159.14,5608.37) -179.71,5608.37 NT1.1@-194.76,5623.43 ; v1@-239.25,5221.15 cw(c-229.86,5211.76) -229.86,5225.04 cw(c-229.86,5238.32) v1@-239.25,5228.93 ; -224.82,5225.04 cw(c-224.82,5199.79) R139.1@-206.97,5217.65 ; R140.1@-206.97,5114.34 ccw(c-216.05,5123.42) -203.21,5123.42 ccw(c-190.37,5123.42) R140.1@-199.45,5114.34 ; R145.1@-206.97,5160.83 cw(c-216.05,5151.75) -203.21,5151.75 cw(c-190.37,5151.75) R145.1@-199.45,5160.83 ; R145.1@-206.97,5169.34 ccw(c-216.05,5178.42) -203.21,5178.42 ccw(c-190.37,5178.42) R145.1@-199.45,5169.34 ; R139.1@-206.97,5216.66 cw(c-216.05,5207.58) -203.21,5207.58 cw(c-190.37,5207.58) R139.1@-199.45,5216.66 ; C105.1@-206.81,5440.14 ccw(c-216.73,5430.22) -216.73,5444.25 ccw(c-216.73,5458.28) C105.1@-206.81,5448.36 ; C105.1@-202.7,5450.06 ccw(c-202.7,5464.09) -192.78,5454.17 ccw(c-182.86,5444.25) C105.1@-196.89,5444.25 ; NT1.1@-196.71,5618.05 ccw(c-179.95,5627.74) NT1.1@-179.95,5608.37 ; -181.53,5465.42 ccw(c-216.19,5500.08) C113.1@-167.17,5500.08 ; C113.1@-165.47,5504.19 ccw(c-180.74,5519.46) -159.14,5519.46 ; v1@-163.03,5612.26 cw(c-172.42,5621.65) -172.42,5608.37 cw(c-172.42,5595.1) -163.03,5604.49 cw(c-172.42,5595.1) -159.14,5595.1 cw(c-145.86,5595.1) v1@-155.25,5604.49 ; -161.04,5485.9 ccw(c-175.22,5500.08) C113.1@-155.17,5500.08 ; v1(-126.48,2708.37) -101.63,2708.37 -95,2715 -55,2715 ; v1@-122.59,2704.49 cw(c-113.2,2695.1) -113.2,2708.37 cw(c-113.2,2721.65) v1@-122.59,2712.26 ; R25.1@-57.58,2689.25 ccw(c-66.66,2698.33) -53.82,2698.33 ccw(c-40.98,2698.33) R25.1@-50.06,2689.25 ; C28.2@-54.33,2595 -15,2595 15,2625 30,2625 ; C32.2@-54.33,2837.5 17.5,2837.5 20,2835 ; R25.1@-53.82,2685 -53.82,2713.82 -55,2715 ; R27.1@-53.82,2945 0,2945 20,2925 20,2895 ; C28.2@-50.22,2590.89 cw(c-40.3,2580.97) -40.3,2595 cw(c-40.3,2609.03) C28.2@-50.22,2599.11 ; C32.2@-50.22,2833.39 cw(c-40.3,2823.47) -40.3,2837.5 cw(c-40.3,2851.53) C32.2@-50.22,2841.61 ; R27.1@-50.06,2941.24 cw(c-40.98,2932.16) -40.98,2945 cw(c-40.98,2957.84) R27.1@-50.06,2948.76 ; v2(-10,5625) 32.99,5625 C111.2@47.99,5640 100.23,5640 ; v2@-5.89,5620.89 cw(c4.03,5610.97) 4.03,5625 cw(c4.03,5639.03) v2@-5.89,5629.11 ; -4.5,2605.5 ccw(c-16.7,2617.7) v1@-3.28,2628.54 ; 4.94,2614.94 ccw(c-6.26,2626.13) v1@6.06,2636.08 ; v1@5,2635.78 ccw(c30,2659.39) 30,2625 ; v1@5.11,2899.11 cw(c-30.83,2863.17) 20,2863.17 ; v1@7.46,2908.28 ccw(c2.58,2925) 20,2925 ; v1@10.82,2896.76 ccw(c7.25,2909) 20,2909 ; v1@12.89,2906.89 ccw(c41.59,2935.59) 41.59,2895 ; v1@13.6,2907.6 cw(c-1.86,2892.14) 20,2892.14 ; 14.37,2624.37 ccw(c4.18,2634.57) 15.39,2643.63 ; R146.2@62.52,5313.62 ccw(c52.2,5323.94) 66.79,5323.94 ; C108.2@62.68,5368.83 cw(c52.76,5358.91) 66.79,5358.91 cw(c80.82,5358.91) C108.2@70.9,5368.83 ; C108.2@62.68,5377.05 ccw(c52.76,5386.97) 66.79,5386.97 ccw(c80.82,5386.97) C108.2@70.9,5377.05 ; C114.1@62.68,5432.4 cw(c52.76,5422.48) 66.79,5422.48 cw(c80.82,5422.48) C114.1@70.9,5432.4 ; C114.1@62.68,5440.62 ccw(c52.76,5450.54) 66.79,5450.54 ccw(c80.82,5450.54) C114.1@70.9,5440.62 ; R146.2@66.28,5309.37 66.79,5309.88 C108.2@66.79,5372.94 C114.1@66.79,5436.51 66.79,5458.23 C112.1@108.64,5500.08 115.19,5506.63 v1(115.19,5625.04) 100.23,5640 ; 66.79,5321.47 ccw(c77.88,5321.47) R146.2@70.04,5313.62 ; C111.2@78.27,5625.97 cw(c100.23,5615.8) 100.23,5640 ; C111.2@78.27,5654.03 ccw(c100.23,5664.2) 100.23,5640 ; C29.2@85.22,2790.89 ccw(c75.3,2780.97) 75.3,2795 ccw(c75.3,2809.03) C29.2@85.22,2799.11 ; C30.2@85.22,2890.89 ccw(c75.3,2880.97) 75.3,2895 ccw(c75.3,2909.03) C30.2@85.22,2899.11 ; C30.2@86.69,2897.64 C30.2@89.33,2895 20,2895 ; C29.2@95.14,2795 ccw(c130.08,2795) 105.38,2770.29 ; C112.1@102.83,5500.08 cw(c88.8,5500.08) 98.72,5490.16 cw(c108.64,5480.24) C112.1@108.64,5494.27 ; C112.1@104.53,5504.19 ccw(c78.8,5529.92) 115.19,5529.92 ; v1@111.3,5621.15 cw(c101.91,5611.76) 115.19,5611.76 cw(c128.47,5611.76) v1@119.08,5621.15 ; C24.1@124.86,2595 ccw(c110.83,2595) 120.75,2604.92 ccw(c130.67,2614.84) 130.67,2600.81 ccw(c130.67,2614.84) 140.59,2604.92 ccw(c150.51,2595) 136.48,2595 ccw(c150.51,2595) 140.59,2585.08 ccw(c130.67,2575.16) C24.1@130.67,2589.19 ; C22.2@124.86,2745 ccw(c110.83,2745) 120.75,2754.92 ccw(c130.67,2764.84) C22.2@130.67,2750.81 ; C26.2@130.67,2449.82 cw(c130.67,2435.79) 140.59,2445.71 cw(c150.51,2455.63) 136.48,2455.63 cw(c150.51,2455.63) 140.59,2465.55 cw(c130.67,2475.47) C26.2@130.67,2461.44 ; C22.2@130.67,2739.19 cw(c130.67,2725.16) 140.59,2735.08 cw(c150.51,2745) C22.2@136.48,2745 ; C25.2@139.69,2400.23 ccw(c116.33,2423.59) 149.37,2423.59 ccw(c182.41,2423.59) C25.2@159.05,2400.23 ; C23.2@139.69,2510.4 cw(c116.33,2487.04) 149.37,2487.04 cw(c182.41,2487.04) C23.2@159.05,2510.4 ; C23.2@139.69,2539.6 ccw(c116.33,2562.96) 149.37,2562.96 ccw(c182.41,2562.96) C23.2@159.05,2539.6 ; C19.2@139.69,2650.4 cw(c116.33,2627.04) 149.37,2627.04 cw(c182.41,2627.04) C19.2@159.05,2650.4 ; C19.2@139.69,2679.6 ccw(c116.33,2702.96) 149.37,2702.96 ccw(c182.41,2702.96) C19.2@159.05,2679.6 ; C25.2@159.05,2375.95 cw(c184.51,2350.49) 184.51,2386.5 ; C25.2@159.05,2395.31 ccw(c180.31,2416.57) 180.31,2386.5 ; v1@327.97,2762.82 cw(c318.58,2753.43) 331.86,2753.43 cw(c345.14,2753.43) v1@335.75,2762.82 ; v1(331.86,2766.71) 331.86,2591.86 329.04,2589.04 ; C145.1@440.89,2584.93 ccw(c430.97,2575.01) 430.97,2589.04 ccw(c430.97,2603.07) 440.89,2593.15 ccw(c430.97,2603.07) 445,2603.07 ccw(c459.03,2603.07) 449.11,2593.15 ccw(c459.03,2603.07) 459.03,2589.04 ccw(c459.03,2575.01) C145.1@449.11,2584.93 ; v1(479.86,2575.04) 465.85,2589.04 C145.1@445,2589.04 ; U44.2@560,2605.78 560,2625.38 560,2635 550,2645 450,2645 445,2640 C145.1@445,2589.04 ; C146.2@693.29,2604.35 ccw(c689.64,2616.68) 702.5,2616.68 ; C146.2@702.5,2568.37 702.5,2616.68 ; C146.2@711.72,2604.35 cw(c715.36,2616.68) 702.5,2616.68 ; v1@715.02,2634.71 cw(c701.75,2634.71) 711.14,2625.32 cw(c720.52,2615.93) v1@720.52,2629.21 ; v1(720.52,2634.71) 702.5,2616.68 ; v1(905.86,2591.71) 942.34,2591.71 C147.1@945,2589.04 ; v1@909.75,2587.82 cw(c919.14,2578.43) 919.14,2591.71 cw(c919.14,2604.99) v1@909.75,2595.6 ; 924.54,2591.71 cw(c924.54,2568.58) C147.1@940.89,2584.93 ; J6.1@1056.57,132.13 1192.13,132.13 1243.37,183.37 1355.61,183.37 1406.86,132.13 ; J6.1@1066.12,122.58 cw(c1089.16,99.54) 1089.16,132.13 cw(c1089.16,164.71) J6.1@1066.12,141.67 ; J6.1@1074.6,114.1 cw(c1118.13,70.57) 1118.13,132.13 cw(c1118.13,193.68) J6.1@1074.6,150.15 ; J4.1@1442.05,115.73 ccw(c1406.86,86.16) 1406.86,132.13 ; J4.1@1442.05,148.53 cw(c1406.86,178.09) 1406.86,132.13 ; J4.1@1471.12,122.58 cw(c1494.16,99.54) 1494.16,132.13 cw(c1494.16,164.71) J4.1@1471.12,141.67 ; J4.1@1479.6,114.1 cw(c1523.13,70.57) 1523.13,132.13 cw(c1523.13,193.68) J4.1@1479.6,150.15 ; 1812.35,135.16 ccw(c1812.35,186.35) J5.1@1848.55,150.15 ; 1830.94,135.16 cw(c1830.94,101.99) J5.1@1856.27,123.41 ; J5.1@1847.11,115.66 ccw(c1805.08,80.11) 1805.08,135.16 ; J5.1@1876.12,122.58 cw(c1906.48,92.22) 1906.48,135.16 ; J5.1@1884.6,114.1 cw(c1935.45,63.25) 1935.45,135.16 ; J5.1@1884.6,150.15 ccw(c1920.8,186.35) 1920.8,135.16 ; J7.1@2252.15,115.61 ccw(c2216.44,85.26) 2216.44,132.13 ; J7.1@2252.15,148.64 cw(c2216.44,178.99) 2216.44,132.13 ; J7.1@2271.57,132.13 2216.44,132.13 ; -55,2715 10,2715 30,2695 30,2625 ; 20,2835 20,2820 45,2795 C29.2@89.33,2795 89.33,2786.34 C22.2@130.67,2745 149.37,2726.3 C19.2@149.37,2665 149.37,2613.7 C24.1@130.67,2595 ; 20,2835 20,2895 ; 30,2625 100.67,2625 C24.1@130.67,2595 ; C24.1@130.67,2595 149.37,2576.3 C23.2@149.37,2525 149.37,2474.33 C26.2@130.67,2455.63 149.37,2436.93 C25.2@149.37,2385.63 150.24,2386.5 226.5,2386.5 260,2420 260,2520 329.04,2589.04 ; 329.04,2589.04 C145.1@445,2589.04 ; 1406.86,132.13 J4.1@1461.57,132.13 1567.13,132.13 1618.37,183.37 1756.86,183.37 1805.07,135.16 ; 1805.07,135.16 1866.57,135.16 2010.16,135.16 2058.37,183.37 2165.19,183.37 2216.44,132.13
  Bottom Layer w20: R4.1@1296.19,950 1296.19,1026.19 1315,1045 1485,1045 1496.18,1033.82 1496.18,1003.82 1496.18,995 R3.1@1496.18,950 v1(1615,950)
  other v1: 1111,213.02 1921,213.02 1205.85,216.58 2015.85,216.58 1414.15,260.27 2224.15,260.27 1509,263.83 1009.15,374.44 1414.15,374.44 1819.15,374.44 2224.15,374.44 2319,378 800.85,389.81 1205.85,389.81 1610.85,389.81 2015.85,389.81 1110,595 1110,615 40,831 1276,833 284,863 1275,887 1082,964 1381,978 1082,1019 230,1258 335,1261 -58,2118 0,2350 -611,2367 -633,2379 747.5,2596.5 1,2632 774,2703 188,2801 188,2894 9,2903 -75,2917 1652,2944 771,2985 1566,2987 1694,3197 -317,3253 554,3263 1682,3286 92,3365 121,3499 -132,3562 -270,3647 -659.5,3693 -55,3770 -251,3787 -51,3893 -354,3930 -345,3994 -138,4117 -350,4329 -201,4442 785,4528 320,4637.81 -515,4652 1172,4652 356,4684 -420,4806 -321,4908 238,4909 201,4930 -215,4944 -250,4956 46,5027 240,5043 -266,5078 -103.5,5121.5 -114,5242
  other v10: 1107.57,383.22 1512.57,383.22 1917.57,383.22