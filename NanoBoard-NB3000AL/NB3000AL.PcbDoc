# Altium PCB NB3000AL.PcbDoc (part 41 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DBUSB.SLOE: U8.AD19 U19.35 | length 4498.6
  Top Layer w4: U8.AD19@5567.17,3808.64 cw(c5567.17,3790.92) 5579.7,3803.45 cw(c5592.23,3815.98) U8.AD19@5574.51,3815.98 ; U8.AD19@5567.17,3815.98 v3(5586.85,3796.3) ; 5574.05,3809.1 cw(c5561.24,3796.3) 5579.35,3796.3 ccw(c5561.24,3796.3) 5574.05,3809.1 ; 5574.05,3809.1 ccw(c5586.85,3821.91) 5586.85,3803.8 cw(c5586.85,3821.91) 5574.05,3809.1
  MidLayer1 w4: v3@5586.2,3788.83 cw(c5584.62,3770.79) 5598.49,3782.43 cw(c5612.36,3794.07) v3@5594.32,3795.65 ; 5598.24,3782.72 cw(c5588.31,3772.79) 5602.36,3772.79 ; 5602.36,3758.86 5602.36,3772.79 ; v4@7402.16,935.66 ccw(c7382.84,935.66) 7396.5,949.32 ccw(c7410.16,962.98) v4@7410.16,943.66 ; v4(7410.16,935.66) 7387.44,958.37 7223.52,958.37 7198.52,933.37 7070,933.37 ; 5602.36,3772.79 5602.36,3679.25 5602.36,3638.82 5602.36,3630.82 5602.36,3564.27 5606.86,3559.77 5606.86,3508.04 5648.52,3466.37 5651.5,3463.4 5651.5,3353.71 5701.81,3303.39 5701.81,3271.31 5699.5,3269 5699.5,2933.67 5729.59,2903.58 5729.59,2901.06 5729.59,2875 5729.59,2821.36 5737.93,2813.02 5741,2809.95 5741,2707.56 5798.52,2650.04 5798.52,2327.54 5800.5,2325.56 5800.5,2305.25 5792.5,2297.25 5792.5,2247.73 5807.23,2233 5970.5,2233 6128.31,2233 6155.92,2205.39 6155.92,2145.57 6155.92,2135 6155.92,2125 6155.92,2091.05 6165.81,2081.16 6165.81,2027.38 6165.81,2012.62 6155.92,2002.73 6155.92,1848.96 6230.67,1774.21 6264.36,1740.52 6273.07,1731.81 6282.62,1731.81 6297.38,1731.81 6307.81,1721.38 6307.81,1683.51 6322.5,1668.82 6373,1618.32 6373,1606.75 6405.5,1574.25 6405.5,1375.5 ; 6405.5,1375.5 6406.81,1374.19 ; 6405.5,1375.5 6406.81,1374.19 ; 6406.81,1374.19 6410.19,1370.81 6410.19,1310.25 6410.19,1300 6410.19,1274.68 6468.68,1216.19 6509.32,1216.19 6523.74,1230.61 6576.38,1230.61 6582.8,1224.19 6665,1224.19 6671.06,1224.19 6720.56,1224.19 6736.94,1207.81 6771.5,1207.81 7045.94,933.37 7048.52,933.37 ; 7048.52,933.37 7070,933.37 ; 7048.52,933.37 7070,933.37
  Bottom Layer w8: v4@7405.91,931.42 cw(c7395.67,921.18) 7410.16,921.18 cw(c7424.64,921.18) v4@7414.4,931.42 ; U19.35@7410.16,904.33 v4(7410.16,935.66)
DBUSB.VBUS: R108.1 R109.1 U8.AE19 | length 5204.1
  Top Layer w4: U8.AE19@5567.17,3769.27 cw(c5567.17,3751.55) 5579.7,3764.08 cw(c5592.23,3776.61) U8.AE19@5574.51,3776.61 ; U8.AE19@5567.17,3776.61 v3(5586.85,3756.93) ; 5574.05,3769.73 cw(c5561.24,3756.93) 5579.35,3756.93 ccw(c5561.24,3756.93) 5574.05,3769.73 ; 5574.05,3769.73 ccw(c5586.85,3782.54) 5586.85,3764.43 cw(c5586.85,3782.54) 5574.05,3769.73
  MidLayer1 w4: v3@5581.66,3751.74 cw(c5569.12,3739.2) 5586.85,3739.2 cw(c5604.58,3739.2) v3@5592.04,3751.74 ; v3(5586.85,3756.93) 5586.85,3679.25 5586.85,3638.82 5586.85,3630.82 5586.85,3568.47 5595.11,3560.2 5595.11,3508.45 5612.27,3491.29 5643.5,3460.06 ; v1@7502.52,1065.54 cw(c7502.52,1042.61) 7518.74,1058.82 cw(c7534.96,1075.04) v1@7512.02,1075.04 ; v1@7502.52,1069.54 cw(c7502.52,1056.26) 7511.91,1065.65 cw(c7521.3,1075.04) v1@7508.02,1075.04 ; v1(7502.52,1075.04) 7523.52,1054.04 7523.52,983.37 7548.52,958.37 7548.52,925.04 7531.86,908.37 7265.19,908.37 7256.86,916.71 7125,916.71 7108,899.71 7074,865.71 6664.36,865.71 6630.36,899.71 6628.42,901.65 6526.19,1003.88 6526.19,1003.94 6380.52,1149.61 6380.52,1242.52 6401.81,1263.81 6401.81,1295 6401.81,1307.32 6401.81,1367.87 6398.81,1370.87 ; 5586.85,3738.82 cw(c5604.96,3738.82) 5592.15,3751.63 ccw(c5604.96,3738.82) 5586.85,3738.82 ; 5586.85,3738.82 ccw(c5568.74,3738.82) 5581.55,3751.63 cw(c5568.74,3738.82) 5586.85,3738.82 ; 5643.5,3432.48 5643.5,3460.06 ; 5643.5,3432.48 5643.5,3460.06 ; 5643.5,3432.48 5643.5,3349.06 5693.81,3298.75 5693.81,3274.62 5691.5,3272.31 5691.5,2930.36 5720.12,2901.74 5720.12,2819.52 5733,2806.64 5733,2704.25 5790.52,2646.73 5790.52,2405 5790.52,2368.02 5790.52,2324.22 5792.5,2322.25 5792.5,2308.56 5784.5,2300.56 5784.5,2240.75 5800.25,2225 5973.81,2225 6125,2225 6140,2210 6140,2037.5 6124,2021.5 6124,1869.57 6256.36,1737.21 6256.36,1711.14 6273,1694.5 6285.5,1694.5 6314.5,1665.5 6365,1615 6365,1602.5 6397.5,1570 6397.5,1372.18 ; 6397.5,1372.18 6398.81,1370.87 ; 6397.5,1372.18 6398.81,1370.87
  Bottom Layer w4: R108.1@7477.23,997.08 ccw(c7461.32,1012.99) 7483.82,1012.99 ccw(c7506.32,1012.99) R108.1@7490.41,997.08 ; R109.1@7477.23,1037.92 cw(c7461.32,1022.01) 7483.82,1022.01 cw(c7506.32,1022.01) R109.1@7490.41,1037.92 ; R108.1@7480.06,994.25 ccw(c7470.98,1003.33) 7483.82,1003.33 ccw(c7496.66,1003.33) R108.1@7487.58,994.25 ; R109.1@7480.06,1040.75 cw(c7470.98,1031.67) 7483.82,1031.67 cw(c7496.66,1031.67) R109.1@7487.58,1040.75 ; R108.1@7483.82,990 R109.1@7483.82,1041.71 ; R109.1@7483.82,1045 R109.1@7483.82,1041.71 ; R109.1@7485.14,1045.57 cw(c7501.49,1046.51) 7489.91,1058.09 ; 7492.36,1060.54 ccw(c7486.07,1066.83) v1@7494.02,1070.8 ; 7493.7,1061.89 cw(c7502.52,1053.07) v1@7502.52,1065.54 ; 7496.28,1064.47 ccw(c7491.31,1069.44) v1@7497.6,1072.58 ; v1(7502.52,1075.04) 7502.52,1070.71 7490.19,1058.37 7490.19,1048.08 7485.47,1043.35 R109.1@7483.82,1041.71 ; R109.1@7483.82,1054.81 ccw(c7483.82,1061.59) 7488.61,1056.8 cw(c7483.82,1061.59) R109.1@7483.82,1054.81
DBUSB.WR_N: U8.W20 U19.2 | length 7808.1
  Top Layer w4: U8.W20@5606.54,4005.49 cw(c5606.54,3987.77) 5619.07,4000.3 cw(c5631.6,4012.83) U8.W20@5613.88,4012.83 ; U8.W20@5606.54,4012.83 v3(5626.22,3993.15) ; 8256.86,1983.37 v1(8276.23,1964) 8247.9,1992.33 8247.9,2342.9 v1(8275,2370) v1@8280.08,2370 ; v1@8265.5,2370 cw(c8242.56,2370) 8258.78,2353.78 cw(c8275,2337.56) v1@8275,2360.5 ; v1@8269.5,2370 cw(c8256.22,2370) 8265.61,2360.61 cw(c8275,2351.22) v1@8275,2364.5 ; 5613.42,4005.95 cw(c5600.61,3993.15) 5618.72,3993.15 ccw(c5600.61,3993.15) 5613.42,4005.95 ; 5613.42,4005.95 ccw(c5626.22,4018.76) 5626.22,4000.65 cw(c5626.22,4018.76) 5613.42,4005.95 ; 8260.02,1980.22 cw(c8243.8,1964) 8266.73,1964 ccw(c8243.8,1964) 8260.02,1980.22 ; 8260.02,1980.22 ccw(c8276.23,1996.43) 8276.23,1973.5 cw(c8276.23,1996.43) 8260.02,1980.22 ; 8266.85,1973.39 cw(c8257.46,1964) 8270.73,1964 ccw(c8257.46,1964) 8266.85,1973.39 ; 8266.85,1973.39 ccw(c8276.23,1982.78) 8276.23,1969.5 cw(c8276.23,1982.78) 8266.85,1973.39
  MidLayer1 w4: v4@7520.27,627 cw(c7500.95,627) 7514.61,613.34 cw(c7528.27,599.69) v4@7528.27,619 ; v4(7528.27,627) 7509.64,608.37 7465.19,608.37 7448.52,591.71 7448.52,536.48 7460,525 7644.38,525 7654.02,534.64 7654.02,1233.47 7644.19,1243.31 7644.19,1264.69 7764.69,1385.19 7765.69,1385.19 7780.81,1400.31 7780.81,1401.31 7871.21,1491.71 8180,1491.71 8250,1561.71 8250,1690 8310,1750 8310,1930.23 v1(8276.23,1964) v1@8276.11,1964.12 ; v1@8276.23,1954.5 cw(c8276.23,1931.56) 8292.45,1947.78 cw(c8308.67,1964) v1@8285.73,1964 ; v1@8276.23,1958.5 cw(c8276.23,1945.22) 8285.62,1954.61 cw(c8295.01,1964) v1@8281.73,1964
  Bottom Layer w4: v3@5626.87,4000.62 ccw(c5628.45,4018.66) 5640.09,4004.79 ccw(c5651.73,3990.92) v3@5633.69,3992.5 ; 5639.8,4004.54 cw(c5649.73,3994.61) 5649.73,4008.66 5723.85,4008.66 5743.27,4008.66 5941.18,4008.66 5949.18,4008.66 6011.86,4008.66 6020,4016.8 6096.35,4016.8 6103.15,4010 6227.13,4010 6241.34,4024.21 6460.77,4024.21 6528.19,4091.63 6528.19,4091.71 6561.52,4125.04 6590.19,4125.04 6606.86,4108.37 6688.86,4108.37 6705.52,4091.71 6790,4091.71 6824.33,4126.04 6835.6,4126.04 6836.1,4125.55 6860.95,4125.55 6861.44,4126.04 7135,4126.04 7153.5,4107.54 7253.77,4107.54 ; 7217.46,4107.54 7253.77,4107.54 ; v1(8275,2370) 8311,2406 ; v1@8275,2375.5 ccw(c8275,2388.78) 8284.39,2379.39 ccw(c8293.78,2370) v1@8280.5,2370 ; v1@8275,2379.5 ccw(c8275,2402.43) 8291.22,2386.22 ccw(c8307.44,2370) v1@8284.5,2370 ; 8285,2380 8311,2406 ; 7253.77,4107.54 7276.23,4130 7372.15,4130 7372.28,4129.87 7386.77,4129.87 7386.9,4130 7616.63,4130 7670,4183.37 7968.79,4183.37 7979.63,4172.54 8089.83,4172.54 8104.83,4172.54 8194,4083.37 8194,3753.43 8231.01,3716.42 8231.01,3628.37 8311,3548.38 8311,2406
  Bottom Layer w8: v4@7524.03,622.76 cw(c7513.78,612.51) 7528.27,612.51 cw(c7542.75,612.51) v4@7532.51,622.76 ; U19.2@7528.27,595.67 v4(7528.27,627)
DBUSB.XTALIN: R244.1 U19.5 | length 8063
  MidLayer1 w4: v4@7469.21,556.34 cw(c7469.21,537.02) 7482.87,550.68 cw(c7496.53,564.34) v4@7477.21,564.34 ; v4(7469.21,564.34) 7493.55,540 7540,540 7646.02,646.02 7646.02,1230.16 7636.19,1240 7636.19,1268 7761.37,1393.19 7762.38,1393.19 7772.81,1403.62 7772.81,1404.63 7868.23,1500.04 7981.86,1500.04 8056.86,1575.04 8224.19,1575.04 8231.86,1582.71 8231.86,2300.04 8160,2371.9 8160,2668 8310,2818 8310,3585 v1(8315,3590) ; v1@8308.28,3583.28 cw(c8304.14,3579.14) 8310,3579.14 ; 8310,3554.99 cw(c8350.01,3554.99) v1@8321.72,3583.28 ; 8310,3564.65 cw(c8340.35,3564.65) v1@8318.89,3586.11 ; 8310,3574.31 cw(c8330.69,3574.31) v1@8316.06,3588.94
  Bottom Layer w4: R244.1@6294.59,5907.92 cw(c6278.68,5892.01) 6301.18,5892.01 cw(c6323.68,5892.01) R244.1@6307.77,5907.92 ; R244.1@6297.42,5910.75 cw(c6288.34,5901.67) 6301.18,5901.67 cw(c6314.02,5901.67) R244.1@6304.94,5910.75 ; R244.1@6301.18,5915 6301.18,5747.38 6348.52,5700.04 7098.52,5700.04 7170.48,5772 7372.36,5772 7633.75,5510.61 7633.75,5386.25 7701.98,5318.02 7701.98,5278.02 7758.88,5221.12 7994.94,5221.12 8240.69,4975.37 8240.69,4862 8131.86,4753.17 8131.86,4168.14 8210,4090 8210,3760.32 8277.5,3692.82 8277.5,3657.75 8269.5,3649.75 8269.5,3613.44 8292.94,3590 ; v1@8308.1,3583.47 ccw(c8292.94,3569.14) 8292.94,3590 ; v1@8308.1,3596.53 cw(c8292.94,3610.86) 8292.94,3590 ; v1@8311,3586.22 ccw(c8302.23,3577.92) 8302.23,3590 ccw(c8302.23,3602.08) v1@8311,3593.78 ; v1(8315,3590) 8292.94,3590
  Bottom Layer w8: v4@7464.97,568.58 ccw(c7454.73,578.82) 7469.21,578.82 ccw(c7483.7,578.82) v4@7473.46,568.58 ; v4(7469.21,564.34) U19.5@7469.21,595.67
DBUSB.XTALOUT: U19.4 | length 54.1
  Bottom Layer w8: v4@7484.65,622.76 cw(c7474.41,612.51) 7488.9,612.51 cw(c7503.38,612.51) v4@7493.14,622.76 ; U19.4@7488.9,595.67 v4(7488.9,627)
DCLK: R78.2 U8.P3 | length 6393.9
  Top Layer w4: 4124.25,4077.93 cw(c4124.25,4044.25) v2@4148.06,4068.06 ; 4133.91,4077.93 cw(c4133.91,4053.91) v2@4150.89,4070.89 ; 4138.38,4077.93 ccw(c4138.38,4091.62) v2@4148.06,4081.94 ; v2(4155,4075) 4152.07,4077.93 4104.28,4077.93 4093.92,4088.28 4093.92,4106.12 4102.8,4115 4125,4115 4152.5,4142.5 4152.5,4147.25 4190.25,4185 v2(4195,4185) ; 4170.15,4164.89 cw(c4195,4140.04) v2@4195,4175.19 ; 4176.97,4171.72 cw(c4195,4153.7) v2@4195,4179.19 ; 4181.61,4176.36 ccw(c4172.97,4185) v2@4185.19,4185 ; 4183.8,4178.55 cw(c4195,4167.35) v2@4195,4183.19 ; v2(4260,4345) 4280.58,4345 ; v2@4264.51,4341.34 cw(c4272.19,4335.12) 4272.19,4345 cw(c4272.19,4354.88) v2@4264.51,4348.66 ; v2@4267.62,4338.82 cw(c4280.58,4328.31) 4280.58,4345 ; v2@4267.62,4351.18 ccw(c4280.58,4361.69) 4280.58,4345 ; v2@4320.28,4292.6 ccw(c4315.89,4300.58) 4325,4300.58 ; v2(4325,4284) 4325,4300.58 ; v2@4329.72,4292.6 cw(c4334.11,4300.58) 4325,4300.58 ; v2@4388.06,4368.06 cw(c4371.31,4351.31) 4395,4351.31 cw(c4418.69,4351.31) v2@4401.94,4368.06 ; v2@4390,4370 v2(4395,4375) 4395,4346.48 4411.98,4329.5 4516.67,4329.5 4562.67,4375.5 4641.75,4375.5 4645.75,4379.5 4660.25,4379.5 4670.5,4369.25 4670.5,4354 4670.19,4353.69 4670.19,4316.56 4676.5,4310.25 4676.5,4280.75 4706.25,4251 4721.38,4251 4725.37,4247 4747.19,4247 4760,4247 4773.25,4247 4788.06,4232.19 4811.69,4232.19 4813.1,4233.6 4828.54,4233.6 4838.82,4233.55 4897.36,4233.55 cw(c4897.36,4194.87) 4924.71,4222.22 ; v2@4390.89,4370.89 cw(c4380.97,4360.97) 4395,4360.97 cw(c4409.03,4360.97) v2@4399.11,4370.89 ; v2@4479.55,4043.68 4505.69,4017.54 4530.77,4017.54 4538.31,4010 v1(4585,4010) ; v1@4578.28,4003.28 ccw(c4562.06,3987.06) 4562.06,4010 ccw(c4562.06,4032.93) v1@4578.28,4016.72 ; v1@4581.11,4006.11 ccw(c4571.72,3996.72) 4571.72,4010 ccw(c4571.72,4023.28) v1@4581.11,4013.89 ; v2@4707.44,3553.67 cw(c4690.69,3536.92) 4714.38,3536.92 cw(c4738.06,3536.92) v2@4721.32,3553.67 ; v2@4710.27,3556.5 cw(c4700.35,3546.58) 4714.38,3546.58 cw(c4728.41,3546.58) v2@4718.49,3556.5 ; v2(4714.38,3560.61) 4714.38,3530.62 4723.7,3521.3 v2(4723.7,3493.7) ; v2@4716.77,3500.64 ccw(c4700.02,3517.39) 4723.7,3517.39 ccw(c4747.39,3517.39) v2@4730.64,3500.64 ; v2@4719.6,3497.81 ccw(c4709.68,3507.73) 4723.7,3507.73 ccw(c4737.73,3507.73) v2@4727.81,3497.81 ; U8.P3@4929.9,4209.68 ccw(c4912.18,4209.68) 4924.71,4222.22 ; U8.P3@4937.24,4217.03 cw(c4937.24,4234.75) 4924.71,4222.22 ; 4280.58,4345 4325,4300.58
  MidLayer1 w4: v2(4195,4185) 4294,4284 v2(4325,4284) ; v2@4195,4190.81 ccw(c4195,4204.84) 4204.92,4194.92 ccw(c4214.84,4185) v2@4200.81,4185 ; v2@4195,4194.81 ccw(c4195,4218.5) 4211.75,4201.75 ccw(c4228.5,4185) v2@4204.81,4185 ; v2@4318.06,4277.06 ccw(c4301.31,4260.31) 4301.31,4284 ccw(c4301.31,4307.69) v2@4318.06,4290.94 ; v2@4320.89,4279.89 ccw(c4310.97,4269.97) 4310.97,4284 ccw(c4310.97,4298.03) v2@4320.89,4288.11 ; v2(5736,3550) 5751.81,3534.19 5785,3534.19 5829.08,3534.19 5865.19,3498.08 5865.19,3478.87 5865.19,3420 5865.19,3369.81 5906.86,3328.14 ; v1@5898.52,3308.22 ccw(c5878.89,3328.14) 5906.86,3328.14 ; v1@5901.33,3305.37 ccw(c5888.31,3318.58) 5906.86,3318.58 ; v1(5905.19,3301.46) 5905.44,3301.46 5906.86,3300.04 5906.86,3328.14 ; 5906.86,3320.37 ccw(c5924.1,3320.37) v1@5911.91,3308.18
  MidLayer2 w4: v2(4155,4075) 4172.5,4092.5 4271.83,4092.5 4305.12,4059.21 4449.24,4059.21 4463.46,4045 ; v2@4155,4080.81 ccw(c4155,4094.84) 4164.92,4084.92 ccw(c4174.84,4075) v2@4160.81,4075 ; v2@4155,4084.81 ccw(c4155,4108.5) 4171.75,4091.75 ccw(c4188.5,4075) v2@4164.81,4075 ; v2(4260,4345) 4305.99,4345 4309.18,4341.81 4381.81,4341.81 4395,4355 ; v2@4264.11,4340.89 cw(c4274.03,4330.97) 4274.03,4345 cw(c4274.03,4359.03) v2@4264.11,4349.11 ; v2@4266.94,4338.06 cw(c4283.69,4321.31) 4283.69,4345 cw(c4283.69,4368.69) v2@4266.94,4351.94 ; v2@4389,4367.24 cw(c4379.52,4355) 4395,4355 ; v2@4391.44,4370.4 cw(c4385.83,4363.15) 4395,4363.15 cw(c4404.17,4363.15) v2@4398.56,4370.4 ; v2(4395,4375) 4395,4355 ; v2@4401,4367.24 ccw(c4410.48,4355) 4395,4355 ; v2@4472.47,4039.92 ccw(c4463.46,4034.46) 4463.46,4045 ; v2@4472.47,4050.08 cw(c4463.46,4055.54) 4463.46,4045 ; v2@4479.55,4045 4463.46,4045 ; v1(4585,4010) 4585,3995 4600,3980 4623.84,3980 4674.27,3929.57 4674.27,3915.73 4684.5,3905.5 4699.5,3905.5 4723,3882 4723,3848.31 4731.31,3840 4776.06,3840 4808.01,3808.05 4815.81,3800.25 4815.81,3699.31 4796.5,3680 4796.5,3663 ; v2@4714.38,3550.79 cw(c4714.38,3527.11) 4731.13,3543.86 cw(c4747.87,3560.61) v2@4724.19,3560.61 ; v2@4714.38,3554.79 cw(c4714.38,3540.77) 4724.3,3550.69 cw(c4734.22,3560.61) v2@4720.19,3560.61 ; v2(4714.38,3560.61) 4732.79,3542.19 4764.19,3542.19 4770,3548 4770,3636.3 4796.5,3662.8 ; 4770,3636.31 4796.5,3662.81 4796.5,3663 ; 4797,3680 4797,3663.5 4796.5,3663 ; v2@5523.02,3166.82 ccw(c5499.33,3166.82) 5516.08,3183.57 ccw(c5532.83,3200.32) v2@5532.83,3176.63 ; v2@5527.02,3166.82 ccw(c5512.99,3166.82) 5522.91,3176.74 ccw(c5532.83,3186.66) v2@5532.83,3172.63 ; v2(5532.83,3166.82) 5513.12,3186.53 5470.87,3186.53 5460.62,3196.78 5460.62,3211.28 5506.54,3257.2 5546.25,3257.2 5556.5,3267.45 5556.5,3294.79 5531.36,3319.94 5531.36,3397.2 5540.04,3405.89 5540.04,3459.79 5544.25,3464.01 5555.89,3475.64 5561.3,3481.05 v2(5561.3,3546.2) v2@5553.73,3546.2 ; v2@5554.36,3539.26 cw(c5537.61,3522.51) 5561.3,3522.51 cw(c5584.99,3522.51) v2@5568.24,3539.26 ; v2@5557.19,3542.09 cw(c5547.27,3532.17) 5561.3,3532.17 cw(c5575.33,3532.17) v2@5565.41,3542.09
  Bottom Layer w4: v2@4716.77,3486.77 cw(c4700.02,3470.02) 4723.7,3470.02 cw(c4747.39,3470.02) v2@4730.64,3486.77 ; v2@4719.6,3489.6 cw(c4709.68,3479.68) 4723.7,3479.68 cw(c4737.73,3479.68) v2@4727.81,3489.6 ; v2(4723.7,3493.7) 4723.7,3456.3 4727.63,3452.37 4770.84,3452.37 4813.52,3409.69 4813.52,3315.65 4868.67,3260.5 4936.09,3260.5 4963.38,3233.21 5020,3233.21 5067.07,3233.21 5071.54,3233.21 5092.5,3212.25 5092.5,3197.75 5106.04,3184.21 5230.67,3184.21 5233.97,3187.5 5288.97,3187.5 5302.15,3200.68 5342.95,3200.68 5360.47,3218.2 5426.37,3218.2 5460.36,3184.21 5515.44,3184.21 v2(5532.83,3166.82) ; v2@5523.02,3166.82 ccw(c5499.33,3166.82) 5516.08,3183.57 ccw(c5532.83,3200.32) v2@5532.83,3176.63 ; v2@5527.02,3166.82 ccw(c5512.99,3166.82) 5522.91,3176.74 ccw(c5532.83,3186.66) v2@5532.83,3172.63 ; v2@5554.36,3539.26 cw(c5537.61,3522.51) 5561.3,3522.51 cw(c5584.99,3522.51) v2@5568.24,3539.26 ; v2@5557.19,3542.09 cw(c5547.27,3532.17) 5561.3,3532.17 cw(c5575.33,3532.17) v2@5565.41,3542.09 ; v2(5561.3,3546.2) 5561.3,3479.51 5576.77,3464.04 5590.62,3450.19 5607.44,3450.19 5628.75,3471.5 5668.25,3471.5 5690.5,3493.75 ; v2@5726.19,3550 cw(c5702.5,3550) 5719.25,3533.25 cw(c5736,3516.5) v2@5736,3540.19 ; v2@5730.19,3550 cw(c5716.16,3550) 5726.08,3540.08 cw(c5736,3530.16) v2@5736,3544.19 ; v2@5736,3542.6 v2(5736,3550) 5690.5,3504.5 ; R78.2@5879.23,3202.08 ccw(c5872.89,3208.43) 5881.86,3208.43 ; 5881.86,3208.24 ccw(c5898.57,3208.24) R78.2@5886.75,3196.42 ; 5881.86,3217.9 ccw(c5908.22,3217.9) R78.2@5889.58,3199.25 ; 5881.86,3227.55 ccw(c5917.88,3227.55) R78.2@5892.41,3202.08 ; R78.2@5885.82,3195 5885.82,3191.71 5881.86,3191.71 5881.86,3195 5881.86,3275.04 5906.86,3300.04 5905.44,3301.46 v1(5905.19,3301.46) ; 5886.79,3279.98 ccw(c5865.31,3301.46) v1@5895.69,3301.46 ; 5893.62,3286.8 ccw(c5878.97,3301.46) v1@5899.69,3301.46 ; 5894.24,3287.42 cw(c5905.19,3276.47) v1@5905.19,3291.96 ; 5690.5,3493.75 5690.5,3497.1 5690.5,3504.5 ; 5690.5,3493.75 5690.5,3504.5
  other v2: 4480.87,4045
DIAGCOMMS.DIN: J33.A46 U30.T4 | length 10447.9
  Top Layer w4: J33.A46@-785.98,2416.64 -637.72,2416.64 -605.08,2384 -575.14,2384 -533.18,2342.04 -354.79,2342.04 -335.52,2322.77 -335.52,1804.48 -464.96,1675.04 v1(-551.48,1675.04) ; J33.A46@-711.58,2411.14 cw(c-698.3,2397.86) -698.3,2416.64 cw(c-698.3,2435.42) J33.A46@-711.58,2422.14 ; J33.A46@-708.76,2408.31 cw(c-688.65,2388.2) -688.65,2416.64 cw(c-688.65,2445.08) J33.A46@-708.76,2424.97 ; v1@-547.59,1671.15 cw(c-538.2,1661.76) -538.2,1675.04 cw(c-538.2,1688.32) v1@-547.59,1678.93 ; v1@-544.76,1668.32 cw(c-528.54,1652.11) -528.54,1675.04 cw(c-528.54,1697.98) v1@-544.76,1681.76 ; U30.T4@6827.64,1564.53 cw(c6815.11,1552) 6832.83,1552 cw(c6850.56,1552) U30.T4@6838.03,1564.53 ; 6832.83,1510.7 6832.83,1503.67 6848.7,1487.81 6848.7,1485.05 6855.81,1477.94 6855.81,1442.13 v2(6836.06,1422.38) ; 6832.83,1512 U30.T4@6832.83,1569.72 ; v2@6836.06,1428.19 ccw(c6836.06,1442.22) 6845.98,1432.3 ccw(c6855.9,1422.38) v2@6841.87,1422.38 ; v2@6836.06,1432.19 ccw(c6836.06,1455.87) 6852.81,1439.13 ccw(c6869.56,1422.38) v2@6845.87,1422.38
  Bottom Layer w4: v1(-551.48,1675.04) -418.14,1675.04 -401.48,1658.37 -401.48,1566.71 -334.81,1500.04 -184.81,1500.04 -59.81,1375.04 4765.19,1375.04 4860.23,1280 5000,1280 5011.71,1291.71 5478.88,1291.71 5635.58,1135 5768.92,1135 5786.92,1117 5813.92,1090 5848.92,1055 5982.88,1055 6079.17,958.71 6467.17,958.71 6491.84,983.37 7056.06,983.37 7165.52,1092.84 7165.52,1158.66 7109.81,1214.37 7109.81,1236.38 7050.19,1296 7025.19,1296 7021.38,1299.81 6998.31,1299.81 6952.93,1345.19 6874.62,1345.19 6855.81,1364 6855.81,1367.38 6836.06,1387.13 v2(6836.06,1422.38) ; v1@-547.59,1671.15 cw(c-538.2,1661.76) -538.2,1675.04 cw(c-538.2,1688.32) v1@-547.59,1678.93 ; v1@-544.76,1668.32 cw(c-528.54,1652.11) -528.54,1675.04 cw(c-528.54,1697.98) v1@-544.76,1681.76 ; v2@6829.13,1415.44 cw(c6812.38,1398.69) 6836.06,1398.69 cw(c6859.75,1398.69) v2@6843,1415.44 ; v2@6831.95,1418.27 cw(c6822.03,1408.35) 6836.06,1408.35 cw(c6850.09,1408.35) v2@6840.17,1418.27
DIAGCOMMS.DOUT: J33.A43 U30.K5 | length 8644.2
  Top Layer w4: J33.A43@-785.98,2534.75 -675.1,2534.75 -668.14,2541.71 v1(-575.48,2541.71) ; J33.A43@-711.58,2529.25 cw(c-698.3,2515.97) -698.3,2534.75 cw(c-698.3,2553.53) J33.A43@-711.58,2540.25 ; J33.A43@-708.76,2526.42 cw(c-688.65,2506.31) -688.65,2534.75 cw(c-688.65,2563.19) J33.A43@-708.76,2543.08 ; v1@-582.19,2534.99 ccw(c-598.41,2518.77) -598.41,2541.71 ccw(c-598.41,2564.64) v1@-582.19,2548.43 ; v1@-579.36,2537.82 ccw(c-588.75,2528.43) -588.75,2541.71 ccw(c-588.75,2554.99) v1@-579.36,2545.6 ; v3(6852.52,1786.26) U30.K5@6872.2,1805.94 ; U30.K5@6864.86,1805.94 cw(c6847.14,1805.94) 6859.67,1793.41 cw(c6872.2,1780.88) U30.K5@6872.2,1798.6 ; 6865.32,1799.06 cw(c6852.52,1811.87) 6852.52,1793.76 ccw(c6852.52,1811.87) 6865.32,1799.06 ; 6865.32,1799.06 ccw(c6878.13,1786.26) 6860.02,1786.26 cw(c6878.13,1786.26) 6865.32,1799.06
  MidLayer2 w4: v1@-582.19,2534.99 cw(c-598.41,2518.77) -575.48,2518.77 cw(c-552.54,2518.77) v1@-568.76,2534.99 ; v1@-579.36,2537.82 cw(c-588.75,2528.43) -575.48,2528.43 cw(c-562.2,2528.43) v1@-571.59,2537.82 ; v1(-575.48,2541.71) -575.48,2468.14 -449.04,2341.71 -325.39,2341.71 -275.69,2292 998,2292 1033,2257 1164.63,2257 1192,2284.37 1409.31,2284.37 1481.69,2212 1539.23,2212 1595.23,2268 1626.98,2268 1627.76,2267.21 1652.62,2267.21 1653.4,2268 1696.98,2268 1808.67,2156.31 1808.67,2075.52 1866.19,2018 2059.67,2018 2085.17,1992.5 2681.69,1992.5 2844.19,2155 3005.25,2155 3056.75,2103.5 3108.36,2103.5 3191.05,2020.81 4984.73,2020.81 5173.67,1831.88 5224.76,1831.88 5234.75,1841.87 5680,1841.87 5691.7,1841.87 5697.34,1841.87 ; 6838.94,1774.87 cw(c6829.01,1784.8) 6829.01,1770.75 6735.47,1770.75 6732.41,1773.81 6639.31,1773.81 6619.69,1754.19 6598.31,1754.19 6576.31,1776.19 6517.31,1776.19 6502,1791.5 6305,1791.5 6297.5,1799 6178.56,1799 6171.06,1791.5 6155.75,1776.19 6028.81,1776.19 6008.81,1796.19 5915.4,1796.19 5890.08,1821.5 5717.71,1821.5 ; v3@6845.05,1786.91 cw(c6827.01,1788.49) 6838.65,1774.62 cw(c6850.29,1760.75) v3@6851.87,1778.79 ; 5697.34,1841.87 5702.52,1836.69 ; 5697.34,1841.87 5702.52,1836.69 ; 5702.52,1836.69 5717.71,1821.5 ; 5702.52,1836.69 5717.71,1821.5
DIAGCOMMS.FLASH_CS_N: J33.A44 R99.1 U30.P2 | length 9191.4
  Top Layer w4: J33.A44@-785.98,2495.38 -610.38,2495.38 -601.48,2486.48 v1(-601.48,2441.71) ; J33.A44@-711.58,2489.88 cw(c-698.3,2476.6) -698.3,2495.38 cw(c-698.3,2514.16) J33.A44@-711.58,2500.88 ; J33.A44@-708.76,2487.05 cw(c-688.65,2466.94) -688.65,2495.38 cw(c-688.65,2523.82) J33.A44@-708.76,2503.71 ; v1@-608.19,2448.43 ccw(c-624.41,2464.64) -601.48,2464.64 ccw(c-578.54,2464.64) v1@-594.76,2448.43 ; v1@-605.36,2445.6 ccw(c-614.75,2454.99) -601.48,2454.99 ccw(c-588.2,2454.99) v1@-597.59,2445.6 ; v1(-445,2375) -390,2375 -350,2415 R99.1@-271.18,2415 ; v1@-441.11,2371.11 cw(c-431.72,2361.72) -431.72,2375 cw(c-431.72,2388.28) v1@-441.11,2378.89 ; v1@-438.28,2368.28 cw(c-422.07,2352.06) -422.07,2375 cw(c-422.07,2397.93) v1@-438.28,2381.72 ; R99.1@-277.77,2408.41 ccw(c-293.68,2392.5) -293.68,2415 ccw(c-293.68,2437.5) R99.1@-277.77,2421.59 ; R99.1@-274.94,2411.24 ccw(c-284.02,2402.16) -284.02,2415 ccw(c-284.02,2427.84) R99.1@-274.94,2418.76 ; v2(6666,1620) 6678.62,1632.62 6734.05,1632.62 6734.38,1632.96 ; 6734.38,1632.96 ccw(c6734.38,1643.11) 6741.56,1635.93 ; 6734.38,1632.96 ccw(c6734.38,1643.11) 6741.56,1635.93 ; 6741.56,1635.93 ccw(c6729.03,1648.46) 6746.75,1648.46 cw(c6729.03,1648.46) 6741.56,1635.93 ; 6741.56,1635.93 cw(c6754.09,1623.4) 6754.09,1641.12 ccw(c6754.09,1623.4) 6741.56,1635.93
  MidLayer2 w4: v1(-601.48,2441.71) -571.67,2441.71 -455,2325.04 -331.35,2325.04 -280,2273.69 -280,2175.13 -260.58,2155.71 -103.29,2155.71 -85,2174 -59,2174 -34,2149 121,2149 377.5,1892.5 873.81,1892.5 936.31,1830 1540,1830 ; 1541.69,1830 1540,1830 ; v2@6659.06,1613.06 ccw(c6642.31,1596.31) 6642.31,1620 ccw(c6642.31,1643.69) v2@6659.06,1626.94 ; v2@6661.89,1615.89 ccw(c6651.97,1605.97) 6651.97,1620 ccw(c6651.97,1634.03) v2@6661.89,1624.11 ; v2(6666,1620) 6641,1620 6635,1626 6606.5,1626 6600.69,1620.19 6579.31,1620.19 6565.63,1633.87 6363.83,1633.87 6307.96,1578 6270,1578 6247,1578 6243.35,1578 6213.31,1608.04 6180.14,1608.04 6113.37,1674.81 5534.19,1674.81 5467.29,1741.71 5140.19,1741.71 5131.86,1750.04 5131.86,1828.41 4971.46,1988.81 3177.79,1988.81 3099.36,2067.25 3095.11,2071.5 3043.5,2071.5 2992,2123 2857.44,2123 2688.44,1954 2064,1954 2009.71,1899.71 1609.71,1899.71 1540,1830
  Bottom Layer w4: v1(-601.48,2441.71) -568.33,2441.71 -501.63,2375 v1(-445,2375) ; v1@-597.59,2437.82 cw(c-588.2,2428.43) -588.2,2441.71 cw(c-588.2,2454.99) v1@-597.59,2445.6 ; v1@-594.76,2434.99 cw(c-578.54,2418.77) -578.54,2441.71 cw(c-578.54,2464.64) v1@-594.76,2448.43 ; v1@-451.72,2368.28 ccw(c-467.94,2352.06) -467.94,2375 ccw(c-467.94,2397.93) v1@-451.72,2381.72 ; v1@-448.89,2371.11 ccw(c-458.28,2361.72) -458.28,2375 ccw(c-458.28,2388.28) v1@-448.89,2378.89
DIAGCOMMS.SCLK: J33.A45 U30.N2 | length 9419.4
  Top Layer w4: J33.A45@-785.98,2456.01 -665.78,2456.01 -609.81,2400.04 v1(-568.14,2400.04) ; J33.A45@-711.58,2450.51 cw(c-698.3,2437.23) -698.3,2456.01 cw(c-698.3,2474.79) J33.A45@-711.58,2461.51 ; J33.A45@-708.76,2447.68 cw(c-688.65,2427.57) -688.65,2456.01 cw(c-688.65,2484.45) J33.A45@-708.76,2464.34 ; v1@-574.86,2393.32 ccw(c-591.08,2377.11) -591.08,2400.04 ccw(c-591.08,2422.98) v1@-574.86,2406.76 ; v1@-572.03,2396.15 ccw(c-581.42,2386.76) -581.42,2400.04 ccw(c-581.42,2413.32) v1@-572.03,2403.93 ; v2(6590,1646) 6601.46,1657.46 6606.19,1662.19 6638.62,1662.19 ; 6638.62,1662.19 6655.38,1662.19 ; 6638.62,1662.19 6655.38,1662.19 ; 6655.38,1662.19 6665.52,1672.33 6734.38,1672.33 ; 6734.38,1672.33 ccw(c6734.38,1682.48) 6741.56,1675.3 ; 6734.38,1672.33 ccw(c6734.38,1682.48) 6741.56,1675.3 ; 6741.56,1675.3 ccw(c6729.03,1687.83) 6746.75,1687.83 cw(c6729.03,1687.83) 6741.56,1675.3 ; 6741.56,1675.3 cw(c6754.09,1662.77) 6754.09,1680.49 ccw(c6754.09,1662.77) 6741.56,1675.3
  MidLayer2 w4: v1(98.52,1800.04) 130.12,1831.64 130.12,1865.12 149.5,1884.5 870.5,1884.5 933,1822 1545,1822 1614.71,1891.71 2043.29,1891.71 2195,1740 2815,1740 2897,1658 4223.15,1658 v1(4281.86,1716.71) ; v1@98.52,1805.54 ccw(c98.52,1818.82) 107.91,1809.43 ccw(c117.3,1800.04) v1@104.02,1800.04 ; v1@98.52,1809.54 ccw(c98.52,1832.48) 114.74,1816.26 ccw(c130.96,1800.04) v1@108.02,1800.04 ; v1@4272.36,1716.71 cw(c4249.42,1716.71) 4265.64,1700.49 cw(c4281.86,1684.27) v1@4281.86,1707.21 ; v1@4276.36,1716.71 cw(c4263.08,1716.71) 4272.47,1707.32 cw(c4281.86,1697.93) v1@4281.86,1711.21
  Bottom Layer w4: v1@-568.14,2390.54 cw(c-568.14,2367.61) -551.93,2383.82 cw(c-535.71,2400.04) v1@-558.64,2400.04 ; v1@-568.14,2394.54 cw(c-568.14,2381.26) -558.75,2390.65 cw(c-549.36,2400.04) v1@-562.64,2400.04 ; v1(-568.14,2400.04) -535,2366.9 -535,2300 -555,2280 -555,1809 -546.04,1800.04 v1(98.52,1800.04) ; v1@91.81,1793.32 ccw(c75.59,1777.11) 75.59,1800.04 ccw(c75.59,1822.98) v1@91.81,1806.76 ; v1@94.64,1796.15 ccw(c85.25,1786.76) 85.25,1800.04 ccw(c85.25,1813.32) v1@94.64,1803.93 ; v1@4281.86,1707.21 cw(c4281.86,1684.27) 4298.07,1700.49 cw(c4314.29,1716.71) v1@4291.36,1716.71 ; v1@4281.86,1711.21 cw(c4281.86,1697.93) 4291.25,1707.32 cw(c4300.64,1716.71) v1@4287.36,1716.71 ; v1(4281.86,1716.71) 4298.7,1699.86 4314.86,1683.71 4873.86,1683.71 4998.52,1808.37 5490,1808.37 5522.65,1775.72 5548.09,1775.72 ; v2@6580.19,1646 cw(c6556.5,1646) 6573.25,1629.25 cw(c6590,1612.5) v2@6590,1636.19 ; v2@6584.19,1646 cw(c6570.16,1646) 6580.08,1636.08 cw(c6590,1626.16) v2@6590,1640.19 ; v2(6590,1646) 6569.71,1625.71 6464.56,1625.71 6421.56,1582.71 6305,1582.71 ; v2@6590,1650.5 v2@6590.65,1650.5 ; 5548.09,1775.72 5624.83,1775.72 ; 5548.09,1775.72 5624.83,1775.72 ; 5624.83,1775.72 5695,1705.55 5695,1695 ; 5695,1655 5695,1695 ; 5695,1655 5695,1695 ; 5695,1655 5695,1645.48 5772.69,1567.79 ; 5772.69,1567.79 5782.94,1557.54 ; 5772.69,1567.79 5782.94,1557.54 ; 5782.94,1557.54 5787.48,1553 6220.77,1553 6224.65,1556.87 ; 6224.65,1556.87 6250.48,1582.71 ; 6224.65,1556.87 6250.48,1582.71 ; 6250.48,1582.71 6305,1582.71 ; 6250.48,1582.71 6305,1582.71
DIPSW.D0: R243.1 SW8.16 U8.AF11 | length 6055.6
  Top Layer w4: v1@5138.47,2340.09 ccw(c5122.26,2356.31) 5145.19,2356.31 ccw(c5168.13,2356.31) v1@5151.91,2340.09 ; v1@5141.3,2337.26 ccw(c5131.91,2346.65) 5145.19,2346.65 ccw(c5158.47,2346.65) v1@5149.08,2337.26 ; v1(5145.19,2333.37) 5145.19,2359.81 5130,2375 5130,2400 5170.5,2440.5 5170.5,2600.34 5139.69,2631.15 5139.69,2655.58 5118.5,2676.77 5118.5,2760.11 5089.36,2789.25 5089.25,2789.25 4987.5,2891 4987.5,2977.25 4991,2980.75 4991,3161.56 5036.99,3207.55 5052.15,3222.71 5065.86,3222.71 5118.86,3275.71 5118.86,3423.37 5137.19,3441.71 5206.71,3441.71 5214.02,3449.02 5214.02,3523.58 5217.81,3527.37 5217.81,3568.63 5217.02,3569.42 5217.02,3605.71 5228.34,3617.03 5228.34,3638.82 5228.34,3697.36 cw(c5267.02,3697.36) 5239.67,3724.71 ; U8.AF11@5244.86,3737.24 cw(c5227.14,3737.24) 5239.67,3724.71 ; U8.AF11@5252.2,3729.9 ccw(c5252.2,3712.18) 5239.67,3724.71 ; v1@6707.14,444.66 cw(c6690.92,428.44) 6713.86,428.44 cw(c6736.79,428.44) v1@6720.57,444.66 ; v1@6709.97,447.49 cw(c6700.58,438.1) 6713.86,438.1 cw(c6727.14,438.1) v1@6717.75,447.49 ; v1(6713.86,451.37) 6713.86,428.14 6727.71,414.29 SW8.16@6790,414.29 ; SW8.16@6775.69,399.98 ccw(c6741.13,365.42) 6741.13,414.29 ccw(c6741.12,463.17) SW8.16@6775.69,428.61 ; SW8.16@6778.51,402.81 ccw(c6750.78,375.08) 6750.78,414.29 ccw(c6750.78,453.51) SW8.16@6778.51,425.78 ; SW8.16@6781.34,405.63 ccw(c6760.44,384.73) 6760.44,414.29 ccw(c6760.44,443.85) SW8.16@6781.34,422.95
  MidLayer1 w4: v1@5135.69,2333.37 cw(c5112.76,2333.37) 5128.97,2317.16 cw(c5145.19,2300.94) v1@5145.19,2323.87 ; v1@5139.69,2333.37 cw(c5126.41,2333.37) 5135.8,2323.99 cw(c5145.19,2314.6) v1@5145.19,2327.87 ; v1(5145.19,2333.37) 4990.19,2178.37 4990.19,1490 ; v1@5182.47,1229.66 ccw(c5166.26,1213.44) 5166.26,1236.37 ccw(c5166.26,1259.31) v1@5182.47,1243.09 ; v1@5185.3,1232.49 ccw(c5175.91,1223.1) 5175.91,1236.37 ccw(c5175.91,1249.65) v1@5185.3,1240.26 ; v1(5189.19,1236.37) 5063.63,1236.37 4990.19,1309.81 4990.19,1454.81 ; 4990.19,1454.81 4990.19,1490 ; 4990.19,1454.81 4990.19,1490
  Bottom Layer w4: R243.1@5061.18,2327.73 5061.18,2333.37 v1(5145.19,2333.37) ; R243.1@5062.11,2327.29 cw(c5076.81,2312.59) 5076.81,2333.37 ; R243.1@5064.94,2324.46 cw(c5086.47,2302.93) 5086.47,2333.37 ; R243.1@5067.77,2321.63 cw(c5096.13,2293.27) 5096.13,2333.37 ; v1@5138.47,2326.66 ccw(c5122.26,2310.44) 5122.26,2333.37 ccw(c5122.26,2356.31) v1@5138.47,2340.09 ; v1@5141.3,2329.49 ccw(c5131.91,2320.1) 5131.91,2333.37 ccw(c5131.91,2346.65) v1@5141.3,2337.26 ; v1(5189.19,1236.37) 5215,1236.37 5246,1267.37 5469.27,1267.37 5625.64,1111 5758.98,1111 5762.73,1107.25 5838.98,1031 5906.63,1031 6003.92,933.71 6476.11,933.71 6501.45,959.04 6695.96,959.04 6713.86,941.14 v1(6713.86,451.37) ; v1@5193.08,1232.49 cw(c5202.47,1223.1) 5202.47,1236.37 cw(c5202.47,1249.65) v1@5193.08,1240.26 ; v1@5195.91,1229.66 cw(c5212.13,1213.44) 5212.13,1236.37 cw(c5212.13,1259.31) v1@5195.91,1243.09 ; v1@6707.14,458.09 ccw(c6690.92,474.31) 6713.86,474.31 ccw(c6736.79,474.31) v1@6720.57,458.09 ; v1@6709.97,455.26 ccw(c6700.58,464.65) 6713.86,464.65 ccw(c6727.14,464.65) v1@6717.75,455.26
DIPSW.D1: R242.1 SW8.15 U8.AC11 | length 6843.8
  Top Layer w4: v2@5083.06,836.94 ccw(c5066.31,853.69) 5090,853.69 ccw(c5113.69,853.69) v2@5096.94,836.94 ; v2@5085.89,834.11 ccw(c5075.97,844.03) 5090,844.03 ccw(c5104.03,844.03) v2@5094.11,834.11 ; v2(5090,830) 5090,1034 5096,1040 5096,1109.69 5149.36,1163.04 5149.36,1265.62 5130.52,1284.46 5130.52,1425 5136.5,1430.98 5136.5,2015.37 5190.19,2069.06 5190.19,2431 5198.52,2439.34 v1(5198.52,2500.04) ; v1@5191.81,2493.32 cw(c5175.59,2477.11) 5198.52,2477.11 cw(c5221.46,2477.11) v1@5205.24,2493.32 ; v1@5194.64,2496.15 cw(c5185.25,2486.76) 5198.52,2486.76 cw(c5211.8,2486.76) v1@5202.41,2496.15 ; v3(5232.52,3835.67) U8.AC11@5252.2,3855.35 ; U8.AC11@5244.86,3855.35 cw(c5227.14,3855.35) 5239.67,3842.82 cw(c5252.2,3830.29) U8.AC11@5252.2,3848.01 ; v1(6816.86,340.04) 6880.04,340.04 6890,350 ; v1@6820.75,336.15 cw(c6830.14,326.76) 6830.14,340.04 cw(c6830.14,353.32) v1@6820.75,343.93 ; v1@6823.57,333.32 cw(c6839.79,317.11) 6839.79,340.04 cw(c6839.79,362.98) v1@6823.57,346.76 ; SW8.15@6878.53,371.83 cw(c6863.51,350) 6890,350 ; SW8.15@6880.79,375.12 cw(c6868.74,357.61) 6890,357.61 cw(c6911.26,357.61) SW8.15@6899.21,375.12 ; SW8.15@6883.06,378.42 cw(c6873.98,365.22) 6890,365.22 cw(c6906.02,365.22) SW8.15@6896.94,378.42 ; SW8.15@6890,414.29 6890,350 ; SW8.15@6901.48,371.83 ccw(c6916.49,350) 6890,350 ; 5245.32,3848.47 cw(c5232.52,3861.28) 5232.52,3843.17 ccw(c5232.52,3861.28) 5245.32,3848.47 ; 5245.32,3848.47 ccw(c5258.13,3835.67) 5240.02,3835.67 cw(c5258.13,3835.67) 5245.32,3848.47
  MidLayer1 w4: v2@5083.06,823.06 ccw(c5066.31,806.31) 5066.31,830 ccw(c5066.31,853.69) v2@5083.06,836.94 ; v2@5085.89,825.89 ccw(c5075.97,815.97) 5075.97,830 ccw(c5075.97,844.03) v2@5085.89,834.11 ; v2(5090,830) 5065,830 5048.19,813.19 5048.19,366.81 5058.27,356.73 5135,356.73 v2(5166.73,325) ; v1@5138.28,2581.72 ccw(c5122.06,2597.93) 5145,2597.93 ccw(c5167.93,2597.93) v1@5151.72,2581.72 ; v1@5141.11,2578.89 ccw(c5131.72,2588.28) 5145,2588.28 ccw(c5158.28,2588.28) v1@5148.89,2578.89 ; v1(5145,2575) 5145,2611.31 5146.5,2612.81 5146.5,2647.19 5142.48,2651.21 5142.48,2765.03 5140.19,2767.32 5140.19,2858.63 5139.36,2859.46 5139.36,2873.96 5150,2884.6 5150,2995.84 5148.02,2997.81 5148.02,3028.02 5156.52,3036.52 5156.52,3225.71 5189.19,3258.37 5223.86,3293.04 5223.86,3562.59 5208.66,3577.79 5208.66,3630.82 5208.66,3638.82 5208.66,3679.25 5208.66,3698.67 5208.66,3772.79 ; v2@5156.92,325 ccw(c5133.23,325) 5149.98,341.75 ccw(c5166.73,358.5) v2@5166.73,334.81 ; v2@5160.92,325 ccw(c5146.89,325) 5156.81,334.92 ccw(c5166.73,344.84) v2@5166.73,330.81 ; 5208.66,3758.86 5208.66,3772.79 ; v3@5225.05,3835.02 cw(c5207.01,3833.44) 5220.88,3821.8 ; v3@5233.17,3828.2 ccw(c5234.75,3810.16) 5220.88,3821.8 ; 5208.66,3772.79 5208.66,3792.29 cw(c5250.39,3792.29) 5220.88,3821.8
  MidLayer2 w4: v2@5159.79,318.06 cw(c5143.04,301.31) 5166.73,301.31 cw(c5190.41,301.31) v2@5173.67,318.06 ; v2@5162.62,320.89 cw(c5152.7,310.97) 5166.73,310.97 cw(c5180.76,310.97) v2@5170.84,320.89 ; v2(5166.73,325) 5166.73,281.84 5240.19,208.37 5398.52,208.37 5431.86,241.71 6473.52,241.71 6485.89,254.08 6730.89,254.08 v1(6816.86,340.04) ; v1@6807.36,340.04 cw(c6784.42,340.04) 6800.64,323.82 cw(c6816.86,307.61) v1@6816.86,330.54 ; v1@6811.36,340.04 cw(c6798.08,340.04) 6807.47,330.65 cw(c6816.86,321.26) v1@6816.86,334.54
  Bottom Layer w4: R242.1@5061.12,2381.45 ccw(c5061.63,2405.49) 5078.63,2388.48 ; R242.1@5061.18,2383.64 5073.79,2383.64 5098.52,2408.37 ; R242.1@5061.21,2385.45 ccw(c5061.91,2418.47) 5085.26,2395.11 ; R242.1@5061.29,2389.45 ccw(c5062.18,2431.46) 5091.89,2401.74 ; R242.1@5061.38,2393.44 ccw(c5062.45,2444.44) 5098.52,2408.37 ; v1(5145,2575) 5162.25,2575 ; v1@5153.03,2569.92 cw(c5162.25,2564.09) 5162.25,2575 ; v1@5153.03,2580.08 ccw(c5162.25,2585.91) 5162.25,2575 ; v1@5191.81,2506.76 ccw(c5175.59,2522.98) 5198.52,2522.98 ccw(c5221.46,2522.98) v1@5205.24,2506.76 ; v1@5193.68,2491.87 cw(c5188.66,2483.38) 5198.52,2483.38 ; v1@5194.64,2503.93 ccw(c5185.25,2513.32) 5198.52,2513.32 ccw(c5211.8,2513.32) v1@5202.41,2503.93 ; v1@5203.36,2491.87 ccw(c5208.39,2483.38) 5198.52,2483.38 ; 5098.52,2408.37 5123.52,2408.37 5198.52,2483.37 ; 5162.25,2575 5198.52,2538.73 v1(5198.52,2500.04) 5198.52,2483.37
DIPSW.D2: R241.1 SW8.14 U8.AE10 | length 6476.8
  Top Layer w4: 5038.95,2953.71 ccw(c5038.95,2981.05) v1@5058.28,2961.72 ; 5045.18,2953.71 cw(c5045.18,2935.18) v1@5058.28,2948.28 ; 5048.6,2953.71 ccw(c5048.6,2971.4) v1@5061.11,2958.89 ; v1(5065,2955) 5063.71,2953.71 5028.71,2953.71 5014.52,2939.52 5014.52,2875.29 5092.57,2797.25 5092.67,2797.25 5106.55,2783.37 5156.86,2783.37 5165.19,2775.04 5165.19,2675.04 5215.19,2625.04 5215.19,2545.19 5181.02,2511.02 5181.02,2316.02 5173.37,2308.37 5140.19,2308.37 5107,2341.56 5107,2432.85 v1(5107.52,2433.37) ; v1@5100.81,2426.66 cw(c5085.85,2411.71) 5107,2411.71 ; v1@5103.64,2429.49 cw(c5095.51,2421.36) 5107,2421.36 ; 5107,2409.17 cw(c5131.72,2409.17) v1@5114.24,2426.66 ; 5107,2418.83 cw(c5122.07,2418.83) v1@5111.41,2429.49 ; v3(5193.15,3756.93) U8.AE10@5212.83,3776.61 ; U8.AE10@5205.49,3776.61 cw(c5187.77,3776.61) 5200.3,3764.08 cw(c5212.83,3751.55) U8.AE10@5212.83,3769.27 ; SW8.14@6983.11,378.38 cw(c6974.24,365.36) 6990,365.36 cw(c7005.76,365.36) SW8.14@6996.89,378.38 ; v1@6983.47,356.76 ccw(c6967.71,372.52) SW8.14@6990,372.52 ; v1@6986.3,353.93 ccw(c6977.37,362.86) 6990,362.86 ; 6990,363.78 ccw(c7003.93,363.78) v1@6994.08,353.93 ; SW8.14@6990,373.43 ccw(c7013.58,373.43) v1@6996.91,356.76 ; SW8.14@6990,414.29 6990,350.23 v1(6990.19,350.04) ; 5205.95,3769.73 cw(c5193.15,3782.54) 5193.15,3764.43 ccw(c5193.15,3782.54) 5205.95,3769.73 ; 5205.95,3769.73 ccw(c5218.76,3756.93) 5200.65,3756.93 cw(c5218.76,3756.93) 5205.95,3769.73
  MidLayer1 w4: v1@4933.47,1591.76 ccw(c4917.26,1607.98) 4940.19,1607.98 ccw(c4963.13,1607.98) v1@4946.91,1591.76 ; v1@4936.3,1588.93 ccw(c4926.91,1598.32) 4940.19,1598.32 ccw(c4953.47,1598.32) v1@4944.08,1588.93 ; v1(4940.19,1585.04) 4940.19,1645 4957.19,1662 4957.19,2283.04 5075.26,2401.11 v1(5107.52,2433.37) ; v1(5065,2955) 5061.82,2955 5148.52,3041.71 5148.52,3229.02 5215.86,3296.35 5215.86,3559.27 5193.15,3581.98 5193.15,3630.82 5193.15,3638.82 5193.15,3679.25 v3(5193.15,3756.93) ; v1@5065,2964.5 ccw(c5065,2979.75) 5075.78,2968.97 ; v1@5070.5,2955 cw(c5091.46,2955) 5076.64,2969.82 ; v1@5074.5,2955 cw(c5105.12,2955) 5083.47,2976.65 ; v1@5098.02,2433.37 cw(c5075.09,2433.37) 5091.31,2417.16 cw(c5107.52,2400.94) v1@5107.52,2423.87 ; v1@5102.02,2433.37 cw(c5088.75,2433.37) 5098.14,2423.99 cw(c5107.52,2414.6) v1@5107.52,2427.87 ; v3@5187.96,3751.74 cw(c5175.42,3739.2) 5193.15,3739.2 cw(c5210.88,3739.2) v3@5198.34,3751.74 ; 5193.15,3738.82 cw(c5211.26,3738.82) 5198.45,3751.63 ccw(c5211.26,3738.82) 5193.15,3738.82 ; 5193.15,3738.82 ccw(c5175.04,3738.82) 5187.85,3751.63 cw(c5175.04,3738.82) 5193.15,3738.82
  MidLayer2 w4: v1@4940.19,1575.54 cw(c4940.19,1552.61) 4956.41,1568.82 cw(c4972.63,1585.04) v1@4949.69,1585.04 ; v1@4940.19,1579.54 cw(c4940.19,1566.26) 4949.58,1575.65 cw(c4958.97,1585.04) v1@4945.69,1585.04 ; v1(4940.19,1585.04) 5000.19,1525.04 5141.86,1383.37 5275.9,1383.37 5436.06,1223.21 5554.01,1223.21 5584.09,1253.29 5686.95,1253.29 5724.02,1216.21 5894.69,1216.21 5919.69,1241.21 6039.05,1241.21 6125.25,1155 6138.52,1155 6148.52,1145 6148.52,983.37 6190.19,941.71 6458.29,941.71 6691.77,708.23 6691.77,648.46 v1(6990.19,350.04) ; v1@6980.69,350.04 ccw(c6957.76,350.04) 6973.97,366.26 ccw(c6990.19,382.48) v1@6990.19,359.54 ; v1@6984.69,350.04 ccw(c6971.41,350.04) 6980.8,359.43 ccw(c6990.19,368.82) v1@6990.19,355.54
  Bottom Layer w4: R241.1@5061.18,2439.55 5061.18,2441.71 5099.19,2441.71 v1(5107.52,2433.37) ; R241.1@5064.47,2441.71 cw(c5064.47,2390.32) v1@5100.81,2426.66 ; R241.1@5064.94,2436.28 cw(c5078.06,2423.16) 5078.06,2441.71 ; R241.1@5067.77,2433.45 cw(c5087.71,2413.51) 5087.71,2441.71 ; R241.1@5067.77,2446.63 ccw(c5079.65,2458.5) 5079.65,2441.71 ; 5074.13,2441.71 cw(c5074.13,2399.98) v1@5103.64,2429.49 ; 5083.79,2441.71 cw(c5083.79,2409.64) v1@5106.46,2432.31 ; 5093.44,2441.71 cw(c5093.44,2419.29) v1@5109.29,2435.14
DIPSW.D3: R240.1 SW8.13 U8.AF10 | length 6151.1
  Top Layer w4: 5095,2342.25 5180,2257.25 5180,2070.18 5143.19,2033.37 ; 5100,2337.25 5090.02,2347.23 5090.02,2450.02 5100,2460 v1(5140,2460) 5162.5,2482.5 5162.5,2570 ; v1@5122.36,1258.37 ccw(c5099.42,1258.37) 5115.64,1274.59 ccw(c5131.86,1290.81) v1@5131.86,1267.87 ; v1@5126.36,1258.37 ccw(c5113.08,1258.37) 5122.47,1267.76 ccw(c5131.86,1277.15) v1@5131.86,1263.87 ; v1(5131.86,1258.37) 5114.86,1275.37 5114.86,1438.39 5128.5,1452.04 5128.5,2018.68 ; v1@5133.28,2453.28 ccw(c5117.06,2437.06) 5117.06,2460 ccw(c5117.06,2482.93) v1@5133.28,2466.72 ; v1@5136.11,2456.11 ccw(c5126.72,2446.72) 5126.72,2460 ccw(c5126.72,2473.28) v1@5136.11,2463.89 ; v1@5140,2465.5 ccw(c5140,2478.78) 5149.39,2469.39 ccw(c5158.78,2460) v1@5145.5,2460 ; v1@5140,2469.5 ccw(c5140,2492.43) 5156.22,2476.22 ccw(c5172.43,2460) v1@5149.5,2460 ; 5156.86,3488.04 5152.19,3483.37 ; 5162.5,2545 5162.5,2570 ; v1(7040,480) 7085,480 7090,475 SW8.13@7090,414.29 ; v1@7043.89,476.11 cw(c7053.28,466.72) 7053.28,480 cw(c7053.28,493.28) v1@7043.89,483.89 ; v1@7046.72,473.28 cw(c7062.93,457.06) 7062.93,480 cw(c7062.93,502.93) v1@7046.72,486.72 ; 5128.5,2018.68 5143.19,2033.37 ; 5128.5,2018.68 5143.19,2033.37 ; 5152.19,3483.37 5179.53,3510.71 5188.97,3520.16 5188.97,3532.47 5193.81,3537.31 5193.81,3558.69 5188.97,3563.53 5188.97,3630.82 5188.97,3638.82 5188.97,3697.36 ; 5152.19,3483.37 5115.19,3483.37 5090.19,3458.37 5090.19,3437.37 5110.86,3416.71 5110.86,3279.02 5062.54,3230.71 5048.84,3230.71 5033.68,3215.55 4983,3164.87 4983,2984.06 4979.5,2980.56 4979.5,2887.69 5091.98,2775.21 5092.09,2775.21 5110.5,2756.79 5110.5,2673.46 5131.69,2652.27 5131.69,2627.83 5162.5,2597.02 5162.5,2570 ; 5188.97,3697.36 cw(c5227.65,3697.36) 5200.3,3724.71 ; 5188.97,3697.36 cw(c5227.65,3697.36) 5200.3,3724.71 ; 5200.3,3724.71 cw(c5212.83,3712.18) 5212.83,3729.9 ccw(c5212.83,3712.18) 5200.3,3724.71 ; 5200.3,3724.71 ccw(c5187.77,3737.24) 5205.49,3737.24 cw(c5187.77,3737.24) 5200.3,3724.71
  Bottom Layer w4: R240.1@5061.18,2495.45 5104.55,2495.45 v1(5140,2460) ; R240.1@5064.94,2491.69 cw(c5074.02,2482.61) 5074.02,2495.45 cw(c5074.02,2508.3) R240.1@5064.94,2499.22 ; R240.1@5067.77,2488.86 cw(c5083.68,2472.96) 5083.68,2495.45 cw(c5083.68,2517.95) R240.1@5067.77,2502.04 ; v1@5130.5,2460 ccw(c5107.56,2460) 5123.78,2476.22 ccw(c5140,2492.43) v1@5140,2469.5 ; v1(5131.86,1258.37) 5165,1258.37 5182,1275.37 5472.58,1275.37 5628.96,1119 5762.29,1119 5770.92,1110.37 5780.29,1101 5786.5,1094.79 5842.29,1039 5909.94,1039 6007.23,941.71 6472.8,941.71 6498.13,967.04 7017.96,967.04 7040,945 v1(7040,480) ; v1@5134.5,2460 ccw(c5121.22,2460) 5130.61,2469.39 ccw(c5140,2478.78) v1@5140,2465.5 ; v1@5135.75,1254.49 cw(c5145.14,1245.1) 5145.14,1258.37 cw(c5145.14,1271.65) v1@5135.75,1262.26 ; v1@5138.57,1251.66 cw(c5154.79,1235.44) 5154.79,1258.37 cw(c5154.79,1281.31) v1@5138.57,1265.09 ; v1@7033.28,486.72 ccw(c7017.06,502.93) 7040,502.93 ccw(c7062.93,502.93) v1@7046.72,486.72 ; v1@7036.11,483.89 ccw(c7026.72,493.28) 7040,493.28 ccw(c7053.28,493.28) v1@7043.89,483.89
DIPSW.D4: R239.1 SW8.12 U8.AG8 | length 6584.1
  Top Layer w4: v1@4950.5,2530 ccw(c4927.56,2530) 4943.78,2546.22 ccw(c4960,2562.43) v1@4960,2539.5 ; v1@4954.5,2530 ccw(c4941.22,2530) 4950.61,2539.39 ccw(c4960,2548.78) v1@4960,2535.5 ; v1(4960,2530) 4915,2575 4915,3163.69 5018.02,3266.71 v1(5053.19,3266.71) ; v1@5046.47,3259.99 ccw(c5030.26,3243.77) 5030.26,3266.71 ccw(c5030.26,3289.64) v1@5046.47,3273.43 ; v1@5049.3,3262.82 ccw(c5039.91,3253.43) 5039.91,3266.71 ccw(c5039.91,3279.99) v1@5049.3,3270.6 ; v1@5117.14,3561.09 ccw(c5091.57,3586.66) 5127.73,3586.66 ; v1@5119.97,3558.26 ccw(c5101.23,3577.01) 5127.73,3577.01 ; v1@5122.8,3555.44 ccw(c5110.88,3567.35) 5127.73,3567.35 ; v1(5123.86,3554.37) 5127.73,3558.25 5127.73,3609.9 5118.59,3619.04 5118.59,3630.82 5118.59,3638.82 5118.59,3678.16 cw(c5128.74,3678.16) 5121.56,3685.34 ; U8.AG8@5126.75,3697.87 cw(c5109.03,3697.87) 5121.56,3685.34 ; 5127.73,3567.96 ccw(c5137.44,3567.96) v1@5130.57,3561.09 ; U8.AG8@5134.09,3690.53 ccw(c5134.09,3672.8) 5121.56,3685.34 ; v1(7075,545) 7120.23,545 7190.19,475.04 ; v1@7078.89,541.11 cw(c7088.28,531.72) 7088.28,545 cw(c7088.28,558.28) v1@7078.89,548.89 ; v1@7081.72,538.28 cw(c7097.94,522.06) 7097.94,545 cw(c7097.94,567.93) v1@7081.72,551.72 ; SW8.12@7180.07,457.72 ccw(c7170.31,475.04) 7190.19,475.04 ; SW8.12@7182.03,454.23 ccw(c7174.16,468.2) 7190.19,468.2 ; SW8.12@7190,414.29 7190,440.08 7190.19,440.08 7190.19,475.04 ; 7190.19,468.07 ccw(c7206.37,468.07) SW8.12@7198.2,454.1 ; SW8.12@7200.22,457.55 cw(c7210.45,475.04) 7190.19,475.04
  MidLayer1 w4: v1@4960,2520.5 cw(c4960,2497.56) 4976.22,2513.78 cw(c4992.43,2530) v1@4969.5,2530 ; v1@4960,2524.5 cw(c4960,2511.22) 4969.39,2520.61 cw(c4978.78,2530) v1@4965.5,2530 ; v1@4960,2529.16 v1(4960,2530) 4990,2500 4990,2441.52 4940.19,2391.71 4940.19,2366.71 4817.47,2243.99 4731.19,2157.71 4731.19,1970.15 4732.34,1969 4732.34,1941 4731.19,1939.85 4731.19,1348.34 5211.53,868 6082,868 6297.69,652.31 6297.69,500 6362.69,435 6475.15,435 6540.19,500.04 7030.31,500.04 7075,544.73 v1(7075,545) ; 7058.59,528.32 ccw(c7041.91,545) v1@7065.5,545 ; 7059.25,528.97 cw(c7075,513.22) v1@7075,535.5 ; 7065.42,535.15 ccw(c7055.57,545) v1@7069.5,545 ; 7066.07,535.8 cw(c7075,526.88) v1@7075,539.5
  MidLayer2 w4: v1@5043.69,3266.71 ccw(c5020.76,3266.71) 5036.97,3282.93 ccw(c5053.19,3299.14) v1@5053.19,3276.21 ; v1@5047.69,3266.71 ccw(c5034.41,3266.71) 5043.8,3276.1 ccw(c5053.19,3285.49) v1@5053.19,3272.21 ; v1(5053.19,3266.71) 5015.19,3304.71 5015.19,3341.37 5023.52,3349.71 5124.52,3349.71 5140.19,3365.37 5140.69,3365.87 5140.69,3473.31 5106.86,3507.14 5106.86,3537.37 v1(5123.86,3554.37) ; v1@5114.36,3554.37 cw(c5091.42,3554.37) 5107.64,3538.16 cw(c5123.86,3521.94) v1@5123.86,3544.87 ; v1@5118.36,3554.37 cw(c5105.08,3554.37) 5114.47,3544.99 cw(c5123.86,3535.6) v1@5123.86,3548.87
  Bottom Layer w4: v1(4960,2530) 4964.96,2525.04 5047.85,2525.04 5061.18,2538.37 R239.1@5061.18,2551.36 ; v1@4961.06,2531.06 ccw(c4975.59,2545.59) 4975.59,2525.04 ; v1@4963.89,2533.89 ccw(c4985.25,2555.25) 4985.25,2525.04 ; v1@4966.72,2523.28 cw(c4970.96,2519.04) 4970.96,2525.04 ; v1@4966.72,2536.72 ccw(c4994.91,2564.91) 4994.91,2525.04 ; 5054.1,2531.29 ccw(c5047.34,2538.04) R239.1@5054.35,2544.54 ; 5057.03,2534.23 ccw(c5050.39,2540.87) R239.1@5057.28,2547.26 ; 5059.97,2537.16 ccw(c5053.44,2543.7) R239.1@5060.21,2549.97