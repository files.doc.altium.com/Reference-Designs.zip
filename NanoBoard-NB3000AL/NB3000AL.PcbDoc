# Altium PCB NB3000AL.PcbDoc (part 70 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
RS485.TX_EN: U8.H8 U46.4 | length 4985.1
  Top Layer w4: v3(5114.41,4465.59) U8.H8@5134.09,4445.91 ; U8.H8@5126.75,4445.91 ccw(c5109.03,4445.91) 5121.56,4458.44 ccw(c5134.09,4470.97) U8.H8@5134.09,4453.25 ; 5127.21,4452.79 cw(c5140.02,4465.59) 5121.91,4465.59 ccw(c5140.02,4465.59) 5127.21,4452.79 ; 5127.21,4452.79 ccw(c5114.41,4439.98) 5114.41,4458.09 cw(c5114.41,4439.98) 5127.21,4452.79
  MidLayer2 w4: v1(1916.86,5575.04) 2051.86,5575.04 2127.99,5498.91 2137.02,5489.88 2201.5,5489.88 2207.17,5495.54 2519.69,5495.54 2533.5,5481.74 2548.52,5466.71 3028.88,5466.71 3029.37,5467.2 3034.34,5467.2 3185.41,5316.14 3340.18,5316.14 3355,5301.31 3355,5230 3434.96,5150.04 4540.19,5150.04 4565.19,5125.04 4565.19,5091.71 4556.86,5083.37 4540.19,5083.37 4506.86,5116.71 4386.71,5116.71 4377.28,5107.28 4377.28,5073.22 4392.13,5058.37 4544.25,5058.37 4620.52,4982.1 4620.52,4821.56 4609.36,4810.4 4609.36,4787.21 4612,4784.57 4612,4784.32 4613.36,4782.95 4613.36,4778.21 4613.36,4740.36 4620.52,4733.2 v1(4620.52,4647.04) ; v1@1920.75,5571.15 cw(c1930.14,5561.76) 1930.14,5575.04 cw(c1930.14,5588.32) v1@1920.75,5578.93 ; v1@1923.57,5568.32 cw(c1939.79,5552.11) 1939.79,5575.04 cw(c1939.79,5597.98) v1@1923.57,5581.76 ; v1@4613.81,4653.76 ccw(c4597.59,4669.98) 4620.52,4669.98 ccw(c4643.46,4669.98) v1@4627.24,4653.76 ; v1@4616.64,4650.93 ccw(c4607.25,4660.32) 4620.52,4660.32 ccw(c4633.8,4660.32) v1@4624.41,4650.93
  Bottom Layer w4: U46.4@1731.54,5570.08 1763.04,5570.08 1765.19,5570.08 1765.19,5570.37 1769.86,5575.04 v1(1916.86,5575.04) ; U46.4@1764.32,5568.8 cw(c1779.39,5553.72) 1779.39,5575.04 ; U46.4@1767.15,5565.97 cw(c1789.05,5544.07) 1789.05,5575.04 ; U46.4@1769.98,5563.14 cw(c1798.71,5534.41) 1798.71,5575.04 ; U46.4@1769.98,5577.01 ccw(c1774.74,5581.78) U46.4@1774.74,5575.04 ; v1@1910.14,5568.32 ccw(c1893.92,5552.11) 1893.92,5575.04 ccw(c1893.92,5597.98) v1@1910.14,5581.76 ; v1@1912.97,5571.15 ccw(c1903.58,5561.76) 1903.58,5575.04 ccw(c1903.58,5588.32) v1@1912.97,5578.93 ; v1(4620.52,4647.04) 4707.96,4647.04 4755.7,4599.3 4830.82,4599.3 4838.82,4599.3 4840.41,4599.3 4898.67,4599.3 4956.93,4599.3 cw(c4956.93,4583.7) 4972.53,4583.7 ccw(c4996.3,4583.7) 4996.3,4559.93 cw(c4996.3,4544.33) 5011.9,4544.33 ccw(c5035.67,4544.33) 5035.67,4520.56 cw(c5035.67,4504.96) 5051.27,4504.96 ccw(c5075.04,4504.96) 5075.04,4481.19 5083.16,4481.19 ; v1@4624.41,4643.15 cw(c4633.8,4633.76) 4633.8,4647.04 cw(c4633.8,4660.32) v1@4624.41,4650.93 ; v1@4627.24,4640.32 cw(c4643.46,4624.11) 4643.46,4647.04 cw(c4643.46,4669.98) v1@4627.24,4653.76 ; 5083.21,4481.14 cw(c5084.82,4457.42) 5099.61,4476.02 ; v3@5107.02,4464.29 ccw(c5089.19,4461.14) 5099.58,4475.98 ccw(c5109.96,4490.81) v3@5113.11,4472.98
RS485.TXD: U8.C3 U46.5 | length 4233.2
  Top Layer w4: v1@4716.81,4893.32 cw(c4700.59,4877.11) 4723.52,4877.11 cw(c4746.46,4877.11) v1@4730.24,4893.32 ; v1@4719.64,4896.15 cw(c4710.25,4886.76) 4723.52,4886.76 cw(c4736.8,4886.76) v1@4727.41,4896.15 ; v1(4723.52,4900.04) 4723.52,4866 4750,4839.53 4750,4822.5 4800,4772.5 4800,4670 4803.38,4666.62 4830.82,4666.62 4838.82,4666.62 ; U8.C3@4929.9,4642.76 ccw(c4912.18,4642.76) 4924.71,4655.29 ; U8.C3@4937.24,4650.1 cw(c4937.24,4667.82) 4924.71,4655.29 ; 4838.82,4666.62 4897.36,4666.62 ; 4838.82,4666.62 4897.36,4666.62 ; 4897.36,4666.62 cw(c4897.36,4627.94) 4924.71,4655.29 ; 4897.36,4666.62 cw(c4897.36,4627.94) 4924.71,4655.29
  MidLayer2 w4: v1(3831.86,5000.04) 4181.86,5000.04 4290.19,4891.71 ; v1@3835.75,4996.15 cw(c3845.14,4986.76) 3845.14,5000.04 cw(c3845.14,5013.32) v1@3835.75,5003.93 ; v1@3838.57,4993.32 cw(c3854.79,4977.11) 3854.79,5000.04 cw(c3854.79,5022.98) v1@3838.57,5006.76 ; v1@4298.68,4886.87 ccw(c4290.19,4881.84) 4290.19,4891.71 ; v1@4298.68,4896.55 cw(c4290.19,4901.58) 4290.19,4891.71 ; v1(4306.86,4891.71) 4290.19,4891.71
  Bottom Layer w4: U46.5@1731.54,5520.08 1789.92,5520.08 1800,5510 1800,5290.23 ; U46.5@1767.15,5515.97 cw(c1777.07,5506.05) 1777.07,5520.08 cw(c1777.07,5534.11) U46.5@1767.15,5524.19 ; U46.5@1769.98,5513.14 cw(c1786.72,5496.39) 1786.72,5520.08 cw(c1786.73,5543.76) U46.5@1769.98,5527.01 ; 1810.61,5279.62 1800,5290.23 ; v1(3831.86,5000.04) 2090.19,5000.04 1800,5290.23 ; v1(4306.86,4891.71) 4332.19,4917.04 4676.85,4917.04 4682.62,4922.81 4700.75,4922.81 v1(4723.52,4900.04) ; v1@4306.86,4897.21 ccw(c4306.86,4910.49) 4316.25,4901.1 ccw(c4325.64,4891.71) v1@4312.36,4891.71 ; v1@4306.86,4901.21 ccw(c4306.86,4924.14) 4323.07,4907.93 ccw(c4339.29,4891.71) v1@4316.36,4891.71 ; v1@4714.02,4900.04 ccw(c4691.09,4900.04) 4707.31,4916.26 ccw(c4723.52,4932.48) v1@4723.52,4909.54 ; v1@4718.02,4900.04 ccw(c4704.75,4900.04) 4714.14,4909.43 ccw(c4723.52,4918.82) v1@4723.52,4905.54
RXER_U: R51.1 U5.24 U6.6 | length 2052.5
  MidLayer1 w4: v1@2233.47,5601.66 cw(c2217.26,5585.44) 2240.19,5585.44 cw(c2263.13,5585.44) v1@2246.91,5601.66 ; v1@2236.3,5604.49 cw(c2226.91,5595.1) 2240.19,5595.1 cw(c2253.47,5595.1) v1@2244.08,5604.49 ; v1(2240.19,5608.37) 2240.19,5581.37 2304.86,5516.71 2456.86,5516.71 2520.39,5516.71 2582.69,5579 2813.82,5579 2828.78,5564.04 v1(3540.19,5564.04) ; v1@3533.47,5557.32 ccw(c3517.26,5541.11) 3517.26,5564.04 ccw(c3517.26,5586.98) v1@3533.47,5570.76 ; v1@3536.3,5560.15 ccw(c3526.91,5550.76) 3526.91,5564.04 ccw(c3526.91,5577.32) v1@3536.3,5567.93
  Bottom Layer w4: R51.1@2106.18,5598.33 U5.24@2193.48,5598.33 ; R51.1@2109.94,5594.57 cw(c2119.02,5585.49) 2119.02,5598.33 cw(c2119.02,5611.18) R51.1@2109.94,5602.09 ; R51.1@2112.77,5591.74 cw(c2128.68,5575.84) 2128.68,5598.33 cw(c2128.68,5620.83) R51.1@2112.77,5604.92 ; 2160.2,5598.33 cw(c2160.2,5588.45) U5.24@2167.19,5595.44 ; 2160.52,5598.33 ccw(c2160.52,5607.77) U5.24@2167.19,5601.1 ; U5.24@2203.06,5598.27 ccw(c2203.06,5644.73) v1@2236.26,5612.22 ; U5.24@2212.58,5598.27 ccw(c2212.58,5635.42) v1@2239.12,5609.42 ; U5.24@2219.9,5595.44 cw(c2226.73,5588.61) 2226.73,5598.27 cw(c2226.73,5607.92) U5.24@2219.9,5601.1 ; U5.24@2222.09,5598.27 ccw(c2222.09,5626.1) v1@2241.98,5606.63 ; 2231.61,5598.27 ccw(c2231.61,5616.78) v1@2244.83,5603.83 ; v1@2233.4,5615.02 cw(c2193.55,5654.05) U5.24@2193.54,5598.27 2238.42,5598.27 2240.19,5600.04 v1(2240.19,5608.37) ; v1@3538.42,5565.81 cw(c3553.86,5550.37) 3553.86,5572.2 ; v1(3540.19,5564.04) 3548.35,5572.2 U6.6@3598.94,5572.2 ; v1@3541.25,5562.98 cw(c3563.52,5540.71) U6.6@3563.52,5572.2 ; v1@3544.08,5560.15 cw(c3573.18,5531.05) U6.6@3573.18,5572.2 ; v1@3546.91,5557.32 cw(c3582.83,5521.4) U6.6@3582.83,5572.2
S_LED0: R57.1 R58.1 U5.9 | length 1810.4
  Top Layer w4: v2@2718.06,5396.94 ccw(c2689.24,5425.76) 2730,5425.76 ; v2@2720.89,5394.11 ccw(c2698.9,5416.1) 2730,5416.1 ; v2@2723.06,5798.06 cw(c2706.31,5781.31) 2730,5781.31 cw(c2753.69,5781.31) v2@2736.94,5798.06 ; v2@2723.72,5391.28 ccw(c2708.56,5406.44) 2730,5406.44 ; v2(2725,5390) 2730,5395 v2(2730,5805) ; v2@2725.89,5800.89 cw(c2715.97,5790.97) 2730,5790.97 cw(c2744.03,5790.97) v2@2734.11,5800.89 ; 2730,5401.61 ccw(c2736.61,5401.61) v2@2731.94,5396.94
  MidLayer2 w4: v2(2290,5260) 2292.46,5257.54 2420,5257.54 2439.7,5277.24 2439.7,5377.53 2462.7,5400.54 2680,5400.54 2690.54,5390 v2(2725,5390) ; v2@2294.11,5264.11 ccw(c2309.97,5279.97) 2309.97,5257.54 ; v2@2296.94,5253.06 cw(c2307.75,5242.25) 2307.75,5257.54 ; v2@2296.94,5266.94 ccw(c2319.62,5289.62) 2319.62,5257.54 ; v2@2718.06,5383.06 ccw(c2701.31,5366.31) 2701.31,5390 ccw(c2701.31,5413.69) v2@2718.06,5396.94 ; v2@2720.89,5385.89 ccw(c2710.97,5375.97) 2710.97,5390 ccw(c2710.97,5404.03) v2@2720.89,5394.11
  Bottom Layer w4: v2(2290,5260) 2311.65,5281.65 U5.9@2311.65,5322.68 ; v2@2290,5265.81 ccw(c2290,5279.84) 2299.92,5269.92 ccw(c2309.84,5260) v2@2295.81,5260 ; v2@2290,5269.81 ccw(c2290,5293.5) 2306.75,5276.75 ccw(c2323.5,5260) v2@2299.81,5260 ; U5.9@2308.82,5296.32 cw(c2302,5289.49) 2311.65,5289.49 cw(c2321.31,5289.49) U5.9@2314.48,5296.32 ; v2(2730,5805) 2774.96,5805 2780,5810.04 2838.22,5810.04 R57.1@2856.18,5828 ; v2@2734.11,5800.89 cw(c2744.03,5790.97) 2744.03,5805 cw(c2744.03,5819.03) v2@2734.11,5809.11 ; v2@2736.94,5798.06 cw(c2753.69,5781.31) 2753.69,5805 cw(c2753.69,5828.69) v2@2736.94,5811.94 ; R58.1@2813.82,5867.19 cw(c2813.82,5843.5) 2830.57,5860.25 ; R58.1@2813.82,5871.19 cw(c2813.82,5857.16) R58.1@2823.74,5867.08 ; R58.1@2813.82,5877 R57.1@2856.18,5834.64 ; R58.1@2819.14,5876.51 ccw(c2830.79,5876.51) R58.1@2822.55,5868.27 ; R58.1@2823.14,5876.51 ccw(c2844.45,5876.51) 2829.38,5861.44 ; 2835.93,5854.89 cw(c2809.53,5828.49) R57.1@2846.86,5828.49 ; 2839.43,5811.25 cw(c2856.18,5794.5) R57.1@2856.18,5818.19 ; 2840.62,5812.44 ccw(c2825.55,5827.51) R57.1@2846.86,5827.51 ; 2842.76,5848.06 cw(c2823.18,5828.49) R57.1@2850.86,5828.49 ; R57.1@2846.26,5818.08 cw(c2856.18,5808.16) R57.1@2856.18,5822.19 ; R57.1@2847.45,5819.27 ccw(c2839.21,5827.51) R57.1@2850.86,5827.51 ; 2849.58,5841.23 cw(c2836.84,5828.49) R57.1@2854.86,5828.49 ; 2850.76,5840.05 ccw(c2856.18,5845.47) R57.1@2856.18,5837.81
S_LED1: R60.2 R62.1 U5.10 | length 1575.8
  MidLayer1 w4: v1@2272.36,5470.04 ccw(c2249.42,5470.04) 2265.64,5486.26 ccw(c2281.86,5502.48) v1@2281.86,5479.54 ; v1@2276.36,5470.04 ccw(c2263.08,5470.04) 2272.47,5479.43 ccw(c2281.86,5488.82) v1@2281.86,5475.54 ; v1(2281.86,5470.04) 2156.02,5595.87 2156.02,5702.34 2195.89,5742.21 2267.21,5742.21 2270.89,5742.21 2287.69,5759 2598.15,5759 2599.61,5757.54 2652.54,5757.54 2730,5835 v1(2730,5950) ; v1@2723.28,5943.28 cw(c2707.06,5927.06) 2730,5927.06 cw(c2752.93,5927.06) v1@2736.72,5943.28 ; v1@2726.11,5946.11 cw(c2716.72,5936.72) 2730,5936.72 cw(c2743.28,5936.72) v1@2733.89,5946.11
  Bottom Layer w4: v1(2281.86,5470.04) 2291.97,5459.93 U5.10@2291.97,5322.68 ; U5.10@2289.14,5349.03 ccw(c2282.31,5355.86) 2291.97,5355.86 ccw(c2301.63,5355.86) U5.10@2294.8,5349.03 ; v1(2730,5950) 2805.49,5950.04 ; v1@2733.89,5946.11 cw(c2743.29,5936.73) 2743.28,5950.01 cw(c2743.27,5963.29) v1@2733.89,5953.89 ; v1@2736.72,5943.29 cw(c2752.95,5927.08) 2752.94,5950.01 cw(c2752.92,5972.95) v1@2736.71,5956.72 ; R62.1@2807.23,5967.92 cw(c2791.32,5952.01) 2813.82,5952.01 cw(c2836.32,5952.01) R62.1@2820.41,5967.92 ; R60.2@2809.58,5934.79 ccw(c2806.06,5941.71) 2813.82,5941.71 ; R62.1@2810.06,5970.75 cw(c2800.98,5961.67) 2813.82,5961.67 cw(c2826.66,5961.67) R62.1@2817.58,5970.75 ; 2813.78,5950.04 2805.49,5950.04 ; R60.2@2813.82,5926 2813.82,5941.71 ; 2813.82,5950 R62.1@2813.82,5975 ; R60.2@2818.05,5934.79 cw(c2821.58,5941.71) 2813.82,5941.71 ; 2805.49,5950.04 2813.82,5941.71
S_LED2: R61.1 R63.1 U5.12 | length 1544.7
  Bottom Layer w4: 2242.62,5322.81 cw(c2242.62,5312.7) U5.12@2249.77,5319.85 ; 2243.26,5322.81 ccw(c2243.26,5332.01) U5.12@2249.77,5325.51 ; U5.12@2252.6,5322.68 2252.46,5322.81 2062.96,5322.81 2048.52,5308.37 2048.52,5064.34 2096.82,5016.04 2796.04,5016.04 2813.82,5033.82 R61.1@2813.82,5150 ; R63.1@2807.23,5087.92 cw(c2791.32,5072.01) 2813.82,5072.01 cw(c2836.32,5072.01) R63.1@2820.41,5087.92 ; R63.1@2807.23,5102.08 ccw(c2791.32,5117.99) 2813.82,5117.99 ccw(c2836.32,5117.99) R63.1@2820.41,5102.08 ; R61.1@2807.23,5142.92 cw(c2791.32,5127.01) 2813.82,5127.01 cw(c2836.32,5127.01) R61.1@2820.41,5142.92 ; R63.1@2810.06,5090.75 cw(c2800.98,5081.67) 2813.82,5081.67 cw(c2826.66,5081.67) R63.1@2817.58,5090.75 ; R63.1@2810.06,5099.25 ccw(c2800.98,5108.33) 2813.82,5108.33 ccw(c2826.66,5108.33) R63.1@2817.58,5099.25 ; R61.1@2810.06,5145.75 cw(c2800.98,5136.67) 2813.82,5136.67 cw(c2826.66,5136.67) R61.1@2817.58,5145.75
S_LED3: R64.2 R66.1 U5.13 | length 2165.1
  MidLayer1 w4: v2@1938.06,5703.06 cw(c1921.31,5686.31) 1945,5686.31 cw(c1968.69,5686.31) v2@1951.94,5703.06 ; v2@1940.89,5705.89 cw(c1930.97,5695.97) 1945,5695.97 cw(c1959.03,5695.97) v2@1949.11,5705.89 ; v2(1945,5710) 1945,5590 1956.86,5578.14 v1(1956.86,5516.71) ; v1@1950.14,5523.43 ccw(c1933.92,5539.64) 1956.86,5539.64 ccw(c1979.79,5539.64) v1@1963.57,5523.43 ; v1@1952.97,5520.6 ccw(c1943.58,5529.99) 1956.86,5529.99 ccw(c1970.14,5529.99) v1@1960.75,5520.6
  MidLayer2 w4: v2(2165,5755) 2586.82,5755 v1(2606.86,5775.04) ; v2@2169.11,5750.89 cw(c2179.03,5740.97) 2179.03,5755 cw(c2179.03,5769.03) v2@2169.11,5759.11 ; v2@2171.94,5748.06 cw(c2188.69,5731.31) 2188.69,5755 cw(c2188.69,5778.69) v2@2171.94,5761.94 ; v1@2597.36,5775.04 cw(c2574.42,5775.04) 2590.64,5758.82 cw(c2606.86,5742.61) v1@2606.86,5765.54 ; v1@2601.36,5775.04 cw(c2588.08,5775.04) 2597.47,5765.65 cw(c2606.86,5756.26) v1@2606.86,5769.54
  Bottom Layer w4: v2(1945,5710) 2020,5785 2135,5785 v2(2165,5755) ; v2@1945,5715.81 ccw(c1945,5729.84) 1954.92,5719.92 ccw(c1964.84,5710) v2@1950.81,5710 ; v2@1945,5719.81 ccw(c1945,5743.5) 1961.75,5726.75 ccw(c1978.5,5710) v2@1954.81,5710 ; v1@1950.14,5509.99 cw(c1933.92,5493.77) 1956.86,5493.77 cw(c1979.79,5493.77) v1@1963.57,5509.99 ; v1@1952.97,5512.82 cw(c1943.58,5503.43) 1956.86,5503.43 cw(c1970.14,5503.43) v1@1960.75,5512.82 ; v1(1956.86,5516.71) 1956.86,5405 1980.13,5381.73 U5.13@2193.54,5381.73 ; v2@2155.19,5755 ccw(c2131.5,5755) 2148.25,5771.75 ccw(c2165,5788.5) v2@2165,5764.81 ; v2@2159.19,5755 ccw(c2145.16,5755) 2155.08,5764.92 ccw(c2165,5774.84) v2@2165,5760.81 ; U5.13@2167.19,5378.9 ccw(c2160.36,5372.08) 2160.36,5381.73 ccw(c2160.36,5391.39) U5.13@2167.19,5384.56 ; v1@2606.86,5765.54 cw(c2606.86,5742.61) 2623.07,5758.82 cw(c2639.29,5775.04) v1@2616.36,5775.04 ; v1@2606.86,5769.54 cw(c2606.86,5756.26) 2616.25,5765.65 cw(c2625.64,5775.04) v1@2612.36,5775.04 ; v1(2606.86,5775.04) 2631.86,5750.04 2854.51,5750.04 2856.18,5751.71 ; R66.1@2849.59,5771.92 cw(c2833.68,5756.01) 2856.18,5756.01 cw(c2878.68,5756.01) R66.1@2862.77,5771.92 ; R64.2@2849.88,5737.35 ccw(c2836.69,5751.71) 2856.18,5751.71 ; R66.1@2852.42,5774.75 cw(c2843.34,5765.67) 2856.18,5765.67 cw(c2869.02,5765.67) R66.1@2859.94,5774.75 ; R64.2@2852.58,5734.41 ccw(c2845.06,5742.6) 2856.18,5742.6 ccw(c2867.3,5742.6) R64.2@2859.78,5734.41 ; R64.2@2856.18,5730 2856.18,5751.71 ; R66.1@2856.18,5779 2856.18,5751.71 ; R64.2@2862.49,5737.35 cw(c2875.67,5751.71) 2856.18,5751.71
S_LED4: R65.1 R67.1 U5.15 | length 1954.1
  MidLayer2 w4: v1@2006.86,5223.87 cw(c2006.86,5200.94) 2023.07,5217.16 cw(c2039.29,5233.37) v1@2016.36,5233.37 ; v1@2006.86,5227.87 cw(c2006.86,5214.6) 2016.25,5223.99 cw(c2025.64,5233.37) v1@2012.36,5233.37 ; v1(2006.86,5233.37) 2191.52,5048.71 v1(2831.86,5048.71) ; v1@2825.14,5041.99 ccw(c2808.92,5025.77) 2808.92,5048.71 ccw(c2808.92,5071.64) v1@2825.14,5055.43 ; v1@2827.97,5044.82 ccw(c2818.58,5035.43) 2818.58,5048.71 ccw(c2818.58,5061.99) v1@2827.97,5052.6
  Bottom Layer w4: v1@2000.14,5240.09 ccw(c1983.92,5256.31) 2006.86,5256.31 ccw(c2029.79,5256.31) v1@2013.57,5240.09 ; v1@2002.97,5237.26 ccw(c1993.58,5246.65) 2006.86,5246.65 ccw(c2020.14,5246.65) v1@2010.75,5237.26 ; v1(2006.86,5233.37) 2006.86,5342.05 2027.62,5362.81 2219.63,5362.81 2231.86,5375.04 2231.86,5413.1 2223.86,5421.1 U5.15@2193.54,5421.1 ; U5.15@2217.07,5421.1 cw(c2217.25,5405.15) 2228.53,5416.43 ; R65.1@2807.23,5212.08 ccw(c2791.32,5227.99) 2813.82,5227.99 ccw(c2836.32,5227.99) R65.1@2820.41,5212.08 ; R67.1@2807.23,5252.92 cw(c2791.32,5237.01) 2813.82,5237.01 cw(c2836.32,5237.01) R67.1@2820.41,5252.92 ; R65.1@2810.06,5209.25 ccw(c2800.98,5218.33) 2813.82,5218.33 ccw(c2826.66,5218.33) R65.1@2817.58,5209.25 ; R67.1@2810.06,5255.75 cw(c2800.98,5246.67) 2813.82,5246.67 cw(c2826.66,5246.67) R67.1@2817.58,5255.75 ; R65.1@2813.82,5195.19 cw(c2813.82,5171.5) 2830.57,5188.25 ; R65.1@2813.82,5199.19 cw(c2813.82,5185.16) R65.1@2823.74,5195.08 ; R67.1@2813.82,5260 R65.1@2813.82,5205 2831.86,5186.96 v1(2831.86,5048.71) ; R65.1@2819.14,5204.51 ccw(c2830.79,5204.51) R65.1@2822.55,5196.27 ; R65.1@2823.14,5204.51 ccw(c2844.45,5204.51) 2829.38,5189.44 ; v1@2825.14,5055.43 ccw(c2808.92,5071.64) 2831.86,5071.64 ccw(c2854.79,5071.64) v1@2838.57,5055.43 ; v1@2827.97,5052.6 ccw(c2818.58,5061.99) 2831.86,5061.99 ccw(c2845.14,5061.99) v1@2835.75,5052.6
SHIELD: C87.1 J8.MH1 J8.MH2 J9.6 J9.7 J9.8 J9.9 J10.6 J10.7 J10.8 J10.9 J17.10 J17.11 J18.16 J18.17 J20.MH1 J20.MH2 J21.MH1 J21.MH2 J22.MH1 J22.MH2 J31.MH1 J31.MH2 J31.MH3 J32.MH1 J32.MH2 J32.MH3 J36.MH1 J36.MH2 J36.MH3 J36.MH4 J37.MH1 J37.MH2 J37.MH3 J37.MH4 J38.MH1 J38.MH2 J38.MH3 J38.MH4 PB_MH1.STAND PB_MH2.STAND PB_MH3.STAND PB_MH4.STAND PB_MH5.STAND R111.1 SW7.S1 SW7.S2 | length 13343.7
  Top Layer w20: v1(523.52,1248.71) 606,1331.18 606,2400.9 v1(573.52,2433.37) 606,2465.85 606,2580.06 385,2801.06 385,3230 215,3400 215,3456.86 181.86,3490 181.86,4258.57 595,4671.72 595,4910 665,4980 1082.19,4980 1355.5,5253.31 1355.5,5389.5 1355,5390 1355,5835 1390,5870 1390,6319.61 J17.10@1252.51,6457.09 ; J17.10@1253.72,6413.41 cw(c1256.38,6317.4) 1324.29,6385.31 cw(c1392.21,6453.23) J17.10@1296.2,6455.89 ; J17.10@1254.27,6393.42 cw(c1258.14,6253.47) 1357.14,6352.46 cw(c1456.14,6451.46) J17.10@1316.19,6455.33 ; J17.10@1254.83,6373.43 cw(c1259.91,6189.53) 1389.99,6319.61 cw(c1520.07,6449.69) J17.10@1336.18,6454.78
  MidLayer1 w20: J31.MH3@2734.02,270.27 ccw(c2670.44,333.85) 2760.35,333.85 ccw(c2850.27,333.85) J31.MH3@2786.69,270.27 ; J31.MH3@2760.35,204.57 2760.35,581.83 2773.52,595 2773.52,1783.52 2815,1825 3165.15,1825 3220.07,1879.93 3220.07,2090.07 3346.71,2216.71 3748.52,2216.71 3831.86,2300.04 3831.86,2481.3 3831.86,2567.91 3831.86,2575.04 3839.98,2575.04 PB_MH4.STAND@3839.98,2567.91 ; 3831.86,2457.31 cw(c3863.97,2457.31) PB_MH4.STAND@3841.26,2480.02 ; PB_MH4.STAND@3831.86,2505.29 ccw(c3863.97,2505.29) PB_MH4.STAND@3841.26,2482.58 ; J36.MH4@5097.22,701.18 5181.04,785 5228.75,785 J36.MH3@5312.57,701.18 ; J36.MH4@5102.22,740.39 ccw(c5102.22,822.99) 5160.62,764.59 ; 5242.1,771.66 ccw(c5317.57,847.13) J36.MH3@5317.57,740.39 ; 5276.24,737.51 ccw(c5317.57,778.85) J36.MH3@5317.57,720.39 ; J37.MH4@5422.22,701.57 5506.04,785.39 5553.75,785.39 J37.MH3@5637.57,701.57 ; J37.MH4@5422.22,720.79 ccw(c5422.22,767.17) J37.MH4@5455.02,734.37 ; J37.MH4@5422.22,740.79 ccw(c5422.22,835.46) 5489.16,768.51 ; 5570.63,768.51 ccw(c5637.57,835.46) J37.MH3@5637.57,740.79 ; J37.MH3@5604.77,734.37 ccw(c5637.57,767.17) J37.MH3@5637.57,720.79 ; J38.MH4@5742.22,720.39 ccw(c5742.22,778.85) 5783.55,737.51 ; J38.MH4@5742.22,740.39 ccw(c5742.22,847.13) 5817.69,771.66 ; J38.MH4@5747.22,701.18 5831.04,785 5878.75,785 J38.MH3@5962.57,701.18 ; 5899.17,764.59 ccw(c5957.57,822.99) J38.MH3@5957.57,740.39
  MidLayer2 w20: v1(573.52,2433.37) 797.32,2433.37 931.86,2567.91 v2(1273.05,2567.91) PB_MH1.STAND@1359.67,2567.91
  Bottom Layer w20: R111.1@210,1180.12 213.26,1183.37 v1(315.19,1183.37) 370,1238.19 ; R111.1@229.14,1164.92 cw(c273.7,1120.36) 273.7,1183.37 ; R111.1@229.14,1195.32 ccw(c257.97,1224.15) 257.97,1183.37 ; C87.1@394.75,1222.58 ccw(c370.01,1210.77) 370.01,1238.19 ; C87.1@394.75,1253.8 cw(c370.01,1265.61) 370.01,1238.19 ; C87.1@494.51,1238.19 ccw(c494.51,1277.72) v1@522.46,1249.77 ; v1(523.52,1248.71) 523.52,1243.45 518.26,1238.19 439.24,1238.19 370,1238.19 ; J18.17@5269.76,6468 5273.52,6468 J18.17@5316.48,6425.04 ; J18.16@6210.66,6425.04 J18.16@6253.61,6468
  other v1: 7607.8,82.32 7607.8,107.32 7607.8,132.32 7126.22,142.32 7220,142.32 7514.02,157.32 7607.8,157.32 7126.22,167.32 7220,167.32 7514.02,182.32 7607.8,182.32 7220,192.32 7514.02,207.32 7607.8,207.32 7220,217.32 7514.02,232.32 7607.8,232.32 7220,237 7151.01,243 7174.01,243 7195.2,243 7537,243 7560,243 7583,243 7220,257.32 7514.02,257.32 7607.8,257.32 7220,282.32 7514.02,282.32 7607.8,282.32 7220,307.32 7514.02,307.32 7607.8,307.32 7126.22,332.32 7220,332.32 7514.02,332.32 7607.8,332.32 7126.22,357.32 7220,357.32 7607.8,357.32 7607.8,382.32 7147.01,396 7534.81,396 7561,396 7587,396 6410,6518 6434.19,6518 6458.19,6518 6797.8,6518 6821.99,6518 6845.99,6518 6387.21,6525.68 6480.99,6525.68 6775,6525.68 6868.78,6525.68 6387.21,6550.68 6480.99,6550.68 6775,6550.68 6868.78,6550.68 6387.21,6575.68 6480.99,6575.68 6775,6575.68 6868.78,6575.68 6775,6600.68 6868.78,6600.68 6387.21,6650.68 6480.99,6650.68 6775,6650.68 6868.78,6650.68 6387.21,6671.68 6480.99,6671.68 6775,6671.68 6868.78,6671.68 6410.19,6672.35 6433.19,6672.35 6456.19,6672.35 6797.99,6672.35 6820.99,6672.35 6843.99,6672.35 6387.21,6696.68 6480.99,6696.68 6775,6696.68 6868.78,6696.68 6387.21,6736.68 6480.99,6736.68 6775,6736.68 6868.78,6736.68 6387.21,6761.68 6480.99,6761.68 6775,6761.68 6868.78,6761.68 6387.21,6786.68 6480.99,6786.68 6775,6786.68 6868.78,6786.68 6387.21,6811.68 6480.99,6811.68 6775,6811.68 6868.78,6811.68 6387.21,6836.68 6480.99,6836.68 6775,6836.68 6868.78,6836.68 6410,6847.35 6434.19,6847.35 6458.19,6847.35 6797.8,6847.35 6821.99,6847.35 6845.99,6847.35
  other v2: 269.12,28.54 2450.22,28.54 4930.54,28.54 207.87,53.91 330.36,53.91 2388.97,53.91 2511.47,53.91 4869.29,53.91 4991.78,53.91 182.5,115.16 355.73,115.16 2363.61,115.16 2536.83,115.16 4843.92,115.16 5017.15,115.16 207.87,176.4 330.36,176.4 2388.97,176.4 2511.47,176.4 4869.29,176.4 4991.78,176.4 269.12,201.77 2450.22,201.77 4930.54,201.77 1359.67,2481.3 3839.98,2481.3 1298.42,2506.67 1420.91,2506.67 3778.74,2506.67 3901.23,2506.67 1446.28,2567.91 3753.37,2567.91 3926.6,2567.91 1298.42,2629.16 1420.91,2629.16 3778.74,2629.16 3901.23,2629.16 1359.67,2654.53 3839.98,2654.53
  other v9: 487.34,224.08 527.34,224.08 567.34,224.08 612.34,224.08
SPAREIO.1: J28.37 U8.AA10 | length 1617.4
  Top Layer w4: v1(4204.86,3444.71) 4204.86,3433.2 4212.86,3425.2 ; J28.37@4219.76,3421.71 ccw(c4212.86,3416.62) 4212.86,3425.2 ; J28.37@4219.76,3428.68 cw(c4212.86,3433.77) 4212.86,3425.2 ; J28.37@4246.61,3425.2 4212.86,3425.2 ; v3(5193.15,3914.41) U8.AA10@5212.83,3934.09 ; U8.AA10@5205.49,3934.09 cw(c5187.77,3934.09) 5200.3,3921.56 cw(c5212.83,3909.03) U8.AA10@5212.83,3926.75 ; 5205.95,3927.21 cw(c5193.15,3940.02) 5193.15,3921.91 ccw(c5193.15,3940.02) 5205.95,3927.21 ; 5205.95,3927.21 ccw(c5218.76,3914.41) 5200.65,3914.41 cw(c5218.76,3914.41) 5205.95,3927.21
  MidLayer2 w4: v1(4204.86,3444.71) 4243.67,3444.71 4255,3433.37 4409.21,3433.37 ; v1@4208.75,3440.82 cw(c4218.14,3431.43) 4218.14,3444.71 cw(c4218.14,3457.99) v1@4208.75,3448.6 ; v1@4211.57,3437.99 cw(c4227.79,3421.77) 4227.79,3444.71 cw(c4227.79,3467.64) v1@4211.57,3451.43 ; 4408.1,3433.37 4408.59,3433.87 4414.68,3433.87 4415.17,3433.37 4515.19,3433.37 4531.86,3450.04 4556.86,3450.04 4568.19,3438.71 4639.56,3438.71 4667.23,3466.37 4786.86,3466.37 4875.48,3555 4886.82,3555 4915.19,3583.37 4949.63,3617.81 5007.96,3617.81 5023.69,3633.54 5104.09,3633.54 5116.63,3621 5162.37,3621 5169.29,3627.92 5169.29,3630.82 5169.29,3638.82 5169.29,3699.73 5169.29,3757.99 5169.29,3777.41 5169.29,3851.53 5169.29,3871.03 cw(c5211.02,3871.03) 5181.51,3900.54 ; v3@5185.68,3913.76 cw(c5167.64,3912.18) 5181.51,3900.54 ; v3@5193.8,3906.94 ccw(c5195.38,3888.9) 5181.51,3900.54
SPAREIO.2: J28.38 U8.AA12 | length 2027.1
  Top Layer w4: J28.38@4323.39,3405.51 4323.52,3405.51 4323.52,3408.37 4340.19,3408.37 4381.86,3366.71 4381.86,3222.37 v1(4348.52,3189.04) ; J28.38@4345.51,3399.64 cw(c4345.51,3391.39) 4351.34,3397.22 ; J28.38@4347.39,3405.51 ccw(c4357.85,3405.51) J28.38@4350.45,3398.12 ; v1@4348.52,3194.54 ccw(c4348.52,3207.82) 4357.91,3198.43 ccw(c4367.3,3189.04) v1@4354.02,3189.04 ; v1@4348.52,3198.54 ccw(c4348.52,3221.48) 4364.74,3205.26 ccw(c4380.96,3189.04) v1@4358.02,3189.04 ; J28.38@4351.39,3405.51 ccw(c4371.5,3405.51) 4357.28,3391.29 ; v3(5271.89,3914.41) U8.AA12@5291.57,3934.09 ; U8.AA12@5284.23,3934.09 cw(c5266.51,3934.09) 5279.04,3921.56 cw(c5291.57,3909.03) U8.AA12@5291.57,3926.75 ; 5284.69,3927.21 cw(c5271.89,3940.02) 5271.89,3921.91 ccw(c5271.89,3940.02) 5284.69,3927.21 ; 5284.69,3927.21 ccw(c5297.5,3914.41) 5279.39,3914.41 cw(c5297.5,3914.41) 5284.69,3927.21
  MidLayer2 w4: v1(4348.52,3189.04) 4367.98,3189.04 ; v1@4356.02,3183.2 cw(c4367.98,3173.87) 4367.98,3189.04 ; v1@4356.02,3194.88 ccw(c4367.98,3204.22) 4367.98,3189.04 ; 5248.03,3641.47 5248.03,3699.73 ; v3@5264.42,3913.76 cw(c5246.38,3912.18) 5260.25,3900.54 ; v3@5272.54,3906.94 ccw(c5274.12,3888.9) 5260.25,3900.54 ; 4367.98,3189.04 4441.94,3263 4593,3263 4629.2,3299.2 4726.01,3299.2 4750.5,3274.71 4784.71,3274.71 4792.37,3282.37 4931.86,3421.86 4931.86,3433.61 4965.75,3467.5 4973.56,3467.5 5012.5,3506.44 5012.5,3541.25 5003.81,3549.93 5003.81,3557.62 5063.73,3617.54 5097.46,3617.54 5110,3605 5218.73,3605 5228.73,3615 5245,3615 5248.03,3618.03 5248.03,3699.73 ; 5248.03,3699.73 5248.03,3757.99 5248.03,3777.41 5248.03,3851.53 5248.03,3871.03 cw(c5289.76,3871.03) 5260.25,3900.54
SPAREIO.3: J28.39 U8.AB11 | length 1804.7
  Top Layer w4: v1@4210.35,3366.55 ccw(c4205.32,3375.04) 4215.19,3375.04 ; v1(4215.19,3358.37) 4215.19,3375.04 ; 4215.93,3375.78 ccw(c4208.81,3382.91) J28.39@4218.71,3384.75 ; 4217,3376.85 cw(c4224.49,3369.36) J28.39@4224.49,3379.95 ; v1@4220.03,3366.55 cw(c4225.06,3375.04) 4215.19,3375.04 ; J28.39@4246.61,3385.83 4248.52,3385.83 4248.52,3386.04 4247.68,3386.89 4242.86,3391.71 4231.86,3391.71 4215.19,3375.04 ; v3(5232.52,3875.04) U8.AB11@5252.2,3894.72 ; U8.AB11@5244.86,3894.72 cw(c5227.14,3894.72) 5239.67,3882.19 cw(c5252.2,3869.66) U8.AB11@5252.2,3887.38 ; 5245.32,3887.84 cw(c5232.52,3900.65) 5232.52,3882.54 ccw(c5232.52,3900.65) 5245.32,3887.84 ; 5245.32,3887.84 ccw(c5258.13,3875.04) 5240.02,3875.04 cw(c5258.13,3875.04) 5245.32,3887.84
  MidLayer2 w4: v1(4215.19,3358.37) 4281.67,3358.37 4290,3366.71 4537.21,3366.71 4562.21,3391.71 4615.19,3391.71 4673.52,3450.04 4765.19,3450.04 4780.23,3435 4820,3435 4891.78,3506.78 ; v1@4219.08,3354.49 cw(c4228.47,3345.1) 4228.47,3358.37 cw(c4228.47,3371.65) v1@4219.08,3362.26 ; v1@4221.91,3351.66 cw(c4238.13,3335.44) 4238.13,3358.37 cw(c4238.13,3381.31) v1@4221.91,3365.09 ; 4837.5,3452.5 4898.52,3513.52 4898.52,3516.71 4904.19,3522.37 4907.32,3525.5 4936.69,3525.5 4959,3547.81 4971.43,3560.25 4971.43,3567.75 4959.19,3580 4959.19,3599.38 4969.62,3609.81 5011.29,3609.81 5027.02,3625.54 5100.77,3625.54 5113.31,3613 5207.39,3613 5217.01,3622.63 5217.01,3632.01 5217.01,3638.82 5217.01,3757.99 5217.01,3851.53 ; 5217.01,3837.6 5217.01,3851.53 ; 5221.13,3861.46 ccw(c5231.06,3851.53) 5217.01,3851.53 ; v3@5225.05,3874.39 cw(c5207.01,3872.81) 5220.88,3861.17 cw(c5234.75,3849.53) v3@5233.17,3867.57
SPAREIO.4: J28.40 U8.AB13 | length 2955.5
  Top Layer w4: 4285.71,3366.71 cw(c4285.71,3350.59) J28.40@4297.11,3361.99 ; v1@4286.69,2933.37 ccw(c4263.76,2933.37) 4279.97,2949.59 ccw(c4296.19,2965.81) v1@4296.19,2942.87 ; 4288.45,3366.71 ccw(c4288.45,3378.96) J28.40@4297.11,3370.3 ; v1@4290.69,2933.37 ccw(c4277.41,2933.37) 4286.8,2942.76 ccw(c4296.19,2952.15) v1@4296.19,2938.87 ; v1(4296.19,2933.37) 4224.52,3005.04 4224.52,3341.71 4249.52,3366.71 4323.39,3366.71 4323.52,3366.71 4323.52,3366.14 J28.40@4323.39,3366.14 ; v3(5311.26,3875.04) U8.AB13@5330.94,3894.72 ; U8.AB13@5323.6,3894.72 cw(c5305.88,3894.72) 5318.41,3882.19 cw(c5330.94,3869.66) U8.AB13@5330.95,3887.38 ; 5324.06,3887.84 cw(c5311.26,3900.65) 5311.26,3882.54 ccw(c5311.26,3900.65) 5324.06,3887.84 ; 5324.06,3887.84 ccw(c5336.87,3875.04) 5318.76,3875.04 cw(c5336.87,3875.04) 5324.06,3887.84
  MidLayer2 w4: v1(4296.19,2933.37) 4495.17,2933.37 4577.8,3016 4665.9,3016 4715.19,2966.71 4825.39,2966.71 5028.69,3170 5054.75,3170 5082.5,3197.75 5082.5,3215.87 5065,3233.37 5022.52,3233.37 4989.19,3266.71 4989.19,3340.04 5006.86,3357.71 5120.86,3357.71 5131.86,3368.71 5131.86,3470.04 5098.52,3503.37 5098.52,3554 5124.52,3580 5172.5,3580 ; v1@4300.08,2929.49 cw(c4309.47,2920.1) 4309.47,2933.37 cw(c4309.47,2946.65) v1@4300.08,2937.26 ; v1@4302.91,2926.66 cw(c4319.13,2910.44) 4319.13,2933.37 cw(c4319.13,2956.31) v1@4302.91,2940.09 ; 5218.75,3533.75 5172.5,3580 ; 5256.33,3524.87 5271.09,3524.87 ; 5299.87,3861.46 ccw(c5309.8,3851.53) 5295.75,3851.53 5295.75,3757.99 5295.75,3638.82 5295.75,3630.82 5295.75,3595.81 5284.04,3584.1 5284.04,3537.82 5271.09,3524.87 ; v3@5303.79,3874.39 cw(c5285.75,3872.81) 5299.62,3861.17 cw(c5313.49,3849.53) v3@5311.91,3867.57 ; 5172.5,3580 5227.63,3524.87 5230.13,3524.87 5271.09,3524.87
SPK.VOL: C105.2 U26.3 VR1.2 | length 7554.4
  Top Layer w4: U26.3@-389.13,5100 -184.81,5100 ; U26.3@-351.56,5095.89 cw(c-341.64,5085.97) -341.64,5100 cw(c-341.64,5114.03) U26.3@-351.56,5104.11 ; U26.3@-348.73,5093.06 cw(c-331.98,5076.31) -331.98,5100 cw(c-331.98,5123.69) U26.3@-348.73,5106.94 ; v1@-81.72,5438.28 cw(c-97.94,5422.06) -75,5422.06 cw(c-52.07,5422.06) v1@-68.28,5438.28 ; v1@-78.89,5441.11 cw(c-88.28,5431.72) -75,5431.72 cw(c-61.72,5431.72) v1@-71.11,5441.11 ; v1(-75,5445) -75,5400 -184.81,5290.19 -184.81,4929.81 -130,4875 -130,4820 -118.37,4808.37 194.21,4808.37 217.58,4785 288.52,4785 298.52,4775 298.52,4641.71 278.52,4621.71 278.52,4516.71 64.86,4303.04 64.86,4255.06 31.86,4222.06 31.86,3300.04 36.9,3295 135,3295 v2(175,3255) ; v2@65.19,2255 cw(c41.5,2255) 58.25,2238.25 cw(c75,2221.5) v2@75,2245.19 ; v2@69.19,2255 cw(c55.16,2255) 65.08,2245.08 cw(c75,2235.16) v2@75,2249.19 ; v2(75,2255) -40,2140 -40,1472.63 390.19,1042.44 390.19,604.81 ; v2@165.19,3255 ccw(c141.5,3255) 158.25,3271.75 ccw(c175,3288.5) v2@175,3264.81 ; v2@169.19,3255 ccw(c155.16,3255) 165.08,3264.92 ccw(c175,3274.84) v2@175,3260.81 ; VR1.2@403.3,562.06 ccw(c356.46,571.08) 390.19,604.81 ; VR1.2@407.23,561.31 ccw(c365.41,569.36) 395.52,599.48 ccw(c425.64,629.59) VR1.2@433.69,587.77 ; VR1.2@411.16,560.55 ccw(c374.35,567.64) 400.86,594.14 ccw(c427.36,620.65) VR1.2@434.45,583.84 ; VR1.2@415.09,559.8 ccw(c383.29,565.92) 406.19,588.81 ccw(c429.08,611.71) VR1.2@435.2,579.91 ; VR1.2@419.02,559.04 ccw(c392.23,564.19) 411.52,583.48 ccw(c430.81,602.77) VR1.2@435.96,575.98 ; VR1.2@432.94,591.7 cw(c423.92,638.54) 390.19,604.81 ; VR1.2@440,555 390.19,604.81
  MidLayer1 w4: v2@68.06,2261.94 ccw(c51.31,2278.69) 75,2278.69 ccw(c98.69,2278.69) v2@81.94,2261.94 ; v2@70.89,2259.11 ccw(c60.97,2269.03) 75,2269.03 ccw(c89.03,2269.03) v2@79.11,2259.11 ; v2(75,2255) 75,2625 -50,2750 -50,2905.94 -49.5,2906.44 -49.5,2907.12 -28.91,2927.71 17.29,2927.71 26.5,2918.5 26.5,2843.5 100,2770 205,2770 240,2805 240,2910 175,2975 v2(175,3255) ; v2@168.06,3248.06 cw(c151.31,3231.31) 175,3231.31 cw(c198.69,3231.31) v2@181.94,3248.06 ; v2@170.89,3250.89 cw(c160.97,3240.97) 175,3240.97 cw(c189.03,3240.97) v2@179.11,3250.89
  Bottom Layer w4: C105.2@-161.36,5444.25 -75.75,5444.25 v1(-75,5445) ; C105.2@-157.25,5440.14 cw(c-147.33,5430.22) -147.33,5444.25 cw(c-147.33,5458.28) C105.2@-157.25,5448.36 ; C105.2@-154.42,5437.31 cw(c-137.67,5420.56) -137.67,5444.25 cw(c-137.67,5467.93) C105.2@-154.42,5451.19 ; -99.75,5444.25 ccw(c-99.75,5469.75) v1@-81.72,5451.72 ; -96.12,5444.25 cw(c-96.12,5423.88) v1@-81.72,5438.28 ; -90.09,5444.25 ccw(c-90.09,5460.09) v1@-78.89,5448.89
SPK_L.SPK+: J34.1 U26.16 | length 1462.3
  Top Layer w12: J34.1@-171.19,6121.57 -171.03,6121.41 -30.16,6121.41 -18.75,6110 110,6110 140,6080 140,5855 60,5775 60,5260 27.02,5227.02 27.02,5207.02 ; J34.1@-154.55,6104.93 cw(c-114.77,6065.15) -114.77,6121.41 ; J34.1@-154.55,6138.2 ccw(c-114.01,6178.75) -114.01,6121.41 ; U26.16@-30.87,5200 20,5200 27.02,5207.02 ; U26.16@-0.8,5194.83 ccw(c6.81,5206.4) 16.61,5196.61 ; U26.16@5.79,5204.85 ccw(c15.08,5218.97) 27.02,5207.02 ; U26.16@6.71,5195.89 cw(c16.63,5185.97) 16.63,5200 cw(c16.63,5214.03) U26.16@6.71,5204.11
SPK_L.SPK-: C106.1 J34.2 U26.14 | length 2236.5
  Top Layer w12: U26.14@-30.87,5100 50,5100 130.87,5019.13 130.87,4980.87 85,4935 v1(85,4905) v1@85,4900 ; U26.14@6.71,5095.89 cw(c16.63,5085.97) 16.63,5100 cw(c16.63,5114.03) U26.14@6.71,5104.11 ; v1@81.11,4908.89 ccw(c71.72,4918.28) 85,4918.28 ccw(c98.28,4918.28) v1@88.89,4908.89
  MidLayer1 w12: J34.2@-103,6160.94 -5.94,6160.94 65,6090 65,5965 53.19,5953.19 53.19,5302.03 -13.48,5235.36 -13.48,5028.48 67.28,4947.72 67.28,4922.72 v1(85,4905) ; J34.2@-86.36,6144.3 cw(c-46.2,6104.14) -46.2,6160.94 cw(c-46.2,6217.74) J34.2@-86.36,6177.57 ; v1@79.5,4905 ccw(c66.22,4905) 75.61,4914.39 ccw(c85,4923.78) v1@85,4910.5
  Bottom Layer w12: C106.1@6.06,4845.28 50.28,4845.28 85,4880 v1(85,4905) ; C106.1@20.83,4858.7 ccw(c42.13,4885.1) 66.11,4861.11 ; C106.1@28.36,4868.04 ccw(c50.56,4895.56) 75.56,4870.56 ; C106.1@35.89,4877.38 ccw(c58.99,4906.01) 85,4880 ; v1@81.11,4901.11 cw(c71.72,4891.72) 85,4891.72 cw(c98.28,4891.72) v1@88.89,4901.11
SPK_R.SPK+: J35.1 U26.9 | length 9263
  Top Layer w23: v1(-64.62,4868.69) -64.62,4850.38 U26.9@-64.24,4850
  MidLayer2 w12: v1(-64.62,4868.69) 8.69,4868.69 69.97,4929.97 96.62,4929.97 223.89,5057.24 ; v1@-60.73,4864.8 cw(c-51.34,4855.41) -51.34,4868.69 cw(c-51.34,4881.97) v1@-60.73,4872.58 ; 223.89,5057.29 250,5083.41 250,5182.63 236,5196.63 236,5563.37 284.63,5612 1465.63,5612 1606.93,5753.3 1840.93,5753.3 1897.63,5810 2693,5810 2735,5852 2821,5852 2861,5812 4473,5812 4507.5,5777.5 4795.53,5777.5 4806.49,5766.54 5231.63,5766.54 5274.09,5809 5821.22,5809 6090,6077.78 6090,6232.63 6198.37,6341 6328,6341 6374.99,6387.99 6705.03,6387.99 6761.85,6444.81 6970.32,6444.81 6972.94,6442.19 7137.81,6442.19 7179.52,6400.48 7271.5,6308.5 7725.87,6308.5 7784.36,6250.01 J35.1@7784.36,6160.94 ; J35.1@7767.73,6177.57 ccw(c7727.56,6217.74) 7784.36,6217.74 ccw(c7841.16,6217.74) J35.1@7801,6177.57
SPK_R.SPK-: C107.1 J35.2 U26.11 | length 10485.4
  Top Layer w12: U26.11@-30.87,4950 50,4950 60,4940 60,4895 75,4880 ; U26.11@6.71,4945.89 cw(c16.63,4935.97) 16.63,4950 cw(c16.63,4964.03) U26.11@6.71,4954.11 ; v1@108.54,4895.78 cw(c75,4923.53) 75,4880 ; v1(112.78,4892.28) 100.5,4880 ; v1@117.79,4888.14 cw(c100.5,4902.44) 100.5,4880 ; 75,4880 100.5,4880
  MidLayer2 w12: v1@107.28,4892.28 cw(c94,4892.28) 103.39,4882.89 cw(c112.78,4873.5) v1@112.78,4886.78 ; v1@108.89,4896.17 ccw(c99.5,4905.56) 112.78,4905.56 ccw(c126.06,4905.56) v1@116.67,4896.17 ; v1@414.5,4930 ccw(c401.22,4930) 410.61,4939.39 ccw(c420,4948.78) v1@420,4935.5 ; v1(420,4930) 369.88,4980.12 169.4,4980.12 112.78,4923.5 v1(112.78,4892.28) 67.69,4847.19 -77.19,4847.19 -90,4860 -90,4880 -79.81,4890.19 7.56,4890.19 63.34,4945.97 89.94,4945.97 234,5090.03 234,5176 220,5190 220,5570 278,5628 1459,5628 1600.3,5769.3 1834.3,5769.3 1891,5826 2673.37,5826 2686.37,5826 2728.37,5868 2827.63,5868 2867.13,5828.5 4479.13,5828.5 4514.13,5793.5 4802.16,5793.5 4813.12,5782.54 5225,5782.54 5267.46,5825 5814.59,5825 6074,6084.41 6074,6239.25 6191.75,6357 6320.01,6357 6367,6403.99 ; 6366.34,6403.99 6367,6403.99 ; J35.2@7835.92,6138.2 ccw(c7795.75,6178.37) 7852.55,6178.37 ccw(c7909.36,6178.37) J35.2@7869.19,6138.2 ; J35.2@7852.55,6121.57 7852.55,6204.45 7732,6325 7277.63,6325 7144.44,6458.19 6979.57,6458.19 6976.95,6460.81 6755.22,6460.81 6698.4,6403.99 6367,6403.99
  Bottom Layer w4: v1(420,4930) v1@422.37,4930
  Bottom Layer w12: v1@420,4924.5 cw(c420,4911.22) 429.39,4920.61 cw(c438.78,4930) v1@425.5,4930 ; v1(420,4930) 446.06,4903.94 ; C107.1@432.11,4884.09 ccw(c424.97,4903.93) 446.06,4903.93 ; C107.1@446.06,4845.28 446.06,4903.94 ; C107.1@460.02,4884.09 cw(c467.16,4903.93) 446.06,4903.93
SW#.D0: J28.1 R102.2 SW1.2 U8.M3 | length 8543.2
  Top Layer w4: v1@4173.36,4440.71 ccw(c4150.42,4440.71) 4166.64,4456.93 ccw(c4182.86,4473.14) v1@4182.86,4450.21 ; v1@4177.36,4440.71 ccw(c4164.08,4440.71) 4173.47,4450.1 ccw(c4182.86,4459.49) v1@4182.86,4446.21 ; 4215.19,4141.52 ccw(c4232.15,4141.52) J28.1@4220.16,4129.53 ; 4215.19,4151.17 ccw(c4241.8,4151.17) J28.1@4222.98,4132.35 ; 4215.19,4160.83 ccw(c4251.46,4160.83) J28.1@4225.81,4135.18 ; 4215.19,4170.49 ccw(c4261.12,4170.49) J28.1@4228.64,4138.01 ; J28.1@4219.18,4131.34 ccw(c4215.19,4129.44) 4215.19,4133.86 ; J28.1@4219.18,4136.38 cw(c4215.19,4138.28) 4215.19,4133.86 ; J28.1@4246.61,4133.86 4215.19,4133.86 ; v1@4293.28,1571.72 ccw(c4277.06,1587.93) 4300,1587.93 ccw(c4322.93,1587.93) v1@4306.72,1571.72 ; v1@4296.11,1568.89 ccw(c4286.72,1578.28) 4300,1578.28 ccw(c4313.28,1578.28) v1@4303.89,1568.89 ; v1(4300,1565) 4300,1595 4312,1607 4312,1902.65 4321.46,1912.1 4321.46,1933.23 4290.52,1964.16 4290.52,2304.48 4256.86,2338.14 4256.86,2481.67 3848.52,2890 3848.52,3288.67 3597.19,3540 3597.19,3789.77 3832.19,4024.77 3832.19,4050 3931.86,4149.67 3931.86,4198.39 3927.5,4202.75 3927.5,4217.25 3931.86,4221.61 3931.86,4316.71 3925.82,4322.75 3925.82,4869 3981.86,4925.04 4148.52,4925.04 4165.19,4908.37 4165.19,4835 4150,4819.81 4150,4473.56 v1(4182.86,4440.71) 4198.52,4425.04 4198.52,4383.37 4156.86,4341.71 4156.86,4283.37 4215.19,4225.04 4215.19,4133.86 ; v1@4359.54,4403.4 4359.54,4417.93 4376.2,4434.59 4393.91,4434.59 4483,4345.5 4510.04,4345.5 4524.04,4359.5 4556.04,4391.5 4635.12,4391.5 4639.12,4395.5 4666.88,4395.5 4691.4,4370.97 4706.16,4370.97 4708.69,4373.5 4747.25,4373.5 4808.46,4312.29 4838.82,4312.29 ; 4830.82,4312.29 4838.82,4312.29 ; U8.M3@4929.9,4288.42 ccw(c4912.18,4288.42) 4924.71,4300.96 ; U8.M3@4937.24,4295.77 cw(c4937.24,4313.49) 4924.71,4300.96 ; R102.2@5302.92,957.23 ccw(c5287.01,941.32) 5287.01,963.82 ccw(c5287.01,986.32) R102.2@5302.92,970.41 ; R102.2@5303.41,957.23 cw(c5287.5,941.32) 5310,941.32 cw(c5332.5,941.32) R102.2@5316.59,957.23 ; R102.2@5305.75,960.06 ccw(c5296.67,950.98) 5296.67,963.82 ccw(c5296.67,976.66) R102.2@5305.75,967.58 ; R102.2@5306.24,960.06 cw(c5297.16,950.98) 5310,950.98 cw(c5322.84,950.98) R102.2@5313.76,960.06 ; SW1.2@5307.02,911.31 ccw(c5299.84,918.49) SW1.2@5310,918.49 ; 5310,921.96 ccw(c5341.83,921.96) SW1.2@5321.83,897.2 ; 5310,930.33 ccw(c5348.58,930.33) SW1.2@5324.35,900.31 ; 5310,938.7 ccw(c5355.34,938.7) SW1.2@5326.86,903.42 ; 5310,947.07 ccw(c5362.1,947.07) SW1.2@5329.37,906.54 ; R102.2@5310,955.44 ccw(c5368.86,955.44) SW1.2@5331.88,909.65 ; SW1.2@5327.52,896.81 5310,914.33 R102.2@5310,963.82 ; SW1.2@5334.4,912.76 cw(c5375.62,963.81) R102.2@5310,963.82 ; v1@5364.02,1010.04 ccw(c5341.09,1010.04) 5357.31,1026.26 ccw(c5373.52,1042.48) v1@5373.52,1019.54 ; v1@5368.02,1010.04 ccw(c5354.75,1010.04) 5364.14,1019.43 ccw(c5373.52,1028.82) v1@5373.52,1015.54 ; v1(5373.52,1010.04) 5348.56,1035 5290,1035 5270,1015 5270,975 5281.18,963.82 R102.2@5310,963.82 ; 4838.82,4312.29 4844.56,4312.29 4897.36,4312.29 cw(c4897.36,4273.61) 4924.71,4300.96
  MidLayer1 w4: v2@4283.06,1281.94 ccw(c4266.31,1298.69) 4290,1298.69 ccw(c4313.69,1298.69) v2@4296.94,1281.94 ; v2@4285.89,1279.11 ccw(c4275.97,1289.03) 4290,1289.03 ccw(c4304.03,1289.03) v2@4294.11,1279.11 ; v2(4290,1275) 4290,1320 4300,1330 4300,1564.75 v1(4300,1565) ; v1@4293.28,1558.28 cw(c4277.06,1542.06) 4300,1542.06 cw(c4322.93,1542.06) v1@4306.72,1558.28 ; v1@4296.11,1561.11 cw(c4286.72,1551.72) 4300,1551.72 cw(c4313.28,1551.72) v1@4303.89,1561.11
  MidLayer2 w4: v1(4182.86,4440.71) 4266.19,4440.71 4303.49,4403.4 4344.55,4403.4 ; v1@4186.75,4436.82 cw(c4196.14,4427.43) 4196.14,4440.71 cw(c4196.14,4453.99) v1@4186.75,4444.6 ; v1@4189.57,4433.99 cw(c4205.79,4417.77) 4205.79,4440.71 cw(c4205.79,4463.64) v1@4189.57,4447.43 ; v2@4290.03,1269.19 cw(c4290.1,1255.41) 4299.85,1265.15 cw(c4309.59,1274.9) v2@4295.81,1274.97 ; v2(4290,1275) 4306.63,1258.37 ; v2@4290.05,1265.19 cw(c4290.17,1241.93) 4306.62,1258.38 ; v2@4299.81,1274.95 ccw(c4323.07,1274.83) 4306.62,1258.38 ; 4344.54,4403.39 v1@4360.46,4403.39 ; v1@5366.81,1016.76 ccw(c5350.59,1032.98) 5373.52,1032.98 ccw(c5396.46,1032.98) v1@5380.24,1016.76 ; v1@5369.64,1013.93 ccw(c5360.25,1023.32) 5373.52,1023.32 ccw(c5386.8,1023.32) v1@5377.41,1013.93 ; v1(5373.52,1010.04) 5373.52,1033.37 5290.19,1116.71 5023.52,1116.71 4881.86,1258.37 4306.63,1258.37
  other v1: 4359.05,4403.31
SW#.D1: J28.2 R103.2 SW2.2 U8.W1 | length 7821.5
  Top Layer w4: v1@3630.69,3991.71 cw(c3607.76,3991.71) 3623.97,3975.49 cw(c3640.19,3959.27) v1@3640.19,3982.21 ; v1@3634.69,3991.71 cw(c3621.41,3991.71) 3630.8,3982.32 cw(c3640.19,3972.93) v1@3640.19,3986.21 ; v1(3640.19,3991.71) 3606.86,3958.37 3540.19,3958.37 3523.52,3941.71 3523.52,2347.02 3503,2326.5 3503,1848 3480,1825 3421.31,1825 3408,1811.69 3408,1373.31 3423.27,1358.04 3658.04,1358.04 3670,1370 3696.86,1370 3706.86,1360 v1(3706.86,1308.37) ; v1@3700.14,1315.09 ccw(c3683.92,1331.31) 3706.86,1331.31 ccw(c3729.79,1331.31) v1@3713.57,1315.09 ; v1@3702.97,1312.26 ccw(c3693.58,1321.65) 3706.86,1321.65 ccw(c3720.14,1321.65) v1@3710.75,1312.26 ; v1(4114.18,4095.43) 4118.91,4095.43 4140.19,4116.71 J28.2@4316.86,4116.71 ; 4280.96,4116.71 cw(c4280.96,4093.87) J28.2@4297.11,4110.02 ; 4290.62,4116.71 cw(c4290.62,4103.53) J28.2@4299.93,4112.85 ; 4293.2,4116.71 ccw(c4293.2,4122.24) J28.2@4297.11,4118.33 ; J28.2@4323.52,4114.17 J28.2@4323.39,4114.17 4436.88,4114.17 4498.68,4052.38 4498.68,4041.57 4512.75,4027.5 4527.25,4027.5 4556.69,4056.94 4556.69,4066.54 ; J28.2@4349.67,4110.02 cw(c4359.69,4099.99) 4359.69,4114.17 cw(c4359.69,4128.35) J28.2@4349.67,4118.33 ; 4556.86,4066.71 4556.69,4066.54 ; v1@5721.28,1057.28 cw(c5688.17,1024.17) 5735,1024.17 ; v1@5724.11,1060.11 cw(c5697.82,1033.82) 5735,1033.82 ; v1@5726.94,1062.94 cw(c5707.48,1043.48) 5735,1043.48 ; v1(5728,1064) 5734,1064 5735,1063 5735,1013.82 R103.2@5785,963.82 5806,942.82 ; v1@5729.77,1065.77 cw(c5717.14,1053.14) 5735,1053.14 ; 5768.25,980.57 cw(c5751.5,963.82) R103.2@5775.19,963.82 ; 5769.44,979.38 ccw(c5784.51,994.45) R103.2@5784.51,973.14 ; R103.2@5775.08,973.74 cw(c5765.16,963.82) R103.2@5779.19,963.82 ; R103.2@5776.27,972.55 ccw(c5784.51,980.79) R103.2@5784.51,969.14 ; R103.2@5785.49,954.5 cw(c5785.49,933.19) 5800.56,948.26 ; R103.2@5785.49,958.5 cw(c5785.49,946.85) R103.2@5793.73,955.09 ; R103.2@5790.81,963.82 ccw(c5804.84,963.82) R103.2@5794.92,953.9 ; SW2.2@5791.86,912.53 ccw(c5766.49,942.82) 5806,942.82 ; SW2.2@5794.43,909.46 ccw(c5773.67,934.25) 5806,934.25 ; R103.2@5794.81,963.82 ccw(c5818.5,963.82) 5801.75,947.07 ; SW2.2@5796.99,906.39 ccw(c5780.84,925.68) 5806,925.68 ; SW2.2@5805.02,896.81 5806,897.79 5806,942.82 ; 5806,923.96 ccw(c5831.26,923.96) SW2.2@5813.71,905.8 ; 5806,933.39 ccw(c5840.36,933.39) SW2.2@5816.49,908.68 ; SW2.2@5819.26,911.55 cw(c5849.47,942.82) 5806,942.82 ; 4556.69,4066.54 4565.15,4075 4665,4075 4715.63,4024.37 4760.63,4024.37 4772.17,4012.83 4838.82,4012.83 ; 4838.82,4012.83 U8.W1@4858.5,4012.83 4838.82,4012.83 ; 4840.78,4012.83 cw(c4840.78,3995.11) 4853.31,4007.64 ccw(c4840.78,3995.11) 4840.78,4012.83 ; 4840.78,4012.83 ccw(c4840.78,4030.56) 4853.31,4018.03 cw(c4840.78,4030.56) 4840.78,4012.83
  Bottom Layer w4: v1(3640.19,3991.71) 3748.52,4100.04 4056.6,4100.04 4061.22,4095.43 v1(4114.18,4095.43) ; v1@3640.19,3997.21 ccw(c3640.19,4010.49) 3649.58,4001.1 ccw(c3658.97,3991.71) v1@3645.69,3991.71 ; v1@3640.19,4001.21 ccw(c3640.19,4024.14) 3656.41,4007.93 ccw(c3672.63,3991.71) v1@3649.69,3991.71 ; v1(3706.86,1308.37) 3757.52,1359.04 4758.56,1359.04 4900.9,1216.71 5206.65,1216.71 5249.31,1259.37 5465.95,1259.37 5622.33,1103 5698.31,1103 5728,1073.31 5728,1071.28 5728.73,1070.54 5731.92,1070.54 5733,1069.46 5733,1069 v1(5728,1064) ; v1@3706.86,1313.87 ccw(c3706.86,1327.15) 3716.25,1317.76 ccw(c3725.64,1308.37) v1@3712.36,1308.37 ; v1@3706.86,1317.87 ccw(c3706.86,1340.81) 3723.07,1324.59 ccw(c3739.29,1308.37) v1@3716.36,1308.37 ; v1@4107.46,4088.71 ccw(c4091.24,4072.49) 4091.24,4095.43 ccw(c4091.24,4118.36) v1@4107.46,4102.14 ; v1@4110.29,4091.54 ccw(c4100.9,4082.15) 4100.9,4095.43 ccw(c4100.9,4108.7) v1@4110.29,4099.32 ; 5705.2,1096.12 cw(c5673.08,1064) v1@5718.5,1064 ; 5712.03,1089.29 cw(c5686.74,1064) v1@5722.5,1064 ; 5718.85,1082.46 cw(c5700.39,1064) v1@5726.5,1064 ; 5725.68,1075.63 cw(c5714.05,1064) v1@5730.5,1064
SW#.D2: J28.3 R104.1 SW3.2 U8.AB1 | length 6978.5
  Top Layer w4: J28.3@4246.61,4094.49 4248.52,4094.49 4251.3,4091.71 4377.42,4091.71 4415.02,4054.1 4415.02,4028.91 4426.02,4017.92 4441.22,4002.71 4473.92,4002.71 4509.77,3966.87 4510.6,3966.04 4567.9,3966.04 4660,3966.04 4685,3966.04 4705.82,3966.04 4725.27,3946.59 4725.5,3946.36 4725.5,3917.77 ; J28.3@4270.07,4095.81 ccw(c4279.98,4105.72) 4279.98,4091.71 ; J28.3@4272.89,4090.33 cw(c4276.21,4087.02) J28.3@4276.21,4091.71 ; J28.3@4272.89,4098.64 ccw(c4289.63,4115.38) 4289.63,4091.71 ; R104.1@6258.41,962.23 cw(c6242.5,946.32) 6265,946.32 cw(c6287.5,946.32) R104.1@6271.59,962.23 ; R104.1@6261.24,965.06 cw(c6252.16,955.98) 6265,955.98 cw(c6277.84,955.98) R104.1@6268.76,965.06 ; SW3.2@6262.02,911.31 ccw(c6254.84,918.49) SW3.2@6265,918.49 ; SW3.2@6265,914.33 R104.1@6265,968.82 ; 6265,923.84 ccw(c6300.9,923.84) SW3.2@6276.85,897.18 ; 6265,932.83 ccw(c6309.01,932.83) SW3.2@6279.53,900.15 ; 6265,941.83 ccw(c6317.13,941.83) SW3.2@6282.21,903.12 ; 6265,950.82 ccw(c6325.24,950.82) SW3.2@6284.89,906.09 ; R104.1@6265,959.82 ccw(c6333.35,959.82) SW3.2@6287.57,909.06 ; R104.1@6269.25,965.06 cw(c6278.33,955.98) 6278.33,968.82 cw(c6278.33,981.66) R104.1@6269.25,972.58 ; R104.1@6272.08,962.23 cw(c6287.99,946.32) 6287.99,968.82 cw(c6287.99,991.32) R104.1@6272.08,975.41 ; SW3.2@6290.25,912.03 cw(c6341.47,968.81) R104.1@6265,968.82 ; v1@6353.19,1028.28 cw(c6336.97,1012.06) 6359.9,1012.06 cw(c6382.84,1012.06) v1@6366.62,1028.28 ; v1@6356.01,1031.11 cw(c6346.62,1021.72) 6359.9,1021.72 cw(c6373.18,1021.72) v1@6363.79,1031.11 ; v1(6359.9,1035) 6359.9,1010.93 6317.79,968.82 R104.1@6265,968.82 ; 4725.5,3907 4725.5,3917.77 ; 4725.5,3907 4725.5,3917.77 ; 4725.5,3907 4724.19,3905.69 4719.19,3900.69 4719.19,3879.31 4734.31,3864.19 4755.69,3864.19 4759.38,3864.19 4765.38,3870.19 4789.91,3894.72 4830.82,3894.72 4838.82,3894.72 ; 4838.82,3894.72 U8.AB1@4858.5,3894.72 4838.82,3894.72 ; 4840.78,3894.72 cw(c4840.78,3877) 4853.31,3889.53 ccw(c4840.78,3877) 4840.78,3894.72 ; 4840.78,3894.72 ccw(c4840.78,3912.45) 4853.31,3899.92 cw(c4840.78,3912.45) 4840.78,3894.72
  MidLayer1 w4: v1@4275.5,1825 ccw(c4252.56,1825) 4268.78,1841.22 ccw(c4285,1857.43) v1@4285,1834.5 ; v1@4279.5,1825 ccw(c4266.22,1825) 4275.61,1834.39 ccw(c4285,1843.78) v1@4285,1830.5 ; v1(4285,1825) 4218,1892 4218,2086.69 4115.19,2189.5 4115.19,2877.67 4315.19,3077.67 4315.19,3255 4288.52,3281.67 4288.52,3798.71 4390.19,3900.37 4390.19,3945 4390.19,3958.37 4390.19,3982.09 4409.75,4001.65 v1(4426.53,4018.42) ; v1@4417.03,4018.42 cw(c4394.09,4018.42) 4410.31,4002.21 cw(c4426.53,3985.99) v1@4426.53,4008.92 ; v1@4421.03,4018.42 cw(c4407.75,4018.42) 4417.14,4009.04 cw(c4426.53,3999.65) v1@4426.53,4012.92
  MidLayer2 w4: v1@4285,1827.15 v1(4285,1825) 4310,1825 4435.04,1950.04 4678.29,1950.04 4691.15,1937.19 4735.44,1937.19 5004.82,1667.81 5464,1667.81 5618.32,1513.5 5704,1513.5 5746.19,1513.5 5758.23,1525.54 5827.27,1525.54 5860.62,1492.19 5877.38,1492.19 5885.23,1500.04 6009.46,1500.04 6019.31,1490.19 6019.81,1490.19 v2(6032,1478) ; v1@4288.89,1821.11 cw(c4298.28,1811.72) 4298.28,1825 cw(c4298.28,1838.28) v1@4288.89,1828.89 ; v1@4291.72,1818.28 cw(c4307.93,1802.06) 4307.93,1825 cw(c4307.93,1847.93) v1@4291.72,1831.72 ; v2(6099,1279) 6115,1263 ; v2@6099.19,1273.19 cw(c6099.6,1260.65) 6108.48,1269.52 cw(c6117.35,1278.4) v2@6104.81,1278.81 ; v2@6099.32,1269.19 cw(c6100.02,1248.02) 6115,1263 ; v2@6108.81,1278.68 ccw(c6129.98,1277.98) 6115,1263 ; v1@6353.19,1028.28 ccw(c6336.97,1012.06) 6336.97,1035 ccw(c6336.97,1057.93) v1@6353.19,1041.72 ; v1@6356.01,1031.11 ccw(c6346.62,1021.72) 6346.62,1035 ccw(c6346.62,1048.28) v1@6356.01,1038.89 ; v1(6359.9,1035) 6329.13,1035 6115,1249.13 6115,1255.15 6115,1263
  Bottom Layer w4: v2@6032,1468.19 cw(c6032,1444.5) 6048.75,1461.25 cw(c6065.5,1478) v2@6041.81,1478 ; v2@6032,1472.19 cw(c6032,1458.16) 6041.92,1468.08 cw(c6051.84,1478) v2@6037.81,1478 ; v2(6032,1478) 6099,1411 v2(6099,1279) v2@6100,1280 ; v2@6092.06,1285.94 ccw(c6075.31,1302.69) 6099,1302.69 ccw(c6122.69,1302.69) v2@6105.94,1285.94 ; v2@6094.89,1283.11 ccw(c6084.97,1293.03) 6099,1293.03 ccw(c6113.03,1293.03) v2@6103.11,1283.11