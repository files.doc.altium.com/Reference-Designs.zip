# Altium PCB NB3000AL.PcbDoc (part 47 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Top Layer w12: U47.12@7555.59,3019.25 7606.86,3019.25 7615.65,3019.25 7615.65,3019.04 7615.52,3019.04 7609.19,3012.71 7606.86,3010.37 v1(7606.86,3015.04) ; v1(7575.52,4645.04) 7581.86,4638.71 7581.86,4634.71 7578.23,4631.08 ; v1@7579.69,4421.37 cw(c7566.41,4421.37) 7575.8,4411.99 cw(c7585.19,4402.6) v1@7585.19,4415.87 ; 7583.41,3019.25 cw(c7583.41,2991.6) v1@7602.97,3011.15 ; v1@7594.64,4071.15 ccw(c7585.25,4061.76) 7585.25,4075.04 ccw(c7585.25,4088.32) 7594.64,4078.93 ccw(c7585.25,4088.32) 7598.52,4088.32 ccw(c7611.8,4088.32) v1@7602.41,4078.93 ; C200.2@7769.4,1682.53 ccw(c7712.43,1739.5) 7792.99,1739.5 ; C190.2@7769.4,1782.47 cw(c7712.43,1725.5) 7792.99,1725.5 ; C203.2@7776.12,1522.73 ccw(c7758.86,1552.17) 7792.99,1552.17 ; C190.2@7776.12,1842.73 ccw(c7758.86,1872.17) 7792.99,1872.17 ; C200.2@7777.88,1674.05 ccw(c7741.4,1710.53) 7792.99,1710.53 ccw(c7844.58,1710.53) C200.2@7808.1,1674.05 ; C190.2@7777.88,1790.95 cw(c7741.4,1754.47) 7792.99,1754.47 cw(c7844.58,1754.47) C190.2@7808.1,1790.95 ; 7792.81,1752.24 cw(c7813.79,1752.24) C190.2@7808,1772.4 ; C203.2@7792.99,1490 7792.99,1552.18 ; 7792.99,1739.5 ccw(c7873.55,1739.5) C200.2@7816.59,1682.53 ; v1(7805,1885) 7805,1884.18 7804.19,1883.37 7792.99,1872.18 ; v1@7809.69,1595.04 ccw(c7796.41,1595.04) 7805.8,1604.43 ccw(c7815.19,1613.82) v1@7815.19,1600.54 ; C203.2@7809.87,1522.73 cw(c7827.12,1552.17) 7792.99,1552.17 ; C190.2@7809.87,1842.73 cw(c7827.12,1872.17) 7792.99,1872.17 ; v1@7811.3,1591.15 cw(c7801.91,1581.76) 7815.19,1581.76 cw(c7828.47,1581.76) v1@7819.08,1591.15 ; U2.5@7874.17,3731.34 7948.52,3731.34 7992.52,3775.34 v1(7992.52,3804.71) 7992.52,3817.48 7981.46,3828.54 7981.28,3828.54 7950.67,3859.16 C33.2@7950.67,3995 ; v1@7886.3,3495.6 ccw(c7876.91,3504.99) 7890.19,3504.99 ccw(c7903.47,3504.99) v1@7894.08,3495.6 ; J25.9@7886.99,5363.75 cw(c7886.99,5293.12) 7936.93,5343.07 ; J25.9@7886.99,5375.75 cw(c7886.99,5334.1) 7916.45,5363.55 ; J25.9@7886.99,5420.25 7886.99,5393.01 v2(7965,5315) ; 7890.19,3515.08 cw(c7906.31,3515.08) C35.2@7905.77,3531.19 ; v1@7890.52,3491.71 v1(7890.19,3491.71) 7890.19,3509.21 C35.2@7905.98,3525 ; LED1.2@7893.79,2459.68 ccw(c7842.92,2510.54) 7914.86,2510.54 ; C35.2@7900.17,3525 cw(c7886.14,3525) 7896.06,3515.08 cw(c7905.98,3505.16) C35.2@7905.98,3519.19 ; U2.5@7901.33,3725.84 cw(c7914.61,3712.56) 7914.61,3731.34 cw(c7914.61,3750.12) U2.5@7901.33,3736.84 ; LED1.2@7902.27,2451.19 ccw(c7871.9,2481.57) 7914.86,2481.57 ; LED1.2@7903.47,2433.51 ccw(c7928.32,2433.51) v1@7910.75,2415.93 ; Y1.4@7904.88,4157.5 7940.34,4157.5 ; J25.9@7905.99,5382.75 ccw(c7927.11,5382.75) 7912.18,5367.82 ; v1(7906.86,2412.04) 7906.86,2413.37 7903.52,2416.71 7903.47,2416.71 LED1.2@7903.47,2450 7914.86,2461.39 v1(7914.86,2550.71) ; Y1.4@7907.14,4159.3 cw(c7922.84,4143.06) 7938.8,4159.03 ; Y1.4@7907.7,4159.71 cw(c7921.98,4132.88) 7943.47,4154.37 ; v1@7910.97,2546.82 cw(c7901.58,2537.43) 7914.86,2537.43 cw(c7928.14,2537.43) v1@7918.75,2546.82 ; Y1.4@7915.48,4150.67 cw(c7931.32,4134.29) 7947.43,4150.4 ; Y1.4@7928.91,4149.69 cw(c7940.33,4145.24) 7940.33,4157.5 ; Y1.4@7928.91,4165.31 ccw(c7940.33,4169.76) 7940.33,4157.5 ; C33.2@7946.56,3999.11 ccw(c7936.64,4009.03) 7950.67,4009.03 ccw(c7964.7,4009.03) C33.2@7954.78,3999.11 ; 7950.67,3966.56 C33.2@7950.67,3995 ; v2@7959.19,5315 ccw(c7945.16,5315) 7955.08,5324.92 ccw(c7965,5334.84) v2@7965,5320.81 ; v1@7988.64,3800.82 cw(c7979.25,3791.43) 7992.52,3791.43 cw(c8005.8,3791.43) v1@7996.41,3800.82 ; v1@7990.19,3505.04 v1(7990.19,3508.37) 8000.53,3508.37 R30.2@8017.15,3525 ; v1@7990.2,3513.87 ccw(c7990.29,3551.85) R30.2@8017.15,3525 ; U47.34@8004.41,3050.75 8075.08,3050.75 C153.2@8080,3055.67 8110.82,3055.67 v1(8123.52,3068.37) ; R30.2@8007.23,3515.08 cw(c8017.15,3505.16) R30.2@8017.15,3519.19 ; R30.2@8008.42,3516.27 ccw(c8000.18,3524.51) R30.2@8011.83,3524.51 ; C34.2@8020.22,3990.89 cw(c8010.3,3980.97) 8024.33,3980.97 cw(c8038.36,3980.97) C34.2@8028.44,3990.89 ; C34.2@8024.33,3995 8024.33,3977.37 8031.66,3970.04 8031.86,3970.04 8048.52,3953.37 v1(8048.52,3910) ; v1@8044.64,3913.89 ccw(c8035.25,3923.28) 8048.52,3923.28 ccw(c8061.8,3923.28) v1@8052.41,3913.89 ; 8054.09,3050.75 ccw(c8054.09,3081.58) C153.2@8075.89,3059.78 ; Y1.2@8067.88,4062.5 8147.5,4062.5 8198.52,4113.52 v1(8198.52,4162.37) ; C154.2@8080,2960.67 8117.49,2960.67 v1(8131.86,2975.04) ; C154.2@8084.11,2956.56 cw(c8094.03,2946.64) 8094.03,2960.67 cw(c8094.03,2974.7) C154.2@8084.11,2964.78 ; C153.2@8084.11,3051.56 cw(c8094.03,3041.64) 8094.03,3055.67 cw(c8094.03,3069.7) C153.2@8084.11,3059.78 ; Y1.2@8087.08,4047.3 cw(c8123.78,4010.59) 8123.78,4062.5 cw(c8123.78,4114.41) Y1.2@8087.08,4077.7 ; C36.2@8125,3317.99 8178.91,3317.99 ; U23.1@8151.81,2570 U23.1@8149,2572.81 8192.19,2572.81 8195,2570 v2(8195,2470) ; U23.1@8153.81,2568.01 cw(c8165.41,2556.4) 8165.41,2572.81 cw(c8165.41,2589.22) U23.1@8153.81,2577.62 ; C36.2@8159.76,3305.21 cw(c8178.9,3297.27) 8178.9,3317.99 ; C36.2@8159.76,3330.78 ccw(c8178.9,3338.72) 8178.9,3317.99 ; v1@8160.64,4365.49 cw(c8150.1,4354.95) 8165,4354.95 ; C57.2@8160.89,4329.78 ccw(c8150.97,4339.7) 8165,4339.7 ccw(c8179.03,4339.7) C57.2@8169.11,4329.78 ; C55.2@8160.89,4585.22 cw(c8150.97,4575.3) 8165,4575.3 cw(c8179.03,4575.3) 8169.11,4585.22 cw(c8179.03,4575.3) 8179.03,4589.33 cw(c8179.03,4603.36) C55.2@8169.11,4593.44 ; C55.2@8164.25,4583.19 ccw(c8166.2,4599.17) 8177.59,4587.79 ; v1(8164.52,4369.37) 8165,4370.04 8165,4369.37 C57.2@8165,4325.67 ; 8165,4357.25 cw(c8176.65,4357.25) v1@8168.41,4365.49 ; C56.2@8174.82,4464 ccw(c8184.48,4454.33) 8170.81,4454.33 cw(c8184.84,4454.33) 8174.92,4464.25 cw(c8165,4474.17) 8165,4460.14 ccw(c8165,4474.53) C56.2@8175.17,4464.35 ; v2@8190.89,2474.11 ccw(c8180.97,2484.03) 8195,2484.03 ccw(c8209.03,2484.03) v2@8199.11,2474.11 ; v1@8194.64,4158.49 cw(c8185.25,4149.1) 8198.52,4149.1 cw(c8211.8,4149.1) v1@8202.41,4158.49 ; v1(8195,4605.19) 8179.14,4589.33 C55.2@8165,4589.33 8165,4566.71 8165.19,4566.71 8190.19,4541.71 8190.19,4479.37 8190.04,4479.37 8185.71,4475.04 ; v1@8199.69,3291.71 ccw(c8186.41,3291.71) 8195.8,3301.1 ccw(c8205.19,3310.49) v1@8205.19,3297.21 ; v1(8205.19,3291.71) 8178.91,3317.99 ; -701.48,2652.86 -668.14,2686.19 v1(-668.14,2708.37) -685.48,2708.37 -701.48,2692.37 -701.48,2692.23 ; Y5.2@5462.5,1855.99 5465.19,1858.68 Y5.2@5462.5,1858.68 ; Y5.2@5462.5,1855.99 Y5.2@5462.5,1858.68 ; Y5.2@5462.5,1858.68 5462.5,1892.02 ; 5508.5,2016.5 Y5.4@5557.5,2016.5 5557.5,1962.02 ; v1@5783.86,2050.04 5786.71,2047.19 5853.02,2047.19 5865.67,2034.54 ; 5808,2860.77 5824.06,2876.84 5840.56,2876.84 5918.72,2955 v2@6020,2955 ; 5823.52,2211.95 5825.91,2214.33 ; 5823.52,2211.95 5825.91,2214.33 ; 5825.91,2214.33 5827.91,2216.33 ; 5827.91,2216.33 5843.59,2216.33 ; 5843.59,2216.33 5845.59,2214.33 ; 5845.59,2214.33 5849.54,2210.37 5881.86,2210.37 5884.96,2213.48 U61.17@5884.96,2240 5884.96,2269.81 5890.19,2275.04 5924.33,2275.04 ; 5864.6,1382.45 5865.52,1383.37 5865.67,1383.37 5865.67,1381.37 ; 5864.6,1382.45 5865.67,1381.37 ; 5865.67,2034.54 5869.84,2038.71 ; 5924.33,2275.04 5974.52,2275.04 5981.86,2267.71 5981.86,2218.24 5983.39,2216.71 ; C279.2@5943.52,3374.47 5943.52,3375 C279.2@5942.99,3375 C279.2@5943.52,3374.47 ; C279.2@5943.52,3374.47 5976.99,3341 5976.99,3316.67 5989.77,3303.89 ; 5983.39,2216.71 5991.72,2208.37 6005,2208.37 6014.42,2208.37 6022.76,2216.71 ; v2@6020,2955 6041.82,2955 6045,2958.18 ; 6022.76,2216.71 6022.76,2265.37 6049.09,2291.71 v1(6056.86,2291.71) ; 6160.55,2216.71 6160.55,2261.4 6174.19,2275.04 ; 6174.19,2275.04 6174.86,2275.71 6190.92,2275.71 6191.59,2275.04 ; 6174.19,2275.04 6191.59,2275.04 ; 6316.52,2567.57 v1@6316.52,2606.94 ; v1@6316.52,2606.94 6316.42,2606.94 v1(6316.52,2607.04) v1@6316.52,2606.94 ; 6486.01,2260.67 C251.2@6500,2260.67 ; v2(6505,2655) 6505,2672.99 6517.01,2685 ; 6531.97,2999.97 6531.97,3016.02 ; 6531.97,3016.02 6531.97,3041.61 ; 6531.97,3041.61 6538.73,3048.37 ; 7123.52,2645.79 7131.86,2637.45 7143.5,2625.81 7195,2625.81 ; 7195,2625.81 7293.64,2625.81 7303.76,2635.93 7321.82,2635.93 7334.6,2623.15 7334.6,2605.08 7331.86,2602.34 7331.86,2441.71 ; 7290.19,2390 7290.19,2430.37 7301.52,2441.71 7331.86,2441.71 ; 7402.99,2608.37 C201.2@7402.99,2555 7445,2555 ; 7402.99,2608.37 7401.99,2609.37 7381.86,2609.37 7373.52,2617.71 7373.52,2646.37 7402.86,2675.71 7402.99,2675.71 ; 7457.52,3011.1 cw(c7470.8,3011.1) 7461.41,3020.49 ccw(c7470.8,3011.1) 7457.52,3011.1 ; 7457.52,3011.1 ccw(c7444.25,3011.1) 7453.64,3020.49 cw(c7444.25,3011.1) 7457.52,3011.1 ; C58.2@7529.19,4625.67 cw(c7515.6,4625.67) 7525.21,4616.06 ccw(c7515.6,4625.67) C58.2@7529.19,4625.67 ; C58.2@7535,4619.86 ccw(c7535,4605.39) 7524.77,4615.62 cw(c7535,4605.39) C58.2@7535,4619.86 ; 7792.99,1552.18 7815.19,1574.37 v1(7815.19,1595.04) 7792.99,1617.24 C200.2@7792.99,1655 C190.2@7792.99,1810 7792.99,1872.18 ; 7940.34,4157.5 7950.67,4147.17 C33.2@7950.67,3995 ; 7950.67,3980.97 ccw(c7936.64,3980.97) 7946.56,3990.89 cw(c7936.64,3980.97) 7950.67,3980.97 ; 7950.67,3980.97 cw(c7964.7,3980.97) 7954.78,3990.89 ccw(c7964.7,3980.97) 7950.67,3980.97 ; 8185.71,4475.04 C56.2@8165,4454.33 8165,4454.18 8165.07,4454.26 8185.86,4475.04 8185.71,4475.04 ; 7457.52,2992.34 ccw(c7476.49,2992.34) 7463.08,2978.93 cw(c7476.49,2992.34) 7457.52,2992.34 ; v1@7457.73,3018.88 cw(c7458.78,2990.3) 7479,3010.52 ccw(c7458.78,2990.3) v1@7457.73,3018.88
  MidLayer1 w4: v2(4745,3890) 4750,3895 v2@4750,3898 ; 4830.82,3780.7 4838.82,3780.7 4840.41,3780.7 4898.67,3780.7 4956.93,3780.7 ccw(c4956.93,3796.3) 4972.53,3796.3 cw(c4996.3,3796.3) 4996.3,3820.07 ccw(c4996.3,3835.67) 5011.9,3835.67 cw(c5035.67,3835.67) 5035.67,3859.44 ccw(c5035.67,3875.04) 5051.27,3875.04 cw(c5075.04,3875.04) 5075.04,3898.81 ccw(c5075.04,3914.41) 5090.64,3914.41 cw(c5114.41,3914.41) 5114.41,3938.18 ccw(c5114.41,3953.78) 5130.01,3953.78 cw(c5153.78,3953.78) 5153.78,3977.55 ccw(c5153.78,3993.15) 5169.38,3993.15 cw(c5193.15,3993.15) 5193.15,4016.92 ccw(c5193.15,4032.52) 5208.75,4032.52 cw(c5232.52,4032.52) 5232.52,4056.29 ccw(c5232.52,4071.89) 5248.12,4071.89 ; 4830.82,3969.29 4838.82,3969.29 4879.25,3969.29 4898.67,3969.29 4972.79,3969.29 ; 4838.82,4087.4 4879.25,4087.4 4898.67,4087.4 4972.79,4087.4 ; 4838.82,4292.6 4879.25,4292.6 4898.67,4292.6 4972.79,4292.6 ; 4838.82,4410.71 4879.25,4410.71 4898.67,4410.71 4972.79,4410.71 ; 4838.82,4607.47 4840.41,4607.47 4898.67,4607.47 4956.93,4607.47 cw(c4956.93,4583.7) 4980.7,4583.7 ccw(c4996.3,4583.7) 4996.3,4568.1 cw(c4996.3,4544.33) 5020.07,4544.33 ccw(c5035.67,4544.33) 5035.67,4528.73 cw(c5035.67,4504.96) 5059.44,4504.96 ccw(c5075.04,4504.96) 5075.04,4489.36 cw(c5075.04,4465.59) 5098.81,4465.59 ccw(c5114.41,4465.59) 5114.41,4449.99 cw(c5114.41,4426.22) 5138.18,4426.22 ccw(c5153.78,4426.22) 5153.78,4410.62 cw(c5153.78,4386.85) 5177.55,4386.85 ccw(c5193.15,4386.85) 5193.15,4371.25 cw(c5193.15,4347.48) 5216.92,4347.48 ccw(c5232.52,4347.48) 5232.52,4331.88 cw(c5232.52,4308.11) 5256.29,4308.11 ccw(c5280.06,4308.11) 5280.06,4284.34 ; 4958.86,3969.29 4972.79,3969.29 ; 4958.86,4087.4 4972.79,4087.4 ; 4958.86,4292.6 4972.79,4292.6 ; 4958.86,4410.71 4972.79,4410.71 ; 4980.7,3640.41 4980.7,3698.67 4980.7,3756.93 cw(c4996.3,3756.93) 4996.3,3772.53 ccw(c4996.3,3796.3) 5020.07,3796.3 cw(c5035.67,3796.3) 5035.67,3811.9 ccw(c5035.67,3835.67) 5059.44,3835.67 cw(c5075.04,3835.67) 5075.04,3851.27 ccw(c5075.04,3875.04) 5098.81,3875.04 cw(c5114.41,3875.04) 5114.41,3890.64 ccw(c5114.41,3914.41) 5138.18,3914.41 cw(c5153.78,3914.41) 5153.78,3930.01 ccw(c5153.78,3953.78) 5177.55,3953.78 cw(c5193.15,3953.78) 5193.15,3969.38 ccw(c5193.15,3993.15) 5216.92,3993.15 cw(c5232.52,3993.15) 5232.52,4008.75 ccw(c5232.52,4032.52) 5256.29,4032.52 cw(c5271.89,4032.52) 5271.89,4048.12 ; v3@5028.2,3993.8 cw(c5010.16,3995.38) 5021.8,3981.51 ; v3@5028.2,4111.91 cw(c5010.16,4113.49) 5021.8,4099.62 ; v3@5028.2,4268.09 ccw(c5010.16,4266.51) 5021.8,4280.38 ; v3@5028.2,4386.2 ccw(c5010.16,4384.62) 5021.8,4398.49 ; v3@5035.02,3985.68 ccw(c5033.44,3967.64) 5021.8,3981.51 ; v3@5035.02,4103.79 ccw(c5033.44,4085.75) 5021.8,4099.62 ; v3@5035.02,4276.21 cw(c5033.44,4294.25) 5021.8,4280.38 ; v3@5035.02,4394.32 cw(c5033.44,4412.36) 5021.8,4398.49 ; 5129.92,3630.82 5129.92,3638.82 5129.92,3679.25 5129.92,3698.67 5129.92,3772.79 ; 5129.92,3758.86 5129.92,3772.79 ; 5129.92,4621.14 5129.92,4607.21 ; 5129.92,4741.18 5129.92,4700.75 5129.92,4681.33 5129.92,4607.21 ; v3@5146.31,3835.02 cw(c5128.27,3833.44) 5142.14,3821.8 ; v3@5146.31,4544.98 ccw(c5128.27,4546.56) 5142.14,4558.2 ; v3@5154.43,3828.2 ccw(c5156.01,3810.16) 5142.14,3821.8 ; v3@5154.43,4551.8 cw(c5156.01,4569.84) 5142.14,4558.2 ; 5248.03,4071.38 cw(c5286.7,4071.38) 5259.36,4098.73 ; v3@5264.55,4111.26 cw(c5246.82,4111.26) 5259.36,4098.73 ; 5271.38,4048.03 ccw(c5271.38,4086.7) 5298.73,4059.36 ; v3@5271.89,4103.92 ccw(c5271.89,4086.19) 5259.36,4098.73 ; 5280.06,4284.29 cw(c5281.67,4260.57) 5296.46,4279.17 ; 5287.4,3638.82 5287.4,3679.25 5287.4,3698.67 5287.4,3772.79 ; 5287.4,3758.86 5287.4,3772.79 ; 5287.4,4621.14 5287.4,4607.21 ; v2@5298.06,4798.06 cw(c5281.31,4781.31) 5305,4781.31 cw(c5328.69,4781.31) v2@5311.94,4798.06 ; v2@5300.89,4800.89 cw(c5290.97,4790.97) 5305,4790.97 cw(c5319.03,4790.97) v2@5309.11,4800.89 ; v3@5303.79,3835.02 cw(c5285.75,3833.44) 5299.62,3821.8 ; v3@5303.79,4544.98 ccw(c5285.75,4546.56) 5299.62,4558.2 ; v3@5303.87,4267.44 ccw(c5286.04,4264.29) 5296.43,4279.13 ccw(c5306.81,4293.96) v3@5309.96,4276.13 ; v3@5303.92,4071.89 cw(c5286.19,4071.89) 5298.73,4059.36 ; v2(5305,4805) 5305,4778.69 5287.4,4761.08 5287.4,4700.75 5287.4,4681.33 5287.4,4607.21 ; v3@5311.26,4064.55 ccw(c5311.26,4046.82) 5298.73,4059.36 ; v3@5311.91,3828.2 ccw(c5313.49,3810.16) 5299.62,3821.8 ; v3@5311.91,4551.8 cw(c5313.49,4569.84) 5299.62,4558.2 ; v2@5314.84,3528.23 5314.68,3528.07 5314.68,3527.15 5314.98,3526.85 v2@5315.07,3526.85 ; v2(5315.07,3534.31) 5316,3533.38 5316,3527.74 v2@5315.11,3526.85 ; v2@5439.5,3556.64 cw(c5449.42,3546.72) 5449.42,3560.75 cw(c5449.42,3574.78) v2@5439.5,3564.86 ; v2@5442.33,3553.81 cw(c5459.07,3537.06) 5459.07,3560.75 cw(c5459.07,3584.43) v2@5442.33,3567.69 ; v2@5443.43,3560.75 v2(5435.39,3560.75) 5471.55,3560.75 5492.6,3581.8 5492.6,3679.25 5492.6,3698.67 5492.6,3772.79 ; v3@5468.09,3828.2 cw(c5466.51,3810.16) 5480.38,3821.8 ; v3@5468.09,4551.8 ccw(c5466.51,4569.84) 5480.38,4558.2 ; v3@5468.74,4315.45 ccw(c5468.74,4333.18) 5481.27,4320.64 ; v3@5470.04,4103.87 cw(c5473.19,4086.04) 5483.57,4100.87 cw(c5493.96,4115.71) v3@5476.13,4112.56 ; v3@5476.08,4308.11 cw(c5493.81,4308.11) 5481.27,4320.64 ; v3@5476.21,3835.02 ccw(c5494.25,3833.44) 5480.38,3821.8 ; v3@5476.21,4544.98 cw(c5494.25,4546.56) 5480.38,4558.2 ; 5483.54,4100.83 ccw(c5498.33,4119.43) 5499.94,4095.71 ; 5492.6,3758.86 5492.6,3772.79 ; 5492.6,4621.14 5492.6,4607.21 ; 5492.6,4741.18 5492.6,4700.75 5492.6,4681.33 5492.6,4607.21 ; 5499.94,4095.66 cw(c5499.94,4071.89) 5523.71,4071.89 ccw(c5547.48,4071.89) 5547.48,4048.12 cw(c5547.48,4032.52) 5563.08,4032.52 ccw(c5586.85,4032.52) 5586.85,4008.75 cw(c5586.85,3993.15) 5602.45,3993.15 ccw(c5626.22,3993.15) 5626.22,3969.38 cw(c5626.22,3953.78) 5641.82,3953.78 ccw(c5665.59,3953.78) 5665.59,3930.01 cw(c5665.59,3914.41) 5681.19,3914.41 ccw(c5704.96,3914.41) 5704.96,3890.64 cw(c5704.96,3875.04) 5720.56,3875.04 ccw(c5744.33,3875.04) 5744.33,3851.27 cw(c5744.33,3835.67) 5759.93,3835.67 ccw(c5783.7,3835.67) 5783.7,3811.9 cw(c5783.7,3796.3) 5799.3,3796.3 ccw(c5823.07,3796.3) 5823.07,3772.53 5881.33,3772.53 5939.59,3772.53 5941.18,3772.53 ; v3@5508.11,4276.08 ccw(c5508.11,4293.81) 5520.64,4281.27 ; 5508.11,4331.88 ccw(c5508.11,4347.48) 5523.71,4347.48 cw(c5547.48,4347.48) 5547.48,4371.25 ccw(c5547.48,4386.85) 5563.08,4386.85 cw(c5586.85,4386.85) 5586.85,4410.62 ccw(c5586.85,4426.22) 5602.45,4426.22 cw(c5626.22,4426.22) 5626.22,4449.99 ccw(c5626.22,4465.59) 5641.82,4465.59 cw(c5665.59,4465.59) 5665.59,4489.36 ccw(c5665.59,4504.96) 5681.19,4504.96 cw(c5704.96,4504.96) 5704.96,4528.73 ccw(c5704.96,4544.33) 5720.56,4544.33 cw(c5744.33,4544.33) 5744.33,4568.1 ccw(c5744.33,4583.7) 5759.93,4583.7 cw(c5783.7,4583.7) 5783.7,4607.47 ccw(c5783.7,4623.07) 5799.3,4623.07 5799.3,4681.33 5799.3,4739.59 5799.3,4741.18 ; 5508.62,4331.97 ccw(c5508.62,4293.3) 5481.27,4320.64 ; v3@5515.45,4268.74 cw(c5533.18,4268.74) 5520.64,4281.27 ; 5531.88,4308.11 cw(c5547.48,4308.11) 5547.48,4323.71 ccw(c5547.48,4347.48) 5571.25,4347.48 cw(c5586.85,4347.48) 5586.85,4363.08 ccw(c5586.85,4386.85) 5610.62,4386.85 cw(c5626.22,4386.85) 5626.22,4402.45 ccw(c5626.22,4426.22) 5649.99,4426.22 cw(c5665.59,4426.22) 5665.59,4441.82 ccw(c5665.59,4465.59) 5689.36,4465.59 cw(c5704.96,4465.59) 5704.96,4481.19 ccw(c5704.96,4504.96) 5728.73,4504.96 cw(c5744.33,4504.96) 5744.33,4520.56 ccw(c5744.33,4544.33) 5768.1,4544.33 cw(c5783.7,4544.33) 5783.7,4559.93 ccw(c5783.7,4583.7) 5807.47,4583.7 cw(c5823.07,4583.7) 5823.07,4599.3 5881.33,4599.3 5939.59,4599.3 5941.18,4599.3 ; 5531.97,4308.62 cw(c5493.3,4308.62) 5520.64,4281.27 ; v3@5547,3954 5567,3934 5567,3900 5572,3895 5606.81,3895 v3(5626.22,3914.41) ; v3@5547.48,3946.28 cw(c5547.48,3928.8) 5559.84,3941.16 ; v3@5554.98,3953.78 ccw(c5573.71,3953.78) 5560.47,3940.53 ; v2@5596.4,3466.7 5597.7,3468 v2(5598,3468) ; v3@5625.57,3828.2 cw(c5623.99,3810.16) 5637.86,3821.8 ; v3@5625.57,4551.8 ccw(c5623.99,4569.84) 5637.86,4558.2 ; v3@5633.69,3835.02 ccw(c5651.73,3833.44) 5637.86,3821.8 ; v3@5633.69,4544.98 cw(c5651.73,4546.56) 5637.86,4558.2 ; 5650.08,3638.82 5650.08,3679.25 5650.08,3698.67 5650.08,3772.79 ; 5650.08,3758.86 5650.08,3772.79 ; 5650.08,4621.14 5650.08,4607.21 ; 5650.08,4741.18 5650.08,4700.75 5650.08,4681.33 5650.08,4607.21 ; v3@5744.98,3985.68 cw(c5746.56,3967.64) 5758.2,3981.51 ; v3@5744.98,4103.79 cw(c5746.56,4085.75) 5758.2,4099.62 ; v3@5744.98,4236.84 ccw(c5746.56,4254.88) 5758.2,4241.01 ; v3@5744.98,4276.21 ccw(c5746.56,4294.25) 5758.2,4280.38 ; v3@5744.98,4394.32 ccw(c5746.56,4412.36) 5758.2,4398.49 ; v3@5751.8,3993.8 ccw(c5769.84,3995.38) 5758.2,3981.51 ; v3@5751.8,4111.91 ccw(c5769.84,4113.49) 5758.2,4099.62 ; v3@5751.8,4228.72 cw(c5769.84,4227.14) 5758.2,4241.01 ; v3@5751.8,4268.09 cw(c5769.84,4266.51) 5758.2,4280.38 ; v3@5751.8,4386.2 cw(c5769.84,4384.62) 5758.2,4398.49 ; v1@5758.28,4828.28 cw(c5742.06,4812.06) 5765,4812.06 cw(c5787.93,4812.06) v1@5771.72,4828.28 ; 5759.93,4751.18 5759.93,4800 ; v1@5761.11,4831.11 cw(c5751.72,4821.72) 5765,4821.72 cw(c5778.28,4821.72) v1@5768.89,4831.11 ; v1(5765,4835) 5765,4805.07 ; 5821.14,3969.29 5807.21,3969.29 ; 5821.14,4087.4 5807.21,4087.4 ; 5821.14,4292.6 5807.21,4292.6 ; 5821.14,4410.71 5807.21,4410.71 ; 5941.18,4087.4 5900.75,4087.4 5881.33,4087.4 5807.21,4087.4 ; 5941.18,4253.23 5900.75,4253.23 5881.33,4253.23 5807.21,4253.23 5787.71,4253.23 ccw(c5787.71,4211.5) 5758.2,4241.01 ; 5941.18,4292.6 5900.75,4292.6 5881.33,4292.6 5807.21,4292.6 ; 5941.18,4410.71 5900.75,4410.71 5881.33,4410.71 5807.21,4410.71 ; 5949.18,3969.29 5941.18,3969.29 5900.75,3969.29 5881.33,3969.29 5807.21,3969.29 ; v2(5986.07,4638.31) 5987.31,4638.31 v2@5990,4641 ; 6665.67,1683.66 6676.15,1683.66 6750.27,1683.66 ; 6665.67,1762.4 6676.15,1762.4 6750.27,1762.4 ; 6665.67,1810.12 6741.1,1810.12 ccw(c6741.27,1843.25) 6758.92,1815.21 ; 6665.67,1967.6 6676.15,1967.6 6750.27,1967.6 ; 6665.67,2046.34 6676.15,2046.34 6750.27,2046.34 ; v3@6729.11,1584.11 cw(c6716.3,1571.3) 6734.41,1571.3 cw(c6752.52,1571.3) v3@6739.71,1584.11 ; v3@6729.22,2145.78 ccw(c6716.68,2158.32) 6734.41,2158.32 ccw(c6752.14,2158.32) v3@6739.6,2145.78 ; 6734.41,1510.67 6734.41,1511.73 6734.41,1531.15 v3(6734.41,1589.41) ; v3(6734.41,2140.59) 6734.41,2198.85 6734.41,2218.27 6734.41,2219.33 ; 6736.34,1683.66 6750.27,1683.66 ; 6736.34,1762.4 6750.27,1762.4 ; 6736.34,1967.6 6750.27,1967.6 ; 6736.34,2046.34 6750.27,2046.34 ; v3@6766.39,1826.93 cw(c6748.56,1830.08) 6758.95,1815.24 ; v3@6772.48,1818.24 ccw(c6769.33,1800.41) 6758.95,1815.24 ; v3@6805.76,1708.82 cw(c6787.93,1711.97) 6798.32,1697.13 ; v3@6805.76,1787.56 cw(c6787.93,1790.71) 6798.32,1775.87 ; v3@6805.76,1942.44 ccw(c6787.93,1939.29) 6798.32,1954.13 ; v3@6805.76,2021.18 ccw(c6787.93,2018.03) 6798.32,2032.87 ; v3@6811.85,1700.13 ccw(c6808.7,1682.3) 6798.32,1697.13 ; v3@6811.85,1778.87 ccw(c6808.7,1761.04) 6798.32,1775.87 ; v3@6811.85,1951.13 cw(c6808.7,1968.96) 6798.32,1954.13 ; v3@6811.85,2029.87 cw(c6808.7,2047.7) 6798.32,2032.87 ; 6837.01,1510.67 6837.01,1511.73 6837.01,1596.1 cw(c6870.14,1596.27) 6842.1,1613.92 ; 6837.01,2219.33 6837.01,2218.27 6837.01,2133.9 ccw(c6870.14,2133.73) 6842.1,2116.08 ; v3@6845.13,1627.48 cw(c6827.3,1624.33) 6842.13,1613.95 ; v3@6845.13,2102.52 ccw(c6827.3,2105.67) 6842.13,2116.05 ; v3@6853.82,1621.39 ccw(c6856.97,1603.56) 6842.13,1613.95 ; v3@6853.82,2108.61 cw(c6856.97,2126.44) 6842.13,2116.05 ; 6907.4,1510.67 6907.4,1511.73 6907.4,1531.15 6907.4,1605.27 ; 6907.4,1591.34 6907.4,1605.27 ; 6907.4,2138.66 6907.4,2124.73 ; 6907.4,2219.33 6907.4,2218.27 6907.4,2198.85 6907.4,2124.73 ; v3@6923.87,1666.85 cw(c6906.04,1663.7) 6920.87,1653.32 ; v3@6923.87,2063.15 ccw(c6906.04,2066.3) 6920.87,2076.68 ; v3@6932.56,1660.76 ccw(c6935.71,1642.93) 6920.87,1653.32 ; v3@6932.56,2069.24 cw(c6935.71,2087.07) 6920.87,2076.68 ; v3@7087.44,1660.76 cw(c7084.29,1642.93) 7099.13,1653.32 ; v3@7087.44,2069.24 ccw(c7084.29,2087.07) 7099.13,2076.68 ; v3@7096.13,1666.85 ccw(c7113.96,1663.7) 7099.13,1653.32 ; v3@7096.13,2063.15 cw(c7113.96,2066.3) 7099.13,2076.68 ; 7112.6,1510.67 7112.6,1511.73 7112.6,1531.15 7112.6,1605.27 ; 7112.6,1591.34 7112.6,1605.27 ; 7112.6,2138.66 7112.6,2124.73 ; v2@7165.44,2267.44 cw(c7149.15,2251.14) 7172.19,2251.14 ; v3@7166.18,1621.39 cw(c7163.03,1603.56) 7177.87,1613.95 ; v3@7166.18,2108.61 ccw(c7163.03,2126.44) 7177.87,2116.05 ; v2@7168.27,2270.26 cw(c7158.81,2260.8) 7172.19,2260.8 ; 7172.19,2250.23 cw(c7196.52,2250.23) v2@7179.32,2267.44 ; 7172.19,2259.89 cw(c7186.86,2259.89) v2@7176.49,2270.26 ; v2@7172.19,2273.36 7172.19,2234.25 7182.99,2223.45 7182.99,2218.27 7182.99,2133.9 cw(c7149.86,2133.73) 7177.9,2116.08 ; v2@7174.5,2330.5 7112.6,2268.6 7112.6,2218.27 7112.6,2198.85 7112.6,2124.73 ; v3@7174.87,1627.48 ccw(c7192.7,1624.33) 7177.87,1613.95 ; v3@7174.87,2102.52 cw(c7192.7,2105.67) 7177.87,2116.05 ; 7182.99,1510.67 7182.99,1511.73 7182.99,1596.1 ccw(c7149.86,1596.27) 7177.9,1613.92 ; v3@7208.15,1700.13 cw(c7211.3,1682.3) 7221.68,1697.13 ; v3@7208.15,1778.87 cw(c7211.3,1761.04) 7221.68,1775.87 ; v3@7208.15,1911.76 ccw(c7211.3,1929.59) 7221.68,1914.76 ; v3@7208.15,1951.13 ccw(c7211.3,1968.96) 7221.68,1954.13 ; v3@7208.15,2029.87 ccw(c7211.3,2047.7) 7221.68,2032.87 ; v3@7214.24,1708.82 ccw(c7232.07,1711.97) 7221.68,1697.13 ; v3@7214.24,1787.56 ccw(c7232.07,1790.71) 7221.68,1775.87 ; v3@7214.24,1903.07 cw(c7232.07,1899.92) 7221.68,1914.76 ; v3@7214.24,1942.44 cw(c7232.07,1939.29) 7221.68,1954.13 ; v3@7214.24,2021.18 cw(c7232.07,2018.03) 7221.68,2032.87 ; v3@7280.4,1584.22 cw(c7267.86,1571.68) 7285.59,1571.68 cw(c7303.32,1571.68) v3@7290.78,1584.22 ; v3@7280.4,2145.78 ccw(c7267.86,2158.32) 7285.59,2158.32 ccw(c7303.32,2158.32) v3@7290.78,2145.78 ; 7283.66,1683.66 7269.73,1683.66 ; 7283.66,1762.4 7269.73,1762.4 ; 7283.66,1928.23 7269.73,1928.23 ; 7283.66,1967.6 7269.73,1967.6 ; 7283.66,2046.34 7269.73,2046.34 ; 7285.59,1510.67 7285.59,1511.73 7285.59,1531.15 v3(7285.59,1589.41) ; v3(7285.59,2140.59) 7285.59,2198.85 7285.59,2218.27 7285.59,2219.33 ; 7354.33,1683.66 7343.85,1683.66 7269.73,1683.66 ; 7354.33,1762.4 7343.85,1762.4 7269.73,1762.4 ; 7354.33,1928.23 7343.85,1928.23 7269.73,1928.23 ; 7354.33,1967.6 7343.85,1967.6 7269.73,1967.6 ; 7354.33,2046.34 7343.85,2046.34 7269.73,2046.34 ; 4972.79,3969.29 4992.29,3969.29 ccw(c4992.29,4011.02) 5021.8,3981.51 ; 4972.79,4087.4 4992.29,4087.4 ccw(c4992.29,4129.13) 5021.8,4099.62 ; 4972.79,4292.6 4992.29,4292.6 cw(c4992.29,4250.87) 5021.8,4280.38 ; 4972.79,4410.71 4992.29,4410.71 cw(c4992.29,4368.98) 5021.8,4398.49 ; 5129.92,3772.79 5129.92,3792.29 cw(c5171.65,3792.29) 5142.14,3821.8 ; 5129.92,4607.21 5129.92,4587.71 ccw(c5171.65,4587.71) 5142.14,4558.2 ; 5287.4,3772.79 5287.4,3792.29 cw(c5329.13,3792.29) 5299.62,3821.8 ; 5287.4,4607.21 5287.4,4587.71 ccw(c5329.13,4587.71) 5299.62,4558.2 ; 5480.38,3821.8 cw(c5450.87,3792.29) 5492.6,3792.29 5492.6,3772.79 ; 5480.38,4558.2 ccw(c5450.87,4587.71) 5492.6,4587.71 5492.6,4607.21 ; 5613.42,3901.61 cw(c5626.22,3888.8) 5626.22,3906.91 ccw(c5626.22,3888.8) 5613.42,3901.61 ; 5613.42,3901.61 ccw(c5600.61,3914.41) 5618.72,3914.41 cw(c5600.61,3914.41) 5613.42,3901.61 ; 5637.86,3821.8 cw(c5608.35,3792.29) 5650.08,3792.29 5650.08,3772.79 ; 5637.86,4558.2 ccw(c5608.35,4587.71) 5650.08,4587.71 5650.08,4607.21 ; 5758.2,3981.51 ccw(c5787.71,4011.02) 5787.71,3969.29 5807.21,3969.29 ; 5758.2,4099.62 ccw(c5787.71,4129.13) 5787.71,4087.4 5807.21,4087.4 ; 5758.2,4280.38 cw(c5787.71,4250.87) 5787.71,4292.6 5807.21,4292.6 ; 5758.2,4398.49 cw(c5787.71,4368.98) 5787.71,4410.71 5807.21,4410.71 ; 5759.93,4800 5765,4805.07 ; 5759.93,4800 5765,4805.07 ; 6734.41,2158.7 cw(c6716.3,2158.7) 6729.11,2145.89 ccw(c6716.3,2158.7) 6734.41,2158.7 ; 6734.41,2158.7 ccw(c6752.52,2158.7) 6739.71,2145.89 cw(c6752.52,2158.7) 6734.41,2158.7 ; 6750.27,1683.66 6773.52,1683.66 ccw(c6773.52,1707.43) 6789.74,1690.05 6798.32,1697.13 ; 6750.27,1762.4 6773.52,1762.4 ccw(c6773.52,1786.17) 6789.74,1768.79 6798.32,1775.87 ; 6750.27,1967.6 6773.52,1967.6 cw(c6773.52,1943.83) 6789.74,1961.21 6798.32,1954.13 ; 6750.27,2046.34 6773.52,2046.34 cw(c6773.52,2022.57) 6789.74,2039.95 6798.32,2032.87 ; 6907.4,1605.27 6907.4,1628.52 cw(c6931.17,1628.52) 6913.79,1644.74 6920.87,1653.32 ; 6907.4,2124.73 6907.4,2101.48 ccw(c6931.17,2101.48) 6913.79,2085.26 6920.87,2076.68 ; 7099.13,1653.32 7106.21,1644.74 cw(c7088.83,1628.52) 7112.6,1628.52 7112.6,1605.27 ; 7099.13,2076.68 7106.21,2085.26 ccw(c7088.83,2101.48) 7112.6,2101.48 7112.6,2124.73 ; 7221.68,1697.13 7230.26,1690.05 ccw(c7246.48,1707.43) 7246.48,1683.66 7269.73,1683.66 ; 7221.68,1775.87 7230.26,1768.79 ccw(c7246.48,1786.17) 7246.48,1762.4 7269.73,1762.4 ; 7221.68,1914.76 7230.26,1921.84 cw(c7246.48,1904.46) 7246.48,1928.23 7269.73,1928.23 ; 7221.68,1954.13 7230.26,1961.21 cw(c7246.48,1943.83) 7246.48,1967.6 7269.73,1967.6 ; 7221.68,2032.87 7230.26,2039.95 cw(c7246.48,2022.57) 7246.48,2046.34 7269.73,2046.34 ; 7285.59,1571.3 cw(c7303.7,1571.3) 7290.89,1584.11 ccw(c7303.7,1571.3) 7285.59,1571.3 ; 7285.59,1571.3 ccw(c7267.48,1571.3) 7280.29,1584.11 cw(c7267.48,1571.3) 7285.59,1571.3 ; 7285.59,2158.7 cw(c7267.48,2158.7) 7280.29,2145.89 ccw(c7267.48,2158.7) 7285.59,2158.7 ; 7285.59,2158.7 ccw(c7303.7,2158.7) 7290.89,2145.89 cw(c7303.7,2158.7) 7285.59,2158.7
  MidLayer1 w12: v1(-130.48,3915.37) -96.64,3949.21 -96.64,4017.28 -97.54,4018.18 ; v1@-130.48,3920.87 ccw(c-130.48,3934.15) -121.09,3924.76 ccw(c-111.7,3915.37) v1@-124.98,3915.37 ; v1@-130.48,4233.87 cw(c-130.48,4220.6) -121.09,4229.99 cw(c-111.7,4239.37) v1@-124.98,4239.37 ; v1@-126.59,4235.49 cw(c-117.2,4226.1) -117.2,4239.37 cw(c-117.2,4252.65) v1@-126.59,4243.26 ; -97.41,4018.31 -106.5,4027.4 -106.5,4048.91 -101.5,4053.91 -101.5,4098.91 -60,4140.41 -60,4168.9 v1(-130.48,4239.37) -75.63,4239.37 40,4355 40,4430 120,4510 v2(130,4510) v2(150,4510) v2(170,4510) ; v1@39.5,4360 cw(c26.22,4360) 35.61,4350.61 cw(c45,4341.22) v1@45,4354.5 ; 40,4385.35 ccw(c70.35,4385.35) v1@48.89,4363.89 ; 103.01,4493.01 cw(c130,4466.02) v2@130,4504.19 ; v2@134.11,4505.89 cw(c144.03,4495.97) 144.03,4510 cw(c144.03,4524.03) v2@134.11,4514.11 ; v2@145.89,4505.89 ccw(c135.97,4495.97) 135.97,4510 ccw(c135.97,4524.03) v2@145.89,4514.11 ; v2@154.11,4505.89 cw(c164.03,4495.97) 164.03,4510 cw(c164.03,4524.03) v2@154.11,4514.11 ; v2@165.89,4505.89 ccw(c155.97,4495.97) 155.97,4510 ccw(c155.97,4524.03) v2@165.89,4514.11 ; J8.10@2173.98,6604.67 cw(c2173.98,6542.17) 2218.18,6586.37 cw(c2262.38,6630.56) J8.10@2199.87,6630.56 ; J8.10@2173.98,6616.67 cw(c2173.98,6583.14) 2197.7,6606.85 cw(c2221.41,6630.56) J8.10@2187.87,6630.56 ; J8.10@2173.98,6630.56 2280,6524.55 2280,6405 2400,6285 2400,6219.54 2425,6194.54 2450.95,6194.54 J8.8@2498,6147.49 ; J8.8@2474.47,6147.49 ccw(c2417.67,6147.49) 2457.84,6187.66 ccw(c2498,6227.82) J8.8@2498,6171.02 ; v1(6683.52,3375.71) v1@6687.52,3379.71 ; v1(6766.19,4008.37) v1@6772.19,4008.37 ; v2(7070,2515) 7080.5,2525.5 7095,2540 7205,2540 7220,2555 7220,2575 v1(7195,2600) ; v2@7070,2520.81 ccw(c7070,2534.84) 7079.92,2524.92 ccw(c7089.84,2515) v2@7075.81,2515 ; v1@7195,2594.5 cw(c7195,2581.22) 7204.39,2590.61 cw(c7213.78,2600) v1@7200.5,2600
  MidLayer2 w4: 4838.82,3772.53 4840.41,3772.53 4898.67,3772.53 4956.93,3772.53 ccw(c4956.93,3796.3) 4980.7,3796.3 cw(c4996.3,3796.3) 4996.3,3811.9 ccw(c4996.3,3835.67) 5020.07,3835.67 cw(c5035.67,3835.67) 5035.67,3851.27 ccw(c5035.67,3875.04) 5059.44,3875.04 cw(c5075.04,3875.04) 5075.04,3890.64 ccw(c5075.04,3914.41) 5098.81,3914.41 cw(c5114.41,3914.41) 5114.41,3930.01 ccw(c5114.41,3953.78) 5138.18,3953.78 cw(c5153.78,3953.78) 5153.78,3969.38 ccw(c5153.78,3993.15) 5177.55,3993.15 cw(c5193.15,3993.15) 5193.15,4008.75 ccw(c5193.15,4032.52) 5216.92,4032.52 5216.92,4052.08 ; 4838.82,4126.77 4841.47,4126.77 4899.73,4126.77 4957.99,4126.77 4977.41,4126.77 5051.53,4126.77 5071.03,4126.77 ccw(c5071.03,4168.5) 5100.54,4138.99 ; 4838.82,4599.3 4840.41,4599.3 4898.67,4599.3 4956.93,4599.3 cw(c4956.93,4583.7) 4972.53,4583.7 ccw(c4996.3,4583.7) 4996.3,4559.93 cw(c4996.3,4544.33) 5011.9,4544.33 ccw(c5035.67,4544.33) 5035.67,4520.56 cw(c5035.67,4504.96) 5051.27,4504.96 ccw(c5075.04,4504.96) 5075.04,4481.19 cw(c5075.04,4465.59) 5090.64,4465.59 ccw(c5114.41,4465.59) 5114.41,4441.82 cw(c5114.41,4426.22) 5130.01,4426.22 ccw(c5153.78,4426.22) 5153.78,4402.45 cw(c5153.78,4386.85) 5169.38,4386.85 ccw(c5193.15,4386.85) 5193.15,4363.08 cw(c5193.15,4347.48) 5208.75,4347.48 ; 4972.53,3638.82 4972.53,3640.41 4972.53,3698.67 4972.53,3756.93 cw(c4996.3,3756.93) 4996.3,3780.7 ccw(c4996.3,3796.3) 5011.9,3796.3 cw(c5035.67,3796.3) 5035.67,3820.07 ccw(c5035.67,3835.67) 5051.27,3835.67 cw(c5075.04,3835.67) 5075.04,3859.44 ccw(c5075.04,3875.04) 5090.64,3875.04 cw(c5114.41,3875.04) 5114.41,3898.81 ccw(c5114.41,3914.41) 5130.01,3914.41 cw(c5153.78,3914.41) 5153.78,3938.18 ccw(c5153.78,3953.78) 5169.38,3953.78 cw(c5193.15,3953.78) 5193.15,3977.55 ccw(c5193.15,3993.15) 5208.75,3993.15 ; 4980.7,4741.18 4980.7,4739.59 4980.7,4681.33 4980.7,4623.07 ccw(c4996.3,4623.07) 4996.3,4607.47 cw(c4996.3,4583.7) 5020.07,4583.7 ccw(c5035.67,4583.7) 5035.67,4568.1 cw(c5035.67,4544.33) 5059.44,4544.33 ccw(c5075.04,4544.33) 5075.04,4528.73 cw(c5075.04,4504.96) 5098.81,4504.96 ccw(c5114.41,4504.96) 5114.41,4489.36 cw(c5114.41,4465.59) 5138.18,4465.59 ccw(c5153.78,4465.59) 5153.78,4449.99 cw(c5153.78,4426.22) 5177.55,4426.22 ccw(c5193.15,4426.22) 5193.15,4410.62 cw(c5193.15,4386.85) 5216.92,4386.85 ; v3@5106.94,4151.28 cw(c5088.9,4152.86) 5100.54,4138.99 ; v3@5113.76,4143.16 ccw(c5112.18,4125.12) 5100.54,4138.99 ; 5129.92,3638.82 5129.92,3699.73 ; 5129.92,3641.47 5129.92,3699.73 ; 5129.92,4738.53 5129.92,4680.27 ; 5129.92,4741.18 5129.92,4680.27 ; v3@5146.39,3913.11 cw(c5128.56,3909.96) 5143.39,3899.58 ; v3@5146.39,4466.89 ccw(c5128.56,4470.04) 5143.39,4480.42 ; v3@5155.08,3907.02 ccw(c5158.23,3889.19) 5143.39,3899.58 ; v3@5155.08,4472.98 cw(c5158.23,4490.81) 5143.39,4480.42 ; 5208.66,4347.39 5208.66,4308.62 ccw(c5247.33,4308.62) 5219.99,4281.27 ; 5215.71,4009.96 ccw(c5232.52,3993.15) 5208.75,3993.15 ; 5217.01,4052.18 cw(c5227.16,4052.18) 5219.99,4059.36 ; v3@5225.18,4071.89 cw(c5207.45,4071.89) 5219.99,4059.36 ; v3@5225.18,4268.74 ccw(c5207.45,4268.74) 5219.99,4281.27 ; v3@5232.52,4064.55 ccw(c5232.52,4046.82) 5219.99,4059.36 ; v3@5232.52,4276.08 cw(c5232.52,4293.81) 5219.99,4281.27 ; 5232.61,4371.34 5271.38,4371.34 cw(c5271.38,4332.67) 5298.73,4360.01 ; 5252.08,4016.92 5232.52,4016.92 ccw(c5232.52,3993.15) 5208.75,3993.15 ; 5252.18,4017.01 ccw(c5252.18,4027.16) 5259.36,4019.99 ; v3@5303.92,4347.48 ccw(c5286.19,4347.48) 5298.73,4360.01 ; v3@5311.26,4354.82 cw(c5311.26,4372.55) 5298.73,4360.01 ; v1(5453.86,4815.47) 5455.62,4815.47 v1@5456.86,4816.71 ; v3@5468.74,4025.18 cw(c5468.74,4007.45) 5481.27,4019.99 ; v3@5476.08,4032.52 ccw(c5493.81,4032.52) 5481.27,4019.99 ; 5527.82,4362.99 ccw(c5527.82,4352.84) 5520.64,4360.01 ; 5527.92,4363.08 5547.48,4363.08 ccw(c5547.48,4386.85) 5571.25,4386.85 ; 5547.39,4008.66 5508.62,4008.66 cw(c5508.62,4047.33) 5481.27,4019.99 ; v3@5547.48,4103.92 cw(c5547.48,4086.19) 5560.01,4098.73 ; v3@5547.48,4315.45 ccw(c5547.48,4333.18) 5560.01,4320.64 ; v3@5554.82,4111.26 ccw(c5572.55,4111.26) 5560.01,4098.73 ; v3@5554.82,4308.11 cw(c5572.55,4308.11) 5560.01,4320.64 ; 5562.99,4327.82 cw(c5552.84,4327.82) 5560.01,4320.64 ; 5563.08,4327.91 5563.08,4347.48 cw(c5586.85,4347.48) 5586.85,4371.25 ccw(c5586.85,4386.85) 5602.45,4386.85 cw(c5626.22,4386.85) 5626.22,4410.62 ccw(c5626.22,4426.22) 5641.82,4426.22 cw(c5665.59,4426.22) 5665.59,4449.99 ccw(c5665.59,4465.59) 5681.19,4465.59 cw(c5704.96,4465.59) 5704.96,4489.36 ccw(c5704.96,4504.96) 5720.56,4504.96 cw(c5744.33,4504.96) 5744.33,4528.73 ccw(c5744.33,4544.33) 5759.93,4544.33 cw(c5783.7,4544.33) 5783.7,4568.1 ccw(c5783.7,4583.7) 5799.3,4583.7 cw(c5823.07,4583.7) 5823.07,4607.47 5881.33,4607.47 5939.59,4607.47 5941.18,4607.47 ; 5564.29,4370.04 ccw(c5547.48,4386.85) 5571.25,4386.85 ; 5571.25,4032.52 ccw(c5586.85,4032.52) 5586.85,4016.92 cw(c5586.85,3993.15) 5610.62,3993.15 ccw(c5626.22,3993.15) 5626.22,3977.55 cw(c5626.22,3953.78) 5649.99,3953.78 ccw(c5665.59,3953.78) 5665.59,3938.18 cw(c5665.59,3914.41) 5689.36,3914.41 ccw(c5704.96,3914.41) 5704.96,3898.81 cw(c5704.96,3875.04) 5728.73,3875.04 ccw(c5744.33,3875.04) 5744.33,3859.44 cw(c5744.33,3835.67) 5768.1,3835.67 ccw(c5783.7,3835.67) 5783.7,3820.07 cw(c5783.7,3796.3) 5807.47,3796.3 ccw(c5823.07,3796.3) 5823.07,3780.7 5881.33,3780.7 5939.59,3780.7 5941.18,3780.7 ; 5571.34,4032.61 5571.34,4071.38 ccw(c5532.67,4071.38) 5560.01,4098.73 ; v3@5624.92,3907.02 cw(c5621.77,3889.19) 5636.61,3899.58 ; v3@5624.92,4472.98 ccw(c5621.77,4490.81) 5636.61,4480.42 ; v3@5633.61,3913.11 ccw(c5651.44,3909.96) 5636.61,3899.58 ; v3@5633.61,4466.89 cw(c5651.44,4470.04) 5636.61,4480.42 ; 5650.08,3638.82 5650.08,3699.73 ; 5650.08,3641.47 5650.08,3699.73 ; 5650.08,4738.53 5650.08,4680.27 ; 5650.08,4741.18 5650.08,4680.27 ; v3@5705.61,4236.84 ccw(c5707.19,4254.88) 5718.83,4241.01 ccw(c5730.47,4227.14) v3@5712.43,4228.72 ; v3@5705.61,4276.21 ccw(c5707.19,4294.25) 5718.83,4280.38 ccw(c5730.47,4266.51) v3@5712.43,4268.09 ; v3@5705.61,4315.58 ccw(c5707.19,4333.62) 5718.83,4319.75 ccw(c5730.47,4305.88) v3@5712.43,4307.46 ; 5718.54,4240.76 cw(c5728.47,4230.83) 5728.47,4244.88 5742.4,4244.88 5802.59,4244.88 5822.01,4244.88 5880.27,4244.88 5938.53,4244.88 5941.18,4244.88 ; 5718.54,4280.13 cw(c5728.47,4270.2) 5728.47,4284.25 5742.4,4284.25 5802.59,4284.25 5822.01,4284.25 5880.27,4284.25 5938.53,4284.25 5941.18,4284.25 ; 5718.54,4319.5 cw(c5728.47,4309.57) 5728.47,4323.62 5742.4,4323.62 5802.59,4323.62 5822.01,4323.62 5880.27,4323.62 5938.53,4323.62 5941.18,4323.62 ; v1(5765,4835) 5765.9,4835 5769.86,4831.04 5769.41,4830.59 v1@5768.1,4829.28 ; 5799.3,3638.82 5799.3,3640.41 5799.3,3698.67 5799.3,3756.93 ccw(c5783.7,3756.93) 5783.7,3772.53 cw(c5783.7,3796.3) 5759.93,3796.3 ccw(c5744.33,3796.3) 5744.33,3811.9 cw(c5744.33,3835.67) 5720.56,3835.67 ccw(c5704.96,3835.67) 5704.96,3851.27 cw(c5704.96,3875.04) 5681.19,3875.04 ccw(c5665.59,3875.04) 5665.59,3890.64 cw(c5665.59,3914.41) 5641.82,3914.41 ccw(c5626.22,3914.41) 5626.22,3930.01 cw(c5626.22,3953.78) 5602.45,3953.78 ccw(c5586.85,3953.78) 5586.85,3969.38 cw(c5586.85,3993.15) 5563.08,3993.15 ; 5807.47,4741.18 5807.47,4739.59 5807.47,4681.33 5807.47,4623.07 cw(c5783.7,4623.07) 5783.7,4599.3 ccw(c5783.7,4583.7) 5768.1,4583.7 cw(c5744.33,4583.7) 5744.33,4559.93 ccw(c5744.33,4544.33) 5728.73,4544.33 cw(c5704.96,4544.33) 5704.96,4520.56 ccw(c5704.96,4504.96) 5689.36,4504.96 cw(c5665.59,4504.96) 5665.59,4481.19 ccw(c5665.59,4465.59) 5649.99,4465.59 cw(c5626.22,4465.59) 5626.22,4441.82 ccw(c5626.22,4426.22) 5610.62,4426.22 cw(c5586.85,4426.22) 5586.85,4402.45 ccw(c5586.85,4386.85) 5571.25,4386.85 ; v3@7168.13,1951.21 ccw(c7169.71,1969.25) 7181.35,1955.38 ccw(c7192.99,1941.51) v3@7174.95,1943.09 ; 7181.06,1955.13 cw(c7190.99,1945.2) 7190.99,1959.25 7284.53,1959.25 7354.33,1959.25 ; 5129.92,3699.73 5129.92,3757.99 5129.92,3777.41 5129.92,3851.53 5129.92,3874.78 cw(c5153.69,3874.78) 5136.31,3891 5143.39,3899.58 ; 5129.92,4680.27 5129.92,4622.01 5129.92,4602.59 5129.92,4528.47 5129.92,4505.22 ccw(c5153.69,4505.22) 5136.31,4489 5143.39,4480.42 ; 5216.92,4386.85 ccw(c5232.52,4386.85) 5232.52,4371.25 cw(c5232.52,4386.85) 5216.92,4386.85 ; 5259.36,4019.99 cw(c5271.89,4007.45) 5271.89,4025.18 ccw(c5271.89,4007.45) 5259.36,4019.99 ; 5259.36,4019.99 ccw(c5246.82,4032.52) 5264.55,4032.52 cw(c5246.82,4032.52) 5259.36,4019.99 ; 5520.64,4360.01 cw(c5508.11,4372.55) 5508.11,4354.82 ccw(c5508.11,4372.55) 5520.64,4360.01 ; 5520.64,4360.01 ccw(c5533.18,4347.48) 5515.45,4347.48 cw(c5533.18,4347.48) 5520.64,4360.01 ; 5563.08,3993.15 ccw(c5547.48,3993.15) 5547.48,4008.75 cw(c5547.48,3993.15) 5563.08,3993.15 ; 5636.61,3899.58 5643.69,3891 cw(c5626.31,3874.78) 5650.08,3874.78 5650.08,3851.53 5650.08,3777.41 5650.08,3757.99 5650.08,3699.73 ; 5636.61,4480.42 5643.69,4489 ccw(c5626.31,4505.22) 5650.08,4505.22 5650.08,4528.47 5650.08,4602.59 5650.08,4622.01 5650.08,4680.27
  MidLayer2 w8: v2@5340,2822.19 cw(c5340,2803.33) 5353.33,2816.67 cw(c5366.67,2830) v2@5347.81,2830 ; v2(5340,2830) 5360,2810 5464,2810 v2(5479,2825)
  MidLayer2 w12: v1@5274,3449.56 v1(5274,3448) ; v2@5309.25,3534.31 cw(c5295.23,3534.31) 5305.15,3524.39 cw(c5315.07,3514.47) v2@5315.07,3528.5 ; v2(5315.07,3534.31) 5285.63,3504.87 ; v1@5453.86,4820.97 ccw(c5453.86,4862.27) 5483.06,4833.06 ; v1@5455.62,4815.47 5465.47,4815.47 5500,4850 5583.23,4850 5595.23,4838 v1(5596,4838) ; v2@6020,2955 6021,2954 v2(6026,2954) ; v1(7457.52,3024.37) v1@7458.19,3025.04 ; v2(7550,1868) 7572,1890 7800,1890 v1(7805,1885) ; v2@7550,1873.81 ccw(c7550,1887.84) 7559.92,1877.92 ccw(c7569.84,1868) v2@7555.81,1868 ; 7779.65,1890 cw(c7779.65,1859.65) v1@7801.11,1881.11 ; 5252.02,3469.98 v1(5274,3448) ; 5252.02,3469.98 5252.02,3492.28 ; 5252.02,3469.98 v1(5274,3448) ; 5252.02,3492.28 5264.62,3504.87 ; 5252.02,3492.28 5264.62,3504.87 ; 5264.61,3457.39 cw(c5255.22,3448) 5268.5,3448 ccw(c5255.22,3448) 5264.61,3457.39 ; 5264.61,3457.39 ccw(c5274,3466.78) 5274,3453.5 cw(c5274,3466.78) 5264.61,3457.39 ; 5264.62,3504.87 5285.63,3504.87 ; 5264.62,3504.87 5285.63,3504.87