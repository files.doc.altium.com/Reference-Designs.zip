# Altium PCB NB3000AL.PcbDoc (part 34 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_FLASH_NBUSY: U7.A4 U8.D25 | length 3937.4
  Top Layer w4: v1@6158.47,5018.32 ccw(c6142.26,5002.11) 6142.26,5025.04 ccw(c6142.26,5047.98) v1@6158.47,5031.76 ; v1@6161.3,5021.15 ccw(c6151.91,5011.76) 6151.91,5025.04 ccw(c6151.91,5038.32) v1@6161.3,5028.93 ; v1(6165.19,5025.04) 6023.52,5025.04 6006.86,5008.37 6003.19,5004.71 6003.19,4919.38 5973.19,4889.38 5973.19,4877.94 5937.5,4842.25 5937.5,4826.29 5866.62,4755.41 5866.62,4748.38 5866.62,4741.18 5866.62,4682.64 cw(c5856.47,4682.64) 5863.64,4675.46 5863.64,4675.24 5855.73,4667.32 cw(c5842.76,4682.13) 5842.76,4662.44 ccw(c5842.76,4642.75) 5823.07,4642.75 5823.07,4631.31 cw(c5803.39,4631.31) 5817.31,4617.39 5817.31,4617.31 5815.92,4615.92 ; 5815.92,4615.92 ccw(c5828.45,4603.39) 5810.73,4603.39 cw(c5828.45,4603.39) 5815.92,4615.92 ; 5815.92,4615.92 cw(c5803.39,4628.45) 5803.39,4610.73 ccw(c5803.39,4628.45) 5815.92,4615.92
  Top Layer w8: U7.A4@7987.8,4504.68 v5(8007.48,4524.37) ; v5@7998.48,4524.37 cw(c7976.75,4524.37) 7992.12,4509.01 cw(c8007.48,4493.64) v5@8007.48,4515.37
  MidLayer1 w4: v1(6165.19,5025.04) 6269.17,5025.04 6300,4994.21 6592.5,4994.21 6626.71,4960 6725,4960 6740.04,4975.04 6960,4975.04 6963,4978.04 v1(6990.19,4978.04) 6990.19,4976.71 v1@6988.52,4975.04 ; v1@6169.08,5021.15 cw(c6178.47,5011.76) 6178.47,5025.04 cw(c6178.47,5038.32) v1@6169.08,5028.93 ; v1@6171.91,5018.32 cw(c6188.13,5002.11) 6188.13,5025.04 cw(c6188.13,5047.98) v1@6171.91,5031.76 ; v1@6983.47,4971.32 ccw(c6967.26,4955.11) 6967.26,4978.04 ccw(c6967.26,5000.98) v1@6983.47,4984.76 ; v1@6986.3,4974.15 ccw(c6976.91,4964.76) 6976.91,4978.04 ccw(c6976.91,4991.32) v1@6986.3,4981.93 ; v5@8000.93,4515.53 cw(c7991.28,4502.52) 8007.48,4502.52 ; v5@8003.31,4518.75 cw(c7997.17,4510.47) 8007.48,4510.47 cw(c8017.79,4510.47) v5@8011.65,4518.75 ; v5@8007.48,4525.04 8006.86,4525.04 8006.86,4524.37 v5(8007.48,4524.37) 8007.48,4502.52 ; v5@8014.03,4515.53 ccw(c8023.68,4502.52) 8007.48,4502.52 ; v1@8038.14,4488.66 ccw(c8021.92,4472.44) 8021.92,4495.37 ccw(c8021.92,4518.31) v1@8038.14,4502.09 ; v1@8040.97,4491.49 ccw(c8031.58,4482.1) 8031.58,4495.37 ccw(c8031.58,4508.65) v1@8040.97,4499.26 ; v1(8044.86,4495.37) 8014.63,4495.37 8007.48,4502.52
  MidLayer2 w4: v1@6990.19,4968.54 cw(c6990.19,4945.61) 7006.41,4961.82 cw(c7022.63,4978.04) v1@6999.69,4978.04 ; v1@6990.19,4972.54 cw(c6990.19,4959.26) 6999.58,4968.65 cw(c7008.97,4978.04) v1@6995.69,4978.04 ; v1(6990.19,4978.04) 7007.69,4960.54 7007.69,4942.79 6989.94,4925.04 6920.44,4925.04 6889.36,4893.96 6889.36,4879.46 6899.61,4869.21 6914.11,4869.21 6953.94,4909.04 7029.21,4909.04 7030.04,4908.21 7035.01,4908.21 7035.84,4909.04 7043.34,4916.54 7140.61,4916.54 7157.94,4899.21 7234.21,4899.21 7319.36,4984.36 7319.36,5045.62 7333.73,5060 7345,5060 7387,5018 7806.17,5018 8048.52,4775.65 8048.52,4518.52 8044.86,4514.86 ; v1@8039.01,4502.86 ccw(c8029.63,4514.86) 8044.86,4514.86 ; v1(8044.86,4495.37) 8044.86,4514.86 ; v1@8050.71,4502.86 cw(c8060.08,4514.86) 8044.86,4514.86
DB_MEM.BUS_FLASH_NCS: U7.F2 U8.C27 | length 2253.5
  Top Layer w4: v1(6002,4661) 5999.26,4658.26 5949.18,4658.26 5941.18,4658.26 ; 5894.66,4655.29 ccw(c5907.19,4642.76) 5889.47,4642.76 cw(c5907.19,4642.76) 5894.66,4655.29 ; 5894.66,4655.29 cw(c5882.13,4667.82) 5882.13,4650.1 ccw(c5882.13,4667.82) 5894.66,4655.29 ; 5894.66,4655.29 cw(c5901.84,4648.11) 5901.84,4658.26 ; 5894.66,4655.29 cw(c5901.84,4648.11) 5901.84,4658.26 ; 5901.84,4658.26 5941.18,4658.26 ; 5901.84,4658.26 5941.18,4658.26
  Top Layer w8: v5@7771.26,4594.11 cw(c7771.26,4572.38) 7786.62,4587.75 cw(c7801.99,4603.11) v5@7780.26,4603.11 ; v5(7771.26,4603.11) U7.F2@7790.95,4583.43
  MidLayer2 w4: v1(6002,4661) 6178.21,4661 6190,4649.21 6239.36,4649.21 6266.02,4675.87 6372.94,4675.87 6376.6,4672.21 6399.13,4672.21 6401.13,4674.21 6454.63,4674.21 6469.13,4674.21 6470.46,4675.54 6543.96,4675.54 6565.09,4675.54 6627.92,4675.54 6631.26,4672.21 6656.96,4646.5 6717.71,4646.5 6722.73,4646.5 6734.52,4634.71 6915.19,4634.71 6924.02,4625.87 7504.71,4625.87 7508.21,4622.37 7725.13,4622.37 ; v1@6005.89,4657.11 cw(c6015.28,4647.72) 6015.28,4661 cw(c6015.28,4674.28) v1@6005.89,4664.89 ; v1@6008.72,4654.28 cw(c6024.93,4638.06) 6024.93,4661 cw(c6024.93,4683.93) v1@6008.72,4667.72 ; v5@7760.26,4603.11 ccw(c7733.71,4603.11) 7752.48,4621.89 ccw(c7771.26,4640.67) v5@7771.26,4614.11 ; v5@7764.26,4603.11 ccw(c7747.36,4603.11) 7759.31,4615.06 ccw(c7771.26,4627.01) v5@7771.26,4610.11 ; v5(7771.26,4603.11) 7752,4622.37 ; 7725.13,4622.37 7752,4622.37 ; 7725.13,4622.37 7752,4622.37
  Bottom Layer w4: v1@6002,4651.85 v1(6002,4661)
DB_MEM.BUS_FLASH_NRESET: U7.B5 U8.P21 | length 2791
  Top Layer w4: U8.P21@5645.91,4209.68 v3(5665.59,4229.37) ; U8.P21@5645.91,4217.03 ccw(c5645.91,4234.75) 5658.44,4222.22 ccw(c5670.97,4209.68) U8.P21@5653.25,4209.68 ; 5652.79,4216.57 cw(c5665.59,4203.76) 5665.59,4221.87 ccw(c5665.59,4203.76) 5652.79,4216.57 ; 5652.79,4216.57 ccw(c5639.98,4229.37) 5658.09,4229.37 cw(c5639.98,4229.37) 5652.79,4216.57
  Top Layer w8: U7.B5@7948.43,4465.32 v5(7968.11,4445.63) ; v5@7959.11,4445.63 ccw(c7937.38,4445.63) 7952.75,4460.99 ccw(c7968.11,4476.36) v5@7968.11,4454.63
  MidLayer2 w4: v3@5666.24,4236.84 ccw(c5667.82,4254.88) 5679.46,4241.01 ; v3@5673.06,4228.72 cw(c5691.1,4227.14) 5679.46,4241.01 ; 6533.29,4266.71 6524.61,4266.71 ; v5(7968.11,4445.63) 7948.52,4426.04 7865.86,4426.04 7826.86,4387.04 7793.52,4387.04 7790.52,4390.04 7790.52,4417.71 7781.86,4426.37 7643.86,4426.37 7609.19,4391.71 7237.86,4391.71 7215.19,4369.04 7215.19,4287.04 7186.03,4257.88 7138.43,4257.88 7121.27,4275.04 7080,4275.04 6990.19,4275.04 6979.86,4264.71 6945,4264.71 6894.9,4264.71 6880.23,4250.04 6864.86,4250.04 6840,4250.04 6619.51,4250.04 6612.51,4257.04 ; 5679.46,4241.01 cw(c5708.97,4211.5) 5708.97,4253.23 5728.47,4253.23 5802.59,4253.23 5822.01,4253.23 5963.23,4253.23 5990,4280 5990,4297.37 6008.13,4315.5 6129.75,4315.5 6146.75,4332.5 6227.81,4332.5 6251.77,4308.54 6262.46,4308.54 6293.5,4277.5 6332.25,4277.5 6337.75,4283 6450,4283 6455,4283 6470,4283 6508.31,4283 6524.61,4266.71 ; 6524.61,4266.71 6563.29,4266.71 6602.84,4266.71 ; 6602.84,4266.71 6612.51,4257.04 ; 6602.84,4266.71 6612.51,4257.04
DB_MEM.BUS_NBE0: U8.W21 U12.15 U16.39 | length 3141.1
  Top Layer w4: U8.W21@5645.91,4005.49 cw(c5645.91,3987.77) 5658.44,4000.3 cw(c5670.97,4012.83) U8.W21@5653.25,4012.83 ; U8.W21@5645.91,4012.83 v3(5665.59,3993.15) ; v1@6792.81,3793.66 cw(c6776.59,3777.44) 6799.52,3777.44 cw(c6822.46,3777.44) v1@6806.24,3793.66 ; v1@6795.64,3796.49 cw(c6786.25,3787.1) 6799.52,3787.1 cw(c6812.8,3787.1) v1@6803.41,3796.49 ; v1(6799.52,3800.37) 6799.52,3736.97 6802.99,3733.5 U12.15@6845.59,3733.5 ; U12.15@6822.37,3727.85 ccw(c6808.72,3714.19) 6808.72,3733.5 ccw(c6808.72,3752.82) U12.15@6822.37,3739.16 ; v1@7092.3,4060.98 ccw(c7069.36,4060.98) 7085.58,4077.2 ccw(c7101.8,4093.41) v1@7101.8,4070.48 ; v1@7096.3,4060.98 ccw(c7083.02,4060.98) 7092.41,4070.37 ccw(c7101.8,4079.76) v1@7101.8,4066.48 ; v1(7101.8,4060.98) 7081.52,4081.25 7081.52,4421.73 7084.86,4425.06 7084.86,4614.86 7206.86,4736.86 7206.86,4791.71 7228.38,4813.23 U16.39@7294.41,4813.23 ; U16.39@7271.19,4807.57 ccw(c7257.54,4793.91) 7257.54,4813.23 ccw(c7257.54,4832.54) U16.39@7271.19,4818.88 ; 5652.79,4005.95 cw(c5639.98,3993.15) 5658.09,3993.15 ccw(c5639.98,3993.15) 5652.79,4005.95 ; 5652.79,4005.95 ccw(c5665.59,4018.76) 5665.59,4000.65 cw(c5665.59,4018.76) 5652.79,4005.95
  MidLayer2 w4: v3@5666.24,3985.68 cw(c5667.82,3967.64) 5679.46,3981.51 ; v3@5673.06,3993.8 ccw(c5691.1,3995.38) 5679.46,3981.51 ; v1(6799.52,3800.37) 6760.9,3839 6640.86,3839 6434.56,3839 6381.86,3891.71 6337.52,3891.71 6325.02,3879.21 6256.68,3879.21 6250.7,3885.19 6235.94,3885.19 6232.63,3881.88 6180.56,3881.88 6154.69,3856 6085.19,3856 6071.11,3870.07 6059.99,3870.07 6048.56,3881.5 6046.81,3881.5 6008,3920.31 6008,3958 5996.71,3969.29 5949.18,3969.29 5941.18,3969.29 5822.01,3969.29 5802.59,3969.29 5728.47,3969.29 5708.97,3969.29 cw(c5708.97,4011.02) 5679.46,3981.51
  Bottom Layer w4: v1(6799.52,3800.37) 6867,3800.37 6875,3808.37 6940.19,3808.37 7064.08,3932.26 7081.7,3949.88 7081.7,4040.88 v1(7101.8,4060.98) ; v1@6803.41,3796.49 cw(c6812.8,3787.1) 6812.8,3800.37 cw(c6812.8,3813.65) v1@6803.41,3804.26 ; v1@6806.24,3793.66 cw(c6822.46,3777.44) 6822.46,3800.37 cw(c6822.46,3823.31) v1@6806.24,3807.09 ; v1@7092.3,4060.98 cw(c7069.36,4060.98) 7085.58,4044.76 cw(c7101.8,4028.54) v1@7101.8,4051.48 ; v1@7096.3,4060.98 cw(c7083.02,4060.98) 7092.41,4051.59 cw(c7101.8,4042.2) v1@7101.8,4055.48
DB_MEM.BUS_NBE1: U8.A25 U12.39 U16.40 | length 4043.9
  Top Layer w4: U8.A25@5798.19,4726.69 ccw(c5785.66,4739.22) 5803.39,4739.22 ccw(c5821.11,4739.22) U8.A25@5808.58,4726.69 ; U8.A25@5803.39,4721.5 5803.39,4741.18 5803.39,4749.18 5803.39,4773.55 5832,4802.16 5832,4908.52 5873.52,4950.04 5873.52,5056.71 v1(5898.52,5081.71) ; v1@5889.02,5081.71 cw(c5866.09,5081.71) 5882.31,5065.49 cw(c5898.52,5049.27) v1@5898.52,5072.21 ; v1@5893.02,5081.71 cw(c5879.75,5081.71) 5889.14,5072.32 cw(c5898.52,5062.93) v1@5898.52,5076.21 ; v1(7173.19,4779.37) 7238.54,4844.72 U16.40@7294.41,4844.72 7326.86,4844.72 ; v1@7173.19,4784.87 ccw(c7173.19,4798.15) 7182.58,4788.76 ccw(c7191.97,4779.37) v1@7178.69,4779.37 ; v1@7173.19,4788.87 ccw(c7173.19,4811.81) 7189.41,4795.59 ccw(c7205.63,4779.37) v1@7182.69,4779.37 ; U16.40@7271.19,4839.07 ccw(c7257.54,4825.41) 7257.54,4844.72 ccw(c7257.54,4864.04) U16.40@7271.19,4850.38 ; U12.39@7294.41,3702.01 7323.97,3702.01 ; U16.40@7318.64,4840.31 cw(c7326.86,4834.87) 7326.86,4844.72 ; U16.40@7318.64,4849.14 ccw(c7326.86,4854.58) 7326.86,4844.72 ; U12.39@7319.35,3698.93 cw(c7323.97,3697.01) 7323.97,3702.01 ; U12.39@7319.35,3705.08 ccw(c7323.97,3707.01) 7323.97,3702.01 ; 7323.97,3702.01 7337.94,3715.98 7349.25,3715.98 7365.19,3700.04 7365.19,3665.04 7371.86,3658.37 7433.37,3658.37 7445,3670 7445,3726.16 7478.19,3759.35 7478.19,3857.37 7435,3900.56 7435,3994.85 7468.86,4028.71 7470.19,4030.04 7470.19,4778.37 7440.19,4808.37 7363.21,4808.37 7326.86,4844.72
  MidLayer1 w4: v1(5898.52,5081.71) 5933.52,5116.71 6520.54,5116.71 6536.88,5133.04 6553.88,5150.04 v1(6773.52,5150.04) ; v1@5898.52,5087.21 ccw(c5898.52,5100.49) 5907.91,5091.1 ccw(c5917.3,5081.71) v1@5904.02,5081.71 ; v1@5898.52,5091.21 ccw(c5898.52,5114.14) 5914.74,5097.93 ccw(c5930.96,5081.71) v1@5908.02,5081.71 ; v1@6766.81,5143.32 ccw(c6750.59,5127.11) 6750.59,5150.04 ccw(c6750.59,5172.98) v1@6766.81,5156.76 ; v1@6769.64,5146.15 ccw(c6760.25,5136.76) 6760.25,5150.04 ccw(c6760.25,5163.32) v1@6769.64,5153.93
  Bottom Layer w4: v1@6773.52,5140.54 cw(c6773.52,5117.61) 6789.74,5133.82 cw(c6805.96,5150.04) v1@6783.02,5150.04 ; v1@6773.52,5144.54 cw(c6773.52,5131.26) 6782.91,5140.65 cw(c6792.3,5150.04) v1@6779.02,5150.04 ; v1(6773.52,5150.04) 6798.52,5125.04 6859.19,5125.04 6884.19,5100.04 6930,5100.04 6942.52,5087.52 6942.52,5069.73 7144.92,4867.33 7144.92,4807.65 v1(7173.19,4779.37) ; v1@7163.69,4779.37 ccw(c7140.76,4779.37) 7156.97,4795.59 ccw(c7173.19,4811.81) v1@7173.19,4788.87 ; v1@7167.69,4779.37 ccw(c7154.41,4779.37) 7163.8,4788.76 ccw(c7173.19,4798.15) v1@7173.19,4784.87
DB_MEM.BUS_NBE2: U8.AC27 U13.15 U17.39 | length 2569.2
  Top Layer w4: 6128.22,3751.78 ccw(c6153.03,3776.6) U13.15@6153.03,3741.5 ; 6135.05,3744.95 ccw(c6153.03,3762.94) U13.15@6153.03,3737.5 ; 6141.87,3738.13 ccw(c6153.03,3749.28) U13.15@6153.03,3733.5 ; U13.15@6186.37,3741.3 cw(c6190.59,3722.8) 6204.01,3736.22 ; v1@6205.69,3725.04 ccw(c6182.76,3725.04) 6198.97,3741.26 ccw(c6215.19,3757.48) v1@6215.19,3734.54 ; v1@6209.69,3725.04 ccw(c6196.41,3725.04) 6205.8,3734.43 ccw(c6215.19,3743.82) v1@6215.19,3730.54 ; v1(6215.19,3725.04) 6198.52,3741.71 6170.59,3741.71 U13.15@6147.19,3741.71 ; v1@6460.47,3706.76 ccw(c6444.26,3722.98) 6467.19,3722.98 ccw(c6490.13,3722.98) v1@6473.91,3706.76 ; v1@6463.3,3703.93 ccw(c6453.91,3713.32) 6467.19,3713.32 ccw(c6480.47,3713.32) v1@6471.08,3703.93 ; v1(6467.19,3700.04) 6467.19,3798.04 6460.08,3805.15 6390.19,3875.04 6390.19,3983.63 6381.02,3992.79 6381.02,4034.96 6415.5,4069.44 6415.5,4183.75 6386.5,4212.75 6386.5,4227.25 6413,4253.75 6435.5,4276.25 6435.5,4389.44 6435.5,4428.67 6416.36,4447.81 6416.36,4468.94 6420.69,4473.27 6420.69,4734.63 6426.72,4740.66 6426.72,4780.72 6459.23,4813.23 U17.39@6619.41,4813.23 ; 5894.66,3842.82 cw(c5907.19,3855.35) 5889.47,3855.35 ccw(c5907.19,3855.35) 5894.66,3842.82 ; 5894.66,3842.82 ccw(c5882.13,3830.29) 5882.13,3848.01 cw(c5882.13,3830.29) 5894.66,3842.82 ; 5894.66,3842.82 ccw(c5901.84,3850) 5901.84,3839.85 ; 5894.66,3842.82 ccw(c5901.84,3850) 5901.84,3839.85 ; 5901.84,3839.85 5941.18,3839.85 ; 5901.84,3839.85 5941.18,3839.85 ; 5941.18,3839.85 5995.46,3839.85 6020.81,3814.5 6060.32,3774.99 6078.14,3774.99 6078.19,3775.04 6090,3775 6105,3775 6146.5,3733.5 U13.15@6155.4,3733.5 ; U13.15@6147.19,3741.71 U13.15@6155.4,3733.5 ; U13.15@6147.19,3741.71 U13.15@6155.4,3733.5 ; U13.15@6155.4,3733.5 U13.15@6170.59,3733.5 U13.15@6155.4,3733.5 ; 6582.54,4813.23 ccw(c6582.54,4832.54) 6596.19,4818.88 cw(c6582.54,4832.54) 6582.54,4813.23 ; 6582.54,4813.23 cw(c6582.54,4793.91) 6596.19,4807.57 ccw(c6582.54,4793.91) 6582.54,4813.23
  Bottom Layer w4: v1(6215.19,3725.04) 6240.19,3750.04 6310,3750.04 6310.5,3750.54 6348.02,3750.54 6365.19,3733.37 6433.86,3733.37 v1(6467.19,3700.04) ; v1@6215.19,3730.54 ccw(c6215.19,3743.82) 6224.58,3734.43 ccw(c6233.97,3725.04) v1@6220.69,3725.04 ; v1@6215.19,3734.54 ccw(c6215.19,3757.48) 6231.41,3741.26 ccw(c6247.63,3725.04) v1@6224.69,3725.04 ; v1@6457.69,3700.04 ccw(c6434.76,3700.04) 6450.97,3716.26 ccw(c6467.19,3732.48) v1@6467.19,3709.54 ; v1@6461.69,3700.04 ccw(c6448.41,3700.04) 6457.8,3709.43 ccw(c6467.19,3718.82) v1@6467.19,3705.54
DB_MEM.BUS_NBE3: U8.V26 U13.39 U17.40 | length 2879.6
  Top Layer w4: U8.V26@5842.76,4044.86 cw(c5842.76,4027.14) 5855.29,4039.67 ; U8.V26@5850.1,4052.2 ccw(c5867.82,4052.2) 5855.29,4039.67 ; v1@6087.48,3987.48 ccw(c6071.26,3971.26) 6071.26,3994.2 ccw(c6071.26,4017.13) v1@6087.48,4000.92 ; v1@6090.31,3990.31 ccw(c6080.92,3980.92) 6080.92,3994.2 ccw(c6080.92,4007.48) v1@6090.31,3998.09 ; v1(6094.2,3994.2) 6056.55,3994.2 6041.95,4008.8 6003.21,4008.8 5983.67,4028.34 5949.18,4028.34 5941.18,4028.34 5882.64,4028.34 cw(c5882.64,4067.02) 5855.29,4039.67 ; U13.39@6619.41,3702.01 6646.97,3702.01 6661.67,3716.71 ; U17.40@6619.41,4844.72 6670.51,4844.72 6765.19,4750.04 ; U13.39@6636.97,3702.01 ccw(c6640.17,3717.29) 6651.21,3706.25 ; U13.39@6637.79,3705.92 ccw(c6641.98,3725.94) 6656.44,3711.48 ; U13.39@6638.61,3709.84 ccw(c6643.79,3734.59) 6661.67,3716.71 ; U17.40@6642.63,4839.07 cw(c6656.28,4825.41) 6656.28,4844.72 cw(c6656.28,4864.04) U17.40@6642.63,4850.38 ; v1@6716.27,3939.75 cw(c6723.3,3946.48) 6716.41,3953.37 ; v1@6719.16,3942.52 cw(c6726.24,3949.31) 6719.3,3956.25 ; v1@6722.05,3945.28 cw(c6729.19,3952.14) 6722.19,3959.14 ; 6775,4330 6775,4330.94 6765,4340.94 6765,4395 6755,4405 6755,4515 6785,4545 6785,4625 6780.52,4629.48 6780.52,4665 ; 6775.5,4330 6775.5,4290.25 ; 6661.67,3716.71 6708.19,3716.71 6724.86,3700.04 6754.19,3700.04 6765.19,3711.04 6765.19,3830.71 6754.19,3841.71 6725.86,3841.71 6715.19,3852.37 v1(6715.19,3938.71) 6715.19,3952.14 6722.19,3959.14 ; 6722.19,3959.14 6722.19,3975 ; 6722.19,3959.14 6722.19,3975 ; 6722.19,3975 6722.19,4045.19 6715.19,4052.19 6715.19,4088.73 6732.4,4105.94 6732.4,4174.5 6714.36,4192.54 6714.36,4214.61 6775.5,4275.75 ; 6765.19,4717.45 6765.19,4720.37 ; 6765.19,4717.45 6780,4702.64 6780.52,4702.12 ; 6765.19,4717.45 6780.52,4702.12 ; 6765.19,4720.37 6765.19,4750.04 ; 6765.19,4720.37 6765.19,4750.04 ; 6775.5,4275.75 6775.5,4290.25 ; 6775.5,4275.75 6775.5,4290.25 ; 6780.52,4665 6780.52,4672 ; 6780.52,4665 6780.52,4672 ; 6780.52,4672 6780.52,4702.12
  MidLayer2 w4: v1(6094.2,3994.2) 6103.4,4003.4 6167.91,4003.4 6210.31,3961 6231.82,3961 6265.19,3994.37 6357.17,3994.37 ; v1@6705.69,3938.71 cw(c6682.76,3938.71) 6698.97,3922.49 cw(c6715.19,3906.27) v1@6715.19,3929.21 ; v1@6709.69,3938.71 cw(c6696.41,3938.71) 6705.8,3929.32 cw(c6715.19,3919.93) v1@6715.19,3933.21 ; v1(6715.19,3938.71) 6684.52,3908.04 6595.65,3908.04 6538.69,3965 6515,3965 ; 6357.17,3994.37 6384.84,3966.71 ; 6357.17,3994.37 6384.84,3966.71 ; 6384.84,3966.71 6386.55,3965 6501.71,3965 ; 6501.71,3965 6515,3965 ; 6501.71,3965 6515,3965
DB_MEM.BUS_NOE: U7.G2 U8.AF12 U16.41 U17.41 U61.107 | length 9359.5
  Top Layer w4: U8.AF12@5284.23,3737.24 cw(c5266.51,3737.24) 5279.04,3724.71 ; U8.AF12@5291.58,3729.9 ccw(c5291.58,3712.18) 5279.04,3724.71 ; v1@5350.98,3325.88 cw(c5334.76,3309.66) 5357.7,3309.66 cw(c5380.63,3309.66) v1@5364.42,3325.88 ; v1@5353.81,3328.71 cw(c5344.42,3319.32) 5357.7,3319.32 cw(c5370.98,3319.32) v1@5361.59,3328.71 ; v1@5356.93,3333.37 v1(5357.7,3332.6) 5357.7,3262.7 5328.37,3233.37 5265.19,3233.37 5232.19,3266.37 5232.19,3422.19 5238.02,3428.02 5238.02,3503.13 5273.02,3538.13 5273.02,3552.62 5268.02,3557.62 5268.02,3645.44 5267.71,3645.75 5267.71,3697.36 cw(c5306.39,3697.36) 5279.04,3724.71 ; v1@5392.43,2683.93 ccw(c5392.43,2697.21) 5401.82,2687.82 ccw(c5411.21,2678.43) v1@5397.93,2678.43 ; v1@5392.43,2687.93 ccw(c5392.43,2710.86) 5408.64,2694.64 ccw(c5424.86,2678.43) v1@5401.93,2678.43 ; v1@5398.24,2678.43 v1(5392.43,2678.43) 5419.36,2705.36 5425.18,2705.36 5440,2705.36 U61.107@5516.83,2705.36 ; U61.107@5500.81,2702.53 ccw(c5493.98,2695.7) 5493.98,2705.36 ccw(c5493.98,2715.02) U61.107@5500.81,2708.19 ; U17.41@6628.23,4876.22 ccw(c6628.23,4916.23) v1@6658.33,4889.87 ; U17.41@6637.06,4876.22 ccw(c6637.06,4908.51) v1@6661.34,4887.23 ; U17.41@6645.88,4876.22 ccw(c6645.88,4900.78) v1@6664.35,4884.6 ; 6654.7,4876.22 ccw(c6654.7,4893.05) v1@6667.36,4881.96 ; v1@6655.32,4892.5 cw(c6619.41,4923.96) U17.41@6619.41,4876.22 6655.68,4876.22 6662.47,4883.01 v1(6662.47,4886.24) ; v1(7185.52,4833.37) 7228.37,4876.22 U16.41@7294.41,4876.22 7346.86,4876.22 7356.86,4866.22 v1(7356.86,4840.71) ; v1@7185.52,4838.87 ccw(c7185.52,4852.15) 7194.91,4842.76 ccw(c7204.3,4833.37) v1@7191.02,4833.37 ; v1@7185.52,4842.87 ccw(c7185.52,4865.81) 7201.74,4849.59 ccw(c7217.96,4833.37) v1@7195.02,4833.37 ; U16.41@7271.19,4870.56 ccw(c7257.54,4856.91) 7257.54,4876.22 ccw(c7257.54,4895.53) U16.41@7271.19,4881.88 ; U16.41@7317.63,4870.56 cw(c7331.28,4856.91) 7331.28,4876.22 cw(c7331.28,4895.53) U16.41@7317.63,4881.88 ; v1@7350.14,4847.43 ccw(c7333.92,4863.64) 7356.86,4863.64 ccw(c7379.79,4863.64) v1@7363.57,4847.43 ; v1@7352.97,4844.6 ccw(c7343.58,4853.99) 7356.86,4853.99 ccw(c7370.14,4853.99) v1@7360.75,4844.6 ; v1@7541.81,3626.66 cw(c7525.59,3610.44) 7548.52,3610.44 cw(c7571.46,3610.44) v1@7555.24,3626.66 ; v1@7544.64,3629.49 cw(c7535.25,3620.1) 7548.52,3620.1 cw(c7561.8,3620.1) v1@7552.41,3629.49 ; v1(7548.52,3633.37) 7548.52,3523.04 7631.86,3439.71 7631.86,3270.37 7690.19,3212.04 7690.19,2984.71 v1(7655.52,2950.04) ; v1@7655.52,2955.54 ccw(c7655.52,2968.82) 7664.91,2959.43 ccw(c7674.3,2950.04) v1@7661.02,2950.04 ; v1@7655.52,2959.54 ccw(c7655.52,2982.48) 7671.74,2966.26 ccw(c7687.96,2950.04) v1@7665.02,2950.04
  Top Layer w8: v5@7731.89,4594.11 cw(c7731.89,4572.38) 7747.25,4587.75 cw(c7762.62,4603.11) v5@7740.89,4603.11 ; v5(7731.89,4603.11) U7.G2@7751.58,4583.43
  MidLayer1 w4: v1@5356.86,3333.37 5357.63,3332.6 v1(5357.7,3332.6) ; v1@5357.67,3332.57 5440.19,3250.04 5440.19,3190 5431.86,3181.67 5431.86,3044.23 5419.5,3031.88 5419.5,2958.19 5403.5,2942.19 5403.5,2934.05 5374.81,2905.36 5374.81,2841.69 5380.81,2835.69 5380.81,2793.31 5353.19,2765.69 5353.19,2739.5 5392.43,2700.26 ; v1@5357.7,3323.1 cw(c5357.7,3300.33) 5373.8,3316.43 ; v1@5357.7,3327.1 cw(c5357.7,3313.99) 5366.97,3323.26 ; v1@5363.2,3332.6 ccw(c5376.64,3332.6) 5367.14,3323.09 ; v1@5367.2,3332.6 ccw(c5390.3,3332.6) 5373.97,3316.27 ; v1@5385.95,2685.38 ccw(c5372.09,2700.26) 5392.43,2700.26 ; v1@5388.68,2682.45 ccw(c5380.66,2691.07) 5392.43,2691.07 ccw(c5404.2,2691.07) v1@5396.18,2682.45 ; v1@5394.32,2680.32 v1(5392.43,2678.43) 5392.43,2700.26 ; v1@5398.9,2685.38 cw(c5412.76,2700.26) 5392.43,2700.26 ; v1@7541.81,3640.09 ccw(c7525.59,3656.31) 7548.52,3656.31 ccw(c7571.46,3656.31) v1@7555.24,3640.09 ; v1@7544.64,3637.26 ccw(c7535.25,3646.65) 7548.52,3646.65 ccw(c7561.8,3646.65) v1@7552.41,3637.26 ; v1(7548.52,3633.37) 7548.52,3720 7506.86,3761.67 7506.86,4456.86 7631.86,4581.86 7631.86,4606.71 7648.52,4623.37 7711.63,4623.37 v5(7731.89,4603.11) ; v5@7720.89,4603.11 ccw(c7694.33,4603.11) 7713.11,4621.89 ccw(c7731.89,4640.67) v5@7731.89,4614.11 ; v5@7724.89,4603.11 ccw(c7707.99,4603.11) 7719.94,4615.06 ccw(c7731.89,4627.01) v5@7731.89,4610.11
  MidLayer2 w4: v1@6655.75,4879.52 cw(c6639.53,4863.31) 6662.47,4863.31 cw(c6685.4,4863.31) v1@6669.19,4879.52 ; v1@6658.58,4882.35 cw(c6649.19,4872.96) 6662.47,4872.96 cw(c6675.75,4872.96) v1@6666.36,4882.35 ; v1(6662.47,4886.24) 6662.47,4857.53 6711.63,4808.37 6760,4808.37 6786.52,4808.37 6811.52,4783.37 7135.52,4783.37 v1(7185.52,4833.37) ; v1@7176.02,4833.37 cw(c7153.09,4833.37) 7169.31,4817.16 cw(c7185.52,4800.94) v1@7185.52,4823.87 ; v1@7180.02,4833.37 cw(c7166.75,4833.37) 7176.14,4823.99 cw(c7185.52,4814.6) v1@7185.52,4827.87
  Bottom Layer w4: v1(5392.43,2678.43) 5398.24,2678.43 5411.52,2691.71 ; v1@5393.99,2683.7 ccw(c5397.64,2696.07) 5406.77,2686.95 ; v1@5395.12,2687.54 ccw(c5399.82,2703.41) 5411.52,2691.71 ; v1@5401.93,2678.43 cw(c5410.82,2678.43) 5404.53,2684.72 ; 6360,2577.71 6210.15,2577.71 ; 6382.17,2577.71 6479.17,2577.71 ; v1@7350.14,4847.43 ccw(c7333.92,4863.64) 7356.86,4863.64 ccw(c7379.79,4863.64) v1@7363.57,4847.43 ; v1@7352.97,4844.6 ccw(c7343.58,4853.99) 7356.86,4853.99 ccw(c7370.14,4853.99) v1@7360.75,4844.6 ; v1(7356.86,4840.71) 7356.86,4881.86 7373.34,4898.34 7373.34,4918.34 7520,5065 7528.69,5065 7533.15,5060.54 7562.77,5060.54 7569.31,5054 7627.9,5054 7673.19,5008.71 7673.19,4631.37 7682.19,4622.37 7712.63,4622.37 v5(7731.89,4603.11) ; v1@7648.81,2943.32 ccw(c7632.59,2927.11) 7632.59,2950.04 ccw(c7632.59,2972.98) v1@7648.81,2956.76 ; v1@7651.64,2946.15 ccw(c7642.25,2936.76) 7642.25,2950.04 ccw(c7642.25,2963.32) v1@7651.64,2953.93 ; v1(7655.52,2950.04) 7538.81,2950.04 7480.48,2891.71 7389.17,2891.71 7388.68,2892.2 7382.35,2892.2 7125.02,2634.87 7038.32,2634.87 7030.32,2642.87 6976.06,2642.87 6952.68,2619.5 6924.88,2619.5 6903.88,2640.5 6876.12,2640.5 6855.12,2619.5 6694.5,2619.5 6683.37,2608.37 6509.84,2608.37 6479.17,2577.71 ; v5@7720.89,4603.11 ccw(c7694.33,4603.11) 7713.11,4621.89 ccw(c7731.89,4640.67) v5@7731.89,4614.11 ; v5@7724.89,4603.11 ccw(c7707.99,4603.11) 7719.94,4615.06 ccw(c7731.89,4627.01) v5@7731.89,4610.11 ; 5411.52,2691.71 5556.86,2691.71 5573.52,2708.37 5573.52,2725.04 5581.86,2733.37 5721.86,2733.37 5723.52,2731.71 5723.52,2691.71 5714.19,2682.37 5714.19,2642.37 5723.19,2633.37 5764.63,2633.37 5820.29,2577.71 6210.15,2577.71 ; 6210.15,2577.71 6479.17,2577.71
DB_MEM.BUS_NWE: U7.A5 U8.G7 U12.16 U13.16 U16.17 U17.17 U61.108 | length 12601.4
  Top Layer w4: v3(5075.04,4504.96) U8.G7@5094.72,4485.28 ; U8.G7@5087.38,4485.28 ccw(c5069.66,4485.28) 5082.19,4497.81 ccw(c5094.72,4510.34) U8.G7@5094.72,4492.62 ; U61.108@5516.83,2685.68 5548.19,2685.68 5583.83,2650.04 5609.52,2650.04 5623.52,2636.04 5623.52,2476.04 5699.52,2400.04 6145.54,2400.04 6202.55,2343.03 6311.97,2343.03 6319.87,2335.13 6319.87,2283.03 6323.52,2279.37 6475.28,2279.37 6530,2334.09 6530,2458.14 6581.86,2510 6581.86,2641.86 6606.71,2666.71 6874.52,2666.71 v1@6923.76,2715.95 ; U61.108@5532.85,2682.85 cw(c5539.68,2676.02) 5539.68,2685.68 cw(c5539.68,2695.33) U61.108@5532.85,2688.5 ; v1@6127.52,4480.54 cw(c6127.52,4457.61) 6143.74,4473.82 cw(c6159.96,4490.04) v1@6137.02,4490.04 ; v1@6127.52,4484.54 cw(c6127.52,4471.26) 6136.91,4480.65 cw(c6146.3,4490.04) v1@6133.02,4490.04 ; v1(6127.52,4490.04) 6150.79,4466.77 U17.17@6170.59,4466.77 U17.17@6173.52,4466.77 ; 6140.96,4476.61 cw(c6131.12,4466.77) U17.17@6145.03,4466.77 ; 6142.38,4475.18 ccw(c6153.03,4485.83) U17.17@6153.03,4470.77 ; U13.16@6170.59,3702.01 6216.91,3702.01 6225.32,3710.43 6317.57,3710.43 v1(6340.19,3733.04) ; U13.16@6193.81,3696.35 cw(c6207.46,3682.69) 6207.46,3702.01 cw(c6207.46,3721.32) U13.16@6193.81,3707.66 ; v1@6330.69,3733.04 cw(c6307.76,3733.04) 6323.97,3716.82 cw(c6340.19,3700.61) v1@6340.19,3723.54 ; v1@6334.69,3733.04 cw(c6321.41,3733.04) 6330.8,3723.65 cw(c6340.19,3714.26) v1@6340.19,3727.54 ; U12.16@6845.59,3702.01 6892.99,3702.01 6898.52,3696.48 v1(6898.52,3666.71) ; U16.17@6845.59,4466.77 6875.59,4466.77 ; U12.16@6868.81,3696.35 cw(c6882.46,3682.69) 6882.46,3702.01 cw(c6882.46,3721.32) U12.16@6868.81,3707.66 ; U16.17@6870.43,4463.45 cw(c6875.59,4461.1) 6875.59,4466.77 ; U16.17@6870.43,4470.09 ccw(c6875.59,4472.44) 6875.59,4466.77 ; v1@6890.18,4469.16 ccw(c6882.52,4464.98) 6882.52,4473.71 ; v1@6890.18,4478.26 cw(c6882.52,4482.43) 6882.52,4473.71 ; v1@6891.81,3673.43 ccw(c6875.59,3689.64) 6898.52,3689.64 ccw(c6921.46,3689.64) v1@6905.24,3673.43 ; v1@6894.64,3670.6 ccw(c6885.25,3679.99) 6898.52,3679.99 ccw(c6911.8,3679.99) v1@6902.41,3670.6 ; v1(6898.52,4473.71) 6882.52,4473.71 ; 6905.7,2697.89 ccw(c6886.89,2716.71) v1@6913.5,2716.71 ; 6909.38,2701.57 cw(c6923,2687.95) v1@6923,2707.21 ; 6912.53,2704.72 ccw(c6900.54,2716.71) v1@6917.5,2716.71 ; 5087.84,4492.16 cw(c5100.65,4504.96) 5082.54,4504.96 ccw(c5100.65,4504.96) 5087.84,4492.16 ; 5087.84,4492.16 ccw(c5075.04,4479.35) 5075.04,4497.46 cw(c5075.04,4479.35) 5087.84,4492.16 ; 6875.59,4466.77 6882.52,4473.71
  Top Layer w8: U7.A5@7987.8,4465.32 v5(8007.48,4445.63) ; v5@7998.48,4445.63 ccw(c7976.75,4445.63) 7992.12,4460.99 ccw(c8007.48,4476.36) v5@8007.48,4454.63
  MidLayer1 w4: v1(6127.52,4490.04) 6190.67,4553.19 6321,4553.19 6334.52,4566.71 6373.52,4566.71 6389.19,4551.04 6568.96,4551.04 6577.96,4542.04 6830.19,4542.04 v1(6898.52,4473.71) 6966.52,4541.71 6990.19,4541.71 7006.86,4558.37 7006.86,4633.37 6931.19,4709.04 6868.84,4709.04 6843.17,4683.37 6758.17,4683.37 6741.5,4700.04 v1(6681.86,4700.04) ; v1@6127.52,4495.54 ccw(c6127.52,4508.82) 6136.91,4499.43 ccw(c6146.3,4490.04) v1@6133.02,4490.04 ; v1@6127.52,4499.54 ccw(c6127.52,4522.48) 6143.74,4506.26 ccw(c6159.96,4490.04) v1@6137.02,4490.04 ; v1@6685.75,4696.15 cw(c6695.14,4686.76) 6695.14,4700.04 cw(c6695.14,4713.32) v1@6685.75,4703.93 ; v1@6688.57,4693.32 cw(c6704.79,4677.11) 6704.79,4700.04 cw(c6704.79,4722.98) v1@6688.57,4706.76 ; v1@6889.02,4473.71 ccw(c6866.09,4473.71) 6882.31,4489.93 ccw(c6898.52,4506.14) v1@6898.52,4483.21 ; v1@6893.02,4473.71 ccw(c6879.75,4473.71) 6889.14,4483.1 ccw(c6898.52,4492.49) v1@6898.52,4479.21 ; v1(6898.52,3666.71) 6928.88,3666.71 7065.52,3803.35 7065.52,4125.37 7135.5,4195.35 7135.5,4245.56 7135,4246.06 7135,4309.18 7140.69,4314.87 7140.69,4394.53 7115.19,4420.02 v1(7115.19,4535) v1@7115.19,4540 ; v1@6902.41,3662.82 cw(c6911.8,3653.43) 6911.8,3666.71 cw(c6911.8,3679.99) v1@6902.41,3670.6 ; v1@6905.24,3659.99 cw(c6921.46,3643.77) 6921.46,3666.71 cw(c6921.46,3689.64) v1@6905.24,3673.43 ; v1@7108.47,4528.28 cw(c7092.26,4512.06) 7115.19,4512.06 cw(c7138.13,4512.06) v1@7121.91,4528.28 ; v1@7111.3,4531.11 cw(c7101.91,4521.72) 7115.19,4521.72 cw(c7128.47,4521.72) v1@7119.08,4531.11
  MidLayer2 w4: v2@4688.06,4701.94 ccw(c4671.31,4718.69) 4695,4718.69 ccw(c4718.69,4718.69) v2@4701.94,4701.94 ; v2@4690.89,4699.11 ccw(c4680.97,4709.03) 4695,4709.03 ccw(c4709.03,4709.03) v2@4699.11,4699.11 ; v2(4695,4695) 4695,4748.89 4766.13,4820.02 4766.13,4931.33 4767.81,4933.01 4767.81,5017.38 4764.36,5020.83 4764.36,5050.29 4872.44,5158.37 5115.19,5158.37 5177.56,5096 5322.15,5096 ; 5330.01,5103.86 5322.15,5096 ; v1(6340.19,3733.04) 6381.71,3733.04 6442.37,3672.37 6729.19,3672.37 6781.86,3725.04 6840.19,3725.04 v1(6898.52,3666.71) 6978.04,3666.71 7015.19,3629.55 7015.19,3272.57 6947.5,3204.88 6947.5,3017.73 6973.52,2991.71 6973.52,2767.23 v1@6924.52,2718.23 ; v1@6344.08,3729.15 cw(c6353.47,3719.76) 6353.47,3733.04 cw(c6353.47,3746.32) v1@6344.08,3736.93 ; v1@6346.91,3726.32 cw(c6363.13,3710.11) 6363.13,3733.04 cw(c6363.13,3755.98) v1@6346.91,3739.76 ; v1@6672.36,4700.04 ccw(c6649.42,4700.04) 6665.64,4716.26 ccw(c6681.86,4732.48) v1@6681.86,4709.54 ; v1@6676.36,4700.04 ccw(c6663.08,4700.04) 6672.47,4709.43 ccw(c6681.86,4718.82) v1@6681.86,4705.54 ; v1(6681.86,4700.04) 6630.02,4751.87 6630.02,5151.74 6576.77,5205 6458.84,5205 6445.21,5191.37 5765.54,5191.37 5757.17,5183 5619.37,5183 5583.37,5219 5445.15,5219 5322.15,5096 ; v1@6889.02,3666.71 ccw(c6866.09,3666.71) 6882.31,3682.93 ccw(c6898.52,3699.14) v1@6898.52,3676.21 ; v1@6893.02,3666.71 ccw(c6879.75,3666.71) 6889.14,3676.1 ccw(c6898.52,3685.49) v1@6898.52,3672.21 ; v1(6898.52,4473.71) 6914.41,4457.83 6963.64,4457.83 6964.19,4458.37 6973.52,4467.71 6973.52,4522.06 6984.84,4533.37 7153.19,4533.37 7211.52,4475.04 7269.19,4475.04 7278.19,4484.04 7969.07,4484.04 ; v1@6902.41,3662.82 cw(c6911.8,3653.43) 6911.8,3666.71 cw(c6911.8,3679.99) v1@6902.41,3670.6 ; v1@6905.24,3659.99 cw(c6921.46,3643.77) 6921.46,3666.71 cw(c6921.46,3689.64) v1@6905.24,3673.43 ; v1@6923,2722.21 ccw(c6923,2735.49) 6932.39,2726.1 ccw(c6941.78,2716.71) v1@6928.5,2716.71 ; v1@6923,2726.21 ccw(c6923,2749.14) 6939.22,2732.93 ccw(c6955.43,2716.71) v1@6932.5,2716.71 ; v5@7996.48,4445.63 ccw(c7969.92,4445.63) 7988.7,4464.41 ccw(c8007.48,4483.19) v5@8007.48,4456.63 ; v5@8000.48,4445.63 ccw(c7983.58,4445.63) 7995.53,4457.58 ccw(c8007.48,4469.53) v5@8007.48,4452.63 ; v1@6924.52,2718.23 6924.52,2716.71 v1(6923,2716.71) v1@6924.52,2718.23 ; 7969.07,4484.04 7969.74,4483.37 ; 7969.07,4484.04 7977.05,4476.06 ; 7969.07,4484.04 7973.92,4479.19 ; 7969.74,4483.37 v5(8007.48,4445.63) ; 7969.74,4483.37 7973.92,4479.19 ; 7973.92,4479.19 7996.56,4456.55 ; 7973.92,4479.19 7977.05,4476.06 ; 7977.05,4476.06 7977.76,4475.35 7980.19,4472.92 7996.56,4456.55 ; 7996.56,4456.55 v5(8007.48,4445.63) ; 7996.56,4456.55 v5(8007.48,4445.63)
  Bottom Layer w4: v2@4688.06,4688.06 cw(c4671.31,4671.31) 4695,4671.31 ; v2@4690.89,4690.89 cw(c4680.97,4680.97) 4695,4680.97 cw(c4709.03,4680.97) v2@4699.11,4690.89 ; v2(4695,4695) 4695,4671.31 ; v2@4701.94,4688.06 ccw(c4718.69,4671.31) 4695,4671.31 ; v3@5067.65,4503.66 ccw(c5049.82,4500.51) 5060.21,4515.35 ; v3@5073.74,4512.35 cw(c5070.59,4530.18) 5060.21,4515.35 ; 4695,4671.31 4758.84,4607.47 4830.82,4607.47 4838.82,4607.47 4840.41,4607.47 4898.67,4607.47 4956.93,4607.47 cw(c4956.93,4583.7) 4980.7,4583.7 ccw(c4996.3,4583.7) 4996.3,4568.1 cw(c4996.3,4544.33) 5020.07,4544.33 ccw(c5035.67,4544.33) 5035.67,4528.73 cw(c5035.67,4504.96) 5052.48,4521.77 5060.21,4515.35
DB_MEM.BUS_SDRAM_CKE: R157.2 R235.1 U8.Y23 U12.37 U13.37 | length 3743.1
  Top Layer w4: U8.Y23@5724.65,3966.12 cw(c5724.65,3948.4) 5737.18,3960.93 cw(c5749.71,3973.46) U8.Y23@5731.99,3973.46 ; U8.Y23@5724.65,3973.46 v3(5744.33,3953.78) ; v1(6572.86,3621.04) 6590.83,3639.02 ; v1@6572.86,3626.54 ccw(c6572.86,3639.82) 6582.25,3630.43 ccw(c6591.64,3621.04) v1@6578.36,3621.04 ; v1@6572.86,3630.54 ccw(c6572.86,3653.48) 6589.07,3637.26 ccw(c6605.29,3621.04) v1@6582.36,3621.04 ; 6583.04,3631.22 cw(c6601.85,3612.41) U13.37@6601.85,3639.02 ; 6589.87,3638.05 cw(c6601.85,3626.07) U13.37@6601.85,3643.02 ; U13.37@6594.24,3636.54 ccw(c6590.83,3635.43) 6590.83,3639.02 ; U13.37@6594.24,3641.49 cw(c6590.83,3642.6) 6590.83,3639.02 ; U13.37@6619.41,3639.02 6590.83,3639.02 ; U12.37@7294.41,3639.02 7334.17,3639.02 v1(7345.19,3650.04) ; U12.37@7317.63,3633.36 cw(c7331.28,3619.7) 7331.28,3639.02 cw(c7331.28,3658.33) U12.37@7317.63,3644.67 ; v1(7481.86,3633.37) 7528.37,3633.37 7530,3635 ; v1@7485.75,3629.49 cw(c7495.14,3620.1) 7495.14,3633.37 cw(c7495.14,3646.65) v1@7485.75,3637.26 ; v1@7488.57,3626.66 cw(c7504.79,3610.44) 7504.79,3633.37 cw(c7504.79,3656.31) v1@7488.57,3640.09 ; R235.1@7523.41,3502.62 ccw(c7507.5,3518.52) 7530,3518.52 ccw(c7552.5,3518.52) R235.1@7536.59,3502.62 ; R157.2@7523.41,3671.01 cw(c7507.5,3655.1) 7530,3655.1 cw(c7552.5,3655.1) R157.2@7536.59,3671.01 ; R157.2@7524.23,3670.28 cw(c7514.83,3658.38) 7530,3658.38 ; R235.1@7526.24,3499.79 ccw(c7517.16,3508.87) 7530,3508.87 ccw(c7542.84,3508.87) R235.1@7533.76,3499.79 ; R157.2@7526.24,3673.84 cw(c7517.16,3664.76) 7530,3664.76 cw(c7542.84,3664.76) R157.2@7533.76,3673.84 ; R235.1@7530,3496.03 7530,3635 ; R157.2@7535.77,3670.28 ccw(c7545.17,3658.38) 7530,3658.38 ; 5731.53,3966.58 cw(c5718.72,3953.78) 5736.83,3953.78 ccw(c5718.72,3953.78) 5731.53,3966.58 ; 5731.53,3966.58 ccw(c5744.33,3979.39) 5744.33,3961.28 cw(c5744.33,3979.39) 5731.53,3966.58 ; 7530,3635 R157.2@7530,3677.6 7530,3658.37
  MidLayer1 w4: v3@5744.98,3946.31 cw(c5746.56,3928.27) 5758.2,3942.14 ; v3@5751.8,3954.43 ccw(c5769.84,3956.01) 5758.2,3942.14 ; 5821.14,3929.92 5807.21,3929.92 ; v1@6243.13,3740.19 ccw(c6236.03,3750.47) 6248.52,3750.47 ; v1(6248.52,3732.37) 6248.52,3750.48 ; v1@6253.92,3740.19 cw(c6261.02,3750.47) 6248.52,3750.47 ; 5758.2,3942.14 ccw(c5787.71,3971.65) 5787.71,3929.92 5807.21,3929.92 ; 5807.21,3929.92 5881.33,3929.92 5900.75,3929.92 5941.18,3929.92 5949.18,3929.92 6013.89,3929.92 6018.62,3925.19 6033.38,3925.19 6041.9,3933.71 6056.78,3933.71 6058.4,3932.09 6075.34,3932.09 6080.75,3937.5 6098.15,3937.5 6124.42,3911.23 6124.42,3874.58 6248.52,3750.48
  MidLayer2 w4: v1(6248.52,3732.37) 6287.63,3732.37 6322.19,3697.81 6322.19,3662.62 6332.62,3652.19 6367.81,3652.19 6370.62,3655 6538.9,3655 v1(6572.86,3621.04) ; v1@6252.41,3728.49 cw(c6261.8,3719.1) 6261.8,3732.37 cw(c6261.8,3745.65) v1@6252.41,3736.26 ; v1@6255.24,3725.66 cw(c6271.46,3709.44) 6271.46,3732.37 cw(c6271.46,3755.31) v1@6255.24,3739.09 ; v1@6563.36,3621.04 ccw(c6540.42,3621.04) 6556.64,3637.26 ccw(c6572.86,3653.48) v1@6572.86,3630.54 ; v1@6567.36,3621.04 ccw(c6554.08,3621.04) 6563.47,3630.43 ccw(c6572.86,3639.82) v1@6572.86,3626.54 ; v1@7345.19,3640.54 cw(c7345.19,3617.61) 7361.41,3633.82 cw(c7377.63,3650.04) v1@7354.69,3650.04 ; v1@7345.19,3644.54 cw(c7345.19,3631.26) 7354.58,3640.65 cw(c7363.97,3650.04) v1@7350.69,3650.04 ; v1(7345.19,3650.04) 7361.86,3633.37 v1(7481.86,3633.37) ; v1@7475.14,3626.66 ccw(c7458.92,3610.44) 7458.92,3633.37 ccw(c7458.92,3656.31) v1@7475.14,3640.09 ; v1@7477.97,3629.49 ccw(c7468.58,3620.1) 7468.58,3633.37 ccw(c7468.58,3646.65) v1@7477.97,3637.26
  Bottom Layer w4: v1@6572.86,3611.54 cw(c6572.86,3588.61) 6589.07,3604.82 cw(c6605.29,3621.04) v1@6582.36,3621.04 ; v1@6572.86,3615.54 cw(c6572.86,3602.26) 6582.25,3611.65 cw(c6591.64,3621.04) v1@6578.36,3621.04 ; v1(6572.86,3621.04) 6602.19,3591.71 6845.54,3591.71 6887.21,3633.37 7048.52,3633.37 7156.86,3741.71 7156.86,3788.96 7199.36,3831.46 7199.36,3845.96 7187.77,3857.54 7182.94,3857.54 7172.61,3867.87 7145.28,3867.87 7135.02,3878.13 7135.02,3901.62 7167.61,3934.21 7264.36,3934.21 7276.02,3922.54 7276.02,3897.81 7273.52,3895.31 7273.52,3656.48 7279.96,3650.04 v1(7345.19,3650.04) ; v1@7338.47,3643.32 ccw(c7322.26,3627.11) 7322.26,3650.04 ccw(c7322.26,3672.98) v1@7338.47,3656.76 ; v1@7341.3,3646.15 ccw(c7331.91,3636.76) 7331.91,3650.04 ccw(c7331.91,3663.32) v1@7341.3,3653.93
DB_MEM.BUS_SDRAM_CLK: NT46.2 R155.2 R156.1 U8.AE5 U12.38 U13.38 | length 6006.4
  Top Layer w4: v3(4996.3,3756.93) U8.AE5@5015.98,3776.61 ; U8.AE5@5008.64,3776.61 cw(c4990.92,3776.61) 5003.45,3764.08 cw(c5015.98,3751.55) U8.AE5@5015.98,3769.27 ; U13.38@6619.41,3670.51 6655.99,3670.51 ; U13.38@6642.69,3664.92 cw(c6655.99,3651.89) 6655.99,3670.51 ; U13.38@6642.69,3676.11 ccw(c6655.99,3689.13) 6655.99,3670.51 ; v1(6665.19,3693.04) 6665.19,3679.71 6655.99,3670.51 ; v1@7224.86,3714.54 cw(c7224.86,3691.61) 7241.07,3707.82 cw(c7257.29,3724.04) v1@7234.36,3724.04 ; v1@7224.86,3718.54 cw(c7224.86,3705.26) 7234.25,3714.65 cw(c7243.64,3724.04) v1@7230.36,3724.04 ; v1(7224.86,3724.04) 7265.19,3683.71 7265.19,3670.51 ; U12.38@7269.39,3667.63 ccw(c7265.19,3666.01) 7265.19,3670.51 ; U12.38@7269.39,3673.39 cw(c7265.19,3675.01) 7265.19,3670.51 ; U12.38@7317.63,3664.85 cw(c7331.28,3651.2) 7331.28,3670.51 cw(c7331.28,3689.83) U12.38@7317.63,3676.17 ; v1(7340.19,3691.71) 7340.19,3678.51 7332.19,3670.51 U12.38@7294.41,3670.51 7265.19,3670.51 ; R155.2@7520.08,4043.74 cw(c7510.16,4033.82) R155.2@7524.19,4033.82 ; R155.2@7521.27,4042.55 ccw(c7529.51,4050.79) R155.2@7529.51,4039.14 ; v1@7523.28,3925.32 cw(c7507.07,3909.11) 7530,3909.11 cw(c7552.94,3909.11) v1@7536.72,3925.32 ; v1@7523.28,3938.76 ccw(c7507.07,3954.98) 7530,3954.98 ccw(c7552.94,3954.98) v1@7536.72,3938.76 ; R156.1@7523.41,3867.26 ccw(c7507.5,3883.17) 7530,3883.17 ccw(c7552.5,3883.17) R156.1@7536.59,3867.26 ; R155.2@7523.41,4027.23 cw(c7507.5,4011.32) 7530,4011.32 cw(c7552.5,4011.32) R155.2@7536.59,4027.23 ; v1@7526.11,3928.15 cw(c7516.72,3918.76) 7530,3918.76 cw(c7543.28,3918.76) v1@7533.89,3928.15 ; v1@7526.11,3935.93 ccw(c7516.72,3945.32) 7530,3945.32 ccw(c7543.28,3945.32) v1@7533.89,3935.93 ; R156.1@7526.24,3864.43 ccw(c7517.16,3873.51) 7530,3873.51 ccw(c7542.84,3873.51) R156.1@7533.76,3864.43 ; R155.2@7526.24,4030.06 cw(c7517.16,4020.98) 7530,4020.98 cw(c7542.84,4020.98) R155.2@7533.76,4030.06 ; R156.1@7530,3860.67 v1(7530,3932.04) ; v1@7530,3933.71 R155.2@7530,4033.82 ; 5009.1,3769.73 cw(c4996.3,3782.54) 4996.3,3764.43 ccw(c4996.3,3782.54) 5009.1,3769.73 ; 5009.1,3769.73 ccw(c5021.91,3756.93) 5003.8,3756.93 cw(c5021.91,3756.93) 5009.1,3769.73
  MidLayer1 w4: v1@4918.28,3316.72 ccw(c4902.06,3332.93) 4925,3332.93 ccw(c4947.93,3332.93) v1@4931.72,3316.72 ; v1@4921.11,3313.89 ccw(c4911.72,3323.28) 4925,3323.28 ccw(c4938.28,3323.28) v1@4928.89,3313.89 ; v1(4925,3310) 4925,3430 4939.5,3444.5 4947.36,3452.36 4980.5,3485.5 4980.5,3500.25 4969.22,3511.52 4969.22,3561.3 4969.22,3569.96 4959.19,3580 4959.19,3599.38 4996.3,3636.49 4996.3,3679.25 v3(4996.3,3756.93) ; v3@4991.11,3751.74 cw(c4978.57,3739.2) 4996.3,3739.2 cw(c5014.03,3739.2) v3@5001.49,3751.74 ; 4996.3,3738.82 cw(c5014.41,3738.82) 5001.6,3751.63 ccw(c5014.41,3738.82) 4996.3,3738.82 ; 4996.3,3738.82 ccw(c4978.19,3738.82) 4991,3751.63 cw(c4978.19,3738.82) 4996.3,3738.82
  MidLayer2 w4: v1@5477.4,3499.2 cw(c5477.4,3474.7) 5494.72,3492.02 ; v1@5477.4,3503.2 cw(c5477.4,3488.36) 5487.9,3498.85 ; v1@5478.05,3508.7 5507.8,3478.95 5507.8,3464.83 5511.63,3461 5524.04,3448.59 5524.04,3415.72 5493.69,3385.37 5493.69,3296.79 5508.2,3282.28 v2(5508.2,3275.7) ; v1@5482.9,3508.7 ccw(c5494.61,3508.7) 5486.33,3500.42 ; v1@5486.9,3508.7 ccw(c5508.27,3508.7) 5493.16,3493.59 ; 5496.23,3294.25 cw(c5480.91,3278.93) v2@5502.43,3276.38 ; 5502.06,3288.42 cw(c5491.34,3277.69) v2@5506.4,3275.91 ; 5502.69,3287.79 ccw(c5508.2,3293.31) v2@5508.2,3285.51 ; v1(7056.86,3741.71) 7102.33,3741.71 7120,3724.04 v1(7224.86,3724.04) ; v1@7060.75,3737.82 cw(c7070.14,3728.43) 7070.14,3741.71 cw(c7070.14,3754.99) v1@7060.75,3745.6 ; v1@7063.57,3734.99 cw(c7079.79,3718.77) 7079.79,3741.71 cw(c7079.79,3764.64) v1@7063.57,3748.43 ; v1@7218.14,3717.32 ccw(c7201.92,3701.11) 7201.92,3724.04 ccw(c7201.92,3746.98) v1@7218.14,3730.76 ; v1@7220.97,3720.15 ccw(c7211.58,3710.76) 7211.58,3724.04 ccw(c7211.58,3737.32) v1@7220.97,3727.93
  Bottom Layer w4: v1@4928.89,3306.11 cw(c4938.28,3296.72) 4938.28,3310 cw(c4938.28,3323.28) v1@4928.89,3313.89 ; v1@4929.18,3305.82 v1(4925,3310) 5020.48,3310 5026.28,3304.21 ; v1@4931.72,3303.28 cw(c4947.93,3287.06) 4947.93,3310 cw(c4947.93,3332.93) v1@4931.72,3316.72 ; 5024.66,3305.82 5026.28,3304.21 ; v1@5477.4,3499.2 cw(c5477.4,3474.7) 5494.72,3492.02 ; v1@5477.4,3503.2 cw(c5477.4,3488.36) 5487.9,3498.85 ; v1@5478.05,3508.7 5510,3476.75 5510,3450.41 5516.04,3444.37 5516.04,3435.33 5516.04,3419.84 5548.88,3387 5564.37,3387 5633.5,3387 5655.5,3409 5675.38,3409 ; v1@5482.9,3508.7 ccw(c5494.61,3508.7) 5486.33,3500.42 ; v1@5486.9,3508.7 ccw(c5508.27,3508.7) 5493.16,3493.59 ; v2(5508.2,3275.7) 5498.4,3265.9 5488.6,3256.1 5464.05,3256.1 5460,3256.1 5449.55,3256.1 5408.95,3296.7 5400,3296.7 5389.69,3296.7 5382.4,3296.7 5356.3,3270.6 5326.57,3240.87 5285.77,3240.87 5272.4,3227.5 5217.4,3227.5 5214.11,3224.21 5165.69,3224.21 5085.69,3304.21 5040.77,3304.21 5026.28,3304.21 ; 5675.46,3409.08 5858.85,3409.08 5937.58,3487.81 6012.38,3487.81 6044.69,3455.5 6175.65,3455.5 6190.19,3470.04 6190.19,3482.71 6190.19,3530 6190.19,3575.04 6205.02,3589.87 6305.02,3589.87 6309.15,3594 6341,3594 6351.63,3583.37 6848.52,3583.37 6890.19,3625.04 7155.04,3625.04 7215.04,3625.04 7219,3629 7219,3640 NT46.2@7219,3669 7219,3689 7224.86,3694.86 v1(7224.86,3724.04) ; v1(6665.19,3693.04) 6680.19,3708.04 6729.15,3708.04 6763.82,3742.71 7055.86,3742.71 v1(7056.86,3741.71) ; v1@7218.14,3717.32 cw(c7201.92,3701.11) 7224.86,3701.11 cw(c7247.79,3701.11) v1@7231.57,3717.32 ; v1@7220.97,3720.15 cw(c7211.58,3710.76) 7224.86,3710.76 cw(c7238.14,3710.76) v1@7228.75,3720.15 ; v1(7340.19,3691.71) 7373.52,3691.71 7421.16,3739.35 7530,3848.18 v1(7530,3932.04) ; v1@7344.08,3687.82 cw(c7353.47,3678.43) 7353.47,3691.71 cw(c7353.47,3704.99) v1@7344.08,3695.6 ; v1@7346.91,3684.99 cw(c7363.13,3668.77) 7363.13,3691.71 cw(c7363.13,3714.64) v1@7346.91,3698.43 ; v1@7523.28,3925.32 cw(c7507.07,3909.11) 7530,3909.11 cw(c7552.94,3909.11) v1@7536.72,3925.32 ; v1@7526.11,3928.15 cw(c7516.72,3918.76) 7530,3918.76 cw(c7543.28,3918.76) v1@7533.89,3928.15
  other v1: 5477.4,3508.7
DB_MEM.BUS_SDRAM_NCAS: U8.AC26 U12.17 U13.17 | length 1558.5
  Top Layer w4: 6017.5,3806.5 6000.01,3823.98 ; 6017.5,3806.5 6019.7,3804.3 ; U13.17@6147.37,3664.85 ccw(c6133.72,3651.2) 6133.72,3670.51 ccw(c6133.72,3689.83) U13.17@6147.37,3676.17 ; U13.17@6193.81,3664.85 cw(c6207.46,3651.2) 6207.46,3670.51 cw(c6207.46,3689.83) U13.17@6193.81,3676.17 ; v1@6353.28,3683.28 ccw(c6337.06,3667.06) 6337.06,3690 ccw(c6337.06,3712.93) v1@6353.28,3696.72 ; v1@6356.11,3686.11 ccw(c6346.72,3676.72) 6346.72,3690 ccw(c6346.72,3703.28) v1@6356.11,3693.89 ; v1(6360,3690) 6334.81,3690 6332.62,3687.81 6315.32,3670.51 U13.17@6170.59,3670.51 6121.39,3670.51 6108.52,3683.37 6081.86,3710.04 6081.86,3742.14 6019.7,3804.3 ; v1@6800.52,3690.54 cw(c6800.52,3667.61) 6816.74,3683.82 cw(c6832.96,3700.04) v1@6810.02,3700.04 ; v1@6800.52,3694.54 cw(c6800.52,3681.26) 6809.91,3690.65 cw(c6819.3,3700.04) v1@6806.02,3700.04 ; v1(6800.52,3700.04) 6830.05,3670.51 U12.17@6845.59,3670.51 ; 6812.95,3687.62 cw(c6795.84,3670.51) U12.17@6820.03,3670.51 ; 6817.83,3682.74 ccw(c6828.03,3692.94) U12.17@6828.03,3678.51 ; 6819.77,3680.79 cw(c6809.49,3670.51) U12.17@6824.03,3670.51 ; 5855.29,3842.82 ccw(c5882.64,3870.17) 5882.64,3831.49 ; 5855.29,3842.82 ccw(c5882.64,3870.17) 5882.64,3831.49 ; 5855.29,3842.82 ccw(c5842.76,3830.29) 5842.76,3848.01 cw(c5842.76,3830.29) 5855.29,3842.82 ; 5855.29,3842.82 cw(c5867.82,3855.35) 5850.1,3855.35 ccw(c5867.82,3855.35) 5855.29,3842.82 ; 5882.64,3831.49 5933.45,3831.49 5941.18,3831.49 5992.5,3831.49 6000.01,3823.98 ; 6000.01,3823.98 6019.7,3804.3
  MidLayer2 w4: v1@6360,3680.5 cw(c6360,3657.56) 6376.22,3673.78 cw(c6392.43,3690) v1@6369.5,3690 ; v1@6360,3684.5 cw(c6360,3671.22) 6369.39,3680.61 cw(c6378.78,3690) v1@6365.5,3690 ; v1(6360,3690) 6387,3663 6627.23,3663 6656.86,3633.37 6716.86,3633.37 6783.52,3700.04 ; v1@6792.43,3695.06 ccw(c6783.52,3689.58) 6783.52,3700.04 ; v1@6792.43,3705.02 cw(c6783.52,3710.5) 6783.52,3700.04 ; v1(6800.52,3700.04) 6783.52,3700.04
DB_MEM.BUS_SDRAM_NCS: U8.AA21 U12.19 U13.19 | length 2436.7
  Top Layer w4: U8.AA21@5645.91,3926.75 cw(c5645.91,3909.03) 5658.44,3921.56 cw(c5670.97,3934.09) U8.AA21@5653.25,3934.09 ; U8.AA21@5645.91,3934.09 v3(5665.59,3914.41) ; U13.19@6170.59,3607.52 6189.86,3607.52 6209.37,3588 6260.82,3588 6266.52,3593.71 ; U13.19@6188.15,3599.52 cw(c6188.15,3576.09) 6204.72,3592.66 ; U13.19@6188.15,3603.52 cw(c6188.15,3589.75) 6197.89,3599.49 ; U13.19@6196.15,3607.52 ccw(c6211.35,3607.52) 6200.6,3596.77 ; v1@6259.81,3624.66 cw(c6243.59,3608.44) 6266.52,3608.44 cw(c6289.46,3608.44) v1@6273.24,3624.66 ; v1@6262.64,3627.49 cw(c6253.25,3618.1) 6266.52,3618.1 cw(c6279.8,3618.1) v1@6270.41,3627.49 ; v1@6265.19,3631.37 v1(6266.52,3631.37) 6266.52,3593.71 ; v1(6315.19,3575.04) 6302.23,3588 6272.23,3588 6266.52,3593.71 ; v1@6772.81,3550.76 ccw(c6756.59,3566.98) 6779.52,3566.98 ccw(c6802.46,3566.98) v1@6786.24,3550.76 ; v1@6775.64,3547.93 ccw(c6766.25,3557.32) 6779.52,3557.32 ccw(c6792.8,3557.32) v1@6783.41,3547.93 ; v1(6779.52,3544.04) 6779.52,3591.71 6787.86,3600.04 6838.11,3600.04 U12.19@6845.59,3607.52 ; 6790.66,3600.04 ccw(c6790.66,3644.89) U12.19@6822.37,3613.18 ; 6800.32,3600.04 ccw(c6800.32,3635.23) U12.19@6825.2,3610.35 ; 6809.98,3600.04 ccw(c6809.98,3625.58) U12.19@6828.03,3607.52 ; U12.19@6819.63,3600.04 ccw(c6819.63,3615.92) U12.19@6830.86,3604.69 ; 5652.79,3927.21 cw(c5639.98,3914.41) 5658.09,3914.41 ccw(c5639.98,3914.41) 5652.79,3927.21 ; 5652.79,3927.21 ccw(c5665.59,3940.02) 5665.59,3921.91 cw(c5665.59,3940.02) 5652.79,3927.21
  Bottom Layer w4: v3@5666.89,3907.02 cw(c5670.04,3889.19) 5680.42,3904.02 cw(c5690.81,3918.86) v3@5672.98,3915.71 ; 5680.39,3903.98 ccw(c5695.18,3922.58) 5696.79,3898.86 ; 5696.84,3898.81 5704.96,3898.81 cw(c5704.96,3875.04) 5728.73,3875.04 ccw(c5744.33,3875.04) 5744.33,3859.44 cw(c5744.33,3835.67) 5768.1,3835.67 ccw(c5783.7,3835.67) 5783.7,3820.07 cw(c5783.7,3796.3) 5807.47,3796.3 ccw(c5823.07,3796.3) 5823.07,3780.7 5881.33,3780.7 5939.59,3780.7 5941.18,3780.7 5949.18,3780.7 5979.3,3780.7 5986.19,3773.81 5986.19,3709.06 6001.12,3694.13 6001.12,3622.83 5989.19,3610.91 5989.19,3591.71 6014.19,3566.71 6131.86,3566.71 6156.52,3591.37 6156.52,3617.84 6156.86,3618.17 6156.86,3672.06 6168.5,3683.71 6215.52,3683.71 6226.27,3672.96 6229.23,3670 6261.52,3670 6266.52,3665 v1(6266.52,3631.37) 6266.52,3655 ; v1(6315.19,3575.04) 6748.52,3575.04 v1(6779.52,3544.04) ; v1@6319.08,3571.15 cw(c6328.47,3561.76) 6328.47,3575.04 cw(c6328.47,3588.32) v1@6319.08,3578.93 ; v1@6321.91,3568.32 cw(c6338.13,3552.11) 6338.13,3575.04 cw(c6338.13,3597.98) v1@6321.91,3581.76 ; v1@6770.02,3544.04 ccw(c6747.09,3544.04) 6763.31,3560.26 ccw(c6779.52,3576.48) v1@6779.52,3553.54 ; v1@6774.02,3544.04 ccw(c6760.75,3544.04) 6770.14,3553.43 ccw(c6779.52,3562.82) v1@6779.52,3549.54 ; 6266.52,3644.65 cw(c6253.25,3644.65) 6262.64,3635.26 ccw(c6253.25,3644.65) 6266.52,3644.65 ; 6266.52,3644.65 ccw(c6279.8,3644.65) 6270.41,3635.26 cw(c6279.8,3644.65) 6266.52,3644.65 ; 6266.52,3654.31 cw(c6243.59,3654.31) 6259.81,3638.09 ccw(c6243.59,3654.31) 6266.52,3654.31 ; 6266.52,3654.31 ccw(c6289.46,3654.31) 6273.24,3638.09 cw(c6289.46,3654.31) 6266.52,3654.31