# Altium PCB NB3000AL.PcbDoc (part 73 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
USB_RSTA: R248.1 U19.42 U49.2 | length 1400
  MidLayer2 w4: v1@7600.14,1430.32 ccw(c7583.92,1414.11) 7583.92,1437.04 ccw(c7583.92,1459.98) v1@7600.14,1443.76 ; v1@7602.97,1433.15 ccw(c7593.58,1423.76) 7593.58,1437.04 ccw(c7593.58,1450.32) v1@7602.97,1440.93 ; v1(7606.86,1437.04) 7507.04,1437.04 7481.86,1411.86 7481.86,1060 7496.86,1045 7585,1045 7615.19,1014.81 v1(7615.19,958.37) ; v1@7608.47,965.09 ccw(c7592.26,981.31) 7615.19,981.31 ccw(c7638.13,981.31) v1@7621.91,965.09 ; v1@7611.3,962.26 ccw(c7601.91,971.65) 7615.19,971.65 ccw(c7628.47,971.65) v1@7619.08,962.26
  Bottom Layer w4: U19.42@7547.95,904.33 7594.33,904.33 7615.19,925.19 v1(7615.19,958.37) ; U19.42@7550.78,901.5 cw(c7557.61,894.67) 7557.61,904.33 cw(c7557.61,913.99) U19.42@7550.78,907.16 ; v1(7606.86,1437.04) 7634.82,1465 ; v1@7606.86,1442.54 ccw(c7606.86,1455.82) 7616.25,1446.43 ccw(c7625.64,1437.04) v1@7612.36,1437.04 ; v1@7606.86,1446.54 ccw(c7606.86,1469.48) 7623.07,1453.26 ccw(c7639.29,1437.04) v1@7616.36,1437.04 ; v1@7608.47,951.66 cw(c7592.26,935.44) 7615.19,935.44 cw(c7638.13,935.44) v1@7621.91,951.66 ; v1@7611.3,954.49 cw(c7601.91,945.1) 7615.19,945.1 cw(c7628.47,945.1) v1@7619.08,954.49 ; U49.2@7642.96,1485.08 cw(c7630.04,1467.15) 7652.15,1467.15 ; U49.2@7645.3,1488.33 cw(c7635.67,1474.96) 7652.15,1474.96 cw(c7668.62,1474.96) U49.2@7658.99,1488.33 ; U49.2@7652.15,1506.69 7652.15,1467.15 ; U49.2@7661.33,1485.08 ccw(c7674.25,1467.15) 7652.15,1467.15 ; 7696.93,1456.75 ccw(c7713.68,1473.5) R248.1@7713.68,1449.81 ; 7698.12,1455.56 cw(c7683.05,1440.49) R248.1@7704.36,1440.49 ; R248.1@7703.76,1449.92 ccw(c7713.68,1459.84) R248.1@7713.68,1445.81 ; R248.1@7704.95,1448.73 cw(c7696.71,1440.49) R248.1@7708.36,1440.49 ; R248.1@7713.68,1440 7688.68,1465 ; 7634.82,1465 7688.68,1465 ; 7634.82,1465 7650,1465 7652.15,1467.15 ; 7652.15,1467.15 7654.29,1465 7655,1465 7688.68,1465
USB_RSTB: R271.1 U56.42 U60.2 | length 1069.5
  Bottom Layer w4: U60.2@6044.34,5543.04 cw(c6041.46,5535) 6050,5535 cw(c6058.94,5535) U60.2@6055.57,5543.28 ; U60.2@6050,5570 6050,5535 6060,5525 6081.18,5525 R271.1@6111.18,5495 6281.86,5665.68 6281.86,5931.71 6283.52,5933.37 6406.86,5933.37 6448.52,5891.71 6473.52,5891.71 6482.05,5900.23 U56.42@6482.05,5980.67 ; 6094.43,5511.75 ccw(c6111.18,5528.5) 6111.18,5504.81 ccw(c6111.18,5528.5) 6127.93,5511.75 ; 6095.62,5510.56 cw(c6080.55,5495.49) R271.1@6101.86,5495.49 ; R271.1@6101.26,5504.92 ccw(c6111.18,5514.84) 6111.18,5500.81 ccw(c6111.18,5514.84) R271.1@6121.1,5504.92 ; R271.1@6102.45,5503.73 cw(c6094.21,5495.49) R271.1@6105.86,5495.49 ; R271.1@6116.5,5495.49 cw(c6128.15,5495.49) R271.1@6119.91,5503.73 ; R271.1@6120.5,5495.49 cw(c6141.81,5495.49) 6126.74,5510.56 ; U56.42@6479.22,5966.91 cw(c6472.39,5960.08) 6482.05,5960.08 cw(c6491.7,5960.08) U56.42@6484.88,5966.91
USER_FLASH.DIN: U30.N6 U52.5 U53.5 | length 2368.5
  Top Layer w4: U53.5@5930.59,1430 6026.9,1430 6081.9,1375 6195,1375 6235,1335 6286.44,1335 6297.19,1345.75 6297.19,1350 6297.19,1380 6306.5,1389.31 6306.5,1492.31 6292.19,1506.62 6292.19,1556 6333.48,1597.3 6333.48,1655.7 6333.48,1684.3 6329.97,1687.81 6327.92,1687.81 6316.19,1699.54 6316.19,1717.38 6326.62,1727.81 6358.38,1727.81 6362.38,1731.81 6402.99,1731.81 6405.59,1734.41 6405.59,1735.6 ; U53.5@5965.62,1424.5 cw(c5978.9,1411.22) 5978.9,1430 cw(c5978.9,1448.78) U53.5@5965.62,1435.5 ; U53.5@5968.45,1421.67 cw(c5988.56,1401.56) 5988.56,1430 cw(c5988.56,1458.44) U53.5@5968.45,1438.33 ; U52.5@6397.26,1761.67 cw(c6377.15,1741.56) 6405.59,1741.56 cw(c6434.03,1741.56) U52.5@6413.92,1761.67 ; U52.5@6400.09,1764.5 cw(c6386.81,1751.22) 6405.59,1751.22 cw(c6424.37,1751.22) U52.5@6411.09,1764.5 ; U52.5@6405.59,1768 6405.59,1735.6 ; v1(6431.86,1655.04) 6419.81,1667.09 6419.81,1721.38 6405.59,1735.6 ; v2@6665,1500.19 cw(c6665,1476.5) 6681.75,1493.25 cw(c6698.5,1510) v2@6674.81,1510 ; v2@6665,1504.19 cw(c6665,1490.16) 6674.92,1500.08 cw(c6684.84,1510) v2@6670.81,1510 ; v2(6665,1510) 6714.21,1460.79 6729.38,1460.79 6734.4,1465.81 6753,1465.81 6768.62,1450.19 6783.38,1450.19 6799.19,1466 v2(6830,1466) ; v2@6823.06,1459.06 ccw(c6806.31,1442.31) 6806.31,1466 ccw(c6806.31,1489.69) v2@6823.06,1472.94 ; v2@6825.89,1461.89 ccw(c6815.97,1451.97) 6815.97,1466 ccw(c6815.97,1480.03) v2@6825.89,1470.11 ; v3(6891.89,1668.15) U30.N6@6911.57,1687.83 ; U30.N6@6904.23,1687.83 cw(c6886.51,1687.83) 6899.04,1675.3 cw(c6911.57,1662.77) U30.N6@6911.57,1680.49 ; 6904.69,1680.95 cw(c6891.89,1693.76) 6891.89,1675.65 ccw(c6891.89,1693.76) 6904.69,1680.95 ; 6904.69,1680.95 ccw(c6917.5,1668.15) 6899.39,1668.15 cw(c6917.5,1668.15) 6904.69,1680.95
  MidLayer1 w4: v1@6425.14,1648.32 cw(c6408.92,1632.11) 6431.86,1632.11 cw(c6454.79,1632.11) v1@6438.57,1648.32 ; v1@6427.97,1651.15 cw(c6418.58,1641.76) 6431.86,1641.76 cw(c6445.14,1641.76) v1@6435.75,1651.15 ; v1(6431.86,1655.04) 6431.86,1626.95 6562.62,1496.19 6609.38,1496.19 6623.19,1510 v2(6665,1510) ; 6513.81,1545.19 6520.16,1538.84 ; v2@6658.06,1503.06 ccw(c6641.31,1486.31) 6641.31,1510 ccw(c6641.31,1533.69) v2@6658.06,1516.94 ; v2@6660.89,1505.89 ccw(c6650.97,1495.97) 6650.97,1510 ccw(c6650.97,1524.03) v2@6660.89,1514.11 ; v2@6830,1471.81 ccw(c6830,1482.97) 6837.89,1475.08 ; v2@6830,1475.81 ccw(c6830,1496.63) 6844.72,1481.91 ; v2@6832.81,1470 6868.03,1505.22 6868.03,1511.73 6868.03,1531.15 6868.03,1605.27 ; v2@6835.81,1466 cw(c6852.71,1466) 6840.76,1477.95 ; v2@6839.81,1466 cw(c6866.37,1466) 6847.59,1484.78 ; 6868.03,1591.34 6868.03,1605.27 ; v3@6884.5,1666.85 cw(c6866.67,1663.7) 6881.5,1653.32 ; v3@6893.19,1660.76 ccw(c6896.34,1642.93) 6881.5,1653.32 ; 6868.03,1605.27 6868.03,1628.52 cw(c6891.8,1628.52) 6874.42,1644.74 6881.5,1653.32
USER_FLASH.DOUT: U30.N3 U52.2 U53.2 | length 2216.1
  Top Layer w4: U53.2@5655,1530 5805,1530 5810,1535 5810,1612.5 5798.52,1623.98 5798.52,1795.52 5853.04,1850.04 6011.23,1850.04 6031.19,1870 U52.2@6130,1870 6181.31,1870 ; U53.2@5690.03,1524.5 cw(c5703.31,1511.22) 5703.31,1530 cw(c5703.31,1548.78) U53.2@5690.03,1535.5 ; U53.2@5692.86,1521.67 cw(c5712.97,1501.56) 5712.97,1530 cw(c5712.97,1558.44) U53.2@5692.86,1538.33 ; U52.2@6092.14,1861.67 ccw(c6072.03,1841.56) 6072.03,1870 ccw(c6072.03,1898.44) U52.2@6092.14,1878.33 ; U52.2@6094.97,1864.5 ccw(c6081.69,1851.22) 6081.69,1870 ccw(c6081.69,1888.78) U52.2@6094.97,1875.5 ; U52.2@6166.04,1865.74 cw(c6173.91,1860.59) 6173.91,1870 cw(c6173.91,1879.4) U52.2@6166.04,1874.26 ; U52.2@6169.39,1863.55 cw(c6181.3,1855.76) 6181.3,1870 ; U52.2@6169.39,1876.45 ccw(c6181.31,1884.24) 6181.3,1870 ; v1(6282,1750) 6299.19,1767.19 6299.19,1859.19 6288.38,1870 6274,1870 ; v1@6282,1755.5 ccw(c6282,1768.78) 6291.39,1759.39 ccw(c6300.78,1750) v1@6287.5,1750 ; v1@6282,1759.5 ccw(c6282,1782.43) 6298.22,1766.22 ccw(c6314.43,1750) v1@6291.5,1750 ; v3(6773.78,1668.15) U30.N3@6793.46,1687.83 ; U30.N3@6786.12,1687.83 cw(c6768.4,1687.83) 6780.93,1675.3 cw(c6793.46,1662.77) U30.N3@6793.46,1680.49 ; 6181.31,1870 6255,1870 ; 6255,1870 6274,1870 ; 6255,1870 6274,1870 ; 6786.58,1680.95 cw(c6773.78,1693.76) 6773.78,1675.65 ccw(c6773.78,1693.76) 6786.58,1680.95 ; 6786.58,1680.95 ccw(c6799.39,1668.15) 6781.28,1668.15 cw(c6799.39,1668.15) 6786.58,1680.95
  MidLayer1 w4: v1@6578,1680.5 cw(c6578,1667.22) 6587.39,1676.61 ; v1(6578,1690) 6578,1688 6580,1686 6580,1684 6614,1650 6614,1640.81 6624.62,1630.19 6625.26,1629.56 6628.62,1626.19 6643.38,1626.19 6653.81,1636.62 6653.81,1637 6661.1,1644.29 6665.67,1644.29 6710.9,1644.29 ; v1@6583.5,1690 ccw(c6606.43,1690) 6590.22,1673.78 ; v1@6587.5,1690 ccw(c6620.09,1690) 6597.05,1666.95 ; 6696.97,1644.29 6710.9,1644.29 ; v3@6766.39,1669.45 cw(c6748.56,1672.6) 6758.95,1657.76 ; v3@6772.48,1660.76 ccw(c6769.33,1642.93) 6758.95,1657.76 ; 6710.9,1644.29 6734.15,1644.29 ccw(c6734.15,1668.06) 6750.37,1650.68 6758.95,1657.76
  Bottom Layer w4: v1(6282,1750) 6303.19,1750 ; v1@6286.11,1746.34 cw(c6294.27,1739.07) 6294.27,1750 cw(c6294.27,1760.93) v1@6286.11,1753.66 ; v1@6289.09,1743.68 cw(c6303.19,1731.12) 6303.19,1750 ; v1@6289.09,1756.32 ccw(c6303.19,1768.88) 6303.19,1750 ; v1@6571.28,1683.28 ccw(c6555.06,1667.06) 6555.06,1690 ccw(c6555.06,1712.93) v1@6571.28,1696.72 ; v1@6574.11,1686.11 ccw(c6564.72,1676.72) 6564.72,1690 ccw(c6564.72,1703.28) v1@6574.11,1693.89 ; v1(6578,1690) 6513.23,1690 6469.86,1733.37 6467.42,1735.81 6359.81,1735.81 6352.19,1728.19 6325,1728.19 6303.19,1750
USER_FLASH.FLASH1_CS_N: U30.P6 U53.1 | length 2479.7
  Top Layer w4: U53.1@5655,1580 5705,1580 5710,1575 v1(5710,1556) ; U53.1@5694.96,1574.53 cw(c5704,1569.8) 5704,1580 cw(c5704,1590.2) U53.1@5694.96,1585.47 ; v1@5704.3,1563.6 ccw(c5695.75,1575) 5710,1575 ccw(c5724.25,1575) v1@5715.7,1563.6 ; v2(6800,1250) 6800,1250.81 6832.19,1283 6832.19,1326.19 6857.2,1351.2 v2(6857.2,1391.18) ; v2@6800,1255.81 ccw(c6800,1267.88) 6808.53,1259.35 ; v2@6800,1259.81 ccw(c6800,1281.54) 6815.36,1266.17 ; v2@6805.81,1250 cw(c6821.8,1250) 6810.49,1261.31 ; v2@6809.81,1250 cw(c6835.46,1250) 6817.32,1268.13 ; v2@6850.26,1384.24 cw(c6833.51,1367.49) 6857.2,1367.49 cw(c6880.88,1367.49) v2@6864.13,1384.24 ; v2@6853.09,1387.07 cw(c6843.17,1377.15) 6857.2,1377.15 cw(c6871.23,1377.15) v2@6861.31,1387.07 ; v3(6891.89,1628.78) U30.P6@6911.57,1648.46 ; U30.P6@6904.23,1648.46 cw(c6886.51,1648.46) 6899.04,1635.93 cw(c6911.57,1623.4) U30.P6@6911.57,1641.12 ; 6904.69,1641.58 cw(c6891.89,1654.39) 6891.89,1636.28 ccw(c6891.89,1654.39) 6904.69,1641.58 ; 6904.69,1641.58 ccw(c6917.5,1628.78) 6899.39,1628.78 cw(c6917.5,1628.78) 6904.69,1641.58
  MidLayer1 w4: v2@6493,1529.19 cw(c6493,1505.5) 6509.75,1522.25 cw(c6526.5,1539) v2@6502.81,1539 ; v2@6493,1533.19 cw(c6493,1519.16) 6502.92,1529.08 cw(c6512.84,1539) v2@6498.81,1539 ; v2(6493,1539) 6546,1486 6546,1292.69 6566.69,1272 6591.56,1272 6599.37,1264.19 6657.38,1264.19 6686.69,1293.5 6705.25,1293.5 6728.75,1270 6780,1270 v2(6800,1250) ; v2@6790.19,1250 ccw(c6766.5,1250) 6783.25,1266.75 ccw(c6800,1283.5) v2@6800,1259.81 ; v2@6794.19,1250 ccw(c6780.16,1250) 6790.08,1259.92 ccw(c6800,1269.84) v2@6800,1255.81 ; v2@6850.26,1398.12 ccw(c6833.51,1414.87) 6857.2,1414.87 ccw(c6880.88,1414.87) v2@6864.13,1398.12 ; v2@6853.09,1395.29 ccw(c6843.17,1405.21) 6857.2,1405.21 ccw(c6871.23,1405.21) v2@6861.31,1395.29 ; v2@6857.2,1391.04 v2(6857.2,1391.18) 6857.2,1483.07 6876.38,1502.26 6876.38,1511.73 6876.38,1596.1 cw(c6909.51,1596.27) 6881.47,1613.92 ; v3@6884.5,1627.48 cw(c6866.67,1624.33) 6881.5,1613.95 cw(c6896.34,1603.56) v3@6893.19,1621.39
  MidLayer2 w4: v1(5710,1556) 5743.57,1556 5745.11,1557.54 5755,1557.54 5883.59,1557.54 5899.75,1541.37 5996.25,1541.37 6012.68,1557.81 6047.32,1557.81 6063.32,1541.81 6156.68,1541.81 6161.68,1546.81 6198.32,1546.81 6203.32,1541.81 6211.31,1541.81 6231.5,1562 6314.59,1562 6329.59,1577 6388.23,1577 6475.69,1577 6493,1559.69 ; v1@5713.89,1552.11 cw(c5723.28,1542.72) 5723.28,1556 cw(c5723.28,1569.28) v1@5713.89,1559.89 ; v1@5716.72,1549.28 cw(c5732.93,1533.06) 5732.93,1556 cw(c5732.93,1578.93) v1@5716.72,1562.72 ; v2@6486.79,1546.6 ccw(c6476.1,1559.69) 6493,1559.69 ; v2@6489.32,1543.5 ccw(c6482.99,1551.25) 6493,1551.25 ccw(c6503.01,1551.25) v2@6496.68,1543.5 ; v2@6491,1539 v2(6493,1539) 6493,1559.69 ; v2@6499.21,1546.6 cw(c6509.9,1559.69) 6493,1559.69
USER_FLASH.FLASH2_CS_N: U30.T7 U52.1 | length 2342.2
  Top Layer w4: U52.1@6130,1920 6185,1920 6213.29,1891.71 v1(6263.52,1891.71) v1@6255.19,1891.71 ; v1@6256.81,1884.99 ccw(c6240.59,1868.77) 6240.59,1891.71 ccw(c6240.59,1914.64) v1@6256.81,1898.43 ; v1@6259.64,1887.82 ccw(c6250.25,1878.43) 6250.25,1891.71 ccw(c6250.25,1904.99) v1@6259.64,1895.6 ; v2(6940,1466) 6938.5,1466 6939.25,1466.75 6951,1478.5 6951,1569.67 U30.T7@6950.94,1569.72 ; U30.T7@6945.75,1564.53 cw(c6933.22,1552) 6950.94,1552 cw(c6968.67,1552) U30.T7@6956.14,1564.53
  MidLayer1 w4: v1@6263.52,1882.21 cw(c6263.52,1859.27) 6279.74,1875.49 cw(c6295.96,1891.71) v1@6273.02,1891.71 ; v1@6263.52,1886.21 cw(c6263.52,1872.93) 6272.91,1882.32 cw(c6282.3,1891.71) v1@6269.02,1891.71 ; v1(6263.52,1891.71) 6326,1829.23 6326,1761 v2(6341,1746) ; v2(6402,1714) 6402,1700.13 6405,1697.13 6405,1667.87 6405,1665 6405,1620 6437.5,1587.5 6437.5,1388.75 6442.19,1384.06 6442.19,1370 6442.19,1361.76 6442.19,1301.81 v2(6452,1292)
  MidLayer2 w4: v2@6345.11,1741.89 cw(c6355.03,1731.97) 6355.03,1746 cw(c6355.03,1760.03) v2@6345.11,1750.11 ; v2@6346,1741 v2(6341,1746) 6370,1746 v2(6402,1714) ; v2@6347.94,1739.06 cw(c6364.69,1722.31) 6364.69,1746 cw(c6364.69,1769.69) v2@6347.94,1752.94 ; v2@6392.19,1714 ccw(c6368.5,1714) 6385.25,1730.75 ccw(c6402,1747.5) v2@6402,1723.81 ; v2@6396.19,1714 ccw(c6382.16,1714) 6392.08,1723.92 ccw(c6402,1733.84) v2@6402,1719.81 ; v2(6452,1292) 6482,1292 6490.19,1283.81 6524.25,1283.81 6545.56,1262.5 6585.56,1262.5 6612.56,1235.5 6652.13,1235.5 6721.13,1166.5 6835.44,1166.5 6839.44,1162.5 6871.88,1162.5 6917.72,1208.35 6917.72,1232.03 6927.5,1241.81 6941.38,1241.81 6996.23,1296.67 6996.23,1299.23 7014.43,1317.43 v2@7017,1317.43 ; v2@6456.11,1287.89 cw(c6466.03,1277.97) 6466.03,1292 cw(c6466.03,1306.03) v2@6456.11,1296.11 ; v2@6458.94,1285.06 cw(c6475.69,1268.31) 6475.69,1292 cw(c6475.69,1315.69) v2@6458.94,1298.94 ; 6996.73,1299.73 ccw(c6978.73,1317.74) v2@7004.19,1317.93 ; 6998.96,1301.96 cw(c7014,1286.92) v2@7014,1308.19 ; 7003.49,1306.49 ccw(c6992.14,1317.84) v2@7008.19,1317.96 ; 7005.79,1308.79 cw(c7014,1300.57) v2@7014,1312.19
  Bottom Layer w4: v2@6940,1456.19 cw(c6940,1427.67) 6960.16,1447.84 ; v2@6940,1460.19 cw(c6940,1441.33) 6953.33,1454.67 ; v2(6940,1466) 6942,1466 6965.48,1442.52 6965.48,1343.95 6991.43,1318 ; v2@6949.81,1466 ccw(c6968.67,1466) 6955.33,1452.67 ; v2@7006.83,1311.31 ccw(c6991.43,1296.95) 6991.43,1318 ; v2@7006.83,1324.69 cw(c6991.43,1339.05) 6991.43,1318 ; v2@7009.75,1314.04 ccw(c7000.63,1305.53) 7000.63,1318 ccw(c7000.63,1330.47) v2@7009.75,1321.96 ; v2(7014,1318) 6991.43,1318
USER_FLASH.SCLK: U30.J6 U52.6 U53.6 | length 1882.8
  Top Layer w4: U53.6@5930.59,1480 5975.25,1480 ; U53.6@5958.79,1475.99 ccw(c5963.82,1491.15) 5975.11,1479.86 ; U53.6@5960.05,1479.79 ccw(c5966.1,1498.03) 5979.69,1484.44 ; U53.6@5961.31,1483.59 ccw(c5968.39,1504.91) 5984.27,1489.02 ; U53.6@5962.57,1487.38 ccw(c5970.67,1511.79) 5988.86,1493.61 ; U53.6@5963.83,1491.18 ccw(c5972.96,1518.67) 5993.44,1498.19 ; U53.6@5971.54,1477.11 cw(c5975.25,1476.17) 5975.25,1480 ; U53.6@5971.54,1482.89 ccw(c5975.25,1483.83) 5975.25,1480 ; v1@6338.28,1807.28 cw(c6322.06,1791.06) 6345,1791.06 cw(c6367.93,1791.06) 6351.72,1807.28 cw(c6382.42,1776.58) U52.6@6382.42,1820 ; v1@6341.11,1810.11 cw(c6331.72,1800.72) 6345,1800.72 cw(c6358.28,1800.72) 6348.89,1810.11 cw(c6372.76,1786.24) U52.6@6372.76,1820 ; v1@6344.86,1812.04 v1@6345,1812.18 ; v1(6345,1814) v1@6345,1812.18 ; v1@6346.06,1812.94 cw(c6363.11,1795.89) U52.6@6363.11,1820 ; U52.6@6369.79,1815.4 ccw(c6360.71,1808.74) 6360.71,1820 ccw(c6360.71,1831.26) U52.6@6369.79,1824.6 ; U52.6@6405.59,1820 6352.82,1820 6345.91,1813.09 v1@6345,1812.18 ; v3(6891.89,1825.63) U30.J6@6911.57,1845.31 ; U30.J6@6904.23,1845.31 cw(c6886.51,1845.31) 6899.04,1832.78 cw(c6911.57,1820.25) U30.J6@6911.57,1837.97 ; 5975.25,1480 5993.44,1498.19 ; 5993.44,1498.19 6043.67,1498.19 6043.86,1498.37 6092.19,1450.04 6229.23,1450.04 6281.81,1502.62 6281.81,1601.34 6281.02,1602.13 6281.02,1616.62 6292.14,1627.74 6292.14,1684.14 6308.19,1700.19 6308.19,1720.69 6323.19,1735.69 6323.19,1753.38 6345,1775.19 v1@6345,1812.18 ; 6904.69,1838.43 cw(c6891.89,1851.24) 6891.89,1833.13 ccw(c6891.89,1851.24) 6904.69,1838.43 ; 6904.69,1838.43 ccw(c6917.5,1825.63) 6899.39,1825.63 cw(c6917.5,1825.63) 6904.69,1838.43
  MidLayer2 w4: v1(6345,1814) 6348.81,1817.81 6447.06,1817.81 6465.37,1799.5 6505.31,1799.5 6520.62,1784.19 6579.62,1784.19 6601.62,1762.19 6616.38,1762.19 6655.96,1801.77 6754.89,1801.77 6829.01,1801.77 6848.51,1801.77 ccw(c6848.51,1843.5) 6878.02,1813.99 ; v1@6346.06,1812.94 cw(c6357.82,1801.18) 6357.82,1817.81 ; v1@6348.89,1810.11 cw(c6367.48,1791.52) 6367.48,1817.81 ; v1@6351.72,1807.28 cw(c6377.14,1781.86) 6377.14,1817.81 ; v1@6351.72,1820.72 ccw(c6358.73,1827.73) 6358.73,1817.81 ; v3@6884.42,1826.28 cw(c6866.38,1827.86) 6878.02,1813.99 ; v3@6891.24,1818.16 ccw(c6889.66,1800.12) 6878.02,1813.99
USER_LEDS.LED0.BLUE: R311.2 U8.R3 U32.3 | length 2012
  Top Layer w4: v1(3869.52,3963.37) 3874.97,3968.82 U32.3@3920,3968.82 ; v1@3870.58,3962.31 cw(c3886.29,3946.61) 3886.29,3968.82 ; v1@3873.41,3959.49 cw(c3895.95,3936.95) U32.3@3895.95,3968.82 ; v1@3876.24,3956.66 cw(c3905.6,3927.29) U32.3@3905.6,3968.82 ; U32.3@3890.69,3965.99 ccw(c3883.86,3959.16) 3883.86,3968.82 ccw(c3883.86,3978.48) U32.3@3890.69,3971.65 ; v1(4696,4172) 4698,4174 4716.04,4174 ; v1@4700.75,4169.23 cw(c4709.07,4164.36) 4709.07,4174 ; v1@4702.72,4178.72 ccw(c4714.11,4190.11) 4714.11,4174 ; v1@4704.2,4167.21 cw(c4716.04,4160.29) 4716.04,4174 ; U8.R3@4929.9,4170.32 cw(c4912.18,4170.32) 4924.71,4157.78 ; U8.R3@4937.24,4162.97 ccw(c4937.24,4145.25) 4924.71,4157.78 ; 4716.04,4174 4725.5,4164.54 4725.5,4164.12 4745.12,4144.5 4789.5,4144.5 4791.45,4146.45 4832.55,4146.45 4838.82,4146.45 4897.36,4146.45 ccw(c4897.36,4185.13) 4924.71,4157.78
  MidLayer1 w4: v1(3869.52,3963.37) 3945,4038.85 v1(3945,4210) v1@3947.07,4207.93 ; v1@3869.52,3968.87 ccw(c3869.52,3982.15) 3878.91,3972.76 ccw(c3888.3,3963.37) v1@3875.02,3963.37 ; v1@3869.52,3972.87 ccw(c3869.52,3995.81) 3885.74,3979.59 ccw(c3901.96,3963.37) v1@3879.02,3963.37 ; v1@3938.28,4203.28 cw(c3922.06,4187.06) 3945,4187.06 cw(c3967.93,4187.06) v1@3951.72,4203.28 ; v1@3941.11,4206.11 cw(c3931.72,4196.72) 3945,4196.72 cw(c3958.28,4196.72) v1@3948.89,4206.11 ; 3947.07,4112.93 4019.08,4112.93 4178.99,4112.93 4193.25,4127.19 4206.69,4127.19 4259.5,4180 4355,4180 4390.19,4215.19 v1(4390.19,4272.71) ; v1@4383.47,4265.99 cw(c4367.26,4249.77) 4390.19,4249.77 cw(c4413.13,4249.77) v1@4396.91,4265.99 ; v1@4386.3,4268.82 cw(c4376.91,4259.43) 4390.19,4259.43 cw(c4403.47,4259.43) v1@4394.08,4268.82
  Bottom Layer w4: v1@3938.28,4203.28 cw(c3919.21,4184.21) 3946.18,4184.21 ; v1@3941.11,4206.11 cw(c3928.87,4193.87) 3946.18,4193.87 ; v1(3945,4210) 3946.18,4208.82 R311.2@3946.18,4170 ; 3946.18,4189.92 cw(c3965.08,4189.92) v1@3951.72,4203.28 ; v1(4390.19,4272.71) 4456.82,4272.71 4483.71,4245.81 4510.69,4245.81 4525.81,4230.69 4525.81,4222.75 4586.06,4162.5 4662.5,4162.5 4671.81,4171.81 4695.81,4171.81 v1(4696,4172) ; v1@4394.08,4268.82 cw(c4403.47,4259.43) 4403.47,4272.71 cw(c4403.47,4285.99) v1@4394.08,4276.6 ; v1@4396.91,4265.99 cw(c4413.13,4249.77) 4413.13,4272.71 cw(c4413.13,4295.64) v1@4396.91,4279.43 ; 4672.61,4171.81 ccw(c4672.61,4195.39) v1@4689.28,4178.72 ; 4673.52,4171.81 cw(c4673.52,4149.52) v1@4689.28,4165.28 ; 4682.27,4171.81 ccw(c4682.27,4185.73) v1@4692.11,4175.89 ; 4683.18,4171.81 cw(c4683.18,4159.18) v1@4692.11,4168.11
USER_LEDS.LED0.GREEN: R312.2 U8.U1 U32.5 | length 3079.6
  Top Layer w4: U32.5@3920,3917.64 3962.64,3917.64 3965.19,3920.19 3965.19,3925 ; U32.5@3949.31,3914.81 cw(c3956.14,3907.98) 3956.14,3917.64 cw(c3956.14,3927.3) U32.5@3949.31,3920.47 ; v1(3980,3930) 3975,3925 3965.19,3925 ; v1@4130.69,4902.04 cw(c4107.76,4902.04) 4123.97,4885.82 cw(c4140.19,4869.61) v1@4140.19,4892.54 ; v1@4134.69,4902.04 cw(c4121.41,4902.04) 4130.8,4892.65 cw(c4140.19,4883.26) v1@4140.19,4896.54 ; v1(4140.19,4902.04) 3981.86,4743.71 3981.86,4177.04 3848.52,4043.71 3848.52,4008.27 3847.5,4007.25 3847.5,3991.4 3848.52,3990.37 3856.86,3982.04 3956.86,3982.04 3965.19,3973.71 3965.19,3925 ; v1@4283.47,4739.99 cw(c4267.26,4723.77) 4290.19,4723.77 cw(c4313.13,4723.77) v1@4296.91,4739.99 ; v1@4286.3,4742.82 cw(c4276.91,4733.43) 4290.19,4733.43 cw(c4303.47,4733.43) v1@4294.08,4742.82 ; v1(4290.19,4746.71) 4290.19,4716.71 4276.5,4703.02 4276.5,4360.4 4291.13,4345.77 4390.19,4246.71 4390.19,4182.37 4398.52,4174.04 4431.86,4174.04 4440.19,4182.37 4440.19,4208.37 4448.52,4216.71 4471.52,4216.71 4492.62,4237.81 4507.38,4237.81 4523.81,4221.37 4532.54,4221.37 4587.7,4166.21 4592.85,4166.21 4608.56,4150.5 4652.69,4150.5 4665.81,4137.38 4665.81,4132.44 4692.34,4105.91 4741.91,4105.91 ; 4742,4106 4754.5,4093.5 4769.25,4093.5 4771.25,4095.5 4817.5,4095.5 4821.43,4091.57 4830.57,4091.57 ; 4830.82,4091.57 4838.82,4091.57 U8.U1@4858.5,4091.57 ; U8.U1@4853.31,4086.38 ccw(c4840.78,4073.85) 4840.78,4091.57 ccw(c4840.78,4109.3) U8.U1@4853.31,4096.77
  MidLayer1 w4: v1@4133.47,4895.32 cw(c4117.26,4879.11) 4140.19,4879.11 cw(c4163.13,4879.11) v1@4146.91,4895.32 ; v1@4136.3,4898.15 cw(c4126.91,4888.76) 4140.19,4888.76 cw(c4153.47,4888.76) v1@4144.08,4898.15 ; v1(4140.19,4902.04) 4140.19,4869.69 4264.88,4745 ; 4271.38,4745 cw(c4271.38,4727.9) v1@4283.47,4739.99 ; 4273.91,4745 ccw(c4273.91,4761.48) v1@4286.12,4750.4 ; v1@4283.16,4753.09 cw(c4264.88,4769.68) 4264.88,4745 ; v1@4290,4745 4264.88,4745
  Bottom Layer w4: R312.2@3946.18,3900 3946.18,3921.18 3955,3930 v1(3980,3930) ; v1@3973.28,3923.28 ccw(c3957.06,3907.06) 3957.06,3930 ccw(c3957.06,3952.93) v1@3973.28,3936.72 ; v1@3976.11,3926.11 ccw(c3966.72,3916.72) 3966.72,3930 ccw(c3966.72,3943.28) v1@3976.11,3933.89
USER_LEDS.LED0.RED: R313.2 U8.R2 U32.1 | length 1673.7
  Top Layer w4: U32.1@3917.17,4022.83 ccw(c3910.34,4029.66) 3920,4029.66 ccw(c3929.66,4029.66) U32.1@3922.83,4022.83 ; U32.1@3920,4020 3920,4044.31 3937.71,4062.02 3937.71,4106.9 v1(3965.19,4134.37) ; v1@3955.69,4134.37 cw(c3932.76,4134.37) 3948.97,4118.16 cw(c3965.19,4101.94) v1@3965.19,4124.87 ; v1@3959.69,4134.37 cw(c3946.41,4134.37) 3955.8,4124.99 cw(c3965.19,4115.6) v1@3965.19,4128.87 ; v1(4433.52,4229.37) 4449.96,4245.81 4510.69,4245.81 4527.13,4229.37 4535.86,4229.37 4590.19,4175.04 4595.34,4175.04 4611.88,4158.5 4657.75,4158.5 4688.75,4189.5 4711.85,4189.5 4733.5,4167.85 4733.5,4167.44 4748.44,4152.5 4769.56,4152.5 4772.44,4155.37 4830.84,4155.37 4838.82,4154.81 4878.16,4154.81 ccw(c4878.16,4164.96) 4885.34,4157.78 ; v1@4433.52,4234.87 ccw(c4433.52,4248.15) 4442.91,4238.76 ccw(c4452.3,4229.37) v1@4439.02,4229.37 ; v1@4433.52,4238.87 ccw(c4433.52,4261.81) 4449.74,4245.59 ccw(c4465.96,4229.37) v1@4443.02,4229.37 ; U8.R2@4890.53,4170.32 cw(c4872.81,4170.32) 4885.34,4157.78 ; U8.R2@4897.87,4162.97 ccw(c4897.87,4145.25) 4885.34,4157.78
  MidLayer1 w4: v1@3966,4135.19 v1(3965.19,4134.37) 3978.64,4120.93 4175.67,4120.93 4177.25,4122.5 ; v1@4426.81,4236.09 ccw(c4410.59,4252.31) 4433.52,4252.31 ccw(c4456.46,4252.31) v1@4440.24,4236.09 ; v1@4429.64,4233.26 ccw(c4420.25,4242.65) 4433.52,4242.65 ccw(c4446.8,4242.65) v1@4437.41,4233.26 ; v1(4433.52,4229.37) 4433.52,4268.74 4412.05,4290.21 4367.71,4290.21 4335.69,4258.19 4326.38,4258.19 4203.38,4135.19 4189.94,4135.19 ; 4177.25,4122.5 4189.94,4135.19 ; 4177.25,4122.5 4189.94,4135.19
  Bottom Layer w4: R313.2@3946.18,4260 3965.19,4240.99 v1(3965.19,4134.37) ; v1@3958.47,4141.09 ccw(c3942.26,4157.31) 3965.19,4157.31 ccw(c3988.13,4157.31) v1@3971.91,4141.09 ; v1@3961.3,4138.26 ccw(c3951.91,4147.65) 3965.19,4147.65 ccw(c3978.47,4147.65) v1@3969.08,4138.26
USER_LEDS.LED1.BLUE: R308.2 U8.V4 U32.11 | length 1620.8
  Top Layer w4: v1(4076.86,3954.37) 4088,3943.23 U32.11@4138.5,3943.23 ; U32.11@4109.2,3940.4 ccw(c4102.37,3933.57) 4102.37,3943.23 ccw(c4102.37,3952.89) U32.11@4109.2,3946.06 ; v3(4956.93,4032.52) U8.V4@4976.61,4052.2 ; U8.V4@4969.27,4052.2 cw(c4951.55,4052.2) 4964.08,4039.67 cw(c4976.61,4027.14) U8.V4@4976.61,4044.86 ; 4969.73,4045.32 cw(c4956.93,4058.13) 4956.93,4040.02 ccw(c4956.93,4058.13) 4969.73,4045.32 ; 4969.73,4045.32 ccw(c4982.54,4032.52) 4964.43,4032.52 cw(c4982.54,4032.52) 4969.73,4045.32
  MidLayer1 w4: v1@4070.14,3961.09 ccw(c4053.92,3977.31) 4076.86,3977.31 ccw(c4099.79,3977.31) v1@4083.57,3961.09 ; v1@4072.97,3958.26 ccw(c4063.58,3967.65) 4076.86,3967.65 ccw(c4090.14,3967.65) v1@4080.75,3958.26 ; v1(4076.86,3954.37) 4076.86,4022.05 4147.62,4092.81 4181.5,4092.81 4199.88,4111.19 4213.32,4111.19 4265.34,4163.21 4377.02,4163.21 4397.42,4142.81 4474.93,4142.81 4507.32,4175.2 4568.73,4175.2 4581.44,4162.5 4596.56,4162.5 4609.06,4150 4653.19,4150 4665.81,4137.38 4665.81,4120 4665.81,4100.5 4736.31,4030 4760,4030 4768.94,4030 4769.44,4029.5 4815.56,4029.5 4818.58,4032.52 4827.48,4032.52 4838.82,4032.52 4879.25,4032.52 v3(4956.93,4032.52) ; v3@4951.63,4027.22 ccw(c4938.82,4014.41) 4938.82,4032.52 ccw(c4938.82,4050.63) v3@4951.63,4037.82 ; v3@4951.74,4027.33 ccw(c4939.2,4014.79) 4939.2,4032.52 ccw(c4939.2,4050.25) v3@4951.74,4037.71
  Bottom Layer w4: R308.2@3946.18,3990 3981.81,3954.37 v1(4076.86,3954.37) ; v1@4070.14,3947.66 ccw(c4053.92,3931.44) 4053.92,3954.37 ccw(c4053.92,3977.31) v1@4070.14,3961.09 ; v1@4072.97,3950.49 ccw(c4063.58,3941.1) 4063.58,3954.37 ccw(c4063.58,3967.65) v1@4072.97,3958.26
USER_LEDS.LED1.GREEN: R309.2 U8.T3 U32.13 | length 1418.4
  Top Layer w4: v1(4059.27,3999.29) 4060.02,4000.04 4092.89,4000.04 4098.52,3994.41 U32.13@4138.5,3994.41 ; v1@4063.16,3995.4 cw(c4074.36,3984.21) 4074.36,4000.04 ; v1@4065.99,3992.58 cw(c4084.01,3974.55) 4084.01,4000.04 ; v1@4065.99,4006.01 ccw(c4080.4,4020.42) 4080.4,4000.04 ; U32.13@4109.2,3991.58 ccw(c4102.37,3984.75) 4102.37,3994.41 ccw(c4102.37,4004.07) U32.13@4109.2,3997.24 ; v1(4762,4111) 4761.83,4111.17 4761.83,4111.85 4762.07,4112.08 4762.54,4112.08 4767.54,4107.08 4830.92,4107.08 4838.82,4107.08 4897.36,4107.08 ccw(c4897.36,4145.76) 4924.71,4118.41 ; U8.T3@4929.9,4130.94 cw(c4912.18,4130.94) 4924.71,4118.41 ; U8.T3@4937.24,4123.6 ccw(c4937.24,4105.88) 4924.71,4118.41
  MidLayer1 w4: v1@4054.51,4007.51 ccw(c4049.73,4015.77) 4059.27,4015.77 ; v1(4059.27,3999.29) 4059.27,4015.77 ; v1@4064.03,4007.51 cw(c4068.82,4015.77) 4059.27,4015.77 ; 4741.48,4112 ccw(c4741.48,4131.52) v1@4755.28,4117.72 ; 4747.76,4112 cw(c4747.76,4098.66) v1@4757.84,4107.4 ; v1@4754.82,4104.78 ccw(c4739,4091.06) 4739,4112 ; v1@4762,4112 4739,4112 ; 4059.27,4015.77 4144.31,4100.81 4178.19,4100.81 4196.57,4119.19 4210,4119.19 4262.82,4172 4381.23,4172 4429.82,4172 4440.32,4182.5 4457.25,4182.5 4462.25,4177.5 4495.65,4177.5 4501.35,4183.2 4572.05,4183.2 4584.75,4170.5 4599.88,4170.5 4611.88,4158.5 4656,4158.5 4673.81,4140.69 4673.81,4124.44 4690.44,4107.81 4734.81,4107.81 4739,4112
  Bottom Layer w4: v1(4059.27,3999.29) v1@4061.45,4001.47 ; v1@4063.8,3996.18 cw(c4073.86,3989.26) 4073.86,4001.47 ; v1@4065.58,4006.42 4065.58,4005.6 v1@4061.45,4001.47 ; v1@4065.99,4006.01 ccw(c4076.95,4016.98) 4076.95,4001.47 ; v1@4067.1,3993.91 cw(c4081.47,3984.03) 4081.47,4001.47 ; R309.2@4176.18,3990 4157.39,4008.79 4088.79,4008.79 4081.47,4001.47 ; v1@4061.45,4001.47 4081.47,4001.47
USER_LEDS.LED1.RED: R310.2 U8.W9 U32.9 | length 2703.8
  Top Layer w4: v1@4088.42,3899.27 ccw(c4105.87,3916.72) 4105.87,3892.05 ; v1@4090.19,3900.04 4098.18,3892.05 U32.9@4138.5,3892.05 ; v1@4091.25,3902.1 ccw(c4115.52,3926.37) U32.9@4115.52,3892.05 ; v1@4094.08,3904.93 ccw(c4125.18,3936.03) U32.9@4125.18,3892.05 ; v1@4096.91,3907.76 ccw(c4134.84,3945.69) U32.9@4134.84,3892.05 ; U32.9@4109.2,3889.22 ccw(c4102.37,3882.39) 4102.37,3892.05 ccw(c4102.37,3901.71) U32.9@4109.2,3894.88 ; v3(5153.78,3993.15) U8.W9@5173.46,4012.83 ; U8.W9@5166.12,4012.83 cw(c5148.4,4012.83) 5160.93,4000.3 cw(c5173.46,3987.77) U8.W9@5173.46,4005.49 ; 5166.58,4005.95 cw(c5153.78,4018.76) 5153.78,4000.65 ccw(c5153.78,4018.76) 5166.58,4005.95 ; 5166.58,4005.95 ccw(c5179.39,3993.15) 5161.28,3993.15 cw(c5179.39,3993.15) 5166.58,4005.95
  MidLayer1 w4: v1@4080.69,3901.04 ccw(c4057.76,3901.04) 4073.97,3917.26 ccw(c4090.19,3933.48) v1@4090.19,3910.54 ; v1@4084.69,3901.04 ccw(c4071.41,3901.04) 4080.8,3910.43 ccw(c4090.19,3919.82) v1@4090.19,3906.54 ; v1(4090.19,3901.04) 4035.73,3955.5 3969.44,3955.5 3959.81,3945.87 3862.28,3945.87 3847.5,3960.65 3847.5,4007.25 3857.75,4017.5 3880.79,4017.5 3927.5,4064.21 3927.5,4277.5 3931.54,4281.54 4148.46,4281.54 4170,4260 v1(4170,4140) ; v1@4163.28,4146.72 ccw(c4147.06,4162.93) 4170,4162.93 ccw(c4192.93,4162.93) v1@4176.72,4146.72 ; v1@4166.11,4143.89 ccw(c4156.72,4153.28) 4170,4153.28 ccw(c4183.28,4153.28) v1@4173.89,4143.89
  Bottom Layer w4: v1(4090.19,3901.04) 4091.23,3900 R310.2@4133.82,3900 ; v1@4094.08,3904.93 ccw(c4105.98,3916.83) 4105.98,3900 ; v1@4096.91,3894.32 cw(c4110.61,3880.62) 4110.61,3900 ; v1@4096.91,3907.76 ccw(c4115.64,3926.49) 4115.64,3900 ; v1@4170,4130.5 cw(c4170,4107.56) 4186.22,4123.78 cw(c4202.43,4140) v1@4179.5,4140 ; v1@4170,4134.5 cw(c4170,4121.22) 4179.39,4130.61 cw(c4188.78,4140) v1@4175.5,4140 ; v1(4170,4140) 4189.07,4120.93 4209.69,4120.93 4251.97,4163.21 4415.73,4163.21 4425.23,4153.71 4479.13,4099.81 4725.38,4099.81 4743.81,4081.38 4743.81,4066.62 4742.5,4065.31 4742.5,4022.5 4756.34,4008.66 4830.82,4008.66 4838.82,4008.66 5036.73,4008.66 5130.27,4008.66 cw(c5130.27,3994.61) 5140.2,4004.54 ; v3@5146.31,3992.5 ccw(c5128.27,3990.92) 5139.91,4004.79 ccw(c5151.55,4018.66) v3@5153.13,4000.62
USER_LEDS.LED2.BLUE: R305.2 U8.AD10 U33.3 | length 3577.5
  Top Layer w4: v1(4330,2310) 4373.36,2353.36 4373.36,2408.61 4377.5,2412.75 4377.5,2427.25 4373.36,2431.39 4373.36,2463.61 4377.5,2467.75 4377.5,2485.73 4373.36,2489.87 4373.36,2540 4365,2548.36 ; v1@4330,2315.5 ccw(c4330,2328.78) 4339.39,2319.39 ccw(c4348.78,2310) v1@4335.5,2310 ; v1@4330,2319.5 ccw(c4330,2342.43) 4346.22,2326.22 ccw(c4362.43,2310) v1@4339.5,2310 ; v1@4358.57,2563.01 cw(c4345.11,2548.36) 4365,2548.36 ; v1@4361.28,2565.95 cw(c4353.48,2557.47) 4365,2557.47 cw(c4376.52,2557.47) v1@4368.72,2565.95 ; v1(4365,2570) 4365,2548.36 ; v1@4371.43,2563.01 ccw(c4384.89,2548.36) 4365,2548.36 ; U33.3@5120,3115 5125,3115 5160,3115 5163.48,3118.48 5163.48,3203.48 5156.86,3210.1 v1(5156.86,3266.71) v1@5163.48,3260.08 ; v1@5150.14,3259.99 cw(c5133.92,3243.77) 5156.86,3243.77 cw(c5179.79,3243.77) v1@5163.57,3259.99 ; v1@5152.97,3262.82 cw(c5143.58,3253.43) 5156.86,3253.43 cw(c5170.14,3253.43) v1@5160.75,3262.82 ; v3(5193.15,3796.3) U8.AD10@5212.83,3815.98 ; U8.AD10@5205.49,3815.98 cw(c5187.77,3815.98) 5200.3,3803.45 cw(c5212.83,3790.92) U8.AD10@5212.83,3808.64 ; 5205.95,3809.1 cw(c5193.15,3821.91) 5193.15,3803.8 ccw(c5193.15,3821.91) 5205.95,3809.1 ; 5205.95,3809.1 ccw(c5218.76,3796.3) 5200.65,3796.3 cw(c5218.76,3796.3) 5205.95,3809.1
  MidLayer1 w4: v1@5073.28,2306.72 ccw(c5057.06,2322.93) 5080,2322.93 ccw(c5102.93,2322.93) v1@5086.72,2306.72 ; v1@5076.11,2303.89 ccw(c5066.72,2313.28) 5080,2313.28 ccw(c5093.28,2313.28) v1@5083.89,2303.89 ; v1(5080,2300) 5080,2353.54 5165.5,2439.04 5165.5,2470.56 5150.56,2485.5 5143.31,2485.5 5127.5,2501.31 5127.5,2605.12 5138.5,2616.12 5138.5,2643.88 5134.48,2647.9 5134.48,2761.71 5097.32,2798.87 5090.94,2798.87 5047.5,2842.32 5047.5,2965.43 5135,3052.93 5135,3244.85 v1(5156.86,3266.71) 5207.69,3317.54 5207.69,3556.13 5177.64,3586.17 5177.64,3630.82 5177.64,3638.82 5177.64,3679.25 5177.64,3772.79 ; v1@5147.36,3266.71 cw(c5124.42,3266.71) 5140.64,3250.49 cw(c5156.86,3234.27) v1@5156.86,3257.21 ; v1@5151.36,3266.71 cw(c5138.08,3266.71) 5147.47,3257.32 cw(c5156.86,3247.93) v1@5156.86,3261.21 ; v1@5156.86,3272.21 ccw(c5156.86,3285.49) 5166.25,3276.1 ccw(c5175.64,3266.71) v1@5162.36,3266.71 ; v1@5156.86,3276.21 ccw(c5156.86,3299.14) 5173.07,3282.93 ccw(c5189.29,3266.71) v1@5166.36,3266.71 ; 5177.64,3758.86 5177.64,3772.79 ; 5181.76,3782.72 ccw(c5191.69,3772.79) 5177.64,3772.79 ; v3@5185.68,3795.65 cw(c5167.64,3794.07) 5181.51,3782.43 cw(c5195.38,3770.79) v3@5193.8,3788.83
  MidLayer2 w4: v1(4330,2310) 4340,2300 v1(5080,2300) ; v1@5073.28,2293.28 ccw(c5057.06,2277.06) 5057.06,2300 ccw(c5057.06,2322.93) v1@5073.28,2306.72 ; v1@5076.11,2296.11 ccw(c5066.72,2286.72) 5066.72,2300 ccw(c5066.72,2313.28) v1@5076.11,2303.89
  Bottom Layer w4: R305.2@4319.71,2607.27 4327.73,2607.27 v1(4365,2570) ; v1@4355.5,2570 ccw(c4332.56,2570) 4348.78,2586.22 ccw(c4365,2602.43) v1@4365,2579.5 ; v1@4359.5,2570 ccw(c4346.22,2570) 4355.61,2579.39 ccw(c4365,2588.78) v1@4365,2575.5
USER_LEDS.LED2.GREEN: R306.2 U8.AG11 U33.5 | length 2397.7
  Top Layer w4: v1(5005,2970) 5031.86,2996.86 5031.86,3046.86 5047.64,3062.64 U33.5@5125,3062.64 5167.64,3062.64 5171.48,3066.48 5171.48,3246.49 5216.19,3291.2 5216.19,3428.82 5222.02,3434.65 5222.02,3520.27 5225.81,3524.05 5225.81,3562.58 5252.02,3588.79 5252.02,3607.98 5251.68,3608.32 5236.7,3623.3 5236.7,3630.82 5236.7,3638.82 5236.7,3678.16 cw(c5246.85,3678.16) 5239.67,3685.34 ; v1@5005,2975.5 ccw(c5005,2988.78) 5014.39,2979.39 ccw(c5023.78,2970) v1@5010.5,2970 ; v1@5005,2979.5 ccw(c5005,3002.43) 5021.22,2986.22 ccw(c5037.43,2970) v1@5014.5,2970 ; U8.AG11@5244.86,3697.87 cw(c5227.14,3697.87) 5239.67,3685.34 ; U8.AG11@5252.2,3690.53 ccw(c5252.2,3672.8) 5239.67,3685.34
  MidLayer1 w4: v1(4660,2715) 4679.9,2715 ; v1@4664.28,2711.54 cw(c4671.52,2705.69) 4671.52,2715 cw(c4671.52,2724.31) v1@4664.28,2718.46 ; v1@4667.39,2709.03 cw(c4679.9,2698.91) 4679.9,2715 ; v1@4667.39,2720.97 ccw(c4679.9,2731.09) 4679.9,2715 ; v1@4765.5,2880 cw(c4742.56,2880) 4758.78,2863.78 cw(c4775,2847.56) v1@4775,2870.5 ; v1@4769.5,2880 cw(c4756.22,2880) 4765.61,2870.61 cw(c4775,2861.22) v1@4775,2874.5 ; v1(4775,2880) 4749.36,2854.36 4749.36,2784.46 4679.9,2715 ; v1@4998.28,2831.72 ccw(c4982.06,2847.93) 5005,2847.93 ccw(c5027.93,2847.93) v1@5011.72,2831.72 ; v1@4998.28,2963.28 cw(c4982.06,2947.06) 5005,2947.06 cw(c5027.93,2947.06) v1@5011.72,2963.28 ; v1@5001.11,2828.89 ccw(c4991.72,2838.28) 5005,2838.28 ccw(c5018.28,2838.28) v1@5008.89,2828.89 ; v1@5001.11,2966.11 cw(c4991.72,2956.72) 5005,2956.72 cw(c5018.28,2956.72) v1@5008.89,2966.11 ; v1(5005,2825) v1(5005,2970)
  MidLayer2 w4: v1@4385,2725.5 cw(c4385,2702.56) 4401.22,2718.78 cw(c4417.43,2735) v1@4394.5,2735 ; v1@4385,2729.5 cw(c4385,2716.22) 4394.39,2725.61 cw(c4403.78,2735) v1@4390.5,2735 ; v1(4385,2735) 4419.5,2700.5 4645.5,2700.5 v1(4660,2715)
  Bottom Layer w4: R306.2@4319.71,2719.09 4335.62,2735 v1(4385,2735) ; v1@4378.28,2728.28 ccw(c4362.06,2712.06) 4362.06,2735 ccw(c4362.06,2757.93) v1@4378.28,2741.72 ; v1@4381.11,2731.11 ccw(c4371.72,2721.72) 4371.72,2735 ccw(c4371.72,2748.28) v1@4381.11,2738.89 ; 4754.83,2869.83 cw(c4768.33,2856.33) v1@4773.51,2874.71 ; 4759.66,2874.66 cw(c4770.45,2863.86) v1@4774.59,2878.56 ; v1(4775,2880) 4765,2880 4755,2870 4755,2835 4767.46,2822.54 5002.54,2822.54 v1(5005,2825)
USER_LEDS.LED2.RED: R307.2 U8.AC10 U33.1 | length 3528.4
  Top Layer w4: v1(5110,3205) 5125,3205 5131.86,3198.14 5131.86,3165 U33.1@5125,3165 ; v3(5193.15,3835.67) U8.AC10@5212.83,3855.35 ; U8.AC10@5205.49,3855.35 cw(c5187.77,3855.35) 5200.3,3842.82 cw(c5212.83,3830.29) U8.AC10@5212.83,3848.01 ; 5205.95,3848.47 cw(c5193.15,3861.28) 5193.15,3843.17 ccw(c5193.15,3861.28) 5205.95,3848.47 ; 5205.95,3848.47 ccw(c5218.76,3835.67) 5200.65,3835.67 cw(c5218.76,3835.67) 5205.95,3848.47
  MidLayer1 w4: v1@4250.5,2240 ccw(c4227.56,2240) 4243.78,2256.22 ccw(c4260,2272.43) v1@4260,2249.5 ; v1@4254.5,2240 ccw(c4241.22,2240) 4250.61,2249.39 ccw(c4260,2258.78) v1@4260,2245.5 ; v1(4260,2240) 4235,2265 4235,2411.77 4250,2426.77 4250,2480 4295,2525 v1(4325,2525) ; v1@4318.28,2518.28 ccw(c4302.06,2502.06) 4302.06,2525 ccw(c4302.06,2547.93) v1@4318.28,2531.72 ; v1@4321.11,2521.11 ccw(c4311.72,2511.72) 4311.72,2525 ccw(c4311.72,2538.28) v1@4321.11,2528.89 ; v1(4990,2235) 5005.25,2250.25 5005.25,2290.1 5157.5,2442.35 5157.5,2467.25 5147.25,2477.5 5140,2477.5 5119.5,2498 5119.5,2608.44 5130.5,2619.44 5130.5,2640.56 5125.82,2645.25 5125.82,2759.06 5094,2790.87 5087.63,2790.87 5038.5,2840 5038.5,2967.75 5110,3039.25 v1(5110,3205) 5110,3240.22 5122.5,3252.72 5122.5,3343.06 5165.19,3385.75 5165.19,3468.88 5193.81,3497.5 5193.81,3558.69 5169.29,3583.21 5169.29,3630.82 5169.29,3638.82 5169.29,3679.25 5169.29,3698.67 5169.29,3772.79 ; v1@5103.28,3198.28 cw(c5087.06,3182.06) 5110,3182.06 cw(c5132.93,3182.06) v1@5116.72,3198.28 ; v1@5103.28,3211.72 ccw(c5087.06,3227.93) 5110,3227.93 ccw(c5132.93,3227.93) v1@5116.72,3211.72 ; v1@5106.11,3201.11 cw(c5096.72,3191.72) 5110,3191.72 cw(c5123.28,3191.72) v1@5113.89,3201.11 ; v1@5106.11,3208.89 ccw(c5096.72,3218.28) 5110,3218.28 ccw(c5123.28,3218.28) v1@5113.89,3208.89 ; 5169.29,3758.86 5169.29,3772.79 ; v3@5185.68,3835.02 cw(c5167.64,3833.44) 5181.51,3821.8 ; v3@5193.8,3828.2 ccw(c5195.38,3810.16) 5181.51,3821.8 ; 5169.29,3772.79 5169.29,3792.29 cw(c5211.02,3792.29) 5181.51,3821.8
  MidLayer2 w4: v1@4255.02,2231.91 cw(c4249.54,2223) 4260,2223 ; v1(4260,2240) 4260,2223 ; v1@4264.98,2231.91 ccw(c4270.46,2223) 4260,2223 ; v1@4980.5,2235 cw(c4957.56,2235) 4973.78,2218.78 cw(c4990,2202.56) v1@4990,2225.5 ; v1@4984.5,2235 cw(c4971.22,2235) 4980.61,2225.61 cw(c4990,2216.22) v1@4990,2229.5 ; v1(4990,2235) 4954.21,2199.21 4713.81,2199.21 4698.02,2215 4285,2215 4268,2215 4260,2223
  Bottom Layer w4: 4319.71,2537.11 ccw(c4332.39,2537.11) v1@4325.78,2526.28 ; R307.2@4319.71,2544.23 ccw(c4336.74,2544.23) v1@4327.87,2529.69 ; v1(4325,2525) 4319.71,2530.29 R307.2@4319.71,2551.36 ccw(c4341.09,2551.36) v1@4329.95,2533.11
USER_LEDS.LED3.BLUE: R302.2 U8.AD11 U33.11 | length 1350.7
  Top Layer w4: v3(5232.52,3796.3) U8.AD11@5252.2,3815.98 ; U8.AD11@5244.86,3815.98 cw(c5227.14,3815.98) 5239.67,3803.45 cw(c5252.2,3790.92) U8.AD11@5252.2,3808.64 ; v1@5275,3091.71 5306.86,3091.71 5310.19,3088.37 ; v1@5276.06,3096.06 ccw(c5286.57,3106.57) 5286.57,3091.71 ; v1@5278.89,3098.89 ccw(c5296.23,3116.23) 5296.23,3091.71 ; v1@5281.72,3088.28 cw(c5289.99,3080.01) 5289.99,3091.71 ; v1@5281.72,3101.72 ccw(c5305.88,3125.88) 5305.88,3091.71 ; U33.11@5313.54,3086.27 ccw(c5310.19,3084.39) 5310.19,3088.23 ; U33.11@5313.54,3090.19 cw(c5310.19,3092.06) 5310.19,3088.23 ; U33.11@5343.5,3088.23 5310.19,3088.23 ; 5245.32,3809.1 cw(c5232.52,3821.91) 5232.52,3803.8 ccw(c5232.52,3821.91) 5245.32,3809.1 ; 5245.32,3809.1 ccw(c5258.13,3796.3) 5240.02,3796.3 cw(c5258.13,3796.3) 5245.32,3809.1
  MidLayer1 w4: 5221.13,3782.72 ccw(c5231.06,3772.79) 5217.01,3772.79 5217.01,3679.25 5217.01,3638.82 5217.01,3630.82 5217.01,3580.74 5231.86,3565.9 5231.86,3197.08 5275,3153.94 v1(5275,3095) ; v3@5225.05,3795.65 cw(c5207.01,3794.07) 5220.88,3782.43 cw(c5234.75,3770.79) v3@5233.17,3788.83 ; v1@5268.28,3101.72 ccw(c5252.06,3117.93) 5275,3117.93 ccw(c5297.93,3117.93) v1@5281.72,3101.72 ; v1@5271.11,3098.89 ccw(c5261.72,3108.28) 5275,3108.28 ccw(c5288.28,3108.28) v1@5278.89,3098.89
  Bottom Layer w4: v1@5275,3085.5 cw(c5275,3062.56) 5291.22,3078.78 cw(c5307.43,3095) v1@5284.5,3095 ; v1@5275,3089.5 cw(c5275,3076.22) 5284.39,3085.61 cw(c5293.78,3095) v1@5280.5,3095 ; v1(5275,3095) 5295,3075 R302.2@5504.87,3075
USER_LEDS.LED3.GREEN: R303.2 U8.AC12 U33.13 | length 3269.3
  Top Layer w4: v1@5225,3155.5 cw(c5225,3132.56) 5241.22,3148.78 cw(c5257.43,3165) v1@5234.5,3165 ; v1@5225,3159.5 cw(c5225,3146.22) 5234.39,3155.61 cw(c5243.78,3165) v1@5230.5,3165 ; v1(5225,3165) 5250.59,3139.41 U33.13@5343.5,3139.41 ; v3(5271.89,3835.67) U8.AC12@5291.57,3855.35 ; U8.AC12@5284.23,3855.35 cw(c5266.51,3855.35) 5279.04,3842.82 cw(c5291.57,3830.29) U8.AC12@5291.57,3848.01 ; U33.13@5314.2,3136.58 ccw(c5307.37,3129.75) 5307.37,3139.41 ccw(c5307.37,3149.07) U33.13@5314.2,3142.24 ; 5284.69,3848.47 cw(c5271.89,3861.28) 5271.89,3843.17 ccw(c5271.89,3861.28) 5284.69,3848.47 ; 5284.69,3848.47 ccw(c5297.5,3835.67) 5279.39,3835.67 cw(c5297.5,3835.67) 5284.69,3848.47
  MidLayer1 w4: v1(4370,2600) 4439.19,2669.19 4439.19,2815.02 4450,2825.83 v1(4450,2985) ; v1@4443.28,2978.28 cw(c4427.06,2962.06) 4450,2962.06 cw(c4472.93,2962.06) v1@4456.72,2978.28 ; v1@4446.11,2981.11 cw(c4436.72,2971.72) 4450,2971.72 cw(c4463.28,2971.72) v1@4453.89,2981.11 ; 5165.25,2899.75 cw(c5140.49,2875) v1@5175.5,2875 ; 5172.08,2892.92 cw(c5154.15,2875) v1@5179.5,2875 ; 5177.32,2887.68 ccw(c5185,2895.36) v1@5185,2884.5 ; 5178.9,2886.1 cw(c5167.81,2875) v1@5183.5,2875 ; v1(5185,2875) 5185,2880 5158,2907 5158,2999.15 5156.02,3001.13 5156.02,3015.62 5172.69,3032.29 5172.69,3065.62 5225,3117.93 v1(5225,3165) 5255,3135 5255,3090.25 5270.78,3074.47 5289.47,3074.47 5295,3080 5295,3145.25 5239.86,3200.39 5239.86,3503.48 5273.25,3536.87 5273.25,3586.75 5248.03,3611.97 5248.03,3630.82 5248.03,3638.82 5248.03,3679.25 5248.03,3698.67 5248.03,3772.79 ; v1@5218.28,3158.28 cw(c5202.06,3142.06) 5225,3142.06 cw(c5247.93,3142.06) v1@5231.72,3158.28 ; v1@5221.11,3161.11 cw(c5211.72,3151.72) 5225,3151.72 cw(c5238.28,3151.72) v1@5228.89,3161.11 ; v1@5225,3155.5 cw(c5225,3132.56) 5241.22,3148.78 cw(c5257.43,3165) v1@5234.5,3165 ; v1@5225,3159.5 cw(c5225,3146.22) 5234.39,3155.61 cw(c5243.78,3165) v1@5230.5,3165 ; 5248.03,3758.86 5248.03,3772.79 ; v3@5264.42,3835.02 cw(c5246.38,3833.44) 5260.25,3821.8 ; v3@5272.54,3828.2 ccw(c5274.12,3810.16) 5260.25,3821.8 ; 5248.03,3772.79 5248.03,3792.29 cw(c5289.76,3792.29) 5260.25,3821.8
  Bottom Layer w4: R303.2@4319.71,2663.18 4366.82,2663.18 4370,2660 v1(4370,2600) ; v1@4363.28,2606.72 ccw(c4347.06,2622.93) 4370,2622.93 ccw(c4392.93,2622.93) v1@4376.72,2606.72 ; v1@4366.11,2603.89 ccw(c4356.72,2613.28) 4370,2613.28 ccw(c4383.28,2613.28) v1@4373.89,2603.89 ; v1(4450,2985) 4455,2990 4455,2965.84 4490.96,2929.87 4805,2929.87 4856.02,2878.85 4856.02,2876.13 4874.11,2858.04 4979.35,2858.04 4987.81,2866.5 5022.19,2866.5 5030.31,2858.37 5076.88,2858.37 5084.88,2866.37 5092.88,2866.37 5110.71,2884.21 5175.79,2884.21 v1(5185,2875)
USER_LEDS.LED3.RED: R304.2 U8.Y13 U33.9 | length 4036.1
  Top Layer w4: 5292.87,3043.05 cw(c5292.87,3012.9) U33.9@5314.2,3034.22 ; 5302.53,3043.05 cw(c5302.53,3022.55) U33.9@5317.02,3037.05 ; v3(5311.26,3953.78) U8.Y13@5330.94,3973.46 ; 5312.19,3043.05 cw(c5312.19,3032.21) U33.9@5319.85,3039.88 ; 5321.84,3043.05 cw(c5321.84,3041.87) U33.9@5322.68,3042.7 ; U8.Y13@5323.6,3973.46 cw(c5305.88,3973.46) 5318.41,3960.93 cw(c5330.94,3948.4) U8.Y13@5330.95,3966.12 ; U33.9@5339.52,3037.43 ccw(c5332.54,3038.09) 5337.5,3043.05 ; U33.9@5343.12,3041.03 cw(c5342.46,3048.01) 5337.5,3043.05 ; U33.9@5343.5,3037.05 5337.5,3043.05 ; v1@5345.19,3358.1 cw(c5345.19,3335.16) 5361.41,3351.38 cw(c5377.63,3367.6) v1@5354.69,3367.6 ; v1@5345.19,3362.1 cw(c5345.19,3348.82) 5354.58,3358.21 cw(c5363.97,3367.6) v1@5350.69,3367.6 ; v1(5345.19,3367.6) 5363.78,3349.01 5368.85,3349.01 5377.3,3340.55 5377.3,3266.41 5335.89,3225 5230,3225 5207.5,3202.5 5207.5,3157.5 5220,3145 5220,3120 5195,3095 5195,3070 5248.29,3016.71 5271.86,3016.71 5277.5,3022.35 5277.5,3035.35 5285.2,3043.05 5337.5,3043.05 ; 5324.06,3966.58 cw(c5311.26,3979.39) 5311.26,3961.28 ccw(c5311.26,3979.39) 5324.06,3966.58 ; 5324.06,3966.58 ccw(c5336.87,3953.78) 5318.76,3953.78 cw(c5336.87,3953.78) 5324.06,3966.58
  MidLayer1 w4: v1(5335,2560) 5335,2587.5 5325.5,2597 5325.5,2643.08 5339.19,2656.77 5339.19,2728 5317.19,2750 5317.19,2832.38 5358.36,2873.55 5358.36,2911.53 5387.5,2940.67 5387.5,2977.15 5358.02,3006.63 5358.02,3128.02 5393.62,3163.62 5393.62,3212.26 5351.2,3254.68 5351.2,3303.04 5332.2,3322.04 5332.2,3343.16 5345.19,3356.15 v1(5345.19,3367.6) ; 5337.92,3348.89 ccw(c5331.64,3355.17) v1@5338.19,3361.18 ; 5340.88,3351.84 ccw(c5334.72,3358) v1@5341.14,3363.88 ; 5343.83,3354.79 ccw(c5337.8,3360.82) v1@5344.08,3366.59
  MidLayer2 w4: v1(4360,2475) 4433.69,2475 4473.69,2515 4473.69,2517.23 4498,2541.54 4589.81,2541.54 4643.19,2594.91 4643.19,2604.5 4688.39,2649.71 4899.84,2649.71 4941.17,2608.37 5108.12,2608.37 5116.96,2617.21 5165.89,2617.21 5173.39,2624.71 5193.25,2624.71 5257.96,2560 v1(5335,2560) ; v1@4363.89,2471.11 cw(c4373.28,2461.72) 4373.28,2475 cw(c4373.28,2488.28) v1@4363.89,2478.89 ; v1@4366.72,2468.28 cw(c4382.93,2452.06) 4382.93,2475 cw(c4382.93,2497.93) v1@4366.72,2481.72 ; v1@5328.28,2553.28 ccw(c5312.06,2537.06) 5312.06,2560 ccw(c5312.06,2582.93) v1@5328.28,2566.72 ; v1@5331.11,2556.11 ccw(c5321.72,2546.72) 5321.72,2560 ccw(c5321.72,2573.28) v1@5331.11,2563.89
  Bottom Layer w4: R304.2@4319.71,2495.45 4339.55,2495.45 v1(4360,2475) ; v1@4350.5,2475 ccw(c4327.56,2475) 4343.78,2491.22 ccw(c4360,2507.43) v1@4360,2484.5 ; v1@4354.5,2475 ccw(c4341.22,2475) 4350.61,2484.39 ccw(c4360,2493.78) v1@4360,2480.5 ; 5299.87,3940.2 ccw(c5309.8,3930.27) 5295.75,3930.27 5295.75,3836.73 5295.75,3638.82 5295.75,3630.82 5295.75,3607.13 5253.62,3565 5245,3565 5238.02,3558.02 5238.02,3371.98 5251.63,3358.37 5345.19,3358.37 v1(5345.19,3367.6) ; 5299.98,3358.37 ccw(c5299.98,3412.81) v1@5338.47,3374.32 ; v3@5303.79,3953.13 cw(c5285.75,3951.55) 5299.62,3939.91 cw(c5313.49,3928.27) v3@5311.91,3946.31 ; 5309.64,3358.37 ccw(c5309.64,3403.15) v1@5341.3,3371.49 ; 5319.3,3358.37 ccw(c5319.3,3393.49) v1@5344.13,3368.66 ; 5328.95,3358.37 ccw(c5328.95,3383.84) v1@5346.96,3365.83
USER_LEDS.LED4.BLUE: R299.2 U8.AB23 U34.3 | length 2447.4
  Top Layer w4: U8.AB23@5724.65,3887.38 cw(c5724.65,3869.66) 5737.18,3882.19 cw(c5749.71,3894.72) U8.AB23@5731.99,3894.72 ; U8.AB23@5724.65,3894.72 v3(5744.33,3875.04) ; v1@6610.35,3258.53 cw(c6605.32,3250.04) 6615.19,3250.04 ; v1(6615.19,3266.71) 6615.19,3250.04 ; v1@6620.03,3258.53 ccw(c6625.06,3250.04) 6615.19,3250.04 ; U34.3@6790.69,3115.99 ccw(c6783.86,3109.16) 6783.86,3118.82 ccw(c6783.86,3128.48) U34.3@6790.69,3121.65 ; U34.3@6820,3118.82 6781.18,3118.82 6773.52,3126.48 6773.52,3171.71 6711.86,3233.37 6631.86,3233.37 6615.19,3250.04 ; 5731.53,3887.84 cw(c5718.72,3875.04) 5736.83,3875.04 ccw(c5718.72,3875.04) 5731.53,3887.84 ; 5731.53,3887.84 ccw(c5744.33,3900.65) 5744.33,3882.54 cw(c5744.33,3900.65) 5731.53,3887.84
  MidLayer1 w4: v3@5745.63,3867.65 cw(c5748.78,3849.82) 5759.16,3864.65 ; v3@5751.72,3876.34 ccw(c5769.55,3879.49) 5759.16,3864.65 ; 5821.14,3851.18 5807.21,3851.18 ; v1(6079,3414) 6102.5,3437.5 6102.5,3521.06 6081.7,3541.87 6081.7,3627.2 6067.19,3641.71 6067.19,3666.77 6063.52,3670.44 6063.52,3747.79 5960.14,3851.18 5949.18,3851.18 5941.18,3851.18 5900.75,3851.18 5881.33,3851.18 5807.21,3851.18 ; v1@6079,3419.5 ccw(c6079,3432.78) 6088.39,3423.39 ccw(c6097.78,3414) v1@6084.5,3414 ; v1@6079,3423.5 ccw(c6079,3446.43) 6095.22,3430.22 ccw(c6111.43,3414) v1@6088.5,3414 ; 5759.16,3864.65 5767.74,3857.57 ccw(c5783.96,3874.95) 5783.79,3851.18 ; 5783.79,3851.18 ccw(c5783.96,3874.95) 5783.96,3851.18 ; 5783.79,3851.18 5783.96,3851.18 ; 5783.96,3851.18 5807.21,3851.18
  MidLayer2 w4: v1(6079,3414) 6081,3412 6130.6,3412 6200.9,3341.71 6267.56,3341.71 6283.23,3326.04 6555.86,3326.04 v1(6615.19,3266.71) ; v1@6082.89,3417.89 ccw(c6097.11,3432.11) 6097.11,3412 ccw(c6097.11,3395.89) v1@6085.72,3407.28 ; v1@6085.72,3420.72 ccw(c6106.76,3441.76) 6106.76,3412 ; v1@6605.69,3266.71 ccw(c6582.76,3266.71) 6598.97,3282.93 ccw(c6615.19,3299.14) v1@6615.19,3276.21 ; v1@6609.69,3266.71 ccw(c6596.41,3266.71) 6605.8,3276.1 ccw(c6615.19,3285.49) v1@6615.19,3272.21
  Bottom Layer w4: v1(6615.19,3266.71) 6615.69,3266.21 6731.61,3266.21 6772.94,3307.54 6855.77,3307.54 6882.44,3334.21 6940,3334.21 6948.58,3325.62 R299.2@7063.82,3325.62