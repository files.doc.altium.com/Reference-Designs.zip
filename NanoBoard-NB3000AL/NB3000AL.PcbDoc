# Altium PCB NB3000AL.PcbDoc (part 21 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
AUGND: (continued)
  MidLayer1 w4: v1@-144.72,4110.28 cw(c-177.83,4077.17) -131,4077.17 ; -144.32,3879.72 -163.13,3898.53 ; -142.7,3878.47 -130.48,3866.24 -130.48,3695.84 -271.97,3554.35 ; v1@-141.89,4113.11 cw(c-168.18,4086.82) -131,4086.82 ; v1@-139.06,4115.94 cw(c-158.52,4096.48) -131,4096.48 ; v1@-136.23,4118.77 cw(c-148.86,4106.14) -131,4106.14 ; -134.25,3892.28 -149.48,3907.5 -149.48,4026.03 -117.34,4058.16 ; -132.64,3891.03 -116.82,3875.22 ; -124.52,4117.61 v1@-128.66,4113.47 ; -124.52,4120.31 cw(c-115,4135) -97.5,4135 cw(c-115,4135) -108.52,4118.74 -108.52,4114.29 ; v1@-61.72,3763.28 cw(c-104.94,3720.06) -43.81,3720.06 ; v1@-58.89,3766.11 cw(c-95.28,3729.72) -43.81,3729.72 ; v1@-56.06,3768.94 cw(c-85.63,3739.37) -43.81,3739.37 ; v1@-53.23,3771.77 cw(c-75.97,3749.03) -43.81,3749.03 ; v1@-50.4,3774.6 cw(c-66.31,3758.69) -43.81,3758.69 ; 721.69,2862 663.72,2862 ; 723.02,2860.66 723.02,2662.39 ; 790.92,358.84 cw(c815.82,358.84) v1@804.98,381.26 ; 790.92,365.22 cw(c812.74,365.22) v1@803.24,384.86 ; 790.92,371.59 cw(c809.66,371.59) v1@801.5,388.46 ; 790.92,377.97 cw(c806.58,377.97) v1@799.76,392.06 ; 790.92,399.67 ccw(c803.67,399.67) v1@800.16,387.41 ; 790.92,404.98 ccw(c805.2,404.98) v1@801.26,391.25 ; 790.92,410.28 ccw(c806.72,410.28) v1@802.37,395.1 ; v1@803.47,398.94 cw(c808.24,415.59) 790.92,415.59 ; v1@1009.14,375.94 ccw(c1009.11,385.91) 1019.08,385.91 ; v1@1009.13,379.94 ccw(c1009.1,389.92) 1019.08,389.92 ; v1@1009.12,383.94 ccw(c1009.08,393.94) 1019.08,393.94 ; v1@1009.16,371.94 ccw(c1009.12,381.9) 1019.08,381.9 ; 1094.07,359.39 cw(c1109.48,359.39) v10@1108.25,374.75 ; 1094.07,363.72 cw(c1109.13,363.72) v10@1107.93,378.73 ; 1094.07,368.05 cw(c1108.79,368.05) v10@1107.61,382.72 ; 1094.07,372.39 cw(c1108.44,372.39) v10@1107.3,386.71 ; 1094.07,376.72 cw(c1108.09,376.72) v10@1106.98,390.7 ; v10@1104.81,395.41 ccw(c1100.24,415.59) 1120.93,415.59 ; v10@1105.7,391.51 ccw(c1101.37,410.58) 1120.93,410.58 ; v10@1106.58,387.61 ccw(c1102.51,405.57) 1120.93,405.57 ; v10@1107.4,374.72 cw(c1107.13,360.92) 1120.93,360.92 ; v10@1107.48,378.72 cw(c1107.21,365) 1120.93,365 ; v10@1107.46,383.71 ccw(c1103.64,400.57) 1120.93,400.57 ; v10@1107.56,382.72 cw(c1107.29,369.09) 1120.93,369.09 ; v10@1107.64,386.72 cw(c1107.37,373.17) 1120.93,373.17 ; v10@1107.73,390.72 cw(c1107.46,377.25) 1120.93,377.25 ; v10@1108.35,379.81 ccw(c1104.78,395.56) 1120.93,395.56 ; v10@1109.23,375.91 ccw(c1105.91,390.55) 1120.93,390.55 ; v1@1110.99,214.52 ccw(c1110.96,224.49) 1120.93,224.49 ; v1@1110.98,218.52 ccw(c1110.95,228.51) 1120.93,228.51 ; v1@1110.97,222.52 ccw(c1110.93,232.52) 1120.93,232.52 ; v1@1111.01,210.52 ccw(c1110.97,220.48) 1120.93,220.48 ; 1195.92,199.21 cw(c1207.92,199.21) v1@1206.5,211.12 ; 1195.92,203.71 cw(c1207.38,203.71) v1@1206.03,215.09 ; 1195.92,208.22 cw(c1206.85,208.22) v1@1205.56,219.07 ; 1195.92,358.84 cw(c1220.82,358.84) v1@1209.98,381.26 ; 1195.92,365.22 cw(c1217.74,365.22) v1@1208.24,384.86 ; 1195.92,371.59 cw(c1214.66,371.59) v1@1206.5,388.46 ; 1195.92,377.97 cw(c1211.58,377.97) v1@1204.76,392.06 ; 1195.92,399.67 ccw(c1208.67,399.67) v1@1205.16,387.41 ; 1195.92,404.98 ccw(c1210.2,404.98) v1@1206.26,391.25 ; 1195.92,410.28 ccw(c1211.72,410.28) v1@1207.37,395.1 ; v1@1208.47,398.94 cw(c1213.24,415.59) 1195.92,415.59 ; v1@1414.14,261.77 ccw(c1414.11,271.74) 1424.08,271.74 ; v1@1414.13,265.77 ccw(c1414.1,275.75) 1424.08,275.75 ; v1@1414.12,269.77 ccw(c1414.08,279.76) 1424.08,279.76 ; v1@1414.14,375.94 ccw(c1414.11,385.91) 1424.08,385.91 ; v1@1414.13,379.94 ccw(c1414.1,389.92) 1424.08,389.92 ; v1@1414.12,383.94 ccw(c1414.08,393.94) 1424.08,393.94 ; v1@1414.16,257.77 ccw(c1414.12,267.72) 1424.08,267.72 ; v1@1414.16,371.94 ccw(c1414.12,381.9) 1424.08,381.9 ; 1499.07,246.45 cw(c1511.07,246.45) v1@1509.65,258.37 ; 1499.07,250.96 cw(c1510.53,250.96) v1@1509.18,262.34 ; 1499.07,255.46 cw(c1510,255.46) v1@1508.7,266.31 ; 1499.07,359.39 cw(c1514.48,359.39) v10@1513.25,374.75 ; 1499.07,363.72 cw(c1514.13,363.72) v10@1512.93,378.73 ; 1499.07,368.05 cw(c1513.79,368.05) v10@1512.61,382.72 ; 1499.07,372.39 cw(c1513.44,372.39) v10@1512.3,386.71 ; 1499.07,376.72 cw(c1513.09,376.72) v10@1511.98,390.7 ; 1507.9,1050.79 1151.69,1407 1060,1407 ; 1507.9,1050.78 1555.43,1003.26 1555.43,452.22 ccw(c1563.43,415.59) 1525.93,415.59 ; v10@1509.81,395.41 ccw(c1505.24,415.59) 1525.93,415.59 ; v10@1510.7,391.51 ccw(c1506.37,410.58) 1525.93,410.58 ; v10@1511.58,387.61 ccw(c1507.51,405.57) 1525.93,405.57 ; v10@1512.4,374.72 cw(c1512.13,360.92) 1525.93,360.92 ; v10@1512.48,378.72 cw(c1512.21,365) 1525.93,365 ; v10@1512.46,383.71 ccw(c1508.64,400.57) 1525.93,400.57 ; v10@1512.56,382.72 cw(c1512.29,369.09) 1525.93,369.09 ; v10@1512.64,386.72 cw(c1512.37,373.17) 1525.93,373.17 ; v10@1512.73,390.72 cw(c1512.46,377.25) 1525.93,377.25 ; v10@1513.35,379.81 ccw(c1509.78,395.56) 1525.93,395.56 ; v10@1514.23,375.91 ccw(c1510.91,390.55) 1525.93,390.55 ; 1600.92,358.84 cw(c1625.82,358.84) v1@1614.98,381.26 ; 1600.92,365.22 cw(c1622.74,365.22) v1@1613.24,384.86 ; 1600.92,371.59 cw(c1619.66,371.59) v1@1611.5,388.46 ; 1600.92,377.97 cw(c1616.58,377.97) v1@1609.76,392.06 ; 1600.92,399.67 ccw(c1613.67,399.67) v1@1610.16,387.41 ; 1600.92,404.98 ccw(c1615.2,404.98) v1@1611.26,391.25 ; 1600.92,410.28 ccw(c1616.72,410.28) v1@1612.37,395.1 ; v1@1613.47,398.94 cw(c1618.24,415.59) 1600.92,415.59 ; 1731.36,3186.7 cw(c1715.19,3180) 1732.69,3180 cw(c1715.19,3180) 1715.52,3197.5 1715.52,4408.16 1691.69,4432 1345.56,4432 ; 1731.52,3188.33 1731.52,4411.48 ; v1@1819.14,375.94 ccw(c1819.11,385.91) 1829.08,385.91 ; v1@1819.13,379.94 ccw(c1819.1,389.92) 1829.08,389.92 ; v1@1819.12,383.94 ccw(c1819.08,393.94) 1829.08,393.94 ; v1@1819.16,371.94 ccw(c1819.12,381.9) 1829.08,381.9 ; 1904.07,359.39 cw(c1919.48,359.39) v10@1918.25,374.75 ; 1904.07,363.72 cw(c1919.13,363.72) v10@1917.93,378.73 ; 1904.07,368.05 cw(c1918.79,368.05) v10@1917.61,382.72 ; 1904.07,372.39 cw(c1918.44,372.39) v10@1917.3,386.71 ; 1904.07,376.72 cw(c1918.09,376.72) v10@1916.98,390.7 ; v10@1914.81,395.41 ccw(c1910.24,415.59) 1930.93,415.59 ; v10@1915.7,391.51 ccw(c1911.37,410.58) 1930.93,410.58 ; v10@1916.58,387.61 ccw(c1912.51,405.57) 1930.93,405.57 ; v10@1917.4,374.72 cw(c1917.13,360.92) 1930.93,360.92 ; v10@1917.48,378.72 cw(c1917.21,365) 1930.93,365 ; v10@1917.46,383.71 ccw(c1913.64,400.57) 1930.93,400.57 ; v10@1917.56,382.72 cw(c1917.29,369.09) 1930.93,369.09 ; v10@1917.64,386.72 cw(c1917.37,373.17) 1930.93,373.17 ; v10@1917.73,390.72 cw(c1917.46,377.25) 1930.93,377.25 ; v10@1918.35,379.81 ccw(c1914.78,395.56) 1930.93,395.56 ; v10@1919.23,375.91 ccw(c1915.91,390.55) 1930.93,390.55 ; v1@1920.99,214.52 ccw(c1920.96,224.49) 1930.93,224.49 ; v1@1920.98,218.52 ccw(c1920.95,228.51) 1930.93,228.51 ; v1@1920.97,222.52 ccw(c1920.93,232.52) 1930.93,232.52 ; v1@1921.01,210.52 ccw(c1920.97,220.48) 1930.93,220.48 ; 2005.92,199.21 cw(c2017.92,199.21) v1@2016.5,211.12 ; 2005.92,203.71 cw(c2017.38,203.71) v1@2016.03,215.09 ; 2005.92,208.22 cw(c2016.85,208.22) v1@2015.56,219.07 ; 2005.92,358.84 cw(c2030.82,358.84) v1@2019.98,381.26 ; 2005.92,365.22 cw(c2027.74,365.22) v1@2018.24,384.86 ; 2005.92,371.59 cw(c2024.66,371.59) v1@2016.5,388.46 ; 2005.92,377.97 cw(c2021.58,377.97) v1@2014.76,392.06 ; 2005.92,399.67 ccw(c2018.67,399.67) v1@2015.16,387.41 ; 2005.92,404.98 ccw(c2020.2,404.98) v1@2016.26,391.25 ; 2005.92,410.28 ccw(c2021.72,410.28) v1@2017.37,395.1 ; v1@2018.47,398.94 cw(c2023.24,415.59) 2005.92,415.59 ; v1@2224.14,261.77 ccw(c2224.11,271.74) 2234.08,271.74 ; v1@2224.13,265.77 ccw(c2224.1,275.75) 2234.08,275.75 ; v1@2224.12,269.77 ccw(c2224.08,279.76) 2234.08,279.76 ; v1@2224.14,375.94 ccw(c2224.11,385.91) 2234.08,385.91 ; v1@2224.13,379.94 ccw(c2224.1,389.92) 2234.08,389.92 ; v1@2224.12,383.94 ccw(c2224.08,393.94) 2234.08,393.94 ; v1@2224.16,257.77 ccw(c2224.12,267.72) 2234.08,267.72 ; v1@2224.16,371.94 ccw(c2224.12,381.9) 2234.08,381.9 ; 2309.07,360.63 cw(c2321.07,360.63) v1@2319.65,372.54 ; 2309.07,365.13 cw(c2320.53,365.13) v1@2319.18,376.51 ; 2309.07,369.63 cw(c2320,369.63) v1@2318.7,380.48 ; -768,2330 ccw(c-760,2330) -765.66,2324.34 ; -768,2330 ccw(c-760,2330) -765.66,2324.34 ; -768,2330 -768,3595 ; -768,3595 cw(c-760,3595) -765.66,3600.66 ; -768,3595 cw(c-760,3595) -765.66,3600.66 ; -765.66,2324.34 -733.66,2292.34 ; -765.66,3600.66 -696.66,3669.65 cw(c-680,3675) -662.5,3675 cw(c-680,3675) -685.35,3658.34 -752,3591.69 -752,2333.31 -724.69,2306 -568,2306 ; -733.66,2292.34 ccw(c-728,2298) -728,2290 ; -733.66,2292.34 ccw(c-728,2298) -728,2290 ; -728,2290 -571.31,2290 -565.02,2283.7 -565.02,1810 ; -568,2306 cw(c-568,2298) -562.34,2303.66 ; -568,2306 cw(c-568,2298) -562.34,2303.66 ; -565.02,1810 ccw(c-557.02,1810) -562.67,1804.34 ; -565.02,1810 ccw(c-557.02,1810) -562.67,1804.34 ; -562.67,1804.34 -517.67,1759.34 ; -562.34,2303.66 -551.36,2292.67 ; -551.36,2292.67 cw(c-557.02,2287.02) -549.02,2287.02 ; -551.36,2292.67 cw(c-557.02,2287.02) -549.02,2287.02 ; -549.02,2287.02 -549.02,1813.31 -508.7,1773 -225,1773 ; -525.69,2499.07 ccw(c-517.69,2499.07) -523.35,2493.41 ; -525.69,2499.07 ccw(c-517.69,2499.07) -523.35,2493.41 ; -525.69,2499.07 -525.69,3032.31 ; -525.69,3032.31 cw(c-517.69,3032.31) -523.35,3037.97 ; -525.69,3032.31 cw(c-517.69,3032.31) -523.35,3037.97 ; -523.35,2493.41 -355.99,2326.06 ; -523.35,3037.97 -498,3063.31 -498,3206.26 ; -517.67,1759.34 ccw(c-512.02,1765) -512.02,1757 ; -517.67,1759.34 ccw(c-512.02,1765) -512.02,1757 ; -512.02,1757 -228.31,1757 -188.09,1716.78 -188.09,1570.09 ; -498,3206.26 cw(c-490,3206.26) -495.66,3211.92 ; -498,3206.26 cw(c-490,3206.26) -495.66,3211.92 ; -495.66,3211.92 -309.31,3398.26 -309.31,3570 ; -484.34,3054.34 ccw(c-490,3060) -482,3060 ; -484.34,3054.34 ccw(c-490,3060) -482,3060 ; -484.34,3054.34 -509.69,3029 -509.69,2502.38 -347.02,2339.71 -321.71,2339.71 ; -482,3060 -482,3202.94 -295.65,3389.29 ; -411.48,4659.54 ccw(c-403.48,4659.54) -409.13,4653.89 ; -411.48,4659.54 ccw(c-403.48,4659.54) -409.13,4653.89 ; -411.48,4659.54 ccw(c-403.48,4659.54) -409.14,4653.89 ; -411.48,4659.54 -411.48,4766.49 ; -411.48,4766.49 cw(c-403.48,4766.49) -409.13,4772.15 ; -411.48,4766.49 cw(c-403.48,4766.49) -409.13,4772.15 ; -409.13,4653.88 -335.12,4579.88 -335.12,4501.19 -400.66,4435.66 ; -409.13,4772.15 -305.14,4876.14 -305.14,4908.83 -314.65,4918.34 cw(c-320,4935) -302.5,4935 cw(c-320,4935) -303.34,4929.65 -291.49,4917.8 ; -403,4335.23 ccw(c-395,4335.23) -400.66,4329.58 ; -403,4335.23 ccw(c-395,4335.23) -400.66,4329.58 ; -403,4335.23 -403,4430 ; -403,4430 cw(c-395,4430) -400.66,4435.66 ; -403,4430 cw(c-395,4430) -400.66,4435.66 ; -400.66,4329.58 -384.81,4313.72 ccw(c-368.14,4308.37) -350.64,4308.37 ccw(c-368.14,4308.37) -373.49,4325.04 -387,4338.55 -387,4426.69 -321.47,4492.22 ; -355.99,2326.06 ccw(c-350.34,2331.71) -350.34,2323.71 ; -355.99,2326.06 ccw(c-350.34,2331.71) -350.34,2323.71 ; -350.34,2323.71 -325.03,2323.71 -86.57,2085.26 ccw(c-80.92,2090.92) -80.9,2082.92 165.77,2082.92 222,2026.69 222,1300.56 ccw(c230,1285) 247.5,1285 ccw(c230,1285) 238,1300.56 238,2030 ; -321.71,2339.71 cw(c-321.71,2331.71) -316.06,2337.37 ; -321.71,2339.71 cw(c-321.71,2331.71) -316.06,2337.37 ; -321.47,4492.22 ccw(c-327.12,4497.88) -319.12,4497.88 ; -321.47,4492.22 ccw(c-327.12,4497.88) -319.12,4497.88 ; -321.47,4588.85 cw(c-327.12,4583.19) -319.12,4583.19 ; -321.47,4588.85 cw(c-327.12,4583.19) -319.12,4583.19 ; -321.47,4588.85 -395.48,4662.86 -395.48,4763.18 -291.49,4867.17 ; -319.12,4497.88 -319.12,4583.19 ; -316.06,2337.37 -77.6,2098.92 169.08,2098.92 ; -314.98,4969.35 ccw(c-306.98,4969.35) -312.63,4963.7 ; -314.98,4969.35 ccw(c-306.98,4969.35) -312.63,4963.7 ; -314.98,4969.35 -314.98,5008.02 ; -314.98,5008.02 cw(c-306.98,5008.02) -312.63,5013.68 ; -314.98,5008.02 cw(c-306.98,5008.02) -312.63,5013.68 ; -312.63,4963.69 -278.14,4929.21 -278.14,4884.01 ; -312.63,5013.68 -281.66,5044.65 cw(c-265,5050) -247.5,5050 cw(c-265,5050) -270.35,5033.34 -298.98,5004.71 -298.98,4972.67 -264.49,4938.18 ; -309.31,3570 cw(c-301.31,3570) -306.97,3575.66 ; -309.31,3570 cw(c-301.31,3570) -306.97,3575.66 ; -306.97,3575.66 -193,3689.62 -193,3821.69 -223.8,3852.49 ; -301.14,3353.62 cw(c-293.14,3353.62) -298.8,3359.27 ; -301.14,3353.62 cw(c-293.14,3353.62) -298.8,3359.27 ; -301.14,3353.62 -301.14,3281.27 ccw(c-293.14,3265.71) -275.64,3265.71 ccw(c-293.14,3265.71) -285.14,3281.27 -285.14,3350.3 -260.65,3374.79 ; -298.8,3359.27 -274.31,3383.76 -274.31,3548.69 ; -295.65,3389.29 ccw(c-301.31,3394.95) -293.31,3394.95 ; -295.65,3389.29 ccw(c-301.31,3394.95) -293.31,3394.95 ; -293.31,3394.95 -293.31,3566.69 -179.34,3680.65 ; -291.49,4867.17 ccw(c-297.14,4872.82) -289.14,4872.82 ; -291.49,4867.17 ccw(c-297.14,4872.82) -289.14,4872.82 ; -291.49,4917.8 cw(c-297.14,4912.14) -289.14,4912.14 ; -291.49,4917.8 cw(c-297.14,4912.14) -289.14,4912.14 ; -289.14,4872.82 -289.14,4912.14 ; -278.14,4884.01 ccw(c-270.14,4884.01) -275.8,4878.35 ; -278.14,4884.01 ccw(c-270.14,4884.01) -275.8,4878.35 ; -275.8,4878.35 -188,4790.55 -188,4475.56 ccw(c-180,4460) -162.5,4460 ccw(c-180,4460) -172,4475.56 -172,4793.86 ; -274.31,3548.69 cw(c-266.31,3548.69) -271.97,3554.35 ; -274.31,3548.69 cw(c-266.31,3548.69) -271.97,3554.35 ; -264.49,4938.18 cw(c-270.14,4932.52) -262.14,4932.52 ; -264.49,4938.18 cw(c-270.14,4932.52) -262.14,4932.52 ; -262.14,4932.52 -262.14,4887.32 -174.34,4799.52 ; -260.65,3374.79 ccw(c-266.31,3380.45) -258.31,3380.45 ; -260.65,3374.79 ccw(c-266.31,3380.45) -258.31,3380.45 ; -258.31,3380.45 -258.31,3545.38 -116.82,3686.87 ; -243,4887.05 ccw(c-235,4887.05) -240.66,4881.39 ; -243,4887.05 ccw(c-235,4887.05) -240.66,4881.39 ; -243,4887.05 -243,4909.44 cw(c-235,4925) -217.5,4925 cw(c-235,4925) -227,4909.44 -227,4890.36 -190.16,4853.52 -162.79,4853.52 -109.48,4906.84 -109.48,4996.69 -132.13,5019.34 ; -240.66,4881.39 -199.13,4839.86 ; -226.14,3858.14 ccw(c-218.14,3858.14) -223.8,3852.49 ; -226.14,3858.14 ccw(c-218.14,3858.14) -223.8,3852.49 ; -226.14,3858.14 -226.14,4033.36 ; -226.14,4033.36 cw(c-218.14,4033.36) -223.8,4039.01 ; -226.14,4033.36 cw(c-218.14,4033.36) -223.8,4039.01 ; -225,1773 cw(c-225,1765) -219.34,1770.66 ; -225,1773 cw(c-225,1765) -219.34,1770.66 ; -223.8,4039.01 -173.16,4089.65 cw(c-156.5,4095) -139,4095 cw(c-156.5,4095) -161.85,4078.34 -210.14,4030.04 -210.14,3861.46 -179.34,3830.66 ; -219.34,1770.66 -174.44,1725.75 ; -199.13,4839.86 ccw(c-193.47,4845.52) -193.47,4837.52 ; -199.13,4839.86 ccw(c-193.47,4845.52) -193.47,4837.52 ; -193.47,4837.52 -159.48,4837.52 ; -188.09,1570.09 ccw(c-180.09,1570.09) -185.75,1564.44 ; -188.09,1570.09 ccw(c-180.09,1570.09) -185.75,1564.44 ; -185.75,1564.44 32.19,1346.5 32.19,873.94 ccw(c40.19,858.37) 57.69,858.37 ccw(c40.19,858.37) 48.19,873.94 48.19,1349.81 ; -179.34,3680.65 ccw(c-185,3686.31) -177,3686.31 ; -179.34,3680.65 ccw(c-185,3686.31) -177,3686.31 ; -179.34,3830.66 cw(c-185,3825) -177,3825 ; -179.34,3830.66 cw(c-185,3825) -177,3825 ; -177,3686.31 -177,3825 ; -174.44,1725.75 cw(c-180.09,1720.09) -172.09,1720.09 ; -174.44,1725.75 cw(c-180.09,1720.09) -172.09,1720.09 ; -174.34,4799.52 cw(c-180,4793.86) -172,4793.86 ; -174.34,4799.52 cw(c-180,4793.86) -172,4793.86 ; -172.09,1720.09 -172.09,1573.41 45.85,1355.47 ; -165.48,3904.19 ccw(c-157.48,3904.19) -163.13,3898.53 ; -165.48,3904.19 ccw(c-157.48,3904.19) -163.13,3898.53 ; -165.48,3904.19 -165.48,4029.34 ; -165.48,4029.34 cw(c-157.48,4029.34) -163.13,4035 ; -165.48,4029.34 cw(c-157.48,4029.34) -163.13,4035 ; -163.13,4035 -131,4067.13 -131,4107.81 ; -159.48,4837.52 ccw(c-159.48,4845.52) -153.82,4839.86 ; -159.48,4837.52 ccw(c-159.48,4845.52) -153.82,4839.86 ; -153.82,4839.86 -95.82,4897.87 ; -134.48,5025 ccw(c-126.48,5025) -132.13,5019.34 ; -134.48,5025 ccw(c-126.48,5025) -132.13,5019.34 ; -134.48,5025 -134.48,5090.29 cw(c-125,5105) -107.5,5105 cw(c-125,5105) -118.48,5088.76 -118.48,5028.31 -95.82,5005.66 ; -131,4107.81 cw(c-123,4107.81) v1@-128.66,4113.47 ; -131,4107.81 cw(c-123,4107.81) v1@-128.66,4113.47 ; -117.34,4058.16 ccw(c-123,4063.82) -115,4063.82 ; -117.34,4058.16 ccw(c-123,4063.82) -115,4063.82 ; -116.82,3686.87 ccw(c-122.48,3692.52) -114.48,3692.52 ; -116.82,3686.87 ccw(c-122.48,3692.52) -114.48,3692.52 ; -116.82,3875.22 cw(c-122.48,3869.56) -114.48,3869.56 ; -116.82,3875.22 cw(c-122.48,3869.56) -114.48,3869.56 ; -115,4063.82 -115,4104.5 -110.86,4108.64 ; -114.48,3692.52 -114.48,3869.56 ; -110.86,4108.64 ccw(c-116.52,4114.29) -108.52,4114.29 ; -110.86,4108.64 ccw(c-116.52,4114.29) -108.52,4114.29 ; -95.82,4897.87 ccw(c-101.48,4903.52) -93.48,4903.52 ; -95.82,4897.87 ccw(c-101.48,4903.52) -93.48,4903.52 ; -95.82,5005.66 cw(c-101.48,5000) -93.48,5000 ; -95.82,5005.66 cw(c-101.48,5000) -93.48,5000 ; -93.48,4903.52 -93.48,5000 ; -77.25,3214.25 ccw(c-69.25,3214.25) -74.91,3208.6 ; -77.25,3214.25 ccw(c-69.25,3214.25) -74.91,3208.6 ; -77.25,3214.25 -77.25,3310.75 ; -77.25,3310.75 cw(c-69.25,3310.75) -74.91,3316.4 ; -77.25,3310.75 cw(c-69.25,3310.75) -74.91,3316.4 ; -74.91,3208.6 -43.35,3177.03 ; -74.91,3316.4 -43.81,3347.5 -43.81,3774.88 cw(c-35,3790) -17.5,3790 cw(c-35,3790) -27.81,3774.04 -27.81,3344.19 ; -53,4035 ccw(c-45,4035) -50.66,4029.34 ; -53,4035 ccw(c-45,4035) -50.66,4029.34 ; -53,4035 -53,4085 ; -53,4085 cw(c-45,4085) -50.66,4090.66 ; -53,4085 cw(c-45,4085) -50.66,4090.66 ; -50.66,4029.34 -33,4011.69 -33,3948.31 -44.65,3936.66 ccw(c-50,3920) -32.5,3920 ccw(c-50,3920) -33.34,3925.35 -19.34,3939.34 ; -50.66,4090.66 114.69,4256 114.69,4297.44 ; -43.35,3177.03 ccw(c-37.69,3182.69) -37.69,3174.69 ; -43.35,3177.03 ccw(c-37.69,3182.69) -37.69,3174.69 ; -40.5,2421.4 ccw(c-32.5,2421.4) -38.16,2415.74 ; -40.5,2421.4 ccw(c-32.5,2421.4) -38.16,2415.74 ; -40.5,2421.4 -40.5,2635.68 ; -40.5,2635.68 cw(c-32.5,2635.68) -38.16,2641.34 ; -40.5,2635.68 cw(c-32.5,2635.68) -38.16,2641.34 ; -38.16,2415.74 3.53,2374.06 ccw(c20.19,2368.71) 37.69,2368.71 ccw(c20.19,2368.71) 14.84,2385.37 -24.5,2424.71 -24.5,2632.37 -15.16,2641.71 ccw(c-9.81,2658.37) 7.69,2658.37 ccw(c-9.81,2658.37) -26.47,2653.03 -38.16,2641.34 ; -37.69,3174.69 59,3174.69 82.19,3151.5 82.19,2870.71 ; -30.16,3338.53 ccw(c-35.81,3344.19) -27.81,3344.19 ; -30.16,3338.53 ccw(c-35.81,3344.19) -27.81,3344.19 ; -30.16,3338.53 -61.25,3307.43 -61.25,3217.57 -34.38,3190.69 62.31,3190.69 ; -26.14,2813.14 ccw(c-18.14,2813.14) -23.8,2807.49 ; -26.14,2813.14 ccw(c-18.14,2813.14) -23.8,2807.49 ; -26.14,2813.14 -26.14,2886.14 cw(c-18.14,2901.71) -0.64,2901.71 cw(c-18.14,2901.71) -10.14,2886.14 -10.14,2816.46 53.31,2753 270.04,2753 ; -23.8,2807.49 44.34,2739.34 ; -19.34,3939.34 ccw(c-25,3945) -17,3945 ; -19.34,3939.34 ccw(c-25,3945) -17,3945 ; -19.34,4020.66 cw(c-25,4015) -17,4015 ; -19.34,4020.66 cw(c-25,4015) -17,4015 ; -19.34,4020.66 -37,4038.31 -37,4081.69 128.35,4247.03 ; -17,3945 -17,4015 ; 44.34,2739.34 ccw(c50,2745) 50,2737 ; 44.34,2739.34 ccw(c50,2745) 50,2737 ; 45.85,1355.47 cw(c40.19,1349.81) 48.19,1349.81 ; 45.85,1355.47 cw(c40.19,1349.81) 48.19,1349.81 ; 50,2737 266.73,2737 284.34,2719.38 ; 62.31,3190.69 cw(c62.31,3182.69) 67.97,3188.35 ; 62.31,3190.69 cw(c62.31,3182.69) 67.97,3188.35 ; 65.52,4995.19 ccw(c73.52,4995.19) 67.87,4989.53 ; 65.52,4995.19 ccw(c73.52,4995.19) 67.87,4989.53 ; 65.52,4995.19 65.52,5009.48 cw(c73.52,5025.04) 91.02,5025.04 cw(c73.52,5025.04) 81.52,5009.48 81.52,4998.5 225.66,4854.37 ; 67.87,4989.53 212,4845.4 212,4645 ; 67.97,3188.35 95.85,3160.47 ; 82.19,2870.71 ccw(c90.19,2870.71) 84.53,2865.05 ; 82.19,2870.71 ccw(c90.19,2870.71) 84.53,2865.05 ; 84.53,2865.05 144.19,2805.39 ccw(c160.86,2800.04) 178.36,2800.04 ccw(c160.86,2800.04) 155.51,2816.7 98.19,2874.02 98.19,3154.81 ; 95.85,3160.47 cw(c90.19,3154.81) 98.19,3154.81 ; 95.85,3160.47 cw(c90.19,3154.81) 98.19,3154.81 ; 114.69,4297.44 cw(c122.69,4297.44) 117.03,4303.1 ; 114.69,4297.44 cw(c122.69,4297.44) 117.03,4303.1 ; 117.03,4303.1 242,4428.06 242,4611.69 214.34,4639.34 ; 128.35,4247.03 ccw(c122.69,4252.69) 130.69,4252.69 ; 128.35,4247.03 ccw(c122.69,4252.69) 130.69,4252.69 ; 130.69,4252.69 130.69,4294.13 255.66,4419.09 ; 158.48,2147.71 cw(c158.48,2139.71) 164.13,2145.36 ; 158.48,2147.71 cw(c158.48,2139.71) 164.13,2145.36 ; 158.48,2147.71 -58.91,2147.71 ccw(c-74.48,2139.71) -58.91,2131.71 155.16,2131.71 557,1729.87 557,855 ; 164.13,2145.36 570.66,1738.84 ; 169.08,2098.92 cw(c169.08,2090.92) 174.74,2096.57 ; 169.08,2098.92 cw(c169.08,2090.92) 174.74,2096.57 ; 174.74,2096.57 235.66,2035.66 ; 212,4645 ccw(c220,4645) 214.34,4639.34 ; 212,4645 ccw(c220,4645) 214.34,4639.34 ; 225.66,4854.37 cw(c220,4848.71) 228,4848.71 ; 225.66,4854.37 cw(c220,4848.71) 228,4848.71 ; 228,4848.71 228,4648.31 255.66,4620.66 ; 235.66,2035.66 cw(c230,2030) 238,2030 ; 235.66,2035.66 cw(c230,2030) 238,2030 ; 255.66,4419.09 ccw(c250,4424.75) 258,4424.75 ; 255.66,4419.09 ccw(c250,4424.75) 258,4424.75 ; 255.66,4620.66 cw(c250,4615) 258,4615 ; 255.66,4620.66 cw(c250,4615) 258,4615 ; 258,4424.75 258,4615 ; 270.04,2753 cw(c270.04,2745) 275.7,2750.66 ; 270.04,2753 cw(c270.04,2745) 275.7,2750.66 ; 275.7,2750.66 293.31,2733.04 674.63,2733.04 cw(c690.19,2725.04) 707.69,2725.04 cw(c690.19,2725.04) 684.84,2708.38 653,2676.54 653,2584.34 686.68,2550.66 ; 281.82,4958.04 cw(c281.82,4950.04) 287.47,4955.7 ; 281.82,4958.04 cw(c281.82,4950.04) 287.47,4955.7 ; 281.82,4958.04 197.42,4958.04 ccw(c181.86,4950.04) 197.42,4942.04 278.5,4942.04 312,4908.54 312,4782.05 ; 284.34,2719.38 ccw(c290,2725.04) 290,2717.04 ; 284.34,2719.38 ccw(c290,2725.04) 290,2717.04 ; 287.47,4955.7 325.66,4917.51 ; 290,2717.04 670.88,2717.04 639.34,2685.51 ; 312,4782.05 ccw(c320,4782.05) 314.34,4776.39 ; 312,4782.05 ccw(c320,4782.05) 314.34,4776.39 ; 314.34,4776.39 322,4768.73 322,4690.56 ccw(c330,4675) 347.5,4675 ccw(c330,4675) 338,4690.56 338,4772.05 ; 315,5023 cw(c315,5015) 320.66,5020.66 ; 315,5023 cw(c315,5015) 320.66,5020.66 ; 315,5023 255.56,5023 ccw(c240,5015) 255.56,5007 311.69,5007 377,4941.69 377,4638.31 356.69,4618 335.56,4618 ccw(c320,4610) 335.56,4602 360,4602 ; 320.66,5020.66 390.66,4950.66 ; 325.66,4917.51 cw(c320,4911.86) 328,4911.86 ; 325.66,4917.51 cw(c320,4911.86) 328,4911.86 ; 328,4911.86 328,4785.36 335.66,4777.71 ; 335.66,4777.71 cw(c330,4772.05) 338,4772.05 ; 335.66,4777.71 cw(c330,4772.05) 338,4772.05 ; 360,4602 ccw(c360,4610) 365.66,4604.34 ; 360,4602 ccw(c360,4610) 365.66,4604.34 ; 365.66,4604.34 390.66,4629.34 ; 390.66,4629.34 ccw(c385,4635) 393,4635 ; 390.66,4629.34 ccw(c385,4635) 393,4635 ; 390.66,4950.66 cw(c385,4945) 393,4945 ; 390.66,4950.66 cw(c385,4945) 393,4945 ; 393,4635 393,4945 ; 547.11,2978.61 ccw(c555.11,2978.61) 549.45,2972.95 ; 547.11,2978.61 ccw(c555.11,2978.61) 549.45,2972.95 ; 547.11,2978.61 547.11,3182.48 ; 547.11,3182.48 cw(c555.11,3182.48) 549.45,3188.14 ; 547.11,3182.48 cw(c555.11,3182.48) 549.45,3188.14 ; 549.45,2972.95 658.06,2864.34 ; 549.45,3188.14 607.01,3245.7 ; 557,855 ccw(c565,855) 559.34,849.34 ; 557,855 ccw(c565,855) 559.34,849.34 ; 559.34,849.34 906.84,501.84 ; 570.66,1738.84 cw(c565,1733.18) 573,1733.18 ; 570.66,1738.84 cw(c565,1733.18) 573,1733.18 ; 573,1733.18 573,858.31 915.81,515.5 1127.5,515.5 ; 592,1065 ccw(c600,1065) 594.34,1059.34 ; 592,1065 ccw(c600,1065) 594.34,1059.34 ; 592,1065 592,2138.18 ; 592,2138.18 cw(c600,2138.18) 594.34,2143.84 ; 592,2138.18 cw(c600,2138.18) 594.34,2143.84 ; 594.34,1059.34 729.34,924.34 ; 594.34,2143.84 673.02,2222.52 673.02,2541.69 639.34,2575.37 ; 607.01,3245.7 cw(c612.67,3240.04) 612.67,3248.04 ; 607.01,3245.7 cw(c612.67,3240.04) 612.67,3248.04 ; 612.67,3248.04 781.73,3248.04 817,3283.31 817,4274.75 ; 619,1076.18 ccw(c627,1076.18) 621.34,1070.53 ; 619,1076.18 ccw(c627,1076.18) 621.34,1070.53 ; 619,1076.18 619,2127 ; 619,2127 cw(c627,2127) 621.34,2132.66 ; 619,2127 cw(c627,2127) 621.34,2132.66 ; 621.34,1070.53 705.82,986.05 ; 621.34,2132.66 700.02,2211.34 700.02,2518.02 ; 637,2581.02 ccw(c645,2581.02) 639.34,2575.37 ; 637,2581.02 ccw(c645,2581.02) 639.34,2575.37 ; 637,2581.02 637,2679.85 ; 637,2679.85 cw(c645,2679.85) 639.34,2685.51 ; 637,2679.85 cw(c645,2679.85) 639.34,2685.51 ; 646,1559 ccw(c654,1559) 648.34,1553.34 ; 646,1559 ccw(c654,1559) 648.34,1553.34 ; 646,1559 646,2115.82 ; 646,2115.82 cw(c654,2115.82) 648.34,2121.47 ; 646,2115.82 cw(c654,2115.82) 648.34,2121.47 ; 648.34,1553.34 657.34,1544.34 ; 648.34,2121.47 727.02,2200.15 727.02,2490 ; 657.34,1544.34 ccw(c663,1550) 663,1542 ; 657.34,1544.34 ccw(c663,1550) 663,1542 ; 658.06,2864.34 ccw(c663.72,2870) 663.72,2862 ; 658.06,2864.34 ccw(c663.72,2870) 663.72,2862 ; 663,1542 921.69,1542 1054.34,1409.34 ; 686.68,2213.55 ccw(c681.02,2219.21) 689.02,2219.21 ; 686.68,2213.55 ccw(c681.02,2219.21) 689.02,2219.21 ; 686.68,2213.55 608,2134.87 608,1068.31 738.31,938 1291.84,938 1340.19,986.36 cw(c1356.86,991.71) 1374.36,991.71 cw(c1356.86,991.71) 1351.51,975.05 1300.81,924.34 ; 686.68,2550.66 cw(c681.02,2545) 689.02,2545 ; 686.68,2550.66 cw(c681.02,2545) 689.02,2545 ; 689.02,2219.21 689.02,2545 ; 700.02,2518.02 cw(c708.02,2518.02) 702.37,2523.68 ; 700.02,2518.02 cw(c708.02,2518.02) 702.37,2523.68 ; 702.37,2523.68 748.34,2569.65 cw(c765,2575) 782.5,2575 cw(c765,2575) 759.65,2558.34 716.02,2514.71 716.02,2208.02 ; 705.82,986.05 ccw(c711.48,991.71) 711.48,983.71 ; 705.82,986.05 ccw(c711.48,991.71) 711.48,983.71 ; 711.48,983.71 1066.29,983.71 ccw(c1081.86,991.71) 1099.36,991.71 ccw(c1081.86,991.71) 1066.29,999.71 714.79,999.71 635,1079.5 635,2123.69 713.68,2202.37 ; 713.68,2202.37 ccw(c708.02,2208.02) 716.02,2208.02 ; 713.68,2202.37 ccw(c708.02,2208.02) 716.02,2208.02 ; 723.02,2662.39 ccw(c731.02,2662.39) 725.37,2656.73 ; 723.02,2662.39 ccw(c731.02,2662.39) 725.37,2656.73 ; 725,2878 cw(c725,2870) 730.66,2875.66 ; 725,2878 cw(c725,2870) 730.66,2875.66 ; 725,2878 667.03,2878 563.11,2981.92 563.11,3179.16 615.99,3232.04 785.04,3232.04 ; 725.37,2656.73 790.5,2591.6 790.5,2556.79 729.37,2495.66 ; 727.02,2490 cw(c735.02,2490) 729.37,2495.66 ; 727.02,2490 cw(c735.02,2490) 729.37,2495.66 ; 729.34,924.34 ccw(c735,930) 735,922 ; 729.34,924.34 ccw(c735,930) 735,922 ; 730.66,2875.66 736.68,2869.63 ; 735,922 1295.15,922 ; 736.68,2869.63 cw(c731.02,2863.98) 739.02,2863.98 ; 736.68,2869.63 cw(c731.02,2863.98) 739.02,2863.98 ; 739.02,2863.98 739.02,2665.71 804.16,2600.57 ; 740.68,2191.18 ccw(c735.02,2196.84) 743.02,2196.84 ; 740.68,2191.18 ccw(c735.02,2196.84) 743.02,2196.84 ; 740.68,2191.18 662,2112.5 662,1562.31 666.31,1558 925,1558 ; 743.02,2196.84 743.02,2486.69 804.16,2547.82 ; 785.04,3232.04 ccw(c785.04,3240.04) 790.7,3234.38 ; 785.04,3232.04 ccw(c785.04,3240.04) 790.7,3234.38 ; 790.7,3234.38 830.66,3274.34 ; 790.92,415.59 ccw(c753.43,415.59) 715.93,415.59 715.93,360.47 ccw(c753.43,360.47) 790.92,360.47 790.92,415.59 ; 804.16,2547.82 ccw(c798.5,2553.48) 806.5,2553.48 ; 804.16,2547.82 ccw(c798.5,2553.48) 806.5,2553.48 ; 804.16,2600.57 cw(c798.5,2594.92) 806.5,2594.92 ; 804.16,2600.57 cw(c798.5,2594.92) 806.5,2594.92 ; 806.5,2553.48 806.5,2594.92 ; 817,4274.75 cw(c825,4274.75) 819.34,4280.41 ; 817,4274.75 cw(c825,4274.75) 819.34,4280.41 ; 819.34,4280.41 852,4313.06 852,4526.69 831.69,4547 795.56,4547 cw(c780,4555) 795.56,4563 835,4563 ; 830.66,3274.34 ccw(c825,3280) 833,3280 ; 830.66,3274.34 ccw(c825,3280) 833,3280 ; 833,3280 833,4271.43 865.66,4304.09 ; 835,4563 cw(c835,4555) 840.66,4560.66 ; 835,4563 cw(c835,4555) 840.66,4560.66 ; 840.66,4560.66 865.66,4535.66 ; 865.66,4304.09 ccw(c860,4309.75) 868,4309.75 ; 865.66,4304.09 ccw(c860,4309.75) 868,4309.75 ; 865.66,4535.66 cw(c860,4530) 868,4530 ; 865.66,4535.66 cw(c860,4530) 868,4530 ; 868,4309.75 868,4530 ; 906.84,501.84 ccw(c912.5,507.5) 912.5,499.5 ; 906.84,501.84 ccw(c912.5,507.5) 912.5,499.5 ; 912.5,499.5 1124.19,499.5 1150.43,473.26 1150.43,452.22 ccw(c1158.43,415.59) 1120.93,415.59 ; 925,1558 cw(c925,1550) 930.66,1555.66 ; 925,1558 cw(c925,1550) 930.66,1555.66 ; 930.66,1555.66 1063.31,1423 1155,1423 ; 1019.08,393.94 cw(c1056.57,393.94) 1094.07,393.94 1094.07,358.5 cw(c1056.57,358.5) 1019.08,358.5 1019.08,393.94 ; 1054.34,1409.34 ccw(c1060,1415) 1060,1407 ; 1054.34,1409.34 ccw(c1060,1415) 1060,1407 ; 1120.93,232.52 cw(c1158.43,232.52) 1195.92,232.52 1195.92,197.09 cw(c1158.43,197.09) 1120.93,197.09 1120.93,232.52 ; 1120.93,415.59 1120.93,360.47 ccw(c1158.43,360.47) 1195.92,360.47 1195.92,415.59 ; 1127.5,515.5 cw(c1127.5,507.5) 1133.16,513.16 ; 1127.5,515.5 cw(c1127.5,507.5) 1133.16,513.16 ; 1133.16,513.16 1164.08,482.23 ; 1155,1423 cw(c1155,1415) 1160.66,1420.66 ; 1155,1423 cw(c1155,1415) 1160.66,1420.66 ; 1160.66,1420.66 1519.2,1062.11 1569.08,1012.23 ; 1164.08,482.23 cw(c1158.43,476.57) 1166.43,476.57 ; 1164.08,482.23 cw(c1158.43,476.57) 1166.43,476.57 ; 1166.43,476.57 1166.43,452.22 cw(c1158.43,415.59) 1195.92,415.59 ; 1295.15,922 ccw(c1295.15,930) 1300.81,924.34 ; 1295.15,922 ccw(c1295.15,930) 1300.81,924.34 ; 1339.91,4434.34 ccw(c1345.56,4440) 1345.56,4432 ; 1339.91,4434.34 ccw(c1345.56,4440) 1345.56,4432 ; 1339.91,4434.34 1155.21,4619.05 cw(c1149.86,4635.71) 1167.36,4635.71 cw(c1149.86,4635.71) 1166.52,4630.36 1348.88,4448 1695,4448 ; 1424.08,279.76 cw(c1461.57,279.76) 1499.07,279.76 1499.07,244.33 cw(c1461.57,244.33) 1424.08,244.33 1424.08,279.76 ; 1424.08,393.94 cw(c1461.57,393.94) 1499.07,393.94 1499.07,358.5 cw(c1461.57,358.5) 1424.08,358.5 1424.08,393.94 ; 1525.93,415.59 1525.93,360.47 ccw(c1563.43,360.47) 1600.92,360.47 1600.92,415.59 ; 1569.08,1012.23 cw(c1563.43,1006.57) 1571.43,1006.57 ; 1569.08,1012.23 cw(c1563.43,1006.57) 1571.43,1006.57 ; 1571.43,1006.57 1571.43,452.22 cw(c1563.43,415.59) 1600.92,415.59 ; 1695,4448 cw(c1695,4440) 1700.66,4445.66 ; 1695,4448 cw(c1695,4440) 1700.66,4445.66 ; 1700.66,4445.66 1729.18,4417.13 ; 1729.18,4417.13 cw(c1723.52,4411.48) 1731.52,4411.48 ; 1729.18,4417.13 cw(c1723.52,4411.48) 1731.52,4411.48 ; 1829.08,393.94 cw(c1866.57,393.94) 1904.07,393.94 1904.07,358.5 cw(c1866.57,358.5) 1829.08,358.5 1829.08,393.94 ; 1930.93,232.52 cw(c1968.43,232.52) 2005.92,232.52 2005.92,197.09 cw(c1968.43,197.09) 1930.93,197.09 1930.93,232.52 ; 1930.93,415.59 cw(c1968.43,415.59) 2005.92,415.59 ; 1930.93,415.59 1930.93,360.47 ccw(c1968.43,360.47) 2005.92,360.47 2005.92,415.59 ; 2234.08,279.76 cw(c2271.57,279.76) 2309.07,279.76 2309.07,244.33 cw(c2271.57,244.33) 2234.08,244.33 2234.08,279.76 ; 2234.08,393.94 cw(c2271.57,393.94) 2309.07,393.94 2309.07,358.5 cw(c2271.57,358.5) 2234.08,358.5 2234.08,393.94 ; -677.5,2380 cw(c-660,2380) -642.5,2380 cw(c-660,2380) -677.5,2380 ; -612.5,2345 cw(c-595,2345) -577.5,2345 cw(c-595,2345) -612.5,2345 ; -527.31,4625.04 cw(c-509.81,4625.04) -492.31,4625.04 cw(c-509.81,4625.04) -527.31,4625.04 ; -462.5,4795 cw(c-445,4795) -427.5,4795 cw(c-445,4795) -462.5,4795 ; -397.5,3940 cw(c-380,3940) -362.5,3940 cw(c-380,3940) -397.5,3940 ; -372.5,4020 cw(c-355,4020) -337.5,4020 cw(c-355,4020) -372.5,4020 ; -282.5,4980 cw(c-265,4980) -247.5,4980 cw(c-265,4980) -282.5,4980 ; -272.5,3670 cw(c-255,3670) -237.5,3670 cw(c-255,3670) -272.5,3670 ; -267.5,3760 cw(c-250,3760) -232.5,3760 cw(c-250,3760) -267.5,3760 ; -177.31,3559.86 cw(c-159.81,3559.86) -142.31,3559.86 cw(c-159.81,3559.86) -177.31,3559.86 ; -143.98,5216.71 cw(c-126.48,5216.71) -108.98,5216.71 cw(c-126.48,5216.71) -143.98,5216.71 ; -143.64,5267.04 cw(c-126.14,5267.04) -108.64,5267.04 cw(c-126.14,5267.04) -143.64,5267.04 ; 40.12,3408.23 cw(c76.12,3408.23) 112.12,3408.23 cw(c76.12,3408.23) 40.12,3408.23 ; 40.12,3508.23 cw(c76.12,3508.23) 112.12,3508.23 cw(c76.12,3508.23) 40.12,3508.23 ; 143.36,2891.71 cw(c160.86,2891.71) 178.36,2891.71 cw(c160.86,2891.71) 143.36,2891.71 ; 267.5,890 cw(c285,890) 302.5,890 cw(c285,890) 267.5,890 ; 337.5,1280 cw(c355,1280) 372.5,1280 cw(c355,1280) 337.5,1280 ; 512.5,3250 cw(c530,3250) 547.5,3250 cw(c530,3250) 512.5,3250 ; 1257.5,860 cw(c1275,860) 1292.5,860 cw(c1275,860) 1257.5,860 ; 1572.5,3000 cw(c1590,3000) 1607.5,3000 cw(c1590,3000) 1572.5,3000 ; 1607.5,2940 cw(c1625,2940) 1642.5,2940 cw(c1625,2940) 1607.5,2940 ; 1642.5,3270 cw(c1660,3270) 1677.5,3270 cw(c1660,3270) 1642.5,3270
  MidLayer1 w12: v1@-247.03,5228.93 ccw(c-256.42,5238.32) -243.14,5238.32 ccw(c-229.86,5238.32) v1@-239.25,5228.93 ; v1@-247.03,5425.49 cw(c-256.42,5416.1) -243.14,5416.1 cw(c-229.86,5416.1) v1@-239.25,5425.49 ; v1@-243.14,5219.54 cw(c-243.14,5206.26) -233.75,5215.65 cw(c-224.36,5225.04) v1@-237.64,5225.04 ; v1(-243.14,5429.37) v1(-243.14,5225.04) -176.48,5158.37 -176.48,4875.99 -175.39,4874.91 -175.09,4874.91 v1(-175,4875) ; -176.48,4891.84 ccw(c-158.16,4891.84) v1@-171.11,4878.89 ; VR1.1@538.43,555 589,504.43 589,498.03 589,341 635,295 893.7,295 J6.1@1056.57,132.13 ; 966,222.7 ccw(c1056.57,313.27) J6.1@1056.57,185.18 ; 986.49,202.21 ccw(c1056.57,272.3) J6.1@1056.57,173.18 ; 1006.97,181.73 ccw(c1056.57,231.33) J6.1@1056.57,161.18
  MidLayer1 w20: J4.1@1461.57,132.13 1592.13,132.13 1640,180 1640,530 1615,555 v1(1615,950) ; J4.1@1476.77,116.93 cw(c1513.47,80.23) 1513.47,132.13 cw(c1513.47,184.02) J4.1@1476.77,147.33