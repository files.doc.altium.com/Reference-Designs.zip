# Altium PCB NB3000AL.PcbDoc (part 20 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
AUGND: C19.2 C22.2 C23.2 C24.1 C25.2 C26.2 C28.2 C29.2 C30.2 C32.2 C105.1 C108.2 C111.2 C112.1 C113.1 C114.1 C145.1 C146.2 C147.1 J4.1 J5.1 J6.1 J7.1 NT1.1 R3.1 R4.1 R25.1 R27.1 R139.1 R140.1 R145.1 R146.2 U1.20 U26.1 U26.8 U44.2 VR1.1 | length 223195.2
  Top Layer w4: -692.37,3662.63 ccw(c-680,3675) -664.44,3667 -584.81,3667 ; -692.37,3687.37 cw(c-680,3675) -664.44,3683 -588.12,3683 -566.63,3704.49 ; v1@-664.1,3688.4 ccw(c-651.05,3701.45) -651.05,3683 ; v1@-661.27,3691.23 ccw(c-641.39,3711.11) -641.39,3683 ; v1@-658.44,3694.06 ccw(c-631.74,3720.76) -631.74,3683 ; v1@-655.61,3696.89 ccw(c-622.08,3730.42) -622.08,3683 ; v1@-652.78,3699.72 ccw(c-612.42,3740.08) -612.42,3683 ; -570.04,3701.09 -566.63,3704.5 ; -555.32,3693.18 -558.73,3689.77 ; -518,3795 -518,3753.12 -566.63,3704.5 ; -517.81,3796.73 -517.81,4068.27 cw(c-510,4070) -517.81,4071.73 -517.81,4101.69 -520.66,4104.53 ; -502,3793.27 -502,3749.81 ; -501.81,3795 -501.81,4070.19 -501.81,4105 ; -338.09,4941.77 cw(c-349.76,4944.09) -349.76,4932.19 -428.5,4932.19 cw(c-428.5,4944.09) -440.41,4944.09 -440.41,4955.91 cw(c-428.5,4955.91) -428.5,4967.81 -349.76,4967.81 cw(c-349.76,4955.91) -338.04,4958 -335,4958 ; -336.66,4940.35 ccw(c-320,4935) -302.5,4935 ccw(c-320,4935) -325.35,4951.66 -329.34,4955.66 ; v1@695.28,2693.28 cw(c679.06,2677.06) 702,2677.06 cw(c724.93,2677.06) v1@708.72,2693.28 ; v1@698.11,2696.11 cw(c688.72,2686.72) 702,2686.72 cw(c715.28,2686.72) v1@705.89,2696.11 ; v1(702,2700) 702,2593 720,2575 745,2575 ; 790.92,358.84 cw(c815.82,358.84) v1@804.98,381.26 ; 790.92,365.22 cw(c812.74,365.22) v1@803.24,384.86 ; 790.92,371.59 cw(c809.66,371.59) v1@801.5,388.46 ; 790.92,377.97 cw(c806.58,377.97) v1@799.76,392.06 ; 790.92,399.67 ccw(c803.67,399.67) v1@800.16,387.41 ; 790.92,404.98 ccw(c805.2,404.98) v1@801.26,391.25 ; 790.92,410.28 ccw(c806.72,410.28) v1@802.37,395.1 ; v1@803.47,398.94 cw(c808.24,415.59) 790.92,415.59 ; v1@1009.14,375.94 ccw(c1009.11,385.91) 1019.08,385.91 ; v1@1009.13,379.94 ccw(c1009.1,389.92) 1019.08,389.92 ; v1@1009.12,383.94 ccw(c1009.08,393.94) 1019.08,393.94 ; v1@1009.16,371.94 ccw(c1009.12,381.9) 1019.08,381.9 ; 1094.07,359.39 cw(c1109.48,359.39) v10@1108.25,374.75 ; 1094.07,363.72 cw(c1109.13,363.72) v10@1107.93,378.73 ; 1094.07,368.05 cw(c1108.79,368.05) v10@1107.61,382.72 ; 1094.07,372.39 cw(c1108.44,372.39) v10@1107.3,386.71 ; 1094.07,376.72 cw(c1108.09,376.72) v10@1106.98,390.7 ; v10@1104.81,395.41 ccw(c1100.24,415.59) 1120.93,415.59 ; v10@1105.7,391.51 ccw(c1101.37,410.58) 1120.93,410.58 ; v10@1106.58,387.61 ccw(c1102.51,405.57) 1120.93,405.57 ; v10@1107.4,374.72 cw(c1107.13,360.92) 1120.93,360.92 ; v10@1107.48,378.72 cw(c1107.21,365) 1120.93,365 ; v10@1107.46,383.71 ccw(c1103.64,400.57) 1120.93,400.57 ; v10@1107.56,382.72 cw(c1107.29,369.09) 1120.93,369.09 ; v10@1107.64,386.72 cw(c1107.37,373.17) 1120.93,373.17 ; v10@1107.73,390.72 cw(c1107.46,377.25) 1120.93,377.25 ; v10@1108.35,379.81 ccw(c1104.78,395.56) 1120.93,395.56 ; v10@1109.23,375.91 ccw(c1105.91,390.55) 1120.93,390.55 ; v1@1110.99,214.52 ccw(c1110.96,224.49) 1120.93,224.49 ; v1@1110.98,218.52 ccw(c1110.95,228.51) 1120.93,228.51 ; v1@1110.97,222.52 ccw(c1110.93,232.52) 1120.93,232.52 ; v1@1111.01,210.52 ccw(c1110.97,220.48) 1120.93,220.48 ; 1195.92,199.21 cw(c1207.92,199.21) v1@1206.5,211.12 ; 1195.92,203.71 cw(c1207.38,203.71) v1@1206.03,215.09 ; 1195.92,208.22 cw(c1206.85,208.22) v1@1205.56,219.07 ; 1195.92,358.84 cw(c1220.82,358.84) v1@1209.98,381.26 ; 1195.92,365.22 cw(c1217.74,365.22) v1@1208.24,384.86 ; 1195.92,371.59 cw(c1214.66,371.59) v1@1206.5,388.46 ; 1195.92,377.97 cw(c1211.58,377.97) v1@1204.76,392.06 ; 1195.92,399.67 ccw(c1208.67,399.67) v1@1205.16,387.41 ; 1195.92,404.98 ccw(c1210.2,404.98) v1@1206.26,391.25 ; 1195.92,410.28 ccw(c1211.72,410.28) v1@1207.37,395.1 ; v1@1208.47,398.94 cw(c1213.24,415.59) 1195.92,415.59 ; v1@1414.14,261.77 ccw(c1414.11,271.74) 1424.08,271.74 ; v1@1414.13,265.77 ccw(c1414.1,275.75) 1424.08,275.75 ; v1@1414.12,269.77 ccw(c1414.08,279.76) 1424.08,279.76 ; v1@1414.14,375.94 ccw(c1414.11,385.91) 1424.08,385.91 ; v1@1414.13,379.94 ccw(c1414.1,389.92) 1424.08,389.92 ; v1@1414.12,383.94 ccw(c1414.08,393.94) 1424.08,393.94 ; v1@1414.16,257.77 ccw(c1414.12,267.72) 1424.08,267.72 ; v1@1414.16,371.94 ccw(c1414.12,381.9) 1424.08,381.9 ; 1499.07,246.45 cw(c1511.07,246.45) v1@1509.65,258.37 ; 1499.07,250.96 cw(c1510.53,250.96) v1@1509.18,262.34 ; 1499.07,255.46 cw(c1510,255.46) v1@1508.7,266.31 ; 1499.07,359.39 cw(c1514.48,359.39) v10@1513.25,374.75 ; 1499.07,363.72 cw(c1514.13,363.72) v10@1512.93,378.73 ; 1499.07,368.05 cw(c1513.79,368.05) v10@1512.61,382.72 ; 1499.07,372.39 cw(c1513.44,372.39) v10@1512.3,386.71 ; 1499.07,376.72 cw(c1513.09,376.72) v10@1511.98,390.7 ; v10@1509.81,395.41 ccw(c1505.24,415.59) 1525.93,415.59 ; v10@1510.7,391.51 ccw(c1506.37,410.58) 1525.93,410.58 ; v10@1511.58,387.61 ccw(c1507.51,405.57) 1525.93,405.57 ; v10@1512.4,374.72 cw(c1512.13,360.92) 1525.93,360.92 ; v10@1512.48,378.72 cw(c1512.21,365) 1525.93,365 ; v10@1512.46,383.71 ccw(c1508.64,400.57) 1525.93,400.57 ; v10@1512.56,382.72 cw(c1512.29,369.09) 1525.93,369.09 ; v10@1512.64,386.72 cw(c1512.37,373.17) 1525.93,373.17 ; v10@1512.73,390.72 cw(c1512.46,377.25) 1525.93,377.25 ; v10@1513.35,379.81 ccw(c1509.78,395.56) 1525.93,395.56 ; v10@1514.23,375.91 ccw(c1510.91,390.55) 1525.93,390.55 ; 1581.84,3015.48 ccw(c1590,3000) 1607.5,3000 ccw(c1590,3000) 1603.89,3010.65 ; 1590.89,3132.97 1600.89,3132.97 cw(c1600.89,3121.97) 1611.64,3124.31 cw(c1622.39,3121.97) 1622.39,3132.97 1632.39,3132.97 cw(c1632.39,3121.97) 1643.13,3124.31 cw(c1653.88,3121.97) 1650.88,3132.55 1650.88,3189.4 ; 1600.92,358.84 cw(c1625.82,358.84) v1@1614.98,381.26 ; 1600.92,365.22 cw(c1622.74,365.22) v1@1613.24,384.86 ; 1600.92,371.59 cw(c1619.66,371.59) v1@1611.5,388.46 ; 1600.92,377.97 cw(c1616.58,377.97) v1@1609.76,392.06 ; 1600.92,399.67 ccw(c1613.67,399.67) v1@1610.16,387.41 ; 1600.92,404.98 ccw(c1615.2,404.98) v1@1611.26,391.25 ; 1600.92,410.28 ccw(c1616.72,410.28) v1@1612.37,395.1 ; 1603.89,3011.15 ccw(c1600.89,3021.73) 1611.64,3019.39 ccw(c1622.39,3021.73) 1619.39,3011.15 1619.39,2956.57 ccw(c1625,2940) 1642.5,2940 ccw(c1625,2940) 1635.39,2954.09 1635.39,3011.15 ccw(c1632.39,3021.73) 1643.13,3019.39 ccw(c1653.88,3021.73) 1653.88,3010.73 1663.88,3010.73 ccw(c1663.88,3021.73) 1674.63,3019.39 ccw(c1685.38,3021.73) 1685.38,3010.73 1695.38,3010.73 ; v1@1613.47,398.94 cw(c1618.24,415.59) 1600.92,415.59 ; 1698.38,3132.55 1698.38,3151.87 1709.84,3163.34 ccw(c1715.19,3180) 1732.69,3180 ccw(c1715.19,3180) 1698.53,3174.65 1684.72,3160.84 ; v1@1819.14,375.94 ccw(c1819.11,385.91) 1829.08,385.91 ; v1@1819.13,379.94 ccw(c1819.1,389.92) 1829.08,389.92 ; v1@1819.12,383.94 ccw(c1819.08,393.94) 1829.08,393.94 ; v1@1819.16,371.94 ccw(c1819.12,381.9) 1829.08,381.9 ; 1904.07,359.39 cw(c1919.48,359.39) v10@1918.25,374.75 ; 1904.07,363.72 cw(c1919.13,363.72) v10@1917.93,378.73 ; 1904.07,368.05 cw(c1918.79,368.05) v10@1917.61,382.72 ; 1904.07,372.39 cw(c1918.44,372.39) v10@1917.3,386.71 ; 1904.07,376.72 cw(c1918.09,376.72) v10@1916.98,390.7 ; v10@1914.81,395.41 ccw(c1910.24,415.59) 1930.93,415.59 ; v10@1915.7,391.51 ccw(c1911.37,410.58) 1930.93,410.58 ; v10@1916.58,387.61 ccw(c1912.51,405.57) 1930.93,405.57 ; v10@1917.4,374.72 cw(c1917.13,360.92) 1930.93,360.92 ; v10@1917.48,378.72 cw(c1917.21,365) 1930.93,365 ; v10@1917.46,383.71 ccw(c1913.64,400.57) 1930.93,400.57 ; v10@1917.56,382.72 cw(c1917.29,369.09) 1930.93,369.09 ; v10@1917.64,386.72 cw(c1917.37,373.17) 1930.93,373.17 ; v10@1917.73,390.72 cw(c1917.46,377.25) 1930.93,377.25 ; v10@1918.35,379.81 ccw(c1914.78,395.56) 1930.93,395.56 ; v10@1919.23,375.91 ccw(c1915.91,390.55) 1930.93,390.55 ; v1@1920.99,214.52 ccw(c1920.96,224.49) 1930.93,224.49 ; v1@1920.98,218.52 ccw(c1920.95,228.51) 1930.93,228.51 ; v1@1920.97,222.52 ccw(c1920.93,232.52) 1930.93,232.52 ; v1@1921.01,210.52 ccw(c1920.97,220.48) 1930.93,220.48 ; 2005.92,199.21 cw(c2017.92,199.21) v1@2016.5,211.12 ; 2005.92,203.71 cw(c2017.38,203.71) v1@2016.03,215.09 ; 2005.92,208.22 cw(c2016.85,208.22) v1@2015.56,219.07 ; 2005.92,358.84 cw(c2030.82,358.84) v1@2019.98,381.26 ; 2005.92,365.22 cw(c2027.74,365.22) v1@2018.24,384.86 ; 2005.92,371.59 cw(c2024.66,371.59) v1@2016.5,388.46 ; 2005.92,377.97 cw(c2021.58,377.97) v1@2014.76,392.06 ; 2005.92,399.67 ccw(c2018.67,399.67) v1@2015.16,387.41 ; 2005.92,404.98 ccw(c2020.2,404.98) v1@2016.26,391.25 ; 2005.92,410.28 ccw(c2021.72,410.28) v1@2017.37,395.1 ; v1@2018.47,398.94 cw(c2023.24,415.59) 2005.92,415.59 ; v1@2224.14,261.77 ccw(c2224.11,271.74) 2234.08,271.74 ; v1@2224.13,265.77 ccw(c2224.1,275.75) 2234.08,275.75 ; v1@2224.12,269.77 ccw(c2224.08,279.76) 2234.08,279.76 ; v1@2224.14,375.94 ccw(c2224.11,385.91) 2234.08,385.91 ; v1@2224.13,379.94 ccw(c2224.1,389.92) 2234.08,389.92 ; v1@2224.12,383.94 ccw(c2224.08,393.94) 2234.08,393.94 ; v1@2224.16,257.77 ccw(c2224.12,267.72) 2234.08,267.72 ; v1@2224.16,371.94 ccw(c2224.12,381.9) 2234.08,381.9 ; 2309.07,360.63 cw(c2321.07,360.63) v1@2319.65,372.54 ; 2309.07,365.13 cw(c2320.53,365.13) v1@2319.18,376.51 ; 2309.07,369.63 cw(c2320,369.63) v1@2318.7,380.48 ; -641,2325.62 ccw(c-633,2325.62) -638.66,2319.97 ; -641,2325.62 ccw(c-633,2325.62) -638.66,2319.97 ; -641,2325.62 -641,2349.69 -654.65,2363.34 cw(c-660,2380) -642.5,2380 cw(c-660,2380) -643.34,2374.65 -627.34,2358.66 ; -638.66,2319.97 -624.53,2305.84 ; -627.34,2358.66 cw(c-633,2353) -625,2353 ; -627.34,2358.66 cw(c-633,2353) -625,2353 ; -625,2353 -625,2328.94 -615.56,2319.5 -585,2319.5 ; -624.53,2305.84 ccw(c-618.88,2311.5) -618.88,2303.5 ; -624.53,2305.84 ccw(c-618.88,2311.5) -618.88,2303.5 ; -618.88,2303.5 -588.31,2303.5 -568,2283.19 -568,1773.31 -595.66,1745.66 ; -598,1520 ccw(c-590,1520) -595.66,1514.34 ; -598,1520 ccw(c-590,1520) -595.66,1514.34 ; -598,1520 -598,1740 ; -598,1740 cw(c-590,1740) -595.66,1745.66 ; -598,1740 cw(c-590,1740) -595.66,1745.66 ; -595.66,1514.34 -540.36,1459.05 ; -585,2319.5 cw(c-585,2311.5) -579.34,2317.16 ; -585,2319.5 cw(c-585,2311.5) -579.34,2317.16 ; -584.81,3667 ccw(c-584.81,3675) -579.15,3669.34 ; -584.81,3667 ccw(c-584.81,3675) -579.15,3669.34 ; -579.34,2317.16 -554.34,2292.16 ; -579.15,3669.34 -558.73,3689.77 ; -558.72,3689.77 -504.34,3744.15 ; -554.34,1764.34 ccw(c-560,1770) -552,1770 ; -554.34,1764.34 ccw(c-560,1770) -552,1770 ; -554.34,1764.34 -582,1736.69 -582,1523.31 -531.39,1472.71 -426.23,1472.71 -398.28,1500.66 ; -554.34,2292.16 cw(c-560,2286.5) -552,2286.5 ; -554.34,2292.16 cw(c-560,2286.5) -552,2286.5 ; -552,1770 -552,2286.5 ; -540.36,1459.05 ccw(c-534.71,1464.71) -534.71,1456.71 ; -540.36,1459.05 ccw(c-534.71,1464.71) -534.71,1456.71 ; -534.71,1456.71 -422.92,1456.71 ; -523,4110.19 ccw(c-515,4110.19) -520.66,4104.53 ; -523,4110.19 ccw(c-515,4110.19) -520.66,4104.53 ; -523,4110.19 -523,4149.44 cw(c-515,4165) -497.5,4165 cw(c-515,4165) -507,4149.44 -507,4113.5 -504.15,4110.66 ; -504.34,3744.15 ccw(c-510,3749.81) -502,3749.81 ; -504.34,3744.15 ccw(c-510,3749.81) -502,3749.81 ; -504.15,4110.66 cw(c-509.81,4105) -501.81,4105 ; -504.15,4110.66 cw(c-509.81,4105) -501.81,4105 ; -439.34,4684.19 ccw(c-445,4689.85) -437,4689.85 ; -439.34,4684.19 ccw(c-445,4689.85) -437,4689.85 ; -439.34,4684.19 -493.15,4630.39 cw(c-509.81,4625.04) -492.31,4625.04 cw(c-509.81,4625.04) -504.46,4641.7 -453,4693.16 -453,4779.44 cw(c-445,4795) -427.5,4795 cw(c-445,4795) -437,4779.44 -437,4689.85 ; -422.92,1456.71 ccw(c-422.92,1464.71) -417.26,1459.05 ; -422.92,1456.71 ccw(c-422.92,1464.71) -417.26,1459.05 ; -417.26,1459.05 -389.31,1487 -88.31,1487 277,1121.69 277,905.56 ccw(c285,890) 302.5,890 ccw(c285,890) 293,905.56 293,1125 ; -398.28,1500.66 cw(c-392.62,1495) -392.62,1503 ; -398.28,1500.66 cw(c-392.62,1495) -392.62,1503 ; -392.62,1503 -85,1503 ; -335,4958 cw(c-335,4950) -329.34,4955.66 ; -335,4958 cw(c-335,4950) -329.34,4955.66 ; -314.44,5008 cw(c-314.44,5000) -308.78,5005.66 ; -314.43,5008 cw(c-314.43,5000) -308.78,5005.66 ; -314.44,5008 -338.04,5008 ccw(c-349.76,5005.91) -349.76,5017.81 -428.5,5017.81 ccw(c-428.5,5005.91) -440.41,5005.91 -440.41,4994.09 ccw(c-428.5,4994.09) -428.5,4982.19 -349.76,4982.19 ccw(c-349.76,4994.09) -338.04,4992 -317.75,4992 -300.09,4974.34 ; -308.78,5005.66 -291.12,4988 -280.56,4988 cw(c-265,4980) -247.5,4980 cw(c-265,4980) -280.56,4972 -294.44,4972 ; -300.09,4974.34 ccw(c-294.44,4980) -294.44,4972 ; -300.09,4974.34 ccw(c-294.44,4980) -294.44,4972 ; -233.09,3194.34 ccw(c-227.44,3200) -227.44,3192 ; -233.09,3194.34 ccw(c-227.44,3200) -227.44,3192 ; -233.09,3194.34 -287.79,3249.05 cw(c-293.14,3265.71) -275.64,3265.71 cw(c-293.14,3265.71) -276.48,3260.36 -224.12,3208 -40,3208 ; -227.44,3192 -43.31,3192 152.86,2995.83 152.86,2907.27 ccw(c160.86,2891.71) 178.36,2891.71 ccw(c160.86,2891.71) 168.86,2907.27 168.86,2999.14 ; -167.81,3305 ccw(c-159.81,3305) -165.47,3299.34 ; -167.81,3305 ccw(c-159.81,3305) -165.47,3299.34 ; -167.81,3305 -167.81,3544.3 cw(c-159.81,3559.86) -142.31,3559.86 cw(c-159.81,3559.86) -151.81,3544.3 -151.81,3308.31 -118.2,3274.71 83.29,3274.71 ; -165.47,3299.34 -127.17,3261.05 ; -127.17,3261.05 ccw(c-121.52,3266.71) -121.52,3258.71 ; -127.17,3261.05 ccw(c-121.52,3266.71) -121.52,3258.71 ; -121.52,3258.71 79.98,3258.71 273.86,3064.83 273.86,1815.23 219.34,1760.72 ; -85,1503 cw(c-85,1495) -79.34,1500.66 ; -85,1503 cw(c-85,1495) -79.34,1500.66 ; -79.34,1500.66 290.66,1130.66 ; -40,3208 cw(c-40,3200) -34.34,3205.66 ; -40,3208 cw(c-40,3200) -34.34,3205.66 ; -34.34,3205.66 166.51,3004.8 ; 83.29,3274.71 cw(c83.29,3266.71) 88.95,3272.36 ; 83.29,3274.71 cw(c83.29,3266.71) 88.95,3272.36 ; 88.95,3272.36 287.51,3073.8 ; 117,4284.85 cw(c125,4284.85) 119.34,4290.51 ; 117,4284.85 cw(c125,4284.85) 119.34,4290.51 ; 117,4284.85 117,3560.43 95.28,3538.71 ccw(c76.12,3508.23) 112.12,3508.23 ccw(c76.12,3508.23) 106.6,3527.4 130.66,3551.46 ; 119.34,4290.51 288.85,4460.02 288.85,4586.85 ; 130.66,3551.46 ccw(c125,3557.11) 133,3557.11 ; 130.66,3551.46 ccw(c125,3557.11) 133,3557.11 ; 133,3557.11 133,4281.54 302.51,4451.05 ; 166.51,3004.8 cw(c160.86,2999.14) 168.86,2999.14 ; 166.51,3004.8 cw(c160.86,2999.14) 168.86,2999.14 ; 217,1410 ccw(c225,1410) 219.34,1404.34 ; 217,1410 ccw(c225,1410) 219.34,1404.34 ; 217,1410 217,1755.06 ; 217,1755.06 cw(c225,1755.06) 219.34,1760.72 ; 217,1755.06 cw(c225,1755.06) 219.34,1760.72 ; 219.34,1404.34 338.34,1285.35 ccw(c355,1280) 372.5,1280 ccw(c355,1280) 349.65,1296.66 233,1413.31 233,1751.75 287.51,1806.26 ; 287.51,1806.26 ccw(c281.86,1811.92) 289.86,1811.92 ; 287.51,1806.26 ccw(c281.86,1811.92) 289.86,1811.92 ; 287.51,3073.8 cw(c281.86,3068.14) 289.86,3068.14 ; 287.51,3073.8 cw(c281.86,3068.14) 289.86,3068.14 ; 288.85,4586.85 cw(c296.85,4586.85) 291.2,4592.51 ; 288.85,4586.85 cw(c296.85,4586.85) 291.2,4592.51 ; 289.86,1811.92 289.86,3068.14 ; 290.66,1130.66 cw(c285,1125) 293,1125 ; 290.66,1130.66 cw(c285,1125) 293,1125 ; 291.2,4592.51 303.34,4604.65 cw(c320,4610) 337.5,4610 cw(c320,4610) 314.65,4593.34 304.85,4583.54 304.85,4456.7 ; 302.51,4451.05 ccw(c296.85,4456.7) 304.85,4456.7 ; 302.51,4451.05 ccw(c296.85,4456.7) 304.85,4456.7 ; 402,2810 ccw(c410,2810) 404.34,2804.34 ; 402,2810 ccw(c410,2810) 404.34,2804.34 ; 402,2810 402,3129.52 ; 402,3129.52 cw(c410,3129.52) 404.34,3135.17 ; 402,3129.52 cw(c410,3129.52) 404.34,3135.17 ; 404.34,2804.34 622,2586.69 622,1170 622,955.57 ; 404.34,3135.17 513.46,3244.29 cw(c530,3250) 547.5,3250 cw(c530,3250) 525.02,3233.22 418,3126.2 418,2813.31 635.66,2595.66 ; 622,955.57 ccw(c630,955.57) 624.34,949.91 ; 622,955.57 ccw(c630,955.57) 624.34,949.91 ; 624.34,949.91 1049.34,524.91 ; 635.66,2595.66 cw(c630,2590) 638,2590 ; 635.66,2595.66 cw(c630,2590) 638,2590 ; 638,2590 638,1173.31 638,958.88 1058.31,538.57 1780,538.57 ; 790.92,415.59 ccw(c753.43,415.59) 715.93,415.59 715.93,360.47 ccw(c753.43,360.47) 790.92,360.47 790.92,415.59 ; 1019.08,393.94 cw(c1056.57,393.94) 1094.07,393.94 1094.07,358.5 cw(c1056.57,358.5) 1019.08,358.5 1019.08,393.94 ; 1049.34,524.91 ccw(c1055,530.57) 1055,522.57 ; 1049.34,524.91 ccw(c1055,530.57) 1055,522.57 ; 1055,522.57 1776.69,522.57 1858.57,440.68 1858.57,430.57 ccw(c1866.57,393.94) 1829.08,393.94 ; 1120.93,232.52 cw(c1158.43,232.52) 1195.92,232.52 1195.92,197.09 cw(c1158.43,197.09) 1120.93,197.09 1120.93,232.52 ; 1120.93,415.59 cw(c1158.43,415.59) 1195.92,415.59 ; 1120.93,415.59 1120.93,360.47 ccw(c1158.43,360.47) 1195.92,360.47 1195.92,415.59 ; 1424.08,279.76 cw(c1461.57,279.76) 1499.07,279.76 1499.07,244.33 cw(c1461.57,244.33) 1424.08,244.33 1424.08,279.76 ; 1424.08,393.94 cw(c1461.57,393.94) 1499.07,393.94 1499.07,358.5 cw(c1461.57,358.5) 1424.08,358.5 1424.08,393.94 ; 1525.93,415.59 cw(c1563.43,415.59) 1600.92,415.59 ; 1525.93,415.59 1525.93,360.47 ccw(c1563.43,360.47) 1600.92,360.47 1600.92,415.59 ; 1650.88,3189.4 cw(c1658.88,3189.4) 1652,3193.48 ; 1650.88,3189.4 cw(c1658.88,3189.4) 1652,3193.48 ; 1652,3193.48 1652,3254.44 cw(c1660,3270) 1677.5,3270 cw(c1660,3270) 1668,3254.44 1668,3190.52 ; 1666.88,3186.44 ccw(c1660,3190.52) 1668,3190.52 ; 1666.88,3186.44 ccw(c1660,3190.52) 1668,3190.52 ; 1666.88,3186.44 1666.88,3132.55 cw(c1663.88,3121.97) 1674.63,3124.31 cw(c1685.38,3121.97) 1682.38,3132.55 1682.38,3155.19 ; 1682.38,3155.19 cw(c1690.38,3155.19) 1684.72,3160.84 ; 1682.38,3155.19 cw(c1690.38,3155.19) 1684.72,3160.84 ; 1780,538.57 cw(c1780,530.57) 1785.66,536.23 ; 1780,538.57 cw(c1780,530.57) 1785.66,536.23 ; 1785.66,536.23 1872.23,449.65 ; 1829.08,393.94 1829.08,358.5 ccw(c1866.57,358.5) 1904.07,358.5 1904.07,393.94 ccw(c1866.57,393.94) 1874.57,430.57 1874.57,443.99 ; 1872.23,449.65 cw(c1866.57,443.99) 1874.57,443.99 ; 1872.23,449.65 cw(c1866.57,443.99) 1874.57,443.99 ; 1930.93,232.52 cw(c1968.43,232.52) 2005.92,232.52 2005.92,197.09 cw(c1968.43,197.09) 1930.93,197.09 1930.93,232.52 ; 1930.93,415.59 cw(c1968.43,415.59) 2005.92,415.59 ; 1930.93,415.59 1930.93,360.47 ccw(c1968.43,360.47) 2005.92,360.47 2005.92,415.59 ; 2234.08,279.76 cw(c2271.57,279.76) 2309.07,279.76 2309.07,244.33 cw(c2271.57,244.33) 2234.08,244.33 2234.08,279.76 ; 2234.08,393.94 cw(c2271.57,393.94) 2309.07,393.94 2309.07,358.5 cw(c2271.57,358.5) 2234.08,358.5 2234.08,393.94 ; -612.5,2345 cw(c-595,2345) -577.5,2345 cw(c-595,2345) -612.5,2345 ; -397.5,3940 cw(c-380,3940) -362.5,3940 cw(c-380,3940) -397.5,3940 ; -385.64,4308.37 cw(c-368.14,4308.37) -350.64,4308.37 cw(c-368.14,4308.37) -385.64,4308.37 ; -372.5,4020 cw(c-355,4020) -337.5,4020 cw(c-355,4020) -372.5,4020 ; -282.5,5050 cw(c-265,5050) -247.5,5050 cw(c-265,5050) -282.5,5050 ; -272.5,3670 cw(c-255,3670) -237.5,3670 cw(c-255,3670) -272.5,3670 ; -267.5,3760 cw(c-250,3760) -232.5,3760 cw(c-250,3760) -267.5,3760 ; -252.5,4925 cw(c-235,4925) -217.5,4925 cw(c-235,4925) -252.5,4925 ; -197.5,4460 cw(c-180,4460) -162.5,4460 cw(c-180,4460) -197.5,4460 ; -174,4095 cw(c-156.5,4095) -139,4095 cw(c-156.5,4095) -174,4095 ; -143.98,5216.71 cw(c-126.48,5216.71) -108.98,5216.71 cw(c-126.48,5216.71) -143.98,5216.71 ; -143.64,5267.04 cw(c-126.14,5267.04) -108.64,5267.04 cw(c-126.14,5267.04) -143.64,5267.04 ; -142.5,5105 cw(c-125,5105) -107.5,5105 cw(c-125,5105) -142.5,5105 ; -132.5,4135 cw(c-115,4135) -97.5,4135 cw(c-115,4135) -132.5,4135 ; -91.98,2139.71 cw(c-74.48,2139.71) -56.98,2139.71 cw(c-74.48,2139.71) -91.98,2139.71 ; -67.5,3920 cw(c-50,3920) -32.5,3920 cw(c-50,3920) -67.5,3920 ; -52.5,3790 cw(c-35,3790) -17.5,3790 cw(c-35,3790) -52.5,3790 ; -35.64,2901.71 cw(c-18.14,2901.71) -0.64,2901.71 cw(c-18.14,2901.71) -35.64,2901.71 ; -27.31,2658.37 cw(c-9.81,2658.37) 7.69,2658.37 cw(c-9.81,2658.37) -27.31,2658.37 ; 2.69,2368.71 cw(c20.19,2368.71) 37.69,2368.71 cw(c20.19,2368.71) 2.69,2368.71 ; 22.69,858.37 cw(c40.19,858.37) 57.69,858.37 cw(c40.19,858.37) 22.69,858.37 ; 40.12,3408.23 cw(c76.12,3408.23) 112.12,3408.23 cw(c76.12,3408.23) 40.12,3408.23 ; v1@56.02,5025.04 cw(c73.52,5025.04) 91.02,5025.04 cw(c73.52,5025.04) v1@56.02,5025.04 ; 143.36,2800.04 cw(c160.86,2800.04) 178.36,2800.04 cw(c160.86,2800.04) 143.36,2800.04 ; 164.36,4950.04 cw(c181.86,4950.04) 199.36,4950.04 cw(c181.86,4950.04) 164.36,4950.04 ; 212.5,1285 cw(c230,1285) 247.5,1285 cw(c230,1285) 212.5,1285 ; 222.5,5015 cw(c240,5015) 257.5,5015 cw(c240,5015) 222.5,5015 ; 312.5,4675 cw(c330,4675) 347.5,4675 cw(c330,4675) 312.5,4675 ; 672.69,2725.04 cw(c690.19,2725.04) 707.69,2725.04 cw(c690.19,2725.04) 672.69,2725.04 ; 747.5,2575 cw(c765,2575) 782.5,2575 cw(c765,2575) 747.5,2575 ; 762.5,4555 cw(c780,4555) 797.5,4555 cw(c780,4555) 762.5,4555 ; 1064.36,991.71 cw(c1081.86,991.71) 1099.36,991.71 cw(c1081.86,991.71) 1064.36,991.71 ; 1132.36,4635.71 cw(c1149.86,4635.71) 1167.36,4635.71 cw(c1149.86,4635.71) 1132.36,4635.71 ; 1257.5,860 cw(c1275,860) 1292.5,860 cw(c1275,860) 1257.5,860 ; 1339.36,991.71 cw(c1356.86,991.71) 1374.36,991.71 cw(c1356.86,991.71) 1339.36,991.71
  Top Layer w12: U26.8@-389.13,4850 -200,4850 v1(-175,4875) ; U26.1@-389.13,5200 -306.18,5200 -281.14,5225.04 v1(-243.14,5225.04) ; U26.8@-351.56,4845.89 cw(c-341.64,4835.97) -341.64,4850 cw(c-341.64,4864.03) U26.8@-351.56,4854.11 ; U26.1@-351.56,5195.89 cw(c-341.64,5185.97) -341.64,5200 cw(c-341.64,5214.03) U26.1@-351.56,5204.11 ; v1@-247.03,5221.15 ccw(c-256.42,5211.76) -256.42,5225.04 ccw(c-256.42,5238.32) v1@-247.03,5228.93 ; v1@-180.5,4875 cw(c-193.78,4875) -184.39,4865.61 cw(c-175,4856.22) v1@-175,4869.5 ; v1@-130.36,2712.26 ccw(c-139.75,2721.65) -126.48,2721.65 ccw(c-113.2,2721.65) v1@-122.59,2712.26 ; v1(-126.48,2708.37) -126.48,2728.52 -120,2735 -80.63,2735 U1.20@-79.84,2734.21 ; v1@109.69,5625.04 cw(c96.41,5625.04) 105.8,5615.65 cw(c115.19,5606.26) v1@115.19,5619.54 ; v1(115.19,5625.04) 85,5594.85 85,5110 210,4985 496.9,4985 575,4906.9 575,4680 155,4260 155,3480 190,3445 190,3385 331.86,3243.14 331.86,3128.14 v1(331.86,2766.71) ; v1@327.97,2770.6 ccw(c318.58,2779.99) 331.86,2779.99 ccw(c345.14,2779.99) v1@335.75,2770.6 ; v1(720.52,2634.71) 800.29,2634.71 815,2620 900,2535 900,850 1110,640 v1(1110,575) ; v1@724.41,2630.82 cw(c733.8,2621.43) 733.8,2634.71 cw(c733.8,2647.99) v1@724.41,2638.6 ; v1@1106.11,578.89 ccw(c1096.72,588.28) 1110,588.28 ccw(c1123.28,588.28) v1@1113.89,578.89 ; v1@1106.11,591.11 cw(c1096.72,581.72) 1110,581.72 cw(c1123.28,581.72) v1@1113.89,591.11 ; v1@1106.11,598.89 ccw(c1096.72,608.28) 1110,608.28 ccw(c1123.28,608.28) v1@1113.89,598.89 ; v1@1106.11,611.11 cw(c1096.72,601.72) 1110,601.72 cw(c1123.28,601.72) v1@1113.89,611.11 ; v1@1106.11,618.89 ccw(c1096.72,628.28) 1110,628.28 ccw(c1123.28,628.28) v1@1113.89,618.89