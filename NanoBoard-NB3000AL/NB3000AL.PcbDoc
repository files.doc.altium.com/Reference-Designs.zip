# Altium PCB NB3000AL.PcbDoc (part 5 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad) (continued)
TSSOP14#1 [mm]
  rrect50% 1.65x0.305 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 6(0,-3.25) 8(5.55,-3.9) 9(5.55,-3.25) 10(5.55,-2.6) 11(5.55,-1.95) 12(5.55,-1.3) 14(5.55,0)
  rrect50% 1.65x0.305 smd mask+0: 5(0,-2.6) 7(0,-3.9) 13(5.55,-0.65)
  silkscreen extent 0.52,-4.19 4.37,0.7, body extent -0.21,-4.45 6.18,0.56, height 0.64
TSSOP14#2 [mm]
  rrect50% 1.65x0.305 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(0,-2.6) 6(0,-3.25) 8(5.55,-3.9) 9(5.55,-3.25) 10(5.55,-2.6) 11(5.55,-1.95) 12(5.55,-1.3) 13(5.55,-0.65) 14(5.55,0)
  rrect50% 1.65x0.305 smd mask+0: 7(0,-3.9)
  silkscreen extent 0.52,-4.19 4.37,0.7, body extent -0.21,-4.45 6.18,0.56, height 0.64
TSSOP50P490-10AN [mm] "TSSOP, 10-Leads, Body 3x3mm, Pitch 0.5mm, IPC Medium Density"
  rrect50% 1.7x0.305 smd: 1(-2.05,1) 2(-2.05,0.5) 3(-2.05,0) 4(-2.05,-0.5) 5(-2.05,-1) 6(2.05,-1) 7(2.05,-0.5) 8(2.05,0) 9(2.05,0.5) 10(2.05,1)
  silkscreen extent -2.17,-1.6 0.8,1.82, body extent -2.4,-1.6 2.4,1.6, height 1.1
TSSOP-24 [mm]
  rrect50% 0.36x1.18 smd mask+0.051: 1(0,0) 2(0.64,0) 3(1.28,0) 4(1.92,0) 5(2.56,0) 7(3.84,0) 8(4.48,0) 9(5.12,0) 10(5.76,0) 11(6.4,0) 12(7.04,0) 14(6.4,6.1) 15(5.76,6.1) 16(5.12,6.1) 17(4.48,6.1) 18(3.84,6.1) 19(3.2,6.1) 20(2.56,6.1) 21(1.92,6.1) 22(1.28,6.1) 23(0.64,6.1) 24(0,6.1)
  rrect50% 0.36x1.18 smd mask+0: 6(3.2,0) 13(7.04,6.1)
  silkscreen extent -0.17,1.37 7.12,4.9, body extent -0.3,0.02 7.25,6.36, height 0.9
XTAL-200X126-4 [mil] "CRYSTAL SMD 200x126x44 mils, 4 pads"
  rect 63x55 smd: 1(-81.5,-47.5) 3(81.5,47.5)
  rect 63x55 smd mask+0: 2(81.5,-47.5) 4(-81.5,47.5)
  silkscreen extent -30,-72 30,72, body extent -114,-52 113,51, height 39

## Part data
"Altium Logo BOT1": library part D-000-0003, "Altium Logo for PCB"
BT1: library part D-302-0000, "Lithium Battery Holder for CR2032 3V Cell"
C1 C2 C106 C107 C129 C133 C137 C138 C141: library part D-101-0088, "Capacitor, Tantalum, 220uF 10% 10V MCCT-D (7343-31)"
C3 C4 C36 C40 C49 C61 C62 C89 C93 C111 C115 C126 C128 C130 C132 C134 C136 C139 C140 C143 C146 C171 C175 C182 C184 C185 C189 C190 C191 C200 C201 C202 C203 C260 C265 C266 C267 C276 C277 C278 C279 C340 C341 C342: library part D-101-0007, "Capacitor, Tantalum, 10uF 10% 20V MCCT-B (3528)"
C5 C6 C8 C9 C10 C11 C12 C14 C15 C16 C17 C108 C109 C110 C121 C122 C123 C124 C125 C142 C144 C145 C147 C152 C181 C183: library part D-101-0131, "Capacitor, Ceramic, 1uF 10% 10V 0402 (1005) X5R"
C7 C13 C18: library part D-101-0132, "Capacitor, Ceramic, 4.7nF 10% 10V 0402 (1005) X7R"
C19 C20 C23 C25 C27 C31 C99: library part D-101-0087, "Capacitor, Ceramic, 10uF 10% 10V 0805 (2012) X5R"
C21 C22 C24 C26: library part D-101-0062, "Capacitor, Ceramic, 100nF 10% 16V 0402 (1005) X7R"
C28 C32: library part D-101-0064, "Capacitor, Ceramic, 220pF 5% 50V 0402 (1005) COG"
C29 C30 C57 C58 C59 C67 C68 C69 C70 C73 C74 C77 C78 C83 C84 C85 C86 C155 C156 C158 C160 C162 C164 C196 C197 C198 C199 C231 C232 C233 C234 C237 C238 C239 C240 C241 C242 C243 C244 C245 C246 C248 C250 C251 C253 C254 C256 C258 C272 C273 C274 C275 C307 C308 C309 C310 C313 C314 C315 C316 C317 C318 C319 C320 C321 C322 C324 C326 C327 C329 C330 C332 C334 C345 C349 C353 C357 C361 C365: library part D-101-0077, "Capacitor, Ceramic, 10nF 10% 16V 0402 (1005) X7R"
C33 C34: library part D-101-0075, "Capacitor, Ceramic, 15pF 5% 50V 0402 (1005)"
C35 C37 C38 C39 C55 C56 C60 C63 C64 C65 C66 C71 C72 C75 C76 C79 C80 C81 C82 C88 C90 C91 C92 C94 C95 C96 C97 C98 C100 C105 C112 C113 C114 C116 C148 C149 C150 C151 C153 C154 C159 C161 C163 C165 C168 C170 C172 C173 C174 C176 C177 C187 C192 C193 C194 C195 C215 C216 C217 C218 C219 C220 C221 C222 C223 C224 C225 C226 C227 C228 C229 C247 C249 C252 C255 C257 C259 C268 C269 C270 C271 C291 C292 C293 C294 C295 C296 C297 C298 C299 C300 C301 C302 C303 C304 C305 C323 C325 C328 C331 C333 C335 C336 C337 C338 C339 C344 C348 C352 C356 C360 C364 C367 C368: library part D-101-0080, "Capacitor, Ceramic, 0.1uF 10% 16V 0402 (1005) X7R"
C41 C42 C43 C44 C47 C48 C50 C51 C52 C53 C54: library part D-101-0045, "Capacitor, Ceramic, 0.1uF 25V 0402 (1005)"
C45 C46 C157 C166 C167 C169: library part D-101-0059, "Capacitor, Ceramic, 22pF 5% 50V 0402 (1005) COG"
C87: library part D-101-0019, "Capacitor, Ceramic, 4.7nF 20% 250V Panasonic BC J Lead (CAPM7163) Y5V"
C101 C102 C103 C104 C117 C118 C119 C120: library part D-101-0133, "Capacitor, Ceramic, 33nF 10% 25V 0402 (1005) X7R"
C127 C131 C135: library part D-101-0027, "Capacitor, Ceramic, 1uF 10% 25V 1206 (3216) X7R"
C186: library part D-101-0116, "Capacitor, Ceramic, 220nF 10% 16V 0402 (1005) X5R"
C343 C347 C351 C355 C359 C363: library part D-101-0112, "Capacitor, Ceramic, 2.2uF 10% 6.3V 0402 (1005) X5R"
C346 C350 C354 C358 C362 C366: library part D-101-0030, "Capacitor, Ceramic, 1nF 10% 50V 0402 (1005) X7R"
D1 D2: library part D-151-0002, "Schottky Diode, BAT54 30V 200mA 30V SOT-23"
D3 D4 D5 D6 D9: library part D-151-0004, "Schottky Diode, 400mA"
D7: library part D-150-0005, "Zener Diode, 3.3V"
D8: library part D-155-0001, "BAT54CW, SOT-323 Plastic-Encapsulated Diode"
D10: library part D-150-0001, "Zener Diode, 5V 5W"
EXTHDR1: library part D-300-0026, "Connector, Molex Docking Station 100 Pin Female 53751"
F1 F2: library part D-106-0000, "Mutifuse, SMD 5A"
FD1 FD2 FD3: library part D-004-0001, "Fiducial - Round 1.5mm Top-Bottom"
J1 J2 J3 J24 J26: library part D-300-0020, "Header IDC, 2 x 1 Pin Vertical 2.54mm Pitch (Non-Boxed, Male)"
J4 J7: library part D-300-0033, "Connector, 3.5mm Stereo Audio Socket, Black, 2 break contacts (normals) and 2 auxiliary make contacts"
J5: library part D-300-0031, "Connector, 3.5mm Stereo Audio Socket, Green, 2 break contacts (normals) and 2 auxiliary make contacts"
J6: library part D-300-0032, "Connector, 3.5mm Stereo Audio Socket, Blue, 2 break contacts (normals) and 2 auxiliary make contacts"
J8: library part D-300-0119, "Socket, 1x1 Tab-DOWN R/A 8-Way RJ45"
J9 J10: library part D-300-0009, "USB, MINI, SMD,  Molex"
J11 J12: library part D-300-0132, "Connector, TRC-005-4 , Black RCA Phono Jack, Right Angle, Thru-Hole, Snap-In"
J13 J15 J16: library part D-300-0122, "Socket, Screw Terminal Block, 6 Way, 5.0mm pitch, 45 degree angle, Through-hole"
J14: library part D-300-0123, "Socket, Screw Terminal Block, 12 Way, 5.0mm pitch, 45 degree angle, Through-hole"
J17: library part D-300-0120, "Connector, DB9 R/A Through-hole Male"
J18: library part D-300-0121, "Socket, High-Density DB15 (HD15) R/A Female Through-hole"
J19: library part D-300-0007, "Connector, 3 Conductor Power Jack 2 break 2 aux contacts"
J20 J21 J22: library part D-300-0118, "Socket, 5-way R/A DIN"
J23: library part D-300-0117, "Socket, PC Jack 8-Way, R/A Low-profile"
J25: library part D-300-0076, "Non-Boxed Header IDC, 2 X 5 Pin SMD"
J27 J28: library part D-300-0125, "Header FFC, 2x20 pin Vertical, 0.5mm"
J29 J30: library part D-300-0126, "Secure Digital Card Socket"
J31 J32: library part D-300-0124, "MINI DIN R/A F/SHLD 6P GOLD PLATED; Black"
J33: library part D-300-0115, "Connector, PCI Express, Used for Automatic Test Equipment (ATE)"
J34 J35: library part D-300-0131, "PH Series 2 x 1 Pin Vertical 2.0mm Pitch (Male)"
J36 J37 J38: library part D-300-0127, "CONNECTOR USB RT ANG RECEPT TYPE A"
JP1 JP2: library part D-300-0019, "Header IDC, 2 x 2 Pin Vertical 2.54mm Pitch (Non-Boxed, Male)"
L1 L2: library part D-102-0006, "Inductor, Coil 22uH  1210 (3225) LQH32CN220K21L"
L3: library part D-102-0005, "Inductor, 4.7uH 650mA 0.15R 1210 (3225) LQH32CN4R7M11L"
L4 L5 L6 L7 L8 L9: library part D-102-0026, "Inductor, Ferrite Bead 1K@100MHz 300mA 0402 BK1005HS102-T"
LED1 LED3 LED4: library part D-153-0002
LED2 LED5 LED8 LED9 LED10 LED12: library part D-153-0007
LED6 LED11 LED13 LED14 LED15: library part D-153-0006
LED7: library part D-153-0009, "LED, Red 0603 (1608) 63mCd"
LED16 LED17 LED18 LED19 LED20 LED21 LED22 LED23 LED24 LED25: library part D-153-0028, "LED, RGB, SMD"
LOGO1: library part D-000-0000
NT1 NT11: library part D-002-0004, "Net-Tie, Surface Mount, 2 x 2.0mm x 0.8mm SMT Pads - For 0.8mm Track"
NT4 NT5 NT6 NT7 NT46 NT47 NT48: library part D-002-0002, "Net-Tie, Surface Mount, 2 x 0.4mm x 0.2mm SMT Pads - For 0.2mm Track"
NT10 NT17 NT18 NT19 NT26 NT27 NT28 NT29 NT30 NT31 NT33 NT34 NT35 NT36 NT37 NT38 NT39 NT40 NT41 NT42 NT43 NT44 NT45: library part D-002-0003, "Net-Tie, Surface Mount, 2 x 1.6mm x 0.8mm SMT Pads - For 0.8mm Track"
PB_MH1 PB_MH2 PB_MH3 PB_MH4 PB_MH5: library part D-306-0001, "Spacer, 8.5mm GOLD, Splitted bottom, Female M3-thread"
PCB1: library part D-810-0053, "NB3000AL Blank PCB - NanoBoard  3000 Series with Altera Cyclone3"
PROTOTYPE1: library part D-006-0002, "Test Point Array"
Q1 Q2 Q3 Q5 Q11: library part D-158-0005, "N-channel Enhancement Mode Field-effect Transistor;  5.8A/30V"
Q4 Q6 Q7 Q8: library part D-158-0002, "N-channel Enhancement Mode Field-effect Transistor"
R1 R14: library part D-100-0098, "Resistor, 3K3 1% 0402 (1005)"
R2 R5 R6 R7 R10 R11 R12 R13 R15 R21 R35 R38 R110 R137 R138 R208 R247 R260 R272 R273 R274 R275 R276: library part D-100-0130, "Resistor, 10K 1% 0402 (1005)"
R3 R4 R215: library part D-100-0092, "Resistor, 47K 1% 0402 (1005)"
R8: library part D-100-0114, "Resistor, 22K 1% 0402 (1005)"
R9 R141 R142: library part D-100-0132, "Resistor, 100K 1% 0402 (1005)"
R16 R17 R18 R19 R20 R33: library part D-100-0102, "Resistor, 33R 1% 0402 (1005)"
R22 R25 R26 R27 R41 R42 R43 R44 R45 R46 R47 R50 R51 R52 R57 R59 R60 R61 R64 R65 R70 R73 R76 R77 R82 R83 R86 R87 R98 R99 R102 R103 R104 R105 R106 R107 R113 R114 R115 R148 R154 R158 R159 R161 R162 R163 R216 R217 R218 R219 R224 R225 R226 R227 R232 R236 R237 R238 R239 R240 R241 R242 R243 R248 R250 R251 R252 R253 R254 R255 R256 R271 R277 R278 R279 R280 R281 R282 R283 R284 R285 R286 R287 R288 R289 R290 R291 R292 R293 R294 R295 R296 R297 R298 R299 R300 R301 R302 R303 R304 R305 R306 R307 R308 R309 R310 R311 R312 R313: library part D-100-0088, "Resistor, 4K7 1% 0402 (1005)"
R23 R24 R116: library part D-100-0096, "Resistor, 430R 1% 0402 (1005)"
R28 R29 R100 R101 R153 R196 R213 R314: library part D-100-0085, "Resistor, 5R6 1% 0402 (1005)"
R30 R53 R56 R91 R93 R95 R97 R124 R126 R128 R130 R139 R140 R143 R144 R266: library part D-100-0121, "Resistor, 1K 1% 0402 (1005)"
R31 R32 R96 R125 R127 R129 R201 R203 R204 R205 R212 R214: library part D-100-0126, "Resistor, 120R 1% 0402 (1005)"
R34 R36: library part D-100-0001, "Resistor, 75R 1% 0402"
R37 R68 R69 R71 R72 R74 R75 R78 R80 R81 R84 R85 R88 R89 R147 R209 R210 R211 R220 R221 R222 R223 R228 R229 R230 R231 R233 R267 R268 R269 R270: library part D-100-0131, "Resistor, 100R 1% 0402 (1005)"
R39 R40 R195: library part D-100-0111, "Resistor, 270R 1% 0402 (1005)"
R48 R49 R54 R55: library part D-100-0017, "Resistor, 49R9 1% 0805 (2012)"
R58 R62 R63 R66 R67: library part D-100-0093, "Resistor, 470R 1% 0402 (1005)"
R79 R90 R92 R94 R112 R123 R133 R134 R135 R136 R149 R150 R151 R152 R160 R244 R249: library part D-100-0108, "Resistor, 27R 1% 0402 (1005)"
R108 R245: library part D-100-0105, "Resistor, 2K7 1% 0402 (1005)"
R109 R246: library part D-100-0086, "Resistor, 5K6 1% 0402 (1005)"
R111: library part D-100-0059, "Resistor, 10M 1%1206 (3216)"
R117 R118 R119 R120 R121 R122 R164 R165 R166 R167 R168 R169 R170 R171 R172 R173 R174 R175 R176 R177 R178 R179 R180 R181 R182 R183 R184 R185 R186 R187 R188 R189 R190 R191 R192 R193 R261 R262 R263: library part D-100-0005, "Resistor, 150R 1% 0402 (1005)"
R131 R145 R146 R155 R156 R157 R234 R235 R265: library part D-100-0107, "Resistor, 2K2 1% 0402 (1005)"
R132 R194 R197 R198 R199 R200: library part D-100-0115, "Resistor, 220R 1% 0402 (1005)"
R202: library part D-100-0174, "Resistor, 56R 1% 0402"
R206: library part D-100-0116, "Resistor, 200R 1% 0402 (1005)"
R207: library part D-100-0137, "Resistor, 0R 5% 0402 (1005)"
R257 R258 R259: library part D-100-0002, "Resistor, 12K 1% 0402"
R264: library part D-100-0104, "Resistor, 330R 1% 0402 (1005)"
RLY1 RLY2 RLY3 RLY4: library part D-313-0001, "Relay, Tyco IM03GR"
SW1 SW2 SW3 SW4 SW5 SW6: library part D-301-0001, "Switch, SPNO Push Button SMD"
SW7: library part D-301-0000, "Switch, SPDT Subminiature Toggle"
SW8: library part D-301-0018, "Switch, SPST, Surface Mount DIP, 8-way"
T1: library part D-107-0004, "Transformer, 1:1, SMD, 0 to 70 deg C,  1 to 7 Mbps, 500Vrms min"
TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12: library part D-006-0000, "Test Point, PCB Mount with Silkscreen Box"
U1: library part D-201-0003, "CS4270; 24-Bit, 192 kHz Stereo Audio CODEC"
U2: library part D-206-0000, "ICS307-02, SPI Programmable Clock Generator"
U3: library part D-205-0010, "74HCU04, HEX Inverter, Unbuffered"
U4 U37 U38 U54 U65 U66 U67 U68 U71 U72: library part D-205-0001, "SN74LVC1G04DBV, Single Inverter Gate, 1.65-V to 5.5-V"
U5: library part D-221-0000, "RTL8201CL-VD, Single-Chip/Single-Port 10/100 Fast Ethernet Phyceiver"
U6: library part D-205-0000, "SN74LVC244ADBR,  Octal Buffer/Driver with 3-State Outputs, 2.0V - 3.6V"
U7: library part D-262-0008, "IC Flash, S29GL128P11FFI010 128 Megabit 3.0V Page Mode Flash Memory"
U8: library part D-241-0023, "FPGA, Altera Cyclone3-40 F780"
U9 U10 U11 U20 U22 U25 U29: library part D-157-0000, "TVS Diode Array  For ESD and Latch-Up Protection"
U12 U13: library part D-261-0000, "MT48LC16M16A2TG, 256 Mbit High-Speed CMOS SDRAM, 16Mb x 16Bit x 4 Banks, TSOP54"
U14 U15 U16 U17 U47: library part D-260-0000, "K6R4016V1D-TC10T, 256K x 16-Bit SRAM, TSOP44"
U18 U55 U62 U63 U64: library part D-204-0001, "NUP2201MR6, Low Capacitance Diode Array, USB Protection"
U19 U56: library part D-221-0004, "CY7C68001-56LFC, EZ-USB SX2 High-Speed USB Interface"
U21: library part D-222-0000, "THS8134BCPHP, Triple 8-Bit, 80 MSPS Video DAC with Tri-Level Sync Generation"
U23: library part D-263-0008, "EPROM, 1-wire, 1024-bit, Surface Mount"
U24: library part D-220-0004, "ADC084S021, 8-bit ADC, 4 Channel, 50 ksps to 200ksps, SPI"
U26: library part D-201-0007, "PT2300, 2W x 2 Class AB Audio Power Amplifier"
U27: library part D-206-0006, "PCF2123TS, SPI Real time clock/calendar, TSSOP14"
U28: library part D-222-0004, "DAC084S085CIMM, Quad 8-bit, Single 2.7V to 5.5V rail-to-rail output"
U30: library part D-241-0026, "FPGA, Altera Cyclone3-10 F256"
U31 U32 U33 U34 U35: library part D-205-0004, "HEX Inverter"
U36: library part D-152-0005, "OPTOISOLATOR; SMD; Digital Output, Normal OFF  Operation"
U39 U40 U41: library part D-204-0033, "AP1084KL, 5A Low Dropout Positive Adjustable Regulator"
U42: library part D-204-0034, "NCP630A, 3.0A Fast Linear Voltage Regulator, D2PAK"
U43 U44 U58: library part D-204-0035, "TC1017R-3.3VLTTR, 3.3V Micropower Low Dropout Regulator, 5-Pin SC70-5"
U45 U49 U60: library part D-243-0000, "MAX6315, Open-Drain Output SOT Reset IC, Customized Reset Thresholds, Timeout Delays"
U46: library part D-221-0016, "ISL8491IB, RS-485/RS-422 Transceivers"
U48: library part D-202-0006, "XPT2046, Touch Screen Controller"
U50 U51 U52 U53: library part D-262-0009
U59: library part D-221-0017, "HIN232ACBNZ-T 5V,  True RS-232 Transceivers"
U61: library part D-221-0018, "Hi-Speed Universal Serial Bus host controller"
U69: library part D-200-0006, "Low Voltage 1R  SPDT Analog Switc"
U70: library part D-200-0000, "CY2305 Zero-Delay Buffer SOIC 8-pin 150mil body"
UH1 UH2: library part D-300-0021, "Header IDC, 2 x 10 Pin Vertical 2.54mm Pitch (Non-Boxed, Male)"
VR1: library part D-105-0001, "Potentiometer, 2 x 5K Linear 9mm PCB Mount Fluted Shaft"
Y1: library part D-103-0012, "Crystal, SMD, 20.000000MHz Stab=30ppm 20.0pF"
Y2: library part D-103-0030, "Crystal, SMD, 25.000000MHz Stab=50ppm 18.0pF"
Y3: library part D-103-0031, "Crystal, 32.768 KHz Surface Mount"
Y4: library part D-103-0013, "Crystal, SMD, 24.000000MHz Stab=30ppm 20.0pF"
Y5: library part D-103-0000, "Crystal, SMD, 12.000000MHz Stab=30ppm 20.0pF"

## Free pads (board coordinates)
  rect 236.22x236.22 hole 161.42: 0(-733.79,1574.73) 0(-733.79,6052.56) 0(8413.75,6052.57) 0(8413.75,1574.73)
  round 122.05 hole 122.05 unplated: 1(-726.95,4502.25) 1(8406.91,4502.25)

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias