# Altium PCB NB3000AL.PcbDoc (part 69 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
PWM.PWM3: LED10.1 R94.1 U8.B4 U11.1 U11.3 U11.4 U11.5 U11.6 | length 2900.3
  Top Layer w4: U11.3@3880,5248.82 U11.4@3952.83,5248.82 4072.34,5248.82 ; U11.1@3880,5300 U11.6@3952.83,5300 3970.9,5300 ; U11.3@3893.01,5244.67 cw(c3903.04,5234.64) 3903.04,5248.82 cw(c3903.04,5263) U11.3@3893.01,5252.97 ; U11.1@3893.01,5295.85 cw(c3903.04,5285.82) 3903.04,5300 cw(c3903.04,5314.18) U11.1@3893.01,5304.15 ; 3935.19,5247.35 cw(c3961.61,5247.35) U11.5@3947.18,5269.49 ; 3935.19,5248.82 3935.19,5274.41 ; 3935.19,5253.46 ccw(c3946.7,5253.46) U11.4@3940.88,5243.53 ; 3935.19,5254.74 cw(c3956.8,5254.74) U11.5@3945,5272.84 ; 3935.19,5260.44 ccw(c3950.79,5260.44) U11.4@3942.9,5246.98 ; 3935.19,5262.12 cw(c3951.99,5262.12) U11.5@3942.82,5276.19 ; 3935.19,5267.43 ccw(c3954.88,5267.43) U11.4@3944.92,5250.44 ; 3935.19,5269.5 cw(c3947.18,5269.5) U11.5@3940.63,5279.54 ; U11.5@3938.55,5272.16 ccw(c3935.19,5270.77) 3935.19,5274.41 ; U11.5@3938.55,5276.65 cw(c3935.19,5278.04) 3935.19,5274.41 ; U11.4@3939.82,5244.67 ccw(c3929.8,5234.64) 3929.8,5248.82 ccw(c3929.79,5263) U11.4@3939.82,5252.97 ; U11.6@3939.82,5295.85 ccw(c3929.8,5285.82) 3929.8,5300 ccw(c3929.79,5314.18) U11.6@3939.82,5304.15 ; U11.4@3946.95,5253.89 cw(c3958.98,5274.41) 3935.19,5274.41 ; U11.6@3958.58,5295.02 cw(c3944.71,5272.8) 3970.9,5272.8 ; U11.5@3958.85,5279.55 ccw(c3947.52,5300) 3970.9,5300 ; U11.6@3960.7,5298.41 cw(c3949.22,5280.02) 3970.9,5280.02 ; U11.5@3960.79,5276.05 ccw(c3951.28,5293.21) 3970.9,5293.21 ; U11.5@3962.72,5272.55 ccw(c3955.04,5286.42) 3970.9,5286.42 ; U11.6@3962.82,5301.8 cw(c3953.72,5287.23) 3970.9,5287.23 ; U11.5@3964.66,5269.05 ccw(c3958.8,5279.64) 3970.9,5279.64 ; U11.6@3964.94,5305.2 cw(c3958.22,5294.45) 3970.9,5294.45 ; U11.4@3965.85,5244.67 cw(c3975.87,5234.64) 3975.87,5248.82 cw(c3975.87,5263) U11.4@3965.85,5252.97 ; U11.6@3967.02,5297.52 cw(c3970.9,5295.72) 3970.9,5300 ; U11.6@3967.02,5302.47 ccw(c3970.9,5304.28) 3970.9,5300 ; 4117.07,5238.25 cw(c4133.82,5221.5) R94.1@4133.82,5245.19 ; 4118.26,5239.44 ccw(c4103.19,5254.51) R94.1@4124.5,5254.51 ; R94.1@4123.9,5245.08 cw(c4133.82,5235.16) R94.1@4133.82,5249.19 ; R94.1@4125.09,5246.27 ccw(c4116.85,5254.51) R94.1@4128.5,5254.51 ; R94.1@4133.82,5255 4099.99,5221.17 ; LED10.1@4574.91,5271.63 cw(c4544.72,5241.44) 4587.42,5241.44 cw(c4630.11,5241.43) LED10.1@4599.92,5271.63 ; LED10.1@4577.74,5274.45 cw(c4554.38,5251.09) 4587.42,5251.09 cw(c4620.45,5251.09) LED10.1@4597.09,5274.45 ; LED10.1@4580.57,5277.28 cw(c4564.03,5260.75) 4587.42,5260.75 cw(c4610.8,5260.75) LED10.1@4594.26,5277.28 ; v1@4581.47,5201.66 ccw(c4565.26,5185.44) 4565.26,5208.37 ccw(c4565.26,5231.31) 4581.47,5215.09 ccw(c4567.13,5229.44) 4587.42,5229.44 ; v1@4584.3,5204.49 ccw(c4574.91,5195.1) 4574.91,5208.37 ccw(c4574.91,5221.65) v1@4584.3,5212.26 ; 4587.42,5223.52 ccw(c4603.34,5223.52) v1@4592.08,5212.26 ; 4587.42,5233.18 ccw(c4613,5233.18) v1@4594.91,5215.09 ; LED10.1@4587.42,5284.13 4587.42,5209.1 v1@4588.14,5208.37 ; v1(4588.19,5208.37) v1@4588.14,5208.37 ; v1@4660.14,5199.99 cw(c4643.92,5183.77) 4666.86,5183.77 cw(c4689.79,5183.77) v1@4673.57,5199.99 ; v1@4662.97,5202.82 cw(c4653.58,5193.43) 4666.86,5193.43 cw(c4680.14,5193.43) v1@4670.75,5202.82 ; v1(4666.86,5206.71) 4666.86,5179.67 4657.19,5170 4657.19,5148.96 4732.19,5073.96 4732.19,4947.34 4803.82,4875.71 4885.61,4875.71 4961.11,4800.21 4961.11,4749.18 4961.11,4741.18 ; 3935.19,5274.41 U11.5@3952.83,5274.41 3970.9,5274.41 ; U11.5@3967.02,5271.93 cw(c3970.9,5270.13) 3970.9,5274.41 ; U11.5@3967.02,5271.93 cw(c3970.9,5270.13) 3970.9,5274.41 ; U11.5@3967.02,5271.93 cw(c3970.9,5270.13) 3970.9,5274.41 ; U11.5@3967.02,5276.88 ccw(c3970.9,5278.69) 3970.9,5274.41 ; U11.5@3967.02,5276.88 ccw(c3970.9,5278.69) 3970.9,5274.41 ; U11.5@3967.02,5276.88 ccw(c3970.9,5278.69) 3970.9,5274.41 ; 3970.9,5274.41 3970.9,5300 ; 4072.34,5248.82 4099.99,5221.17 ; 4072.34,5248.82 4099.99,5221.17 ; 4099.99,5221.17 4133.82,5187.34 4235,5187.34 4256.03,5208.37 v1@4588.14,5208.37 ; 4961.11,4701.84 ccw(c4971.26,4701.84) 4964.08,4694.66 ; 4961.11,4701.84 ccw(c4971.26,4701.84) 4964.08,4694.66 ; 4961.11,4701.84 4961.11,4741.18 ; 4961.11,4701.84 4961.11,4741.18 ; 4964.08,4694.66 ccw(c4976.61,4707.19) 4976.61,4689.47 cw(c4976.61,4707.19) 4964.08,4694.66 ; 4964.08,4694.66 cw(c4951.55,4682.13) 4969.27,4682.13 ccw(c4951.55,4682.13) 4964.08,4694.66
  MidLayer2 w4: v1(4588.19,5208.37) 4589.86,5206.71 v1(4666.86,5206.71) ; v1@4592.08,5212.26 ccw(c4605.49,5225.68) 4605.49,5206.71 ; v1@4594.91,5201.66 cw(c4607.1,5189.46) 4607.1,5206.71 ; v1@4594.91,5215.09 ccw(c4615.15,5235.33) 4615.15,5206.71 ; v1@4660.14,5199.99 ccw(c4643.92,5183.77) 4643.92,5206.71 ccw(c4643.92,5229.64) v1@4660.14,5213.43 ; v1@4662.97,5202.82 ccw(c4653.58,5193.43) 4653.58,5206.71 ccw(c4653.58,5219.99) v1@4662.97,5210.6
PWMPWR: F1.2 J16.1 J33.B13 | length 8596
  Top Layer w4: v1@2108.47,4956.76 ccw(c2092.26,4972.98) 2115.19,4972.98 ccw(c2138.13,4972.98) v1@2121.91,4956.76 ; v1@2111.3,4953.93 ccw(c2101.91,4963.32) 2115.19,4963.32 ccw(c2128.47,4963.32) v1@2119.08,4953.93 ; v1(2115.19,4950.04) 2115.19,5060.19 2122,5067 3077,5067 3098.19,5088.19 3098.19,5963.19 3132.06,5997.06 3307.94,5997.06 3335.92,5969.08 ; J16.1@3309.42,5909.08 ccw(c3254.75,5969.08) 3335.92,5969.08 ; J16.1@3312.12,5906.13 ccw(c3263,5960.02) 3335.92,5960.02 ccw(c3408.83,5960.02) J16.1@3359.72,5906.13 ; J16.1@3314.81,5903.17 ccw(c3271.26,5950.96) 3335.92,5950.96 ccw(c3400.58,5950.96) J16.1@3357.03,5903.17 ; J16.1@3317.5,5900.21 ccw(c3279.51,5941.91) 3335.92,5941.91 ccw(c3392.33,5941.91) J16.1@3354.33,5900.21 ; J16.1@3320.2,5897.26 ccw(c3287.76,5932.85) 3335.92,5932.85 ccw(c3384.07,5932.85) J16.1@3351.64,5897.26 ; J16.1@3322.89,5894.3 ccw(c3296.02,5923.79) 3335.92,5923.79 ccw(c3375.82,5923.79) J16.1@3348.94,5894.3 ; J16.1@3335.92,5880.01 3335.92,5969.08 ; J16.1@3362.41,5909.08 cw(c3417.09,5969.08) 3335.92,5969.08
  Top Layer w20: v1(3245,5730) v1(3265,5730) v1(3285,5730) v1@3290.19,5730 ; J16.1@3313.76,5857.85 cw(c3260.26,5804.35) 3335.92,5804.35 cw(c3411.58,5804.35) J16.1@3358.08,5857.85 ; 3335.92,5730 J16.1@3335.92,5880.01
  Bottom Layer w4: J33.B13@-785.98,3715.85 -655,3715.85 -623.63,3747.22 -459.09,3747.22 -435,3771.31 -435,4368.89 -243.85,4560.04 303.39,4560.04 ; J33.B13@-711.58,3710.35 cw(c-698.3,3697.07) -698.3,3715.85 cw(c-698.3,3734.63) J33.B13@-711.58,3721.35 ; J33.B13@-708.76,3707.52 cw(c-688.65,3687.41) -688.65,3715.85 cw(c-688.65,3744.29) J33.B13@-708.76,3724.18 ; 303.43,4560 465.15,4560 493.84,4588.69 585.21,4680.06 585.21,4953.9 630.5,4999.19 1277.52,4999.19 1310,4966.71 2098.52,4966.71 v1(2115.19,4950.04) ; v1@2105.69,4950.04 ccw(c2082.76,4950.04) 2098.97,4966.26 ccw(c2115.19,4982.48) v1@2115.19,4959.54 ; v1@2109.69,4950.04 ccw(c2096.41,4950.04) 2105.8,4959.43 ccw(c2115.19,4968.82) v1@2115.19,4955.54
  Bottom Layer w20: v1(3245,5730) v1(3265,5730) v1(3285,5730) v1(3305,5730) 3670,5730 3675.46,5724.54 4210.46,5724.54 4235.75,5699.25 ; F1.2@4216.92,5665.11 ccw(c4195.38,5699.25) 4235.75,5699.25 ; F1.2@4235.75,5590 4235.75,5699.25 ; F1.2@4254.57,5665.11 cw(c4276.12,5699.25) 4235.75,5699.25
REF_CLKA: R314.1 U8.AH14 U8.J28 | length 6840.7
  Top Layer w4: U8.AH14@5365.12,3653.31 cw(c5352.59,3640.78) 5370.32,3640.78 cw(c5388.04,3640.78) U8.AH14@5375.51,3653.31 ; v12(5365.4,3625) 5365.4,3619.3 5370.32,3624.22 5370.32,3630.42 5370.32,3638.82 U8.AH14@5370.31,3658.5 ; U8.J28@5921.5,4406.54 5941.18,4406.54 5949.46,4406.54 5978.21,4406.54 5991.75,4393 6021.38,4393 6030.57,4383.81 6068.38,4383.81 6083.19,4369 v2(6087,4369) ; U8.J28@5926.69,4401.34 cw(c5939.22,4388.81) 5939.22,4406.54 cw(c5939.22,4424.26) U8.J28@5926.69,4411.73 ; 6070.28,4381.9 ccw(c6080.17,4391.79) v2@6084.18,4378.4 ; 6072.95,4379.24 cw(c6062.7,4369) v2@6077.19,4369 ; 6075.02,4377.17 ccw(c6082.35,4384.5) v2@6085.33,4374.57 ; v2@6690.16,3886.34 ccw(c6653.62,3922.88) 6705.3,3922.88 ; v2@6692.99,3883.51 ccw(c6663.27,3913.23) 6705.3,3913.23 ; v2@6695.82,3880.68 ccw(c6672.93,3903.57) 6705.3,3903.57 ; v2(6697.1,3879.4) 6705.3,3887.6 6705.3,3923.85 6697.69,3931.46 6697.69,3945.96 6714.19,3962.46 6714.19,4041.87 6707.19,4048.87 6707.19,4092.04 6724.4,4109.25 6724.4,4123.75 ; v2@6698.65,3877.85 ccw(c6682.59,3893.91) 6705.3,3893.91 ; v2(6698.93,4336.01) 6698.93,4321.2 6707.02,4313.11 6707.02,4275.52 ; 6706.36,4274.86 6706.36,4189.23 6723.86,4171.73 6723.86,4124.29
  MidLayer1 w4: v12@5360.1,3619.7 cw(c5347.29,3606.89) 5365.4,3606.89 cw(c5383.51,3606.89) v12@5370.7,3619.7 ; v12@5364.6,3624.2 v12(5365.4,3625) 5365.4,3593.54 5384.19,3574.75 5384.19,3534.31 5389,3529.5 5389,3494.76 5386.8,3492.56 5386.8,3471.44 5393.9,3464.34 5393.9,3372.6 v1@5394.6,3371.9 ; v1@5387.38,3378.7 ccw(c5371.65,3394.43) 5393.9,3394.43 ; v1@5390.21,3375.87 ccw(c5381.3,3384.77) 5393.9,3384.77 ; 5393.9,3385.74 ccw(c5407.86,3385.74) v1@5397.99,3375.87 ; 5393.9,3395.4 ccw(c5417.52,3395.4) v1@5400.82,3378.7 ; v2@5998.06,3463.06 cw(c5981.31,3446.31) 6005,3446.31 cw(c6028.69,3446.31) v2@6011.94,3463.06 ; v2@5999.06,3338.94 ccw(c5982.31,3355.69) 6006,3355.69 ccw(c6029.69,3355.69) v2@6012.94,3338.94 ; v2@5999.41,3475.59 v2@6002.81,3478.99 ; v2@6000.89,3465.89 cw(c5990.97,3455.97) 6005,3455.97 cw(c6019.03,3455.97) v2@6009.11,3465.89 ; v2@6001.89,3336.11 ccw(c5991.97,3346.03) 6006,3346.03 ccw(c6020.03,3346.03) v2@6010.11,3336.11 ; v2(6005,3470) 6005,3405 6000,3400 6000,3363 6006,3357 v2(6006,3332) ; v2(6482.04,4391) 6505.19,4391 ; v2@6486.22,4386.96 cw(c6495.75,4377.73) 6495.75,4391 cw(c6495.75,4404.27) v2@6486.22,4395.04 ; v2@6489.09,4384.18 cw(c6505.19,4368.59) 6505.19,4391 ; v2@6489.09,4397.82 ccw(c6505.19,4413.41) 6505.19,4391 ; v2@6590.96,3197.54 ccw(c6574.72,3213.78) 6597.69,3213.78 ; v2@6593.79,3194.71 ccw(c6584.38,3204.12) 6597.69,3204.12 ; 6597.69,3205.14 ccw(c6612.44,3205.14) v2@6602.01,3194.71 ; 6597.69,3214.79 ccw(c6622.09,3214.79) v2@6604.84,3197.54 ; v2(6597.9,3190.6) 6597.69,3190.81 6597.69,3273.96 6615.7,3291.96 6615.7,3706.15 6697.1,3787.56 v2(6697.1,3879.4) ; v2@6690.16,3872.46 cw(c6673.41,3855.71) 6697.1,3855.71 cw(c6720.79,3855.71) v2@6704.04,3872.46 ; v2@6691.99,4329.08 ccw(c6675.24,4312.33) 6675.24,4336.01 ccw(c6675.24,4359.7) v2@6691.99,4342.95 ; v2@6692.99,3875.29 cw(c6683.07,3865.37) 6697.1,3865.37 cw(c6711.13,3865.37) v2@6701.21,3875.29 ; v2@6694.82,4331.91 ccw(c6684.9,4321.99) 6684.9,4336.01 ccw(c6684.9,4350.04) v2@6694.82,4340.12 ; v2(6698.93,4336.01) 6672.11,4336.01 6641.08,4367.04 6529.15,4367.04 6505.19,4391
  MidLayer2 w4: v1(5394.1,3371.98) 5392.5,3373.58 5392.5,3437.45 5431.05,3476 5442.44,3476 5450,3483.56 5450,3525 5468.7,3543.7 ; v1@5478.86,3538.34 ccw(c5468.7,3531.4) 5468.7,3543.7 ; v1@5478.86,3549.06 cw(c5468.7,3556) 5468.7,3543.7 ; v1(5486.7,3543.7) 5468.7,3543.7 ; v2(5785.3,3472.4) 5820,3472.4 5822.4,3470 v2(6005,3470) ; v2@5789.41,3468.29 cw(c5799.33,3458.37) 5799.33,3472.4 cw(c5799.33,3486.43) v2@5789.41,3476.51 ; v2@5792.24,3465.46 cw(c5808.99,3448.71) 5808.99,3472.4 cw(c5808.99,3496.09) v2@5792.24,3479.34 ; v2@5998.06,3463.06 ccw(c5981.31,3446.31) 5981.31,3470 ccw(c5981.31,3493.69) v2@5998.06,3476.94 ; v2@6000.89,3465.89 ccw(c5990.97,3455.97) 5990.97,3470 ccw(c5990.97,3484.03) v2@6000.89,3474.11 ; v2@6006,3322.19 cw(c6006,3298.5) 6022.75,3315.25 cw(c6039.5,3332) v2@6015.81,3332 ; v2@6006,3326.19 cw(c6006,3312.16) 6015.92,3322.08 cw(c6025.84,3332) v2@6011.81,3332 ; v2(6006,3332) 6023.97,3314.03 6026.46,3314.03 6098.98,3241.5 6267.3,3241.5 6300,3208.8 6437.1,3208.8 6463.8,3235.5 6553,3235.5 v2(6597.9,3190.6) ; v2@6087,4359.19 cw(c6087,4335.5) 6103.75,4352.25 cw(c6120.5,4369) v2@6096.81,4369 ; v2@6087,4363.19 cw(c6087,4349.16) 6096.92,4359.08 cw(c6106.84,4369) v2@6092.81,4369 ; v2(6087,4369) 6103.81,4352.19 6120.94,4352.19 6132.5,4363.75 ; 6133.37,4364.37 6169,4400 6250.65,4400 6281.15,4369.5 6446.67,4369.5 6468.17,4391 v2(6482.04,4391) ; v2@6588.09,3190.6 ccw(c6564.4,3190.6) 6581.15,3207.35 ccw(c6597.9,3224.1) v2@6597.9,3200.41 ; v2@6592.09,3190.6 ccw(c6578.06,3190.6) 6587.98,3200.52 ccw(c6597.9,3210.44) v2@6597.9,3196.41
  Bottom Layer w4: v1@5486.7,3534.2 cw(c5486.7,3511.26) 5502.92,3527.48 cw(c5519.13,3543.7) v1@5496.2,3543.7 ; v1@5486.7,3538.2 cw(c5486.7,3524.92) 5496.09,3534.31 cw(c5505.48,3543.7) v1@5492.2,3543.7 ; v1(5486.7,3543.7) 5518,3512.4 5518,3453.72 5524.04,3447.68 5524.04,3423.15 5552.19,3395 5630.19,3395 5652.19,3417 5665.5,3417 ; 5698.5,3450 5665.5,3417 ; v2@5778.36,3465.46 ccw(c5761.61,3448.71) 5761.61,3472.4 ccw(c5761.61,3496.09) v2@5778.36,3479.34 ; v2@5781.19,3468.29 ccw(c5771.27,3458.37) 5771.27,3472.4 ccw(c5771.27,3486.43) v2@5781.19,3476.51 ; v2(5785.3,3472.4) 5720.9,3472.4 5665.5,3417 ; v2(6697.1,3879.4) 6756.08,3879.4 6800.48,3835 6830,3835 6890,3895 6965,3895 7006.36,3936.36 7006.36,4066.36 7027.21,4087.21 7111.63,4087.21 7140.96,4057.87 7204.96,4057.87 7238.63,4091.54 7260.4,4091.54 7282.86,4114 7365.52,4114 7365.65,4113.87 7393.4,4113.87 7393.53,4114 7805.88,4114 7864.88,4055 R314.1@7980,4055 ; v2@6701.21,3875.29 cw(c6711.13,3865.37) 6711.13,3879.4 cw(c6711.13,3893.43) v2@6701.21,3883.51 ; v2@6704.04,3872.46 cw(c6720.79,3855.71) 6720.79,3879.4 cw(c6720.79,3903.09) v2@6704.04,3886.34
REF_CLKB: R213.1 U8.B14 | length 4769
  Top Layer w4: U8.B14@5362.97,4682.13 ccw(c5345.25,4682.13) 5357.78,4694.66 ; U8.B14@5370.32,4689.47 cw(c5370.32,4707.19) 5357.78,4694.66 ; v2(5387.44,4922.44) 5377.5,4912.5 5377.5,4817.5 5354.81,4794.81 5354.81,4750.19 5354.81,4741.18 5354.81,4701.84 ccw(c5364.96,4701.84) 5357.78,4694.66
  MidLayer2 w4: v2(7995,3980) 8026.24,3980 8075,4028.76 v2(8075,4210) ; v2@7999.11,3975.89 cw(c8009.03,3965.97) 8009.03,3980 cw(c8009.03,3994.03) v2@7999.11,3984.11 ; v2@8001.94,3973.06 cw(c8018.69,3956.31) 8018.69,3980 cw(c8018.69,4003.69) v2@8001.94,3986.94 ; v2@8068.06,4203.06 cw(c8051.31,4186.31) 8075,4186.31 cw(c8098.69,4186.31) v2@8081.94,4203.06 ; v2@8070.89,4205.89 cw(c8060.97,4195.97) 8075,4195.97 cw(c8089.03,4195.97) v2@8079.11,4205.89
  Bottom Layer w4: v2@5380.5,4929.37 ccw(c5363.75,4946.12) 5387.44,4946.12 ccw(c5411.12,4946.12) v2@5394.37,4929.37 ; v2@5383.33,4926.55 ccw(c5373.41,4936.47) 5387.44,4936.47 ccw(c5401.47,4936.47) v2@5391.55,4926.55 ; v2@5390,4925 v2(5387.44,4922.44) 5387.44,4949.79 ; v2(7995,3980) 8015,3980 ; v2@7999.6,3976.44 cw(c8006.85,3970.83) 8006.85,3980 cw(c8006.85,3989.17) v2@7999.6,3983.56 ; v2@8002.76,3974 cw(c8015,3964.52) 8015,3980 ; v2@8002.76,3986 ccw(c8015,3995.48) 8015,3980 ; R213.1@8020.24,3945 8020.24,3974.76 8015,3980 ; v2@8065.19,4210 ccw(c8041.5,4210) 8058.25,4226.75 ccw(c8075,4243.5) v2@8075,4219.81 ; v2@8069.19,4210 ccw(c8055.16,4210) 8065.08,4219.92 ccw(c8075,4229.84) v2@8075,4215.81 ; v2(8075,4210) 8046,4239 8046,4252 8106.86,4312.86 8106.86,4637.86 7956.16,4788.56 7956.16,4816.16 7902.62,4869.69 ; 5356.86,4980.37 5356.86,5025.52 5376.46,5045.12 5397.59,5045.12 5404.07,5038.64 5711.87,5038.64 5748.52,5075.29 5748.52,5163.52 5835.04,5250.04 7059.96,5250.04 7118.63,5191.37 7139.25,5191.37 7139.41,5191.54 7157.64,5191.54 7157.8,5191.37 7424.94,5191.37 7536.31,5080 7570.25,5080 7577.75,5072.5 7631.79,5072.5 7632.42,5073.13 7731.86,4973.69 7731.86,4951.96 7766.44,4917.38 7854.93,4917.38 ; 5356.86,4980.37 5370.11,4967.12 ; 5356.86,4980.37 5370.11,4967.12 ; 5370.11,4967.12 5376.74,4960.49 5387.44,4949.79 ; 5370.11,4967.12 5387.44,4949.79 ; 7854.93,4917.38 7902.62,4869.69 ; 7854.93,4917.38 7855.24,4917.38 7902.62,4870 7902.62,4869.69
RELAY.RELAY0: LED11.1 R96.1 U8.C7 | length 4861.8
  Top Layer w4: v1@4732.47,5334.99 cw(c4714.3,5316.82) R96.1@4740,5316.82 ; v1@4735.3,5337.82 cw(c4723.96,5326.47) 4740,5326.47 ; R96.1@4736.24,5314.94 ccw(c4727.16,5324.02) 4740,5324.02 ccw(c4752.84,5324.02) R96.1@4743.76,5314.94 ; v1@4739.19,5347.21 ccw(c4739.19,5360.49) 4748.58,5351.1 ccw(c4757.97,5341.71) v1@4744.69,5341.71 ; v1@4739.19,5351.21 ccw(c4739.19,5374.14) 4755.41,5357.93 ccw(c4771.63,5341.71) v1@4748.69,5341.71 ; R96.1@4740,5311.18 4740,5341.04 4739.33,5341.71 v1(4739.19,5341.71) 4756.86,5359.37 4756.86,5540.04 4808.52,5591.71 4972.54,5591.71 4990,5574.25 4990,5385 4978,5373 4978,5306.88 4989.86,5295.02 4989.86,5234.69 5023.52,5201.02 5023.52,5175.04 5010.19,5161.71 5009.5,5161.02 5009.5,4955.73 5010.19,4955.04 5031.86,4933.37 5031.86,4876.98 5065,4843.84 ; R96.1@4740,5320.73 cw(c4760.17,5320.73) v1@4745.91,5334.99 ; 5065,4844 5065,4843.84 ; LED11.1@7227.37,5782.07 cw(c7204.06,5755.88) 7239.12,5755.88 ; LED11.1@7230.03,5785.06 cw(c7211.99,5764.79) 7239.12,5764.79 cw(c7266.25,5764.79) LED11.1@7248.22,5785.06 ; LED11.1@7232.69,5788.05 cw(c7219.92,5773.7) 7239.12,5773.7 cw(c7258.32,5773.7) LED11.1@7245.56,5788.05 ; LED11.1@7239.12,5795.28 7239.12,5755.88 ; LED11.1@7250.88,5782.07 ccw(c7274.18,5755.88) 7239.12,5755.88 ; v1@7257.88,5743.97 ccw(c7244.96,5733.25) 7244.96,5750.04 ; v1@7257.88,5756.11 cw(c7244.96,5766.83) 7244.96,5750.04 ; v1@7260.96,5746.53 ccw(c7253.48,5740.32) 7253.48,5750.04 ccw(c7253.48,5759.76) v1@7260.96,5753.55 ; v1(7265.19,5750.04) 7244.96,5750.04 ; 5065,4843.84 5065,4815.84 5070.86,4809.97 5070.86,4741.18 5070.86,4737.07 5070.86,4682.64 ; 5070.86,4682.64 ccw(c5109.54,4682.64) 5082.19,4655.29 ; 5070.86,4682.64 ccw(c5109.54,4682.64) 5082.19,4655.29 ; 5082.19,4655.29 cw(c5069.66,4642.76) 5087.38,4642.76 ccw(c5069.66,4642.76) 5082.19,4655.29 ; 5082.19,4655.29 ccw(c5094.72,4667.82) 5094.72,4650.1 cw(c5094.72,4667.82) 5082.19,4655.29 ; 7239.12,5755.88 7244.96,5750.04
  MidLayer2 w4: v1(4739.19,5341.71) 4990.19,5341.71 5041.86,5393.37 v1(5873.52,5393.37) ; v1@4743.08,5337.82 cw(c4752.47,5328.43) 4752.47,5341.71 cw(c4752.47,5354.99) v1@4743.08,5345.6 ; v1@4745.91,5334.99 cw(c4762.13,5318.77) 4762.13,5341.71 cw(c4762.13,5364.64) v1@4745.91,5348.43 ; v1@5866.81,5386.66 ccw(c5850.59,5370.44) 5850.59,5393.37 ccw(c5850.59,5416.31) v1@5866.81,5400.09 ; v1@5869.64,5389.49 ccw(c5860.25,5380.1) 5860.25,5393.37 ccw(c5860.25,5406.65) v1@5869.64,5397.26
  Bottom Layer w4: v1(5873.52,5393.37) 5897.52,5417.37 6140.86,5417.37 6373.52,5650.04 6415.52,5692.04 7101.84,5692.04 7159.84,5750.04 v1(7265.19,5750.04) ; v1@5873.52,5398.87 ccw(c5873.52,5412.15) 5882.91,5402.76 ccw(c5892.3,5393.37) v1@5879.02,5393.37 ; v1@5873.52,5402.87 ccw(c5873.52,5425.81) 5889.74,5409.59 ccw(c5905.96,5393.37) v1@5883.02,5393.37 ; v1@7258.47,5743.32 ccw(c7242.26,5727.11) 7242.26,5750.04 ccw(c7242.26,5772.98) v1@7258.47,5756.76 ; v1@7261.3,5746.15 ccw(c7251.91,5736.76) 7251.91,5750.04 ccw(c7251.91,5763.32) v1@7261.3,5753.93
RELAY.RELAY1: LED13.1 R125.1 U8.C11 | length 3770.4
  Top Layer w4: U8.C11@5244.86,4642.76 ccw(c5227.14,4642.76) 5239.67,4655.29 ; U8.C11@5252.2,4650.1 cw(c5252.2,4667.82) 5239.67,4655.29 ; v1(5365.19,5325.04) 5351.33,5311.18 ; LED13.1@7226.62,5637.4 ccw(c7193.85,5670.17) 7240.19,5670.17 ; LED13.1@7229.45,5634.57 ccw(c7203.51,5660.51) 7240.19,5660.51 ; LED13.1@7232.27,5631.75 ccw(c7213.17,5650.86) 7240.19,5650.86 ; v1@7233.47,5693.32 cw(c7217.26,5677.11) 7240.19,5677.11 cw(c7263.13,5677.11) v1@7246.91,5693.32 ; v1@7236.3,5696.15 cw(c7226.91,5686.76) 7240.19,5686.76 cw(c7253.47,5686.76) v1@7244.08,5696.15 ; LED13.1@7239.12,5624.9 7240.19,5625.96 v1(7240.19,5700.04) ; 7240.19,5645.7 ccw(c7259.93,5645.7) LED13.1@7245.97,5631.75 ; 7240.19,5655.36 ccw(c7269.59,5655.36) LED13.1@7248.8,5634.57 ; 7240.19,5665.02 ccw(c7279.24,5665.02) LED13.1@7251.63,5637.4 ; 5239.67,4655.29 cw(c5267.02,4682.64) 5228.34,4682.64 5228.34,4741.18 5228.34,4751.18 5228.34,4770.59 5219.5,4779.44 5219.5,4800.56 5230,4811.06 5230,4876.85 5241.69,4888.54 5241.69,4963.31 5217.7,4987.3 5217.7,5060 5265,5107.3 5265,5124 ; 5265,5124 5292.37,5151.37 ; 5265,5124 5292.37,5151.37 ; 5292.38,5151.37 cw(c5292.38,5132.59) 5306.42,5145.07 ccw(c5292.38,5132.59) 5292.38,5151.37 ; 5292.38,5151.37 ccw(c5292.38,5170.16) 5306.42,5157.68 cw(c5292.38,5170.16) 5292.38,5151.37 ; 5292.37,5151.37 v1(5313.52,5151.37) 5292.37,5151.37 ; 5301.28,5151.37 cw(c5301.28,5140.5) 5309.41,5147.72 ccw(c5301.28,5140.5) 5301.28,5151.37 ; 5301.28,5151.37 ccw(c5301.28,5162.25) 5309.41,5155.03 cw(c5301.28,5162.25) 5301.28,5151.37 ; 5342.39,5311.18 ccw(c5342.39,5300.54) 5334.46,5307.64 cw(c5342.38,5300.54) 5342.38,5311.18 ; 5342.39,5311.18 cw(c5342.39,5321.82) 5334.46,5314.73 ccw(c5342.39,5321.82) 5342.39,5311.18 ; 5351.33,5311.18 ccw(c5351.33,5292.54) 5337.44,5304.97 cw(c5351.33,5292.54) 5351.33,5311.18 ; 5351.33,5311.18 cw(c5351.33,5329.82) 5337.44,5317.39 ccw(c5351.33,5329.82) 5351.33,5311.18 ; 5351.33,5311.18 R125.1@5330,5311.18 5351.33,5311.18
  MidLayer1 w4: v1@5306.81,5158.09 ccw(c5290.59,5174.31) 5313.52,5174.31 ccw(c5336.46,5174.31) v1@5320.24,5158.09 ; v1@5309.64,5155.26 ccw(c5300.25,5164.65) 5313.52,5164.65 ccw(c5326.8,5164.65) v1@5317.41,5155.26 ; v1(5313.52,5151.37) 5313.52,5189.68 5321.15,5197.31 5321.15,5218.69 5321.15,5250.66 ; v1@5358.47,5318.32 cw(c5342.26,5302.11) 5365.19,5302.11 cw(c5388.13,5302.11) v1@5371.91,5318.32 ; v1@5361.3,5321.15 cw(c5351.91,5311.76) 5365.19,5311.76 cw(c5378.47,5311.76) v1@5369.08,5321.15 ; v1(5365.19,5325.04) 5365.19,5294.71 ; 5321.15,5250.66 5339.36,5268.87 ; 5321.15,5250.66 5339.36,5268.87 ; 5339.36,5268.87 5341.96,5271.47 ; 5339.36,5268.87 5341.96,5271.47 ; 5341.96,5271.47 5365.19,5294.71 ; 5341.96,5271.47 5365.19,5294.71
  Bottom Layer w4: v1(5365.19,5325.04) 5406.86,5366.71 5884.84,5366.71 5919.5,5401.37 6147.69,5401.37 6422.35,5676.04 7123.96,5676.04 7160,5640 7205,5640 7240.19,5675.19 v1(7240.19,5700.04) ; v1@5365.19,5330.54 ccw(c5365.19,5343.82) 5374.58,5334.43 ccw(c5383.97,5325.04) v1@5370.69,5325.04 ; v1@5365.19,5334.54 ccw(c5365.19,5357.48) 5381.41,5341.26 ccw(c5397.63,5325.04) v1@5374.69,5325.04 ; v1@7233.47,5693.32 cw(c7217.26,5677.11) 7240.19,5677.11 cw(c7263.13,5677.11) v1@7246.91,5693.32 ; v1@7236.3,5696.15 cw(c7226.91,5686.76) 7240.19,5686.76 cw(c7253.47,5686.76) v1@7244.08,5696.15
RELAY.RELAY2: LED14.1 R127.1 U8.B12 | length 3684
  Top Layer w4: v1(5278.32,5182.58) 5307.07,5182.58 5348.36,5141.29 5348.36,4969.84 5298,4919.48 5298,4845.82 5271.19,4819 5271.19,4791 5276.07,4786.12 5276.07,4701.84 ccw(c5286.22,4701.84) 5279.04,4694.66 ; v1@5282.21,5178.69 cw(c5291.6,5169.3) 5291.6,5182.58 cw(c5291.6,5195.86) v1@5282.21,5186.47 ; U8.B12@5284.23,4682.13 ccw(c5266.51,4682.13) 5279.04,4694.66 ; v1@5285.04,5175.86 cw(c5301.25,5159.65) 5301.25,5182.58 cw(c5301.25,5205.52) v1@5285.04,5189.3 ; U8.B12@5291.58,4689.47 cw(c5291.58,4707.19) 5279.04,4694.66 ; v1(5876.86,5333.37) 5876.86,5319.18 5884.86,5311.18 R127.1@5910,5311.18 ; R127.1@5902.92,5304.59 ccw(c5887.01,5288.68) 5887.01,5311.18 ccw(c5887.01,5333.68) R127.1@5902.92,5317.77 ; R127.1@5905.75,5307.42 ccw(c5896.67,5298.34) 5896.67,5311.18 ccw(c5896.67,5324.02) R127.1@5905.75,5314.94 ; LED14.1@7239.12,5454.51 7242.99,5458.37 v1(7298.52,5458.37) ; LED14.1@7243.14,5450.49 cw(c7262.18,5431.46) 7262.18,5458.37 ; LED14.1@7245.97,5447.66 cw(c7271.83,5421.8) 7271.83,5458.37 ; LED14.1@7248.8,5444.83 cw(c7281.49,5412.14) 7281.49,5458.37 ; LED14.1@7248.8,5464.19 ccw(c7262.83,5478.22) 7262.83,5458.37 ; LED14.1@7251.63,5467.02 ccw(c7272.49,5487.88) 7272.49,5458.37 ; v1@7291.81,5451.66 ccw(c7275.59,5435.44) 7275.59,5458.37 ccw(c7275.59,5481.31) v1@7291.81,5465.09 ; v1@7294.64,5454.49 ccw(c7285.25,5445.1) 7285.25,5458.37 ccw(c7285.25,5471.65) v1@7294.64,5462.26
  MidLayer2 w4: v1@5271.6,5189.3 ccw(c5257.3,5203.6) 5277.52,5203.6 ; 5277.52,5197.78 ccw(c5293.51,5197.78) v1@5282.21,5186.47 ; 5277.52,5207.43 ccw(c5303.17,5207.43) v1@5285.04,5189.3 ; v1(5278.32,5182.58) 5277.52,5183.37 5277.52,5215.37 5362.19,5300.04 5405,5300.04 ; v1@5867.36,5333.37 cw(c5844.42,5333.37) 5860.64,5317.16 cw(c5876.86,5300.94) v1@5876.86,5323.87 ; v1@5871.36,5333.37 cw(c5858.08,5333.37) 5867.47,5323.99 cw(c5876.86,5314.6) v1@5876.86,5327.87 ; v1(5876.86,5333.37) 5843.52,5300.04 5431.86,5300.04 ; 5405,5300.04 5431.86,5300.04 ; 5405,5300.04 5431.86,5300.04
  Bottom Layer w4: v1(5876.86,5333.37) 6500,5333.37 ; v1@5880.75,5329.49 cw(c5890.14,5320.1) 5890.14,5333.37 cw(c5890.14,5346.65) v1@5880.75,5337.26 ; v1@5883.57,5326.66 cw(c5899.79,5310.44) 5899.79,5333.37 cw(c5899.79,5356.31) v1@5883.57,5340.09 ; v1@7291.81,5451.66 cw(c7275.59,5435.44) 7298.52,5435.44 cw(c7321.46,5435.44) v1@7305.24,5451.66 ; v1@7294.64,5454.49 cw(c7285.25,5445.1) 7298.52,5445.1 cw(c7311.8,5445.1) v1@7302.41,5454.49 ; v1(7298.52,5458.37) 7298.52,5383.52 7270.54,5355.54 ; 6500,5333.37 6571.63,5333.37 ; 6500,5333.37 6505,5333.37 ; 6505,5333.37 6571.63,5333.37 ; 6505,5333.37 6571.63,5333.37 ; 6571.63,5333.37 6622.29,5282.71 7075.04,5282.71 ; 7075.04,5282.71 7083.37,5291.04 ; 7075.04,5282.71 7083.37,5291.04 ; 7083.37,5291.04 7161.04,5291.04 7225.54,5355.54 ; 7225.54,5355.54 7270.54,5355.54 ; 7225.54,5355.54 7270.54,5355.54
RELAY.RELAY3: LED15.1 R129.1 U8.A12 | length 2939.2
  Top Layer w4: U8.A12@5286.38,4726.69 ccw(c5273.85,4739.22) 5291.57,4739.22 ccw(c5309.3,4739.22) U8.A12@5296.77,4726.69 ; U8.A12@5291.57,4721.5 5291.58,4781.92 5279.19,4794.31 5279.19,4815.69 5306,4842.5 5306,4916 5356.36,4966.36 5356.36,5157.88 5356.86,5158.37 v1(5373.52,5175.04) ; v1@5364.02,5175.04 cw(c5341.09,5175.04) 5357.31,5158.82 cw(c5373.52,5142.61) v1@5373.52,5165.54 ; v1@5368.02,5175.04 cw(c5354.75,5175.04) 5364.13,5165.65 cw(c5373.52,5156.26) v1@5373.52,5169.54 ; R129.1@6505,5311.18 6523.86,5311.18 ; R129.1@6513.01,5305.68 cw(c6523.86,5297.74) 6523.86,5311.18 ; R129.1@6513.01,5316.68 ccw(c6523.86,5324.62) 6523.86,5311.18 ; 6522.54,5312.49 cw(c6509.85,5299.8) v1@6526.7,5293.61 ; 6526.97,5308.07 cw(c6516.32,5297.43) v1@6530.45,5292.23 ; 6531.39,5303.65 cw(c6522.79,5295.05) v1@6534.2,5290.84 ; v1(6531.86,5291.71) 6531.86,5303.18 6523.86,5311.18 ; v1(7231.86,5333.37) 7231.86,5318.64 7239.12,5311.37 ; LED15.1@7231.92,5300.28 ccw(c7226.97,5311.37) 7239.12,5311.37 ; LED15.1@7233.55,5296.62 ccw(c7229.72,5305.21) 7239.12,5305.21 ccw(c7248.53,5305.21) LED15.1@7244.7,5296.62 ; LED15.1@7239.12,5284.12 7239.12,5311.37 ; LED15.1@7246.33,5300.28 cw(c7251.27,5311.37) 7239.12,5311.37
  Bottom Layer w4: v1(5373.52,5175.04) 5506.86,5308.37 5513.98,5315.5 5900,5315.5 5909.87,5325.37 6498.19,5325.37 v1(6531.86,5291.71) 6548.86,5274.71 7078.35,5274.71 7086.69,5283.04 7181.52,5283.04 7183.48,5285 7205.48,5307 v1(7231.86,5333.37) ; v1@6522.36,5291.71 ccw(c6499.42,5291.71) 6515.64,5307.93 ccw(c6531.86,5324.14) v1@6531.86,5301.21 ; v1@6526.36,5291.71 ccw(c6513.08,5291.71) 6522.47,5301.1 ccw(c6531.86,5310.49) v1@6531.86,5297.21 ; v1@6531.86,5282.21 cw(c6531.86,5259.27) 6548.07,5275.49 cw(c6564.29,5291.71) v1@6541.36,5291.71 ; v1@6531.86,5286.21 cw(c6531.86,5272.93) 6541.25,5282.32 cw(c6550.64,5291.71) v1@6537.36,5291.71 ; v1@7222.36,5333.37 cw(c7199.42,5333.37) 7215.64,5317.16 cw(c7231.86,5300.94) v1@7231.86,5323.87 ; v1@7226.36,5333.37 cw(c7213.08,5333.37) 7222.47,5323.99 cw(c7231.86,5314.6) v1@7231.86,5327.87
RELAYS#.C0: J14.2 RLY1.3 RLY1.6 | length 872.6
  Top Layer w30: J14.2@4999.71,5880 ccw(c5071.45,5880) 5020.72,5829.28 ; J14.2@5003.37,5880 5003.37,5846.63 5167.6,5682.4 RLY1.6@5167.6,5481.22 RLY1.3@5167.6,5245 ; J14.2@5029.71,5880 ccw(c5173.87,5880) 5071.94,5778.06
RELAYS#.C1: J14.5 RLY2.3 RLY2.6 | length 796.5
  Top Layer w30: J14.5@5593.93,5853.66 cw(c5593.93,5790.07) 5638.89,5835.04 cw(c5683.85,5880) J14.5@5620.26,5880 ; J14.5@5593.93,5880 5742.6,5731.33 RLY2.6@5742.6,5481.22 RLY2.3@5742.6,5245
RELAYS#.C2: J14.8 RLY3.3 RLY3.6 | length 800.4
  Top Layer w30: J14.8@6184.48,5853.66 cw(c6184.48,5790.07) 6229.44,5835.04 cw(c6274.4,5880) J14.8@6210.82,5880 ; J14.8@6184.48,5880 6342.6,5721.88 RLY3.6@6342.6,5481.22 RLY3.3@6342.6,5245
RELAYS#.C3: J14.11 RLY4.3 RLY4.6 | length 895.4
  Top Layer w30: J14.11@6775.03,5880 6775.03,5824.97 ; RLY4.3@6922.6,5245 RLY4.6@6922.6,5481.22 6922.6,5747.4 6860,5810 6790,5810 6775.03,5824.97 ; 6775.03,5824.98 ccw(c6730.72,5824.98) 6758.51,5859.49 cw(c6730.72,5824.98) 6775.03,5824.98 ; 6775.03,5824.98 cw(c6819.34,5824.98) 6791.55,5859.49 ccw(c6819.34,5824.98) 6775.03,5824.98
RELAYS#.NC0: J14.1 RLY1.2 RLY1.7 | length 930.6
  Top Layer w30: J14.1@4787.9,5861.38 cw(c4742.94,5816.41) 4806.52,5816.41 cw(c4870.11,5816.41) J14.1@4825.15,5861.38 ; J14.1@4806.52,5880 4806.52,5768.48 4855,5720 4995,5720 5035,5680 5035,5510 5072.38,5472.62 5080.98,5464.02 RLY1.2@5080.98,5245
RELAYS#.NC1: J14.4 RLY2.2 RLY2.7 | length 944.6
  Top Layer w30: J14.4@5378.45,5861.38 cw(c5333.49,5816.41) 5397.07,5816.41 cw(c5460.66,5816.41) J14.4@5415.7,5861.38 ; J14.4@5397.08,5880 5397.08,5732.92 5445,5685 5620,5685 5655.98,5649.02 RLY2.7@5655.98,5481.22 RLY2.2@5655.98,5245
RELAYS#.NC2: J14.7 RLY3.2 RLY3.7 | length 846
  Top Layer w30: J14.7@5987.63,5853.66 cw(c5987.63,5790.07) 6032.59,5835.04 cw(c6077.55,5880) J14.7@6013.96,5880 ; J14.7@5987.63,5880 6255.98,5611.64 RLY3.7@6255.98,5481.22 RLY3.2@6255.98,5245
RELAYS#.NC3: J14.10 RLY4.2 RLY4.7 | length 950
  Top Layer w30: J14.10@6559.55,5861.38 cw(c6514.59,5816.41) 6578.18,5816.41 cw(c6641.76,5816.41) J14.10@6596.8,5861.38 ; J14.10@6578.18,5880 6578.18,5781.82 6620,5740 6805,5740 6835.98,5709.02 RLY4.7@6835.98,5481.22 RLY4.2@6835.98,5245
RELAYS#.NO0: J14.3 RLY1.4 RLY1.5 | length 757.2
  Top Layer w30: J14.3@5181.6,5861.38 cw(c5136.64,5816.41) 5200.22,5816.41 cw(c5263.81,5816.41) J14.3@5218.85,5861.38 ; J14.3@5200.22,5880 5200.22,5778.99 5254.21,5725 RLY1.5@5254.21,5481.22 RLY1.4@5254.21,5245
RELAYS#.NO1: J14.6 RLY2.4 RLY2.5 | length 750.8
  Top Layer w30: J14.6@5772.15,5861.38 cw(c5727.19,5816.41) 5790.78,5816.41 cw(c5854.36,5816.41) J14.6@5809.4,5861.38 ; J14.6@5790.78,5880 5790.78,5808.44 5829.21,5770 RLY2.5@5829.21,5481.22 RLY2.4@5829.21,5245
RELAYS#.NO2: J14.9 RLY3.4 RLY3.5 | length 754.7
  Top Layer w30: J14.9@6362.7,5861.38 cw(c6317.74,5816.41) 6381.33,5816.41 cw(c6444.91,5816.41) J14.9@6399.95,5861.38 ; J14.9@6381.33,5880 6381.33,5790 6429.21,5742.11 RLY3.5@6429.21,5481.22 RLY3.4@6429.21,5245
RELAYS#.NO3: J14.12 RLY4.4 RLY4.5 | length 750.3
  Top Layer w30: J14.12@6953.25,5861.38 cw(c6908.29,5816.41) 6971.88,5816.41 cw(c7035.47,5816.41) J14.12@6990.5,5861.38 ; J14.12@6971.88,5880 6971.88,5798.12 7009.21,5760.79 RLY4.5@7009.21,5481.22 RLY4.4@7009.21,5245
RS232.CTS: R210.1 U8.K1 | length 5740.4
  Top Layer w4: v1(4485,4430) 4523.69,4430 ; v1@4488.89,4426.11 cw(c4498.28,4416.72) 4498.28,4430 cw(c4498.28,4443.28) v1@4488.89,4433.89 ; v1@4491.72,4423.28 cw(c4507.93,4407.06) 4507.93,4430 cw(c4507.93,4452.93) v1@4491.72,4436.72 ; U8.K1@4858.5,4367.17 4838.82,4367.16 4830.82,4367.16 4798.84,4367.16 4752.24,4413.77 4740.36,4413.77 4723.53,4430.59 4628.96,4430.59 4622.87,4424.5 4529.19,4424.5 ; 4523.69,4430 4529.19,4424.5 ; 4523.69,4430 4529.19,4424.5 ; 4840.78,4367.16 cw(c4840.78,4349.44) 4853.31,4361.97 ccw(c4840.78,4349.44) 4840.78,4367.16 ; 4840.78,4367.16 ccw(c4840.78,4384.89) 4853.31,4372.36 cw(c4840.78,4384.89) 4840.78,4367.16
  MidLayer2 w4: v1@619.19,5160.87 cw(c619.19,5137.94) 635.41,5154.16 cw(c651.63,5170.37) v1@628.69,5170.37 ; v1@619.19,5164.87 cw(c619.19,5151.6) 628.58,5160.99 cw(c637.97,5170.37) v1@624.69,5170.37 ; v1(619.19,5170.37) 665.02,5124.54 1330.48,5124.54 1330.98,5125.04 1673.52,5125.04 1781.86,5016.71 3723.52,5016.71 3956.86,4783.37 4150,4783.37 4320,4783.37 4368.37,4783.37 4432.5,4847.5 4432.5,4857.75 4432.5,4872.25 4442.75,4882.5 4457.25,4882.5 4573.36,4766.39 4573.36,4669.88 4571,4667.52 4571,4593.5 ; v1(4485,4430) 4520,4465 4532.5,4477.5 4532.5,4517.5 4532.5,4555 4571,4593.5 ; v1@4485,4435.5 ccw(c4485,4448.78) 4494.39,4439.39 ccw(c4503.78,4430) v1@4490.5,4430 ; v1@4485,4439.5 ccw(c4485,4462.43) 4501.22,4446.22 ccw(c4517.43,4430) v1@4494.5,4430 ; 4563.58,4586.08 4567.5,4590 4571,4593.5
  Bottom Layer w4: R210.1@489.34,5413 cw(c473.43,5397.09) 495.93,5397.09 cw(c518.43,5397.09) R210.1@502.52,5413 ; R210.1@492.17,5415.82 cw(c483.09,5406.74) 495.93,5406.74 cw(c508.77,5406.74) R210.1@499.69,5415.82 ; R210.1@495.93,5420.08 495.93,5380.93 479.63,5364.63 479.63,5195 504.25,5170.37 v1(619.19,5170.37) v1@615.19,5174.37 ; v1@612.47,5163.66 ccw(c596.26,5147.44) 596.26,5170.37 ccw(c596.26,5193.31) v1@612.47,5177.09 ; v1@615.3,5166.49 ccw(c605.91,5157.1) 605.91,5170.37 ccw(c605.91,5183.65) v1@615.3,5174.26
RS232.RTS: U8.F2 U59.10 | length 6200.4
  Top Layer w4: v1@4540.19,5098.87 cw(c4540.19,5075.94) 4556.41,5092.16 cw(c4572.63,5108.37) v1@4549.69,5108.37 ; v1@4540.19,5102.87 cw(c4540.19,5089.6) 4549.58,5098.99 cw(c4558.97,5108.37) v1@4545.69,5108.37 ; v1(4540.19,5108.37) 4561.36,5087.21 4561.36,4885.6 4561.36,4820.54 4656.86,4725.04 4656.86,4615.9 4704.26,4568.5 4708.88,4568.5 4731.78,4545.59 4752.13,4545.59 4757.57,4540.15 4830.82,4540.15 4838.82,4540.15 ; 4838.82,4540.15 4878.16,4540.15 ; 4838.82,4540.15 4878.16,4540.15 ; 4878.16,4540.15 cw(c4878.16,4530) 4885.34,4537.18 ; 4878.16,4540.15 cw(c4878.16,4530) 4885.34,4537.18 ; 4885.34,4537.18 cw(c4872.81,4524.65) 4890.53,4524.65 ccw(c4872.81,4524.65) 4885.34,4537.18 ; 4885.34,4537.18 ccw(c4897.87,4549.71) 4897.87,4531.99 cw(c4897.87,4549.71) 4885.34,4537.18
  MidLayer1 w4: v1(380,5460) 445,5460 450,5455 v2(532.81,5455) ; v1@383.89,5456.11 cw(c393.28,5446.72) 393.28,5460 cw(c393.28,5473.28) v1@383.89,5463.89 ; v1@386.72,5453.28 cw(c402.93,5437.06) 402.93,5460 cw(c402.93,5482.93) v1@386.72,5466.72 ; v2@525.87,5448.06 ccw(c509.13,5431.31) 509.13,5455 ccw(c509.13,5478.69) v2@525.87,5461.94 ; v2@528.7,5450.89 ccw(c518.78,5440.97) 518.78,5455 ccw(c518.78,5469.03) v2@528.7,5459.11
  MidLayer2 w4: v1(380,5460) 406.19,5486.19 406.19,5527.5 469.55,5590.86 1869.14,5590.86 1905,5555 ; v1@380,5465.5 ccw(c380,5478.78) 389.39,5469.39 ccw(c398.78,5460) v1@385.5,5460 ; v1@380,5469.5 ccw(c380,5492.43) 396.22,5476.22 ccw(c412.43,5460) v1@389.5,5460 ; 1870,5590 1905,5555 ; v1@4530.69,5108.37 ccw(c4507.76,5108.37) 4523.97,5124.59 ccw(c4540.19,5140.81) v1@4540.19,5117.87 ; v1@4534.69,5108.37 ccw(c4521.41,5108.37) 4530.8,5117.76 ccw(c4540.19,5127.15) v1@4540.19,5113.87 ; v1(4540.19,5108.37) 4506.86,5141.71 3431.67,5141.71 3347,5226.37 3347,5298 3336.86,5308.14 3182.09,5308.14 3031.86,5458.37 2545.54,5458.37 2516.38,5487.54 2212.54,5487.54 2206.88,5481.88 2133.7,5481.88 2092.77,5522.81 2007.19,5522.81 1975,5555 1905,5555
  Bottom Layer w4: v2(532.81,5455) 560.08,5455 595,5420.08 U59.10@704.59,5420.08 ; v2@536.92,5450.89 cw(c546.84,5440.97) 546.84,5455 cw(c546.84,5469.03) v2@536.92,5459.11 ; v2@539.75,5448.06 cw(c556.5,5431.31) 556.5,5455 cw(c556.5,5478.69) v2@539.75,5461.94 ; U59.10@674.61,5411.75 ccw(c654.5,5391.64) 654.5,5420.08 ccw(c654.5,5448.52) U59.10@674.61,5428.41 ; U59.10@677.44,5414.58 ccw(c664.16,5401.3) 664.16,5420.08 ccw(c664.16,5438.86) U59.10@677.44,5425.58
RS232.RXD: R209.1 U8.H3 | length 5573.2
  Top Layer w4: v1@4615,4491.5 cw(c4615,4468.56) 4631.22,4484.78 cw(c4647.43,4501) v1@4624.5,4501 ; v1@4615,4495.5 cw(c4615,4482.22) 4624.39,4491.61 cw(c4633.78,4501) v1@4620.5,4501 ; v1(4615,4501) 4634.48,4481.52 4690.36,4481.52 4699.5,4490.66 4714.44,4505.59 4735.56,4505.59 4771.39,4469.77 4838.82,4469.77 4897.36,4469.77 cw(c4897.36,4431.09) 4924.71,4458.44 ; U8.H3@4929.9,4445.91 ccw(c4912.18,4445.91) 4924.71,4458.44 ; U8.H3@4937.24,4453.25 cw(c4937.24,4470.97) 4924.71,4458.44
  Bottom Layer w4: R209.1@489.34,5558 cw(c473.43,5542.09) 495.93,5542.09 cw(c518.43,5542.09) R209.1@502.52,5558 ; R209.1@492.17,5560.82 cw(c483.09,5551.74) 495.93,5551.74 cw(c508.77,5551.74) R209.1@499.69,5560.82 ; R209.1@495.93,5565.08 495.93,5540 515,5520.93 515,5355 536.63,5333.37 701.63,5333.37 715.52,5319.48 715.52,5065 737.71,5042.81 1247.38,5042.81 1256.81,5033.37 1323.52,5033.37 1353.66,5003.24 1373.36,4983.54 3812.3,4983.54 3821.29,4974.54 3868.23,4974.54 3891.69,4998 4087.19,4998 4097.81,4987.38 4097.81,4972.19 4286.29,4783.71 4332.01,4783.71 4335.77,4779.95 4370.41,4779.95 4374.16,4783.71 4580,4783.71 4597.86,4765.85 4597.86,4627.02 4604.88,4620 4618.31,4620 4645.5,4592.81 4645.5,4531.5 v1(4615,4501) ; v1@4615,4506.5 ccw(c4615,4519.78) 4624.39,4510.39 ccw(c4633.78,4501) v1@4620.5,4501 ; v1@4615,4510.5 ccw(c4615,4533.43) 4631.22,4517.22 ccw(c4647.43,4501) v1@4624.5,4501
RS232.TXD: U8.D3 U59.11 | length 5151.1
  Top Layer w4: v1@4743.86,4745.21 cw(c4743.86,4722.27) 4760.07,4738.49 cw(c4776.29,4754.71) v1@4753.36,4754.71 ; v1@4743.86,4749.21 cw(c4743.86,4735.93) 4753.25,4745.32 cw(c4762.64,4754.71) v1@4749.36,4754.71 ; v1(4743.86,4754.71) 4770,4728.56 4770,4660 4770,4650 4770,4635 4777.75,4627.25 4792.75,4627.25 4830.82,4627.25 4838.82,4627.25 4897.36,4627.25 ; 4897.36,4627.25 cw(c4897.36,4588.57) 4924.71,4615.92 ; 4897.36,4627.25 cw(c4897.36,4588.57) 4924.71,4615.92 ; 4924.71,4615.92 ccw(c4937.24,4628.45) 4937.24,4610.73 cw(c4937.24,4628.45) 4924.71,4615.92 ; 4924.71,4615.92 cw(c4912.18,4603.39) 4929.9,4603.39 ccw(c4912.18,4603.39) 4924.71,4615.92
  Bottom Layer w4: U59.11@700.52,5470 745,5470 ; U59.11@736.82,5464.9 cw(c745,5460.9) 745,5470 ; U59.11@736.89,5475.13 ccw(c745,5478.98) 745,5470 ; 4720.22,4755 cw(c4720.22,4731.07) v1@4737.14,4747.99 ; 4721.63,4755 ccw(c4721.63,4776.94) v1@4737.14,4761.43 ; 4729.87,4755 cw(c4729.87,4740.72) v1@4739.97,4750.82 ; 4731.28,4755 ccw(c4731.28,4767.28) v1@4739.97,4758.6 ; v1(4743.86,4754.71) 4743.56,4755 4626.71,4755 4590,4791.71 4370.85,4791.71 4367.09,4787.95 4339.08,4787.95 4335.33,4791.71 4290.19,4791.71 4105.81,4976.09 4105.81,4990.69 4090.5,5006 3888.37,5006 3864.91,4982.54 3824.61,4982.54 3815.61,4991.54 1376.68,4991.54 1326.01,5042.2 1259.3,5042.2 1250.69,5050.81 742.71,5050.81 723.52,5070 723.52,5323.52 750,5350 750,5465 745,5470
RS232_C1+: C148.1 U59.1 | length 305
  Bottom Layer w4: U59.1@929,5720.08 1019.92,5720.08 1029.92,5710.08 C148.1@1096.44,5710.08 ; U59.1@956.15,5714.58 cw(c969.43,5701.3) 969.43,5720.08 cw(c969.43,5738.86) U59.1@956.15,5725.58 ; U59.1@958.98,5711.75 cw(c979.09,5691.64) 979.09,5720.08 cw(c979.09,5748.52) U59.1@958.98,5728.41 ; C148.1@1089.5,5703.14 ccw(c1072.76,5686.39) 1072.76,5710.08 ccw(c1072.76,5733.76) C148.1@1089.5,5717.01 ; C148.1@1092.33,5705.97 ccw(c1082.41,5696.05) 1082.41,5710.08 ccw(c1082.41,5724.11) C148.1@1092.33,5714.19
RS232_C1-: C148.2 U59.3 | length 420.5
  Bottom Layer w4: U59.3@929,5620.08 1117.86,5620.08 1137.78,5640 C148.2@1137.78,5710.08 ; U59.3@956.15,5614.58 cw(c969.43,5601.3) 969.43,5620.08 cw(c969.43,5638.86) U59.3@956.15,5625.58 ; U59.3@958.98,5611.75 cw(c979.09,5591.64) 979.09,5620.08 cw(c979.09,5648.52) U59.3@958.98,5628.41 ; C148.2@1130.84,5703.14 cw(c1114.09,5686.39) 1137.78,5686.39 cw(c1161.47,5686.39) C148.2@1144.72,5703.14 ; C148.2@1133.67,5705.97 cw(c1123.75,5696.05) 1137.78,5696.05 cw(c1151.81,5696.05) C148.2@1141.89,5705.97
RS232_C2+: C150.1 U59.4 | length 302.9
  Bottom Layer w4: U59.4@929,5570.08 1024.92,5570.08 1029.92,5565.08 C150.1@1096.44,5565.08 ; U59.4@956.15,5564.58 cw(c969.43,5551.3) 969.43,5570.08 cw(c969.43,5588.86) U59.4@956.15,5575.58 ; U59.4@958.98,5561.75 cw(c979.09,5541.64) 979.09,5570.08 cw(c979.09,5598.52) U59.4@958.98,5578.41 ; C150.1@1089.5,5558.14 ccw(c1072.76,5541.39) 1072.76,5565.08 ccw(c1072.76,5588.76) C150.1@1089.5,5572.01 ; C150.1@1092.33,5560.97 ccw(c1082.41,5551.05) 1082.41,5565.08 ccw(c1082.41,5579.11) C150.1@1092.33,5569.19
RS232_C2-: C150.2 U59.5 | length 382.7
  Bottom Layer w4: U59.5@929,5520.08 1130.08,5520.08 1137.78,5527.78 C150.2@1137.78,5565.08 ; U59.5@956.15,5514.58 cw(c969.43,5501.3) 969.43,5520.08 cw(c969.43,5538.86) U59.5@956.15,5525.58 ; U59.5@958.98,5511.75 cw(c979.09,5491.64) 979.09,5520.08 cw(c979.09,5548.52) U59.5@958.98,5528.41 ; C150.2@1130.84,5558.14 cw(c1114.09,5541.39) 1137.78,5541.39 cw(c1161.47,5541.39) C150.2@1144.72,5558.14 ; C150.2@1133.67,5560.97 cw(c1123.75,5551.05) 1137.78,5551.05 cw(c1151.81,5551.05) C150.2@1141.89,5560.97
RS232_CTS#: R210.2 U59.9 | length 310.6
  Bottom Layer w4: R210.2@538.29,5410.27 cw(c538.29,5382.64) 557.82,5402.18 ; R210.2@538.29,5414.27 cw(c538.29,5396.3) 551,5409 ; R210.2@538.29,5420.08 539.92,5420.08 589.92,5370.08 U59.9@704.59,5370.08 ; R210.2@547.61,5419.59 ccw(c564.98,5419.59) 552.7,5407.3 ; U59.9@674.61,5361.75 ccw(c654.5,5341.64) 654.5,5370.08 ccw(c654.5,5398.52) U59.9@674.61,5378.41 ; U59.9@677.44,5364.58 ccw(c664.16,5351.3) 664.16,5370.08 ccw(c664.16,5388.86) U59.9@677.44,5375.58
RS232_RX#: R209.2 U59.12 | length 314.6
  Bottom Layer w4: R209.2@538.29,5555.27 cw(c538.29,5531.58) 555.04,5548.33 ; R209.2@538.29,5559.27 cw(c538.29,5545.24) R209.2@548.21,5555.16 ; R209.2@538.29,5565.08 583.29,5520.08 U59.12@704.59,5520.08 ; R209.2@543.61,5564.59 ccw(c555.26,5564.59) R209.2@547.02,5556.35 ; R209.2@547.61,5564.59 ccw(c568.92,5564.59) 553.85,5549.52 ; U59.12@674.61,5511.75 ccw(c654.5,5491.64) 654.5,5520.08 ccw(c654.5,5548.52) U59.12@674.61,5528.41 ; U59.12@677.44,5514.58 ccw(c664.16,5501.3) 664.16,5520.08 ccw(c664.16,5538.86) U59.12@677.44,5525.58
RS232_V+: C149.2 U59.2 | length 542.2
  Bottom Layer w4: C149.2@537.78,5710.08 593.76,5710.08 608.84,5695 785,5695 810,5670 U59.2@930,5670 ; C149.2@541.89,5705.97 cw(c551.81,5696.05) 551.81,5710.08 cw(c551.81,5724.11) C149.2@541.89,5714.19 ; C149.2@544.72,5703.14 cw(c561.47,5686.39) 561.47,5710.08 cw(c561.47,5733.76) C149.2@544.72,5717.01 ; 878.72,5670 ccw(c878.72,5698.7) U59.2@899.02,5678.41 ; 879.1,5670 cw(c879.1,5641.83) U59.2@899.02,5661.75 ; 888.38,5670 ccw(c888.38,5689.05) U59.2@901.85,5675.58 ; 888.75,5670 cw(c888.75,5651.48) U59.2@901.85,5664.58
RS232_V-: C151.1 U59.6 | length 336.2
  Bottom Layer w4: U59.6@929,5470.08 1029.92,5470.08 1040,5460 1040,5435 1054.92,5420.08 C151.1@1096.44,5420.08 ; U59.6@956.15,5464.58 cw(c969.43,5451.3) 969.43,5470.08 cw(c969.43,5488.86) U59.6@956.15,5475.58 ; U59.6@958.98,5461.75 cw(c979.09,5441.64) 979.09,5470.08 cw(c979.09,5498.52) U59.6@958.98,5478.41 ; C151.1@1089.5,5413.14 ccw(c1072.76,5396.39) 1072.76,5420.08 ccw(c1072.76,5443.76) C151.1@1089.5,5427.01 ; C151.1@1092.33,5415.97 ccw(c1082.41,5406.05) 1082.41,5420.08 ccw(c1082.41,5434.11) C151.1@1092.33,5424.19
RS485.RX_EN: U8.B3 U46.3 | length 4473.3
  Top Layer w4: v1@4683.47,5023.28 cw(c4667.26,5007.06) 4690.19,5007.06 cw(c4713.13,5007.06) v1@4696.91,5023.28 ; v1@4686.3,5026.11 cw(c4676.91,5016.72) 4690.19,5016.72 cw(c4703.47,5016.72) v1@4694.08,5026.11 ; v1(4690.19,5030) 4690.19,4966.71 4797.19,4859.71 4855,4859.71 4875,4859.71 4878.98,4859.71 4921.74,4816.95 4921.74,4812.97 4921.74,4800 4921.74,4749.18 4921.74,4741.18 4921.74,4701.84 ; 4921.74,4701.84 ccw(c4931.89,4701.84) 4924.71,4694.66 ; 4921.74,4701.84 ccw(c4931.89,4701.84) 4924.71,4694.66 ; 4924.71,4694.66 ccw(c4937.24,4707.19) 4937.24,4689.47 cw(c4937.24,4707.19) 4924.71,4694.66 ; 4924.71,4694.66 cw(c4912.18,4682.13) 4929.9,4682.13 ccw(c4912.18,4682.13) 4924.71,4694.66
  MidLayer1 w4: v1(4466.19,5586.04) 4578.96,5586.04 4623.52,5541.48 4623.52,5117.71 4690.19,5051.04 ; v1@4470.08,5582.15 cw(c4479.47,5572.76) 4479.47,5586.04 cw(c4479.47,5599.32) v1@4470.08,5589.93 ; v1@4472.91,5579.32 cw(c4489.13,5563.11) 4489.13,5586.04 cw(c4489.13,5608.98) v1@4472.91,5592.76 ; v1@4683.91,5037.13 ccw(c4671.64,5051.04) 4690.19,5051.04 ; v1@4686.55,5034.13 ccw(c4679.45,5042.18) 4690.19,5042.18 ccw(c4700.93,5042.18) v1@4693.83,5034.13 ; v1(4690.19,5030) 4690.19,5051.04 ; v1@4696.47,5037.13 cw(c4708.74,5051.04) 4690.19,5051.04
  MidLayer2 w4: v1(1861.86,5616.71) 2065.19,5616.71 2131.86,5550.04 2148.52,5550.04 2231.86,5633.37 2236.29,5637.81 4414.42,5637.81 4418.86,5633.37 v1(4466.19,5586.04) ; v1@1865.75,5612.82 cw(c1875.14,5603.43) 1875.14,5616.71 cw(c1875.14,5629.99) v1@1865.75,5620.6 ; v1@1868.57,5609.99 cw(c1884.79,5593.77) 1884.79,5616.71 cw(c1884.79,5639.64) v1@1868.57,5623.43 ; v1@4456.69,5586.04 ccw(c4433.76,5586.04) 4449.97,5602.26 ccw(c4466.19,5618.48) v1@4466.19,5595.54 ; v1@4460.69,5586.04 ccw(c4447.41,5586.04) 4456.8,5595.43 ccw(c4466.19,5604.82) v1@4466.19,5591.54
  Bottom Layer w4: U46.3@1731.54,5620.08 1810,5620.08 1813.37,5616.71 v1(1861.86,5616.71) ; U46.3@1767.15,5615.97 cw(c1777.07,5606.05) 1777.07,5620.08 cw(c1777.07,5634.11) U46.3@1767.15,5624.19 ; U46.3@1769.98,5613.14 cw(c1786.72,5596.39) 1786.72,5620.08 cw(c1786.73,5643.76) U46.3@1769.98,5627.01 ; v1@1855.14,5609.99 ccw(c1838.92,5593.77) 1838.92,5616.71 ccw(c1838.92,5639.64) v1@1855.14,5623.43 ; v1@1857.97,5612.82 ccw(c1848.58,5603.43) 1848.58,5616.71 ccw(c1848.58,5629.99) v1@1857.97,5620.6
RS485.RXD: R211.1 U8.E8 | length 5340.2
  Top Layer w4: v3(5114.41,4583.7) U8.E8@5134.09,4564.02 ; U8.E8@5126.75,4564.02 ccw(c5109.03,4564.02) 5121.56,4576.55 ccw(c5134.09,4589.08) U8.E8@5134.09,4571.36 ; 5127.21,4570.9 cw(c5140.02,4583.7) 5121.91,4583.7 ccw(c5140.02,4583.7) 5127.21,4570.9 ; 5127.21,4570.9 ccw(c5114.41,4558.09) 5114.41,4576.2 cw(c5114.41,4558.09) 5127.21,4570.9
  MidLayer1 w4: v1@2166.81,5681.76 ccw(c2150.59,5697.98) 2173.52,5697.98 ccw(c2196.46,5697.98) v1@2180.24,5681.76 ; v1@2169.64,5678.93 ccw(c2160.25,5688.32) 2173.52,5688.32 ccw(c2186.8,5688.32) v1@2177.41,5678.93 ; v1(2173.52,5675.04) 2173.52,5708.52 2199.21,5734.21 2274.21,5734.21 2291,5751 2594.84,5751 2596.29,5749.54 3054.54,5749.54 3488.37,6183.37 4916.63,6183.37 4950,6150 4950,5715.23 4973.52,5691.71 4973.52,5389.04 4929.52,5345.04 4929.52,5030.94 4985.43,4975.04 5028.45,4975.04 5051.23,4952.26 ; 5050,4953.49 5114.41,4889.08 5114.41,4810 5098.9,4794.49 5098.9,4749.18 5098.9,4741.18 5098.9,4700.75 5098.9,4681.33 5098.9,4621.14 5098.9,4607.21 ccw(c5112.95,4607.21) 5103.02,4597.28 ; v3@5106.94,4584.35 ccw(c5088.9,4585.93) 5102.77,4597.57 ccw(c5116.64,4609.21) v3@5115.06,4591.17
  Bottom Layer w4: R211.1@1861.18,5670 1861.18,5666.71 1956.86,5666.71 1965.19,5675.04 v1(2173.52,5675.04) ; R211.1@1864.94,5673.27 ccw(c1880.78,5689.11) 1880.78,5666.71 ; R211.1@1867.77,5662.92 cw(c1876.92,5653.77) 1876.92,5666.71 ; R211.1@1867.77,5676.1 ccw(c1890.44,5698.77) 1890.44,5666.71 ; v1@2166.81,5668.32 ccw(c2150.59,5652.11) 2150.59,5675.04 ccw(c2150.59,5697.98) v1@2166.81,5681.76 ; v1@2169.64,5671.15 ccw(c2160.25,5661.76) 2160.25,5675.04 ccw(c2160.25,5688.32) v1@2169.64,5678.93