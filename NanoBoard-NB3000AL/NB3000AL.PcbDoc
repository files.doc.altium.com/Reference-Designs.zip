# Altium PCB NB3000AL.PcbDoc (part 72 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
TFT_IO.DB13: J27.17 U8.AA17 | length 1531.5
  Top Layer w4: U8.AA17@5488.42,3926.75 cw(c5488.42,3909.03) 5500.96,3921.56 cw(c5513.49,3934.09) U8.AA17@5495.77,3934.09 ; U8.AA17@5488.43,3934.09 v3(5508.11,3914.41) ; v1@5977.28,3159.28 cw(c5966.24,3148.24) J27.17@5981.86,3148.24 ; J27.17@5980.16,3144.67 ccw(c5976.07,3148.75) 5981.86,3148.75 ; J27.17@5981.86,3137.89 cw(c6012.11,3137.89) v1@5990.72,3159.28 ; J27.17@5981.86,3147.55 cw(c6002.45,3147.55) v1@5987.89,3162.11 ; 5981.86,3150.97 ccw(c5994.78,3150.97) J27.17@5985.64,3141.84 ; v1@5981.86,3163.37 5981.86,3125.04 5984.32,3125.04 J27.17@5984.32,3118.39 ; 5495.31,3927.21 cw(c5482.5,3914.41) 5500.61,3914.41 ccw(c5482.5,3914.41) 5495.31,3927.21 ; 5495.31,3927.21 ccw(c5508.11,3940.02) 5508.11,3921.91 cw(c5508.11,3940.02) 5495.31,3927.21
  MidLayer2 w4: v3@5507.46,3906.94 cw(c5505.88,3888.9) 5519.75,3900.54 ; v3@5515.58,3913.76 ccw(c5533.62,3912.18) 5519.75,3900.54 ; 5531.97,3641.47 5531.97,3699.73 ; v1@5977.28,3172.72 ccw(c5961.06,3188.93) 5984,3188.93 ccw(c6006.93,3188.93) v1@5990.72,3172.72 ; v1@5980.11,3169.89 ccw(c5970.72,3179.28) 5984,3179.28 ccw(c5997.28,3179.28) v1@5987.89,3169.89 ; v1(5984,3166) 5984,3170.53 5984,3189 6005,3210 6005,3229.56 5998.52,3236.04 5917.96,3236.04 5899.5,3254.5 5762.65,3254.5 5739.44,3277.71 5713.17,3277.71 5664.19,3326.69 5664.19,3401.35 5690.5,3427.66 5690.5,3512.25 5660.25,3542.5 5620.29,3542.5 5612.82,3542.5 5571.01,3584.31 5557,3584.31 5553.96,3587.35 5543.31,3598 ; 5519.75,3900.54 cw(c5490.24,3871.03) 5531.97,3871.03 5531.97,3851.53 5531.97,3777.41 5531.97,3757.99 5531.97,3699.73 ; 5531.97,3598 5531.97,3630.82 5531.97,3638.82 5531.97,3699.73 ; 5531.97,3598 5543.31,3598 ; 5531.97,3598 5543.31,3598
TFT_IO.DB14: J27.19 U8.AF21 | length 1343.2
  Top Layer w4: U8.AF21@5645.91,3729.9 cw(c5645.91,3712.18) 5658.44,3724.71 ; U8.AF21@5653.25,3737.24 ccw(c5670.97,3737.24) 5658.44,3724.71 ; v1@5727.36,3382.37 ccw(c5704.42,3382.37) 5720.64,3398.59 ccw(c5736.86,3414.81) v1@5736.86,3391.87 ; v1@5731.36,3382.37 ccw(c5718.08,3382.37) 5727.47,3391.76 ccw(c5736.86,3401.15) v1@5736.86,3387.87 ; v1(5736.86,3382.37) 5691.19,3428.04 5691.19,3483.81 5682.86,3492.14 5682.86,3519.89 5650.02,3552.72 5650.02,3590.02 5669.77,3609.77 5669.77,3630.82 5669.77,3638.82 5669.77,3697.36 ccw(c5631.09,3697.36) 5658.44,3724.71 ; v1@5881.14,3383.99 cw(c5864.92,3367.77) 5887.86,3367.77 cw(c5910.79,3367.77) v1@5894.57,3383.99 ; v1@5883.97,3386.82 cw(c5874.58,3377.43) 5887.86,3377.43 cw(c5901.14,3377.43) v1@5891.75,3386.82 ; v1(5887.86,3390.71) 5887.86,3335.71 5898.52,3325.04 5949.27,3325.04 6000.36,3273.96 6000.36,3259.46 5982.61,3241.71 5973.52,3241.71 5960,3228.18 5960,3160 5944.95,3144.95 J27.19@5944.95,3118.39 ; J27.19@5946.82,3140.51 cw(c5962.05,3140.51) 5951.28,3151.28 ; J27.19@5950.82,3140.51 cw(c5975.71,3140.51) 5958.11,3158.11
  Bottom Layer w4: v1@5743.19,3376.04 v1(5736.86,3382.37) ; v1@5885.19,3382.37 5887.86,3385.04 v1(5887.86,3390.71) ; v1(5736.86,3382.37) 5778.67,3382.37 ; v1(5736.86,3382.37) 5778.67,3382.37 ; 5750.14,3382.37 cw(c5750.14,3395.65) 5740.75,3386.26 ccw(c5750.14,3395.65) 5750.14,3382.37 ; 5750.14,3382.37 ccw(c5750.14,3369.1) 5740.75,3378.49 cw(c5750.14,3369.1) 5750.14,3382.37 ; 5759.79,3382.37 cw(c5759.79,3405.31) 5743.57,3389.09 ccw(c5759.79,3405.31) 5759.79,3382.37 ; 5759.79,3382.37 ccw(c5759.79,3359.44) 5743.57,3375.66 cw(c5759.79,3359.44) 5759.79,3382.37 ; 5778.67,3382.37 5812.37,3382.37 5820.71,3390.71 5868.29,3390.71 ; 5868.3,3390.71 cw(c5868.3,3375.32) 5880.39,3384.83 ccw(c5868.3,3375.32) 5868.3,3390.71 ; 5868.3,3390.71 ccw(c5868.3,3406.1) 5880.39,3396.58 cw(c5868.3,3406.1) 5868.3,3390.71 ; 5868.29,3390.71 v1(5887.86,3390.71) ; 5868.29,3390.71 v1(5887.86,3390.71)
TFT_IO.DB15: J27.21 U8.AB18 | length 1399.1
  Top Layer w4: U8.AB18@5527.8,3887.38 cw(c5527.8,3869.66) 5540.33,3882.19 cw(c5552.86,3894.72) U8.AB18@5535.14,3894.72 ; U8.AB18@5527.8,3894.72 v3(5547.48,3875.04) ; J27.21@5901.42,3144.67 ccw(c5891.4,3154.69) 5905.58,3154.69 ccw(c5919.76,3154.69) J27.21@5909.73,3144.67 ; J27.21@5905.58,3118.39 5905.58,3189.43 v1(5982.86,3266.71) ; v1@5973.36,3266.71 cw(c5950.42,3266.71) 5966.64,3250.49 cw(c5982.86,3234.27) v1@5982.86,3257.21 ; v1@5977.36,3266.71 cw(c5964.08,3266.71) 5973.47,3257.32 cw(c5982.86,3247.93) v1@5982.86,3261.21 ; 5534.68,3887.84 cw(c5521.87,3875.04) 5539.98,3875.04 ccw(c5521.87,3875.04) 5534.68,3887.84 ; 5534.68,3887.84 ccw(c5547.48,3900.65) 5547.48,3882.54 cw(c5547.48,3900.65) 5534.68,3887.84
  MidLayer2 w4: v3@5546.83,3867.57 cw(c5545.25,3849.53) 5559.12,3861.17 cw(c5572.99,3872.81) v3@5554.95,3874.39 ; 5558.87,3861.46 cw(c5548.94,3851.53) 5562.99,3851.53 ; 5562.99,3837.6 5562.99,3851.53 ; v1(5982.86,3266.71) 5982.86,3282.12 5982.86,3287.73 5944.71,3325.87 5939.1,3325.87 5915,3325.87 5767.17,3325.87 5758,3316.71 5685.48,3316.71 5672.19,3330 5672.19,3398.04 5698.5,3424.35 5698.5,3515.56 5663.56,3550.5 5630,3550.5 ; 5562.99,3851.53 5562.99,3757.99 5562.99,3617.01 5562.99,3603.64 5616.13,3550.5 5629.5,3550.5 ; 5629.5,3550.5 5630,3550.5 ; 5629.5,3550.5 5630,3550.5
TFT_IO.DB16: J27.23 U8.AF18 | length 1095
  Top Layer w4: U8.AF18@5527.79,3729.9 cw(c5527.79,3712.18) 5540.33,3724.71 ; v1(5533.8,3568.8) 5551.66,3586.66 5551.66,3630.82 5551.66,3638.82 5551.66,3697.36 ccw(c5512.98,3697.36) 5540.33,3724.71 ; v1@5533.8,3574.3 ccw(c5533.8,3587.58) 5543.19,3578.19 ccw(c5552.58,3568.8) v1@5539.3,3568.8 ; v1@5533.8,3578.3 ccw(c5533.8,3601.23) 5550.02,3585.02 ccw(c5566.24,3568.8) v1@5543.3,3568.8 ; U8.AF18@5535.14,3737.24 ccw(c5552.86,3737.24) 5540.33,3724.71 ; v1@5840.19,3165.71 5866.21,3139.69 J27.23@5866.21,3118.39 ; v1@5840.43,3156.45 cw(c5840.43,3134.68) 5855.82,3150.07 ; v1@5840.43,3160.45 cw(c5840.43,3148.34) 5848.99,3156.9 ; v1@5845.93,3165.95 ccw(c5860.38,3165.95) 5850.16,3155.73 ; v1@5849.93,3165.95 ccw(c5874.04,3165.95) 5856.99,3148.91 ; 5854.78,3151.12 ccw(c5866.21,3162.55) J27.23@5866.21,3146.39 ; 5856.76,3149.14 cw(c5848.13,3140.51) J27.23@5860.33,3140.51
  MidLayer2 w4: v1(5533.8,3568.8) 5534.29,3568.31 5564.38,3568.31 5615.81,3516.88 5615.81,3460.62 5608.5,3453.31 5608.5,3436.75 5615.5,3429.75 5615.5,3226.5 5647,3195 5769.98,3195 5788.35,3176.63 5794.98,3170 5799.03,3165.95 v1(5840.43,3165.95) ; v1@5833.71,3159.23 ccw(c5817.5,3143.01) 5817.5,3165.95 ccw(c5817.5,3188.88) v1@5833.71,3172.67 ; v1@5836.54,3162.06 ccw(c5827.15,3152.67) 5827.15,3165.95 ccw(c5827.15,3179.23) v1@5836.54,3169.84
TFT_IO.DB17: J27.25 U8.AB17 | length 1451.7
  Top Layer w4: U8.AB17@5488.42,3887.38 cw(c5488.42,3869.66) 5500.96,3882.19 cw(c5513.49,3894.72) U8.AB17@5495.77,3894.72 ; U8.AB17@5488.43,3894.72 v3(5508.11,3875.04) ; J27.25@5822.76,3144.75 ccw(c5813.56,3154.31) 5826.84,3154.31 ; J27.25@5826.84,3118.39 5826.84,3154.31 ; J27.25@5830.91,3144.75 cw(c5840.11,3154.31) 5826.84,3154.31 ; v1@5861.31,3173.9 ccw(c5849.58,3187.47) 5867.52,3187.47 ; v1@5863.93,3170.87 ccw(c5857.13,3178.73) 5867.52,3178.73 ccw(c5877.92,3178.73) v1@5871.12,3170.87 ; v1(5867.52,3166.71) 5867.52,3175.04 5867.52,3187.48 ; v1@5873.74,3173.9 cw(c5885.47,3187.47) 5867.52,3187.47 ; 5495.31,3887.84 cw(c5482.5,3875.04) 5500.61,3875.04 ccw(c5482.5,3875.04) 5495.31,3887.84 ; 5495.31,3887.84 ccw(c5508.11,3900.65) 5508.11,3882.54 cw(c5508.11,3900.65) 5495.31,3887.84 ; 5826.84,3154.31 5822.69,3158.46 5822.69,3174.21 5822.69,3182.69 5830,3190 5865,3190 5867.52,3187.48
  MidLayer2 w4: v3@5507.46,3867.57 cw(c5505.88,3849.53) 5519.75,3861.17 cw(c5533.62,3872.81) v3@5515.58,3874.39 ; 5519.5,3861.46 cw(c5509.57,3851.53) 5523.62,3851.53 ; 5523.62,3641.47 5523.62,3699.73 ; 5523.62,3837.6 5523.62,3851.53 ; v1@5858.02,3166.71 ccw(c5835.09,3166.71) 5851.31,3182.93 ccw(c5867.52,3199.14) v1@5867.52,3176.21 ; v1@5862.02,3166.71 ccw(c5848.75,3166.71) 5858.14,3176.1 ccw(c5867.52,3185.49) v1@5867.52,3172.21 ; v1(5867.52,3166.71) 5850.78,3183.45 5809.68,3183.45 5809.44,3183.21 5794.94,3183.21 5775.15,3203 5650.31,3203 5623.5,3229.81 5623.5,3416.75 5643.5,3436.75 5643.5,3451.25 5631.36,3463.39 5631.36,3512.64 5567.69,3576.31 5553.69,3576.31 5540,3590 5528.62,3590 5523.62,3595 5523.62,3630.82 5523.62,3638.82 5523.62,3699.73 ; 5523.62,3699.73 5523.62,3757.99 5523.62,3851.53
TFT_IO.IR38KRX: J27.36 U8.AA15 | length 1718
  Top Layer w4: U8.AA15@5409.69,3926.75 cw(c5409.69,3909.03) 5422.22,3921.56 cw(c5434.75,3934.09) U8.AA15@5417.03,3934.09 ; U8.AA15@5409.68,3934.09 v3(5429.37,3914.41) ; v1(5598.52,2991.71) 5610.3,3003.48 J27.36@5610.3,3041.61 ; J27.36@5606.15,3015.33 cw(c5596.12,3005.31) 5610.3,3005.31 cw(c5624.48,3005.31) J27.36@5614.45,3015.33 ; 5416.57,3927.21 cw(c5403.76,3914.41) 5421.87,3914.41 ccw(c5403.76,3914.41) 5416.57,3927.21 ; 5416.57,3927.21 ccw(c5429.37,3940.02) 5429.37,3921.91 cw(c5429.37,3940.02) 5416.57,3927.21
  MidLayer2 w4: v1(5295,3025) 5298.48,3025 5298.52,3025.04 5340.19,3066.71 5340.19,3260.06 5312.5,3287.75 5312.5,3302.25 5312.5,3380.04 5339.69,3407.23 5339.69,3428.04 5347.5,3435.85 5347.5,3461.74 5338,3471.24 5338,3516.06 5352.29,3530.35 5352.29,3559.59 5367.41,3574.71 5412.85,3574.71 5453.23,3615.09 5453.23,3757.99 5453.23,3777.41 5453.23,3851.53 5453.23,3871.03 ccw(c5411.5,3871.03) 5441.01,3900.54 ; v1@5295,3030.5 ccw(c5295,3052.19) 5310.34,3036.85 ; v1@5295,3034.5 ccw(c5295,3065.84) 5317.16,3043.68 ; v1@5304.5,3025 cw(c5319.03,3025) 5308.75,3035.27 ; v3@5428.72,3906.94 cw(c5427.14,3888.9) 5441.01,3900.54 ; v3@5436.84,3913.76 ccw(c5454.88,3912.18) 5441.01,3900.54
  Bottom Layer w4: v1(5295,3025) 5337.17,3025 5351.67,3039.5 5505.5,3039.5 5535,3010 5580.23,3010 v1(5598.52,2991.71) ; v1@5298.89,3021.11 cw(c5308.28,3011.72) 5308.28,3025 cw(c5308.28,3038.28) v1@5298.89,3028.89 ; v1@5301.72,3018.28 cw(c5317.93,3002.06) 5317.93,3025 cw(c5317.93,3047.93) v1@5301.72,3031.72 ; v1@5589.02,2991.71 ccw(c5566.09,2991.71) 5582.31,3007.93 ccw(c5598.52,3024.14) v1@5598.52,3001.21 ; v1@5593.02,2991.71 ccw(c5579.75,2991.71) 5589.14,3001.1 ccw(c5598.52,3010.49) v1@5598.52,2997.21
TFT_IO.IR38KTX: J27.38 U8.AB15 | length 1384.9
  Top Layer w4: U8.AB15@5409.69,3887.38 cw(c5409.69,3869.66) 5422.22,3882.19 cw(c5434.75,3894.72) U8.AB15@5417.03,3894.72 ; U8.AB15@5409.68,3894.72 v3(5429.37,3875.04) ; v1(5410.8,3350.4) 5410.8,3335.8 5406.69,3331.69 5406.69,3300.74 5422,3285.43 5422,3232 5440.52,3213.48 5440.52,3151.48 5458.63,3133.37 5505.19,3133.37 5506.86,3131.71 5506.86,3107.04 5531.86,3082.04 5560.34,3082.04 5570.93,3071.45 J27.38@5570.93,3041.61 ; 5562.95,3079.44 cw(c5548.16,3064.65) J27.38@5569.06,3063.81 ; 5569.41,3072.97 cw(c5560.59,3064.15) J27.38@5573.06,3063.66 ; 5416.57,3887.84 cw(c5403.76,3875.04) 5421.87,3875.04 ccw(c5403.76,3875.04) 5416.57,3887.84 ; 5416.57,3887.84 ccw(c5429.37,3900.65) 5429.37,3882.54 cw(c5429.37,3900.65) 5416.57,3887.84
  MidLayer2 w4: v1(5317.52,3580) 5360,3580 5362.71,3582.71 5409.54,3582.71 5444.88,3618.05 5444.88,3630.82 5444.88,3638.82 5444.88,3757.99 5444.88,3851.53 ccw(c5430.83,3851.53) 5440.76,3861.46 ; v1@5321.41,3576.11 cw(c5330.8,3566.72) 5330.8,3580 cw(c5330.8,3593.28) v1@5321.41,3583.89 ; v1@5324.24,3573.28 cw(c5340.46,3557.06) 5340.46,3580 cw(c5340.46,3602.93) v1@5324.24,3586.72 ; v3@5428.72,3867.57 cw(c5427.14,3849.53) 5441.01,3861.17 cw(c5454.88,3872.81) v3@5436.84,3874.39
  Bottom Layer w4: v1@5308.02,3580 cw(c5285.09,3580) 5301.31,3563.78 cw(c5317.52,3547.56) v1@5317.52,3570.5 ; v1@5312.02,3580 cw(c5298.75,3580) 5308.14,3570.61 cw(c5317.52,3561.22) v1@5317.52,3574.5 ; v1(5317.52,3580) 5297.25,3559.73 5297.25,3557.81 5297.25,3526.93 5307.69,3516.5 5319.25,3516.5 5330,3505.75 5330,3491.62 5335.8,3485.82 5335.8,3462.12 5392.5,3405.42 5392.5,3402.12 5404.81,3389.81 5411.6,3383.02 5411.6,3364.63 5411.6,3351.2 v1(5410.8,3350.4)
TFT_IO.RD: J27.16 U8.AF22 | length 1444.2
  Top Layer w4: v1@5683.52,3580.54 ccw(c5683.52,3592.65) 5692.09,3584.09 ; v1@5683.52,3584.54 ccw(c5683.52,3606.31) 5698.92,3590.92 ; v1@5689.02,3575.04 cw(c5703.47,3575.04) 5693.26,3585.26 ; v1@5690.04,3575.04 v1(5683.52,3575.04) 5683.52,3575.52 5709.14,3601.14 5709.14,3630.82 5709.14,3638.82 ; v1@5693.02,3575.04 cw(c5717.13,3575.04) 5700.08,3592.08 ; v1@5981.86,3207.21 cw(c5981.86,3184.27) 5998.07,3200.49 cw(c6014.29,3216.71) v1@5991.36,3216.71 ; v1@5981.86,3211.21 cw(c5981.86,3197.93) 5991.25,3207.32 cw(c6000.64,3216.71) v1@5987.36,3216.71 ; v1(5981.86,3216.71) 5999.5,3199.06 5999.5,3175.25 6001.5,3173.25 6001.5,3158.75 5998.52,3155.78 5998.52,3083.37 6004,3077.9 ; J27.16@5999.85,3067.9 ccw(c5989.88,3077.9) 6004,3077.9 ; J27.16@6004,3041.61 6004,3077.9 ; J27.16@6008.15,3067.9 cw(c6018.12,3077.9) 6004,3077.9 ; 5697.81,3724.71 cw(c5710.34,3737.24) 5692.62,3737.24 ccw(c5710.34,3737.24) 5697.81,3724.71 ; 5697.81,3724.71 ccw(c5685.28,3712.18) 5685.28,3729.9 cw(c5685.28,3712.18) 5697.81,3724.71 ; 5697.81,3724.71 cw(c5670.46,3697.36) 5709.14,3697.36 ; 5697.81,3724.71 cw(c5670.46,3697.36) 5709.14,3697.36 ; 5709.14,3638.82 5709.14,3697.36 ; 5709.14,3638.82 5709.14,3697.36
  MidLayer1 w4: v1(5683.52,3575.04) 5701.71,3575.04 ; v1@5691.32,3569.62 cw(c5701.71,3562.39) 5701.71,3575.04 ; v1@5691.32,3580.47 ccw(c5701.71,3587.69) 5701.71,3575.04 ; v1@5814.02,3233.37 ccw(c5791.09,3233.37) 5807.31,3249.59 ccw(c5823.52,3265.81) v1@5823.52,3242.87 ; v1@5818.02,3233.37 ccw(c5804.75,3233.37) 5814.14,3242.76 ccw(c5823.52,3252.15) v1@5823.52,3238.87 ; v1(5823.52,3233.37) 5801.02,3255.88 5792.41,3264.49 5792.41,3389.49 ; 5701.71,3575.04 5717.5,3559.25 5717.5,3538.5 5706.86,3527.86 5706.86,3500.04 5748.52,3458.37 5749.09,3457.81 5763.38,3457.81 5773.81,3447.38 5773.81,3408.09 ; 5773.81,3408.09 5792.41,3389.49 ; 5773.81,3408.09 5792.41,3389.49
  MidLayer2 w4: v1(5823.52,3233.37) 5908.63,3233.37 5924,3218 5980.56,3218 v1(5981.86,3216.71) ; v1@5827.41,3229.49 cw(c5836.8,3220.1) 5836.8,3233.37 cw(c5836.8,3246.65) v1@5827.41,3237.26 ; v1@5830.24,3226.66 cw(c5846.46,3210.44) 5846.46,3233.37 cw(c5846.46,3256.31) v1@5830.24,3240.09 ; 5955.8,3218 cw(c5955.8,3190.65) v1@5975.14,3209.99 ; 5962.04,3218 ccw(c5962.04,3236.52) v1@5975.14,3223.43 ; 5965.46,3218 cw(c5965.46,3200.31) v1@5977.97,3212.82
TFT_IO.RESET: J27.27 U8.Y17 | length 1553.8
  Top Layer w4: U8.Y17@5488.42,3966.12 cw(c5488.42,3948.4) 5500.96,3960.93 cw(c5513.49,3973.46) U8.Y17@5495.77,3973.46 ; U8.Y17@5488.43,3973.46 v3(5508.11,3953.78) ; v1@5773.52,3157.21 cw(c5773.52,3134.27) 5789.74,3150.49 cw(c5805.96,3166.71) v1@5783.02,3166.71 ; v1@5773.52,3161.21 cw(c5773.52,3147.93) 5782.91,3157.32 cw(c5792.3,3166.71) v1@5779.02,3166.71 ; v1(5773.52,3166.71) 5790.19,3150.04 ; J27.27@5786.86,3146.35 ccw(c5786.49,3150.04) 5790.19,3150.04 ; J27.27@5787.47,3118.39 5787.47,3116.71 5790.19,3116.71 5790.19,3118.39 5790.19,3150.04 ; 5789.26,3150.97 cw(c5778.8,3140.51) J27.27@5793.59,3140.51 ; J27.27@5790.19,3148.12 ccw(c5795.07,3148.12) J27.27@5791.62,3144.67 ; 5495.31,3966.58 cw(c5482.5,3953.78) 5500.61,3953.78 ccw(c5482.5,3953.78) 5495.31,3966.58 ; 5495.31,3966.58 ccw(c5508.11,3979.39) 5508.11,3961.28 cw(c5508.11,3979.39) 5495.31,3966.58
  MidLayer1 w4: v1@5550.14,3326.66 cw(c5533.92,3310.44) 5556.86,3310.44 cw(c5579.79,3310.44) v1@5563.57,3326.66 ; v1@5552.97,3329.49 cw(c5543.58,3320.1) 5556.86,3320.1 cw(c5570.14,3320.1) v1@5560.75,3329.49 ; v1(5556.86,3333.37) 5556.86,3308.14 5583,3282 5583,3266.9 ; v1@5577.68,3256.87 ccw(c5570.89,3266.9) 5583,3266.9 ; v1(5583,3249) 5583,3266.9 ; v1@5588.32,3256.87 cw(c5595.11,3266.9) 5583,3266.9
  Bottom Layer w4: v3@5507.46,3946.31 cw(c5505.88,3928.27) 5519.75,3939.91 cw(c5533.62,3951.55) v3@5515.58,3953.13 ; 5519.5,3940.2 cw(c5509.57,3930.27) 5523.62,3930.27 5523.62,3916.34 5523.62,3856.15 5523.62,3836.73 5523.62,3778.47 5523.62,3720.21 5523.62,3661.95 5523.62,3638.82 5523.62,3628.62 5523.62,3583.62 5509.2,3569.2 5476.14,3569.2 5461.2,3554.26 5461.2,3540.56 5451.9,3531.26 5451.9,3470.46 5469.9,3452.46 5469.9,3420.33 v1(5556.86,3333.37) ; v1@5547.36,3333.37 ccw(c5524.42,3333.37) 5540.64,3349.59 ccw(c5556.86,3365.81) v1@5556.86,3342.87 ; v1@5551.36,3333.37 ccw(c5538.08,3333.37) 5547.47,3342.76 ccw(c5556.86,3352.15) v1@5556.86,3338.87 ; v1(5583,3249) 5584,3250 5608.15,3250 ; v1@5586.91,3245.13 cw(c5598.57,3233.61) 5598.57,3250 ; v1@5589.72,3255.72 ccw(c5603.52,3269.52) 5603.52,3250 ; v1@5589.76,3242.32 cw(c5608.15,3224.13) 5608.15,3250 ; v1@5766.81,3159.99 ccw(c5750.59,3143.77) 5750.59,3166.71 ccw(c5750.59,3189.64) v1@5766.81,3173.43 ; v1@5769.64,3162.82 ccw(c5760.25,3153.43) 5760.25,3166.71 ccw(c5760.25,3179.99) v1@5769.64,3170.6 ; v1(5773.52,3166.71) 5692.52,3166.71 5660.19,3199.04 5642.88,3199.04 5623.52,3218.39 5623.52,3234.71 5608.19,3250.04 ; 5608.15,3250 5608.19,3250.04
TFT_IO.RS: J27.20 U8.AF20 | length 954.8
  Top Layer w4: U8.AF20@5606.54,3729.9 cw(c5606.54,3712.18) 5619.07,3724.71 ; U8.AF20@5613.88,3737.24 ccw(c5631.6,3737.24) 5619.07,3724.71 ; 5907.74,3074.16 ccw(c5920.1,3086.51) J27.20@5923.96,3069.47 ; 5912.87,3069.03 ccw(c5922,3078.15) J27.20@5924.85,3065.57 ; J27.20@5925.26,3041.61 5925.26,3041.71 5923.52,3041.71 5923.52,3058.37 5904.19,3077.71 5893.19,3077.71 5890.19,3080.71 5890.19,3233.37 5869.06,3254.5 5827.4,3254.5 5823.52,3258.37 5765.19,3316.71 5736.82,3316.71 5723.52,3330 5723.52,3343.37 5705.86,3361.04 5665.19,3401.71 5665.19,3416.71 5655.9,3426 5619.25,3426 5608.5,3436.75 5608.5,3453.31 5619.11,3463.92 5619.11,3603.11 5630.4,3614.4 5630.4,3638.82 5630.4,3697.36 ccw(c5591.72,3697.36) 5619.07,3724.71
TFT_IO.WR: J27.18 U8.AF23 | length 1314.5
  Top Layer w4: v1@5726.52,3513.87 ccw(c5726.52,3527.15) 5735.91,3517.76 ccw(c5745.3,3508.37) v1@5732.02,3508.37 ; v1@5726.52,3517.87 ccw(c5726.52,3540.81) 5742.74,3524.59 ccw(c5758.96,3508.37) v1@5736.02,3508.37 ; v1@5728.56,3508.37 v1(5726.52,3508.37) 5753.81,3535.66 5753.81,3557.38 5748.51,3562.68 5748.51,3630.82 5748.51,3638.82 5748.51,3697.36 ; v1(5906.41,3000.41) 5906,3000 5906.96,2999.04 5947.52,2999.04 5965.19,3016.71 5965.19,3041.61 5965.19,3041.71 5964.63,3041.71 J27.18@5964.63,3041.61 ; v1@5910.29,3004.29 ccw(c5922.98,3016.98) 5922.98,2999.04 ; v1@5913.12,2993.69 cw(c5926.05,2980.77) 5926.05,2999.04 ; v1@5913.12,3007.12 ccw(c5932.64,3026.64) 5932.64,2999.04 ; 5952.24,3003.76 ccw(c5936.52,3019.49) J27.18@5958.76,3019.49 ; 5959.07,3010.59 ccw(c5950.17,3019.49) J27.18@5962.76,3019.49 ; J27.18@5960.3,3011.82 cw(c5964.63,3007.49) J27.18@5964.63,3013.61 ; 5737.18,3724.71 cw(c5749.71,3737.24) 5731.99,3737.24 ccw(c5749.71,3737.24) 5737.18,3724.71 ; 5737.18,3724.71 ccw(c5724.65,3712.18) 5724.65,3729.9 cw(c5724.65,3712.18) 5737.18,3724.71 ; 5737.18,3724.71 cw(c5709.83,3697.36) 5748.51,3697.36 ; 5737.18,3724.71 cw(c5709.83,3697.36) 5748.51,3697.36
  MidLayer1 w4: v1@5727.52,3509.37 5756.86,3509.37 5765.19,3501.04 5768.04,3498.19 5783.38,3498.19 5793.81,3508.62 5793.81,3508.91 5800,3515.1 ; v1@5902.18,3008.91 ccw(c5897.62,3018.08) 5907.86,3018.08 ; v1(5906.41,3000.41) 5906,3000 5906.41,3000 5906.9,3000 5907.86,2999.04 5907.86,3000.41 5907.86,3018.08 ; v1@5912.64,3007.57 cw(c5921.79,3018.08) 5907.86,3018.08 ; 5800,3515.1 5817.65,3515.1 ; 5800,3515.1 5817.65,3515.1 ; 5817.65,3515.1 5836.86,3515.1 5856.86,3495.1 5856.86,3475.89 ; 5856.86,3425 5856.86,3475.89 ; 5856.86,3425 5856.86,3475.89 ; 5856.86,3425 5856.86,3366.83 5882.86,3340.83 5882.86,3194.69 5898.19,3179.36 5898.19,3027.75 5907.86,3018.08
TFT_TOUCH.X+: J27.12 U48.2 | length 913.8
  Top Layer w4: 6082.74,3010.54 ccw(c6106.69,3010.54) v1@6089.76,2993.61 ; J27.12@6082.74,3020.2 ccw(c6116.35,3020.2) v1@6092.58,2996.44 ; J27.12@6082.74,3029.85 ccw(c6126,3029.85) v1@6095.41,2999.26 ; J27.12@6082.74,3039.51 ccw(c6135.66,3039.51) v1@6098.24,3002.09 ; J27.12@6082.74,3041.61 6082.74,3004.16 v1(6091.52,2995.37) ; U48.2@6497.8,3143.98 6546.26,3143.98 v1(6556.86,3133.37) ; U48.2@6527.83,3140.52 cw(c6536.17,3132.17) 6536.17,3143.98 cw(c6536.18,3155.78) U48.2@6527.83,3147.43
  Bottom Layer w4: v1@6084.81,3002.09 ccw(c6068.59,3018.31) 6091.52,3018.31 ccw(c6114.46,3018.31) v1@6098.24,3002.09 ; v1@6087.64,2999.26 ccw(c6078.25,3008.65) 6091.52,3008.65 ccw(c6104.8,3008.65) v1@6095.41,2999.26 ; v1(6091.52,2995.37) 6091.52,3026.06 6173.84,3108.37 6384.84,3108.37 6418.17,3141.71 6445,3141.71 6505,3141.71 6518.17,3141.71 6526.5,3133.37 v1(6556.86,3133.37) ; v1@6550.14,3126.66 ccw(c6533.92,3110.44) 6533.92,3133.37 ccw(c6533.92,3156.31) v1@6550.14,3140.09 ; v1@6552.97,3129.49 ccw(c6543.58,3120.1) 6543.58,3133.37 ccw(c6543.58,3146.65) v1@6552.97,3137.26
TFT_TOUCH.X-: J27.8 U48.4 | length 714.7
  Top Layer w4: J27.8@6157.33,3015.33 cw(c6147.3,3005.31) 6161.48,3005.31 cw(c6175.66,3005.31) J27.8@6165.64,3015.33 ; J27.8@6161.48,3041.61 6161.48,3003.37 6169.48,2995.37 v1(6183.19,2995.37) ; v1@6441.81,3056.76 ccw(c6425.59,3072.98) 6448.52,3072.98 ccw(c6471.46,3072.98) v1@6455.24,3056.76 ; v1@6444.64,3053.93 ccw(c6435.25,3063.32) 6448.52,3063.32 ccw(c6461.8,3063.32) v1@6452.41,3053.93 ; v1(6448.52,3050.04) 6448.52,3081.37 6459.94,3092.79 ; U48.4@6467.65,3089.45 ccw(c6459.94,3082.24) 6459.94,3092.79 ; U48.4@6467.65,3096.14 cw(c6459.94,3103.35) 6459.94,3092.79 ; U48.4@6497.8,3092.8 6459.94,3092.79
  Bottom Layer w4: v1@6176.47,3002.09 ccw(c6160.26,3018.31) 6183.19,3018.31 ccw(c6206.13,3018.31) v1@6189.91,3002.09 ; v1@6179.3,2999.26 ccw(c6169.91,3008.65) 6183.19,3008.65 ccw(c6196.47,3008.65) v1@6187.08,2999.26 ; v1(6183.19,2995.37) 6183.19,3063.19 6204.04,3084.04 6414.52,3084.04 v1(6448.52,3050.04) ; v1@6439.02,3050.04 ccw(c6416.09,3050.04) 6432.31,3066.26 ccw(c6448.52,3082.48) v1@6448.52,3059.54 ; v1@6443.02,3050.04 ccw(c6429.75,3050.04) 6439.14,3059.43 ccw(c6448.52,3068.82) v1@6448.52,3055.54
TFT_TOUCH.Y+: J27.10 U48.3 | length 826.5
  Top Layer w4: J27.10@6118.8,3014.63 cw(c6114.54,3008.38) 6122.11,3008.38 ; J27.10@6122.11,3041.61 6122.11,3008.37 ; J27.10@6125.42,3014.63 ccw(c6129.69,3008.38) 6122.11,3008.38 ; v1(6141.52,3000.04) 6130.45,3000.04 6122.11,3008.37 ; U48.3@6497.8,3118.39 6530.18,3118.39 v1(6548.52,3100.04) ; U48.3@6524.37,3117.5 cw(c6524.37,3101.32) 6535.81,3112.76 ; v1@6539.02,3100.04 ccw(c6516.09,3100.04) 6532.31,3116.26 ccw(c6548.52,3132.48) v1@6548.52,3109.54 ; v1@6543.02,3100.04 ccw(c6529.75,3100.04) 6539.14,3109.43 ccw(c6548.52,3118.82) v1@6548.52,3105.54
  Bottom Layer w4: v1@6134.81,3006.76 ccw(c6118.59,3022.98) 6141.52,3022.98 ccw(c6164.46,3022.98) v1@6148.24,3006.76 ; v1@6137.64,3003.93 ccw(c6128.25,3013.32) 6141.52,3013.32 ccw(c6154.8,3013.32) v1@6145.41,3003.93 ; v1(6141.52,3000.04) 6141.52,3064.75 6176.82,3100.04 6387.82,3100.04 6421.15,3133.37 6465,3133.37 6515.19,3133.37 v1(6548.52,3100.04) ; v1@6539.02,3100.04 ccw(c6516.09,3100.04) 6532.31,3116.26 ccw(c6548.52,3132.48) v1@6548.52,3109.54 ; v1@6543.02,3100.04 ccw(c6529.75,3100.04) 6539.14,3109.43 ccw(c6548.52,3118.82) v1@6548.52,3105.54
TFT_TOUCH.Y-: J27.6 U48.5 | length 989.2
  Top Layer w4: v1(6181.86,2947.37) 6206.86,2972.37 6206.86,2995 6200.85,3001 J27.6@6200.85,3041.61 ; v1@6181.86,2952.87 ccw(c6181.86,2966.15) 6191.25,2956.76 ccw(c6200.64,2947.37) v1@6187.36,2947.37 ; v1@6181.86,2956.87 ccw(c6181.86,2979.81) 6198.07,2963.59 ccw(c6214.29,2947.37) v1@6191.36,2947.37 ; J27.6@6196.7,3015.33 cw(c6186.67,3005.31) 6200.85,3005.31 cw(c6215.03,3005.31) J27.6@6205.01,3015.33 ; U48.5@6497.8,3067.2 6543.67,3067.2 6559.84,3083.37 v1(6615.19,3083.37) ; U48.5@6527.83,3063.75 cw(c6536.17,3055.4) 6536.17,3067.2 cw(c6536.17,3079.01) U48.5@6527.83,3070.66 ; v1@6608.47,3076.66 ccw(c6592.26,3060.44) 6592.26,3083.37 ccw(c6592.26,3106.31) v1@6608.47,3090.09 ; v1@6611.3,3079.49 ccw(c6601.91,3070.1) 6601.91,3083.37 ccw(c6601.91,3096.65) v1@6611.3,3087.26
  Bottom Layer w4: v1(6181.86,2947.37) 6201.19,2966.71 6498.52,2966.71 v1(6615.19,3083.37) ; v1@6181.86,2952.87 ccw(c6181.86,2966.15) 6191.25,2956.76 ccw(c6200.64,2947.37) v1@6187.36,2947.37 ; v1@6181.86,2956.87 ccw(c6181.86,2979.81) 6198.07,2963.59 ccw(c6214.29,2947.37) v1@6191.36,2947.37 ; v1@6605.69,3083.37 cw(c6582.76,3083.37) 6598.97,3067.16 cw(c6615.19,3050.94) v1@6615.19,3073.87 ; v1@6609.69,3083.37 cw(c6596.41,3083.37) 6605.8,3073.99 cw(c6615.19,3064.6) v1@6615.19,3077.87
TFT_TSC.BUSY: U8.W28 U48.13 | length 2446.6
  Top Layer w4: v1@6027.98,3984.58 ccw(c6011.76,3968.36) 6011.76,3991.3 ccw(c6011.76,4014.23) v1@6027.98,3998.02 ; v1@6030.81,3987.41 ccw(c6021.42,3978.02) 6021.42,3991.3 ccw(c6021.42,4004.58) v1@6030.81,3995.19 ; v1(6034.7,3991.3) 6008.7,3991.3 5987.17,4012.83 5949.18,4012.83 5941.18,4012.83 ; v1@6700.14,3683.32 cw(c6683.92,3667.11) 6706.86,3667.11 cw(c6729.79,3667.11) v1@6713.57,3683.32 ; v1@6702.97,3686.15 cw(c6693.58,3676.76) 6706.86,3676.76 cw(c6720.14,3676.76) v1@6710.75,3686.15 ; v1(6706.86,3690.04) 6706.86,3634.33 6715.19,3626 6715.19,3600.04 6756.86,3558.37 6756.86,3516.71 6790.19,3483.37 6790.19,3465 6760,3434.81 6760,3405.27 6717.36,3362.62 6717.36,3340 6717.36,3322.21 6717.36,3297.87 6731.86,3283.37 6790.19,3283.37 6797.5,3290.68 6797.5,3292.25 6813.63,3308.37 6831.86,3308.37 6873.52,3266.71 6873.52,3113.52 6866.71,3106.71 6777.58,3106.71 6763.67,3092.79 U48.13@6722.2,3092.8 ; U48.13@6752.24,3089.34 cw(c6760.58,3080.99) 6760.58,3092.79 cw(c6760.59,3104.6) U48.13@6752.24,3096.25 ; 5939.22,4012.83 cw(c5939.22,4030.56) 5926.69,4018.03 ccw(c5939.22,4030.56) 5939.22,4012.83 ; 5939.22,4012.83 ccw(c5939.22,3995.11) 5926.69,4007.64 cw(c5939.22,3995.11) 5939.22,4012.83 ; 5941.18,4012.83 U8.W28@5921.5,4012.83 5941.18,4012.83
  MidLayer2 w4: v1(6106.86,3741.71) 6186.17,3741.71 6195,3750.54 6375.52,3750.54 6443.52,3682.54 6629.94,3682.54 6657.94,3710.54 6686.36,3710.54 v1(6706.86,3690.04) ; v1@6110.75,3737.82 cw(c6120.14,3728.43) 6120.14,3741.71 cw(c6120.14,3754.99) v1@6110.75,3745.6 ; v1@6113.57,3734.99 cw(c6129.79,3718.77) 6129.79,3741.71 cw(c6129.79,3764.64) v1@6113.57,3748.43 ; v1@6697.36,3690.04 ccw(c6674.42,3690.04) 6690.64,3706.26 ccw(c6706.86,3722.48) v1@6706.86,3699.54 ; v1@6701.36,3690.04 ccw(c6688.08,3690.04) 6697.47,3699.43 ccw(c6706.86,3708.82) v1@6706.86,3695.54
  Bottom Layer w4: v1@6028.14,3984.43 cw(c6013.54,3969.11) 6034.7,3969.11 ; v1@6030.9,3987.32 cw(c6022.45,3978.45) 6034.7,3978.45 cw(c6046.95,3978.45) v1@6038.5,3987.32 ; v1(6034.7,3991.3) 6034.7,3969.11 ; v1@6041.26,3984.43 ccw(c6055.86,3969.11) 6034.7,3969.11 ; v1@6100.14,3748.43 ccw(c6083.92,3764.64) 6106.86,3764.64 ccw(c6129.79,3764.64) v1@6113.57,3748.43 ; v1@6102.97,3745.6 ccw(c6093.58,3754.99) 6106.86,3754.99 ccw(c6120.14,3754.99) v1@6110.75,3745.6 ; v1(6106.86,3741.71) 6106.86,3842.39 6082.5,3866.75 6082.5,3900.75 6070.5,3912.75 6070.5,3919.99 6043.81,3946.68 6043.81,3960 6034.7,3969.11
TFT_TSC.CLK: U8.AB16 U48.16 | length 2748.5
  Top Layer w4: U8.AB16@5449.05,3887.38 cw(c5449.05,3869.66) 5461.59,3882.19 cw(c5474.12,3894.72) U8.AB16@5456.4,3894.72 ; U8.AB16@5449.06,3894.72 v3(5468.74,3875.04) ; v1(6665.19,3200.04) 6709.96,3200.04 6722.2,3187.8 U48.16@6722.2,3169.57 ; v1@6669.08,3196.15 cw(c6678.47,3186.76) 6678.47,3200.04 cw(c6678.47,3213.32) v1@6669.08,3203.93 ; v1@6671.91,3193.32 cw(c6688.13,3177.11) 6688.13,3200.04 cw(c6688.13,3222.98) v1@6671.91,3206.76 ; U48.16@6718.75,3173.02 ccw(c6710.4,3181.37) 6722.2,3181.37 ccw(c6734.01,3181.37) U48.16@6725.66,3173.02 ; 5455.94,3887.84 cw(c5443.13,3875.04) 5461.24,3875.04 ccw(c5443.13,3875.04) 5455.94,3887.84 ; 5455.94,3887.84 ccw(c5468.74,3900.65) 5468.74,3882.54 cw(c5468.74,3900.65) 5455.94,3887.84
  MidLayer2 w4: v1@5353.4,3198.43 ccw(c5337.18,3214.64) 5360.12,3214.64 ccw(c5383.05,3214.64) v1@5366.84,3198.43 ; v1@5356.23,3195.6 ccw(c5346.84,3204.99) 5360.12,3204.99 ccw(c5373.4,3204.99) v1@5364.01,3195.6 ; v1(5360.12,3191.71) 5360.12,3249.23 5362.5,3251.61 ; v3@5468.09,3867.57 cw(c5466.51,3849.53) 5480.38,3861.17 cw(c5494.25,3872.81) v3@5476.21,3874.39 ; 5480.13,3861.46 cw(c5470.2,3851.53) 5484.25,3851.53 5484.25,3757.99 5484.25,3609.25 5480,3605 5454.45,3605 5416.16,3566.71 5370.72,3566.71 5360.29,3556.28 5360.29,3527.04 5346,3512.75 5346,3474.55 5355.5,3465.05 5355.5,3432.54 5347.69,3424.73 5347.69,3389.85 5362.69,3374.85 5362.69,3367.33 5375.2,3354.82 5375.2,3325.35 5375.2,3264.31 ; 5362.5,3251.61 5375.2,3264.31 ; 5362.5,3251.61 5374.11,3263.22 5375.2,3264.31
  Bottom Layer w4: v1(5360.12,3191.71) 5389.52,3191.71 5447.02,3134.21 5520,3134.21 5548.69,3134.21 5549.86,3133.04 5640,3133.04 5840,3133.04 5845,3133.04 5860,3133.04 5875,3133.04 6039.92,3133.04 6083.05,3176.18 6083.05,3193.8 6093.31,3204.05 ; v1@5364.01,3187.82 cw(c5373.4,3178.43) 5373.4,3191.71 cw(c5373.4,3204.99) v1@5364.01,3195.6 ; v1@5366.84,3184.99 cw(c5383.05,3168.77) 5383.05,3191.71 cw(c5383.05,3214.64) v1@5366.84,3198.43 ; 6093.43,3204.05 6098.77,3209.4 6122.38,3233 6135,3233 6153.31,3233 6166.71,3219.6 6166.71,3211.22 6166.71,3194.6 6177.94,3183.37 6191.88,3183.37 6205,3183.37 6237.21,3183.37 6270.54,3216.71 6381.86,3216.71 6420.15,3255 6530.37,3255 6576.96,3208.41 6605.28,3208.41 6613.65,3200.04 v1(6665.19,3200.04) ; v1@6658.47,3193.32 ccw(c6642.26,3177.11) 6642.26,3200.04 ccw(c6642.26,3222.98) v1@6658.47,3206.76 ; v1@6661.3,3196.15 ccw(c6651.91,3186.76) 6651.91,3200.04 ccw(c6651.91,3213.32) v1@6661.3,3203.93
TFT_TSC.CS_N: U8.AD28 U48.15 | length 1758.3
  Top Layer w4: U8.AD28@5921.5,3815.98 5995.33,3815.98 5996.7,3815.98 6014.18,3798.5 6073.52,3739.16 ; U8.AD28@5926.69,3810.79 cw(c5939.22,3798.26) 5939.22,3815.98 cw(c5939.22,3833.71) U8.AD28@5926.69,3821.18 ; v1@6057.48,3613.35 ccw(c6041.26,3629.57) 6064.2,3629.57 ccw(c6087.13,3629.57) v1@6070.91,3613.35 ; v1@6060.31,3610.52 ccw(c6050.92,3619.91) 6064.2,3619.91 ccw(c6077.47,3619.91) v1@6068.08,3610.52 ; v1(6064.2,3606.63) 6064.2,3684.2 6073.52,3693.52 6073.52,3739.16 ; 6073.52,3713.02 6073.52,3739.16 ; v1@6564,3273.5 cw(c6564,3250.56) 6580.22,3266.78 cw(c6596.43,3283) v1@6573.5,3283 ; v1@6564,3277.5 cw(c6564,3264.22) 6573.39,3273.61 cw(c6582.78,3283) v1@6569.5,3283 ; 6686.84,3153.39 cw(c6677.43,3143.98) U48.15@6690.74,3143.98 ; 6688.35,3151.88 ccw(c6695.63,3159.16) U48.15@6695.63,3148.87 ; U48.15@6722.2,3143.98 6696.26,3143.98 6645.88,3194.36 6645.88,3201.12 v1@6565.19,3281.81 ; v1@6565.19,3281.81 6565.19,3283 6565.19,3283.37 6564.82,3283 v1(6564,3283) v1@6565.19,3281.81
  MidLayer1 w4: v1@6033.47,3389.09 ccw(c6017.26,3405.31) 6040.19,3405.31 ccw(c6063.13,3405.31) v1@6046.91,3389.09 ; v1@6036.3,3386.26 ccw(c6026.91,3395.65) 6040.19,3395.65 ccw(c6053.47,3395.65) v1@6044.08,3386.26 ; v1(6040.19,3382.37) 6040.19,3570 6040.19,3576.71 6040.19,3582.63 v1(6064.2,3606.63) ; v1@6054.7,3606.63 cw(c6031.76,3606.63) 6047.98,3590.41 cw(c6064.2,3574.2) v1@6064.2,3597.13 ; v1@6058.7,3606.63 cw(c6045.42,3606.63) 6054.81,3597.24 cw(c6064.2,3587.85) v1@6064.2,3601.13
  MidLayer2 w4: v1(6040.19,3382.37) 6065.19,3382.37 6114.19,3333.37 6264.58,3333.37 6279.92,3318.04 6417.86,3318.04 6435.86,3300.04 6452.52,3283.37 6564,3283.37 6565.19,3283.37 6564.82,3283 v1(6564,3283) ; v1@6044.08,3378.49 cw(c6053.47,3369.1) 6053.47,3382.37 cw(c6053.47,3395.65) v1@6044.08,3386.26 ; v1@6046.91,3375.66 cw(c6063.13,3359.44) 6063.13,3382.37 cw(c6063.13,3405.31) v1@6046.91,3389.09 ; 6540.16,3283.37 cw(c6540.16,3259.16) v1@6557.28,3276.28 ; 6541.97,3283.37 ccw(c6541.97,3305.03) v1@6557.28,3289.72 ; 6549.82,3283.37 cw(c6549.82,3268.82) v1@6560.11,3279.11 ; 6551.63,3283.37 ccw(c6551.63,3295.37) v1@6560.11,3286.89
TFT_TSC.DIN: U8.AD25 U48.14 | length 1901.4
  Top Layer w4: U8.AD25@5803.39,3808.64 cw(c5803.39,3790.92) 5815.92,3803.45 cw(c5828.45,3815.98) U8.AD25@5810.73,3815.98 ; U8.AD25@5803.39,3815.98 v3(5823.07,3796.3) ; v1@6658.86,3132.21 cw(c6658.86,3114.1) 6671.66,3126.9 ; v1@6658.86,3139.71 6680.18,3118.39 U48.14@6722.2,3118.39 ; v1@6664.36,3141.71 ccw(c6682.46,3141.71) 6669.66,3128.9 ; v1@6668.36,3141.71 ccw(c6696.12,3141.71) 6676.49,3122.08 ; U48.14@6692.17,3114.93 ccw(c6683.83,3106.58) 6683.83,3118.39 ccw(c6683.83,3130.19) U48.14@6692.17,3121.84 ; 5810.27,3809.1 cw(c5797.46,3796.3) 5815.57,3796.3 ccw(c5797.46,3796.3) 5810.27,3809.1 ; 5810.27,3809.1 ccw(c5823.07,3821.91) 5823.07,3803.8 cw(c5823.07,3821.91) 5810.27,3809.1
  MidLayer1 w4: v3(5823.07,3796.3) 5881.33,3796.3 5900.75,3796.3 5941.18,3796.3 5949.18,3796.3 5953.7,3796.3 5960,3790 5960,3602.39 6022.81,3539.58 6022.81,3485 6022.81,3462.62 6022.81,3409.12 6010,3396.31 6010,3368.92 6022.92,3356 6057.69,3356 6073.52,3340.16 v1(6073.52,3291.71) ; v3@5828.26,3791.11 cw(c5840.8,3778.57) 5840.8,3796.3 cw(c5840.8,3814.03) v3@5828.26,3801.49 ; v1@6066.81,3298.43 ccw(c6050.59,3314.64) 6073.52,3314.64 ccw(c6096.46,3314.64) v1@6080.24,3298.43 ; v1@6069.64,3295.6 ccw(c6060.25,3304.99) 6073.52,3304.99 ccw(c6086.8,3304.99) v1@6077.41,3295.6 ; 5841.18,3796.3 cw(c5841.18,3814.41) 5828.37,3801.6 ccw(c5841.18,3814.41) 5841.18,3796.3 ; 5841.18,3796.3 ccw(c5841.18,3778.19) 5828.37,3791 cw(c5841.18,3778.19) 5841.18,3796.3
  MidLayer2 w4: v1(6073.52,3291.71) 6099.04,3291.71 6123.5,3267.25 6125.87,3264.87 6341.34,3264.87 6344.87,3264.87 6363.71,3283.71 6375,3283.71 6428.54,3283.71 6461.88,3250.37 6573.31,3250.37 6658.86,3164.83 v1(6658.86,3141.71) ; v1@6077.41,3287.82 cw(c6086.8,3278.43) 6086.8,3291.71 cw(c6086.8,3304.99) v1@6077.41,3295.6 ; v1@6080.24,3284.99 cw(c6096.46,3268.77) 6096.46,3291.71 cw(c6096.46,3314.64) v1@6080.24,3298.43 ; v1@6652.14,3148.43 ccw(c6635.92,3164.64) 6658.86,3164.64 ccw(c6681.79,3164.64) v1@6665.57,3148.43 ; v1@6654.97,3145.6 ccw(c6645.58,3154.99) 6658.86,3154.99 ccw(c6672.14,3154.99) v1@6662.75,3145.6
TFT_TSC.DOUT: U8.AA22 U48.12 | length 2529.3
  Top Layer w4: U8.AA22@5685.28,3926.75 cw(c5685.28,3909.03) 5697.81,3921.56 cw(c5710.34,3934.09) U8.AA22@5692.62,3934.09 ; U8.AA22@5685.28,3934.09 v3(5704.96,3914.41) ; U48.12@6722.2,3067.2 6752.8,3067.2 6765.29,3054.71 6869.86,3054.71 6890.19,3075.04 6890.19,3175.04 v1(6923.52,3208.37) ; U48.12@6748.78,3062.32 cw(c6748.78,3040.82) 6763.98,3056.02 ; U48.12@6748.78,3066.32 cw(c6748.78,3054.47) 6757.15,3062.85 ; v1@6914.02,3208.37 cw(c6891.09,3208.37) 6907.31,3192.16 cw(c6923.52,3175.94) v1@6923.52,3198.87 ; v1@6918.02,3208.37 cw(c6904.75,3208.37) 6914.14,3198.99 cw(c6923.52,3189.6) v1@6923.52,3202.87 ; 5692.16,3927.21 cw(c5679.35,3914.41) 5697.46,3914.41 ccw(c5679.35,3914.41) 5692.16,3927.21 ; 5692.16,3927.21 ccw(c5704.96,3940.02) 5704.96,3921.91 cw(c5704.96,3940.02) 5692.16,3927.21
  MidLayer2 w4: v1(6125.5,3699.54) 6217.85,3699.54 6226.27,3707.96 6265.54,3707.96 6329.31,3644.19 6337.71,3644.19 6490.19,3491.71 6634.52,3491.71 6659.52,3516.71 6931.86,3516.71 6948.52,3500.04 6948.52,3233.37 v1(6923.52,3208.37) ; v1@6129.39,3695.65 cw(c6138.78,3686.26) 6138.78,3699.54 cw(c6138.78,3712.82) v1@6129.39,3703.43 ; v1@6132.22,3692.82 cw(c6148.43,3676.6) 6148.43,3699.54 cw(c6148.43,3722.47) v1@6132.22,3706.26 ; v1@6923.52,3213.87 ccw(c6923.52,3227.15) 6932.91,3217.76 ccw(c6942.3,3208.37) v1@6929.02,3208.37 ; v1@6923.52,3217.87 ccw(c6923.52,3240.81) 6939.74,3224.59 ccw(c6955.96,3208.37) v1@6933.02,3208.37
  Bottom Layer w4: v3@5706.26,3907.02 cw(c5709.41,3889.19) 5719.79,3904.02 ; v3@5712.35,3915.71 ccw(c5730.18,3918.86) 5719.79,3904.02 ; v1@6118.78,3692.82 ccw(c6102.56,3676.6) 6102.56,3699.54 ccw(c6102.56,3722.47) v1@6118.78,3706.26 ; v1@6121.61,3695.65 ccw(c6112.22,3686.26) 6112.22,3699.54 ccw(c6112.22,3712.82) v1@6121.61,3703.43 ; v1(6125.5,3699.54) 6101.65,3699.54 6097.48,3703.71 6047.5,3753.69 6047.5,3830 6044.69,3832.81 6004.3,3832.81 5975.7,3832.81 5971.03,3828.14 5971.03,3816.03 5966.9,3811.9 5949.18,3811.9 5941.18,3811.9 5939.59,3811.9 5881.33,3811.9 5823.07,3811.9 cw(c5823.07,3835.67) 5799.3,3835.67 ccw(c5783.7,3835.67) 5783.7,3851.27 cw(c5783.7,3875.04) 5759.93,3875.04 ccw(c5744.33,3875.04) 5744.33,3890.64 cw(c5744.33,3914.41) 5727.52,3897.6 5719.79,3904.02
TFT_TSC.TFT_INT: R215.2 U8.AB19 U48.11 | length 2865
  Top Layer w4: U8.AB19@5567.17,3887.38 cw(c5567.17,3869.66) 5579.7,3882.19 cw(c5592.23,3894.72) U8.AB19@5574.51,3894.72 ; U8.AB19@5567.17,3894.72 v3(5586.85,3875.04) ; v1@6673.52,3048.87 cw(c6673.52,3025.94) 6689.74,3042.16 cw(c6705.96,3058.37) v1@6683.02,3058.37 ; v1@6673.52,3052.87 cw(c6673.52,3039.6) 6682.91,3048.99 cw(c6692.3,3058.37) v1@6679.02,3058.37 ; v1(6673.52,3058.37) 6690.28,3041.61 U48.11@6722.2,3041.61 ; 6684.99,3046.91 ccw(c6695.63,3057.56) U48.11@6695.63,3042.5 ; R215.2@6831.18,2685 6858.48,2685 6865.19,2691.71 v1(6873.52,2691.71) ; R215.2@6834.94,2681.24 cw(c6844.02,2672.16) 6844.02,2685 cw(c6844.02,2697.84) R215.2@6834.94,2688.76 ; R215.2@6837.77,2678.41 cw(c6853.68,2662.5) 6853.68,2685 cw(c6853.68,2707.5) R215.2@6837.77,2691.59 ; 5574.05,3887.84 cw(c5561.24,3875.04) 5579.35,3875.04 ccw(c5561.24,3875.04) 5574.05,3887.84 ; 5574.05,3887.84 ccw(c5586.85,3900.65) 5586.85,3882.54 cw(c5586.85,3900.65) 5574.05,3887.84
  MidLayer2 w4: v3@5586.2,3867.57 cw(c5584.62,3849.53) 5598.49,3861.17 cw(c5612.36,3872.81) v3@5594.32,3874.39 ; 5598.24,3861.46 cw(c5588.31,3851.53) 5602.36,3851.53 ; 5602.36,3641.47 5602.36,3699.73 ; 5602.36,3837.6 5602.36,3851.53 ; v1@6673.52,3063.87 ccw(c6673.52,3077.15) 6682.91,3067.76 ccw(c6692.3,3058.37) v1@6679.02,3058.37 ; v1@6673.52,3067.87 ccw(c6673.52,3090.81) 6689.74,3074.59 ccw(c6705.96,3058.37) v1@6683.02,3058.37 ; v1@6677.41,3054.49 cw(c6686.8,3045.1) 6686.8,3058.37 cw(c6686.8,3071.65) v1@6677.41,3062.26 ; v1@6680.24,3051.66 cw(c6696.46,3035.44) 6696.46,3058.37 cw(c6696.46,3081.31) v1@6680.24,3065.09 ; v1@6866.81,2698.43 ccw(c6850.59,2714.64) 6873.52,2714.64 ccw(c6896.46,2714.64) v1@6880.24,2698.43 ; v1@6869.64,2695.6 ccw(c6860.25,2704.99) 6873.52,2704.99 ccw(c6886.8,2704.99) v1@6877.41,2695.6 ; v1(6873.52,2691.71) 6873.52,2992.79 6824.61,3041.71 6757.52,3041.71 6740.86,3058.37 v1(6673.52,3058.37) 6690.19,3075.04 6690.19,3305.73 6661.88,3334.04 6286.54,3334.04 6270.54,3350.04 6203.88,3350.04 6128.73,3425.19 6104.31,3425.19 6088,3441.5 6076.8,3441.5 6070,3441.5 6015.69,3495.81 5879.38,3495.81 5848.25,3495.81 5825.19,3518.87 5801.13,3518.87 5787.37,3532.63 5725,3595 5720,3595 5710,3595 5685,3595 5605,3595 5602.36,3597.64 5602.36,3630.82 5602.36,3638.82 5602.36,3699.73 ; 5602.36,3699.73 5602.36,3757.99 5602.36,3851.53
TMS: R68.2 U8.P8 | length 4444.8
  Top Layer w4: v1@4181.95,4306.95 4230.71,4258.19 4326.63,4258.19 4373.86,4210.97 4373.86,4158.04 4398.52,4133.37 4428.99,4133.37 4517.37,4045 v1(4520,4045) ; v1@4185,4300.5 cw(c4185,4292.3) 4190.8,4298.1 ; v1@4186.5,4310 ccw(c4204.85,4310) 4191.88,4297.02 ; v1@4190.5,4310 ccw(c4218.51,4310) 4198.7,4290.19 ; v1@4194.5,4310 ccw(c4232.17,4310) 4205.53,4283.37 ; 4499.29,4063.08 ccw(c4520,4083.79) v1@4520,4054.5 ; 4505.64,4056.72 cw(c4493.92,4045) v1@4510.5,4045 ; 4506.12,4056.25 ccw(c4520,4070.13) v1@4520,4050.5 ; v3(5114.41,4229.37) U8.P8@5134.09,4209.68 ; U8.P8@5126.75,4209.68 ccw(c5109.03,4209.68) 5121.56,4222.22 ccw(c5134.09,4234.75) U8.P8@5134.09,4217.03 ; v1@5537.98,3232.98 cw(c5521.76,3216.76) 5544.7,3216.76 cw(c5567.63,3216.76) v1@5551.42,3232.98 ; v1@5540.81,3235.81 cw(c5531.42,3226.42) 5544.7,3226.42 cw(c5557.98,3226.42) v1@5548.59,3235.81 ; v1(5544.7,3239.7) 5544.7,3215.3 5551.1,3208.9 v1(5563.4,3208.9) ; 5127.21,4216.57 cw(c5140.02,4229.37) 5121.91,4229.37 ccw(c5140.02,4229.37) 5127.21,4216.57 ; 5127.21,4216.57 ccw(c5114.41,4203.76) 5114.41,4221.87 cw(c5114.41,4203.76) 5127.21,4216.57
  MidLayer1 w4: v1@4510.5,4045 cw(c4487.56,4045) 4503.78,4028.78 cw(c4520,4012.56) v1@4520,4035.5 ; v1@4514.5,4045 cw(c4501.22,4045) 4510.61,4035.61 cw(c4520,4026.22) v1@4520,4039.5 ; v1(4520,4045) 4473.95,3998.95 4473.95,3953.7 4464.69,3944.44 4464.69,3700.55 4490.19,3675.04 4632.52,3675.04 4675.7,3631.87 4675.7,3570.8 4790.19,3456.31 4790.19,3375.04 v1(4856.86,3308.37) ; v1@4847.36,3308.37 ccw(c4824.42,3308.37) 4840.64,3324.59 ccw(c4856.86,3340.81) v1@4856.86,3317.87 ; v1@4851.36,3308.37 ccw(c4838.08,3308.37) 4847.47,3317.76 ccw(c4856.86,3327.15) v1@4856.86,3313.87
  MidLayer2 w4: v1@4185,4307.04 v1(4256.86,4307.04) 4279.92,4307.04 4298.69,4325.81 4345,4325.81 4404.36,4325.81 4405.96,4324.21 4439.22,4324.21 4500.93,4262.5 4516.53,4262.5 4526.79,4272.75 4526.79,4282.21 4537.22,4292.64 4551.97,4292.64 4564.5,4280.12 4564.5,4190.75 4584.75,4170.5 4599.88,4170.5 4612.28,4158.09 4624.16,4158.09 4630.37,4164.31 4661.37,4164.31 4686.56,4189.5 4719.56,4189.5 4734.06,4204 4760,4204 4786.5,4204 4822.12,4239.62 4822.12,4248.19 4827.16,4253.23 4830.46,4253.23 4838.82,4253.23 4841.47,4253.23 4899.73,4253.23 4957.99,4253.23 4977.41,4253.23 5051.53,4253.23 5071.03,4253.23 cw(c5071.03,4211.5) 5100.54,4241.01 ; v1@4188.89,4313.89 ccw(c4205.42,4330.42) 4205.42,4307.04 ; v1@4191.72,4303.28 cw(c4200.79,4294.21) 4200.79,4307.04 ; v1@4191.72,4316.72 ccw(c4215.08,4340.08) 4215.08,4307.04 ; v1@4250.14,4300.32 ccw(c4233.92,4284.11) 4233.92,4307.04 ccw(c4233.92,4329.98) v1@4250.14,4313.76 ; v1@4252.97,4303.15 ccw(c4243.58,4293.76) 4243.58,4307.04 ccw(c4243.58,4320.32) v1@4252.97,4310.93 ; v1@4260.75,4303.15 cw(c4270.14,4293.76) 4270.14,4307.04 cw(c4270.14,4320.32) v1@4260.75,4310.93 ; v1@4263.57,4300.32 cw(c4279.79,4284.11) 4279.79,4307.04 cw(c4279.79,4329.98) v1@4263.57,4313.76 ; v3@5106.94,4228.72 ccw(c5088.9,4227.14) 5100.54,4241.01 ; v3@5113.76,4236.84 cw(c5112.18,4254.88) 5100.54,4241.01
  Bottom Layer w4: v1(4856.86,3308.37) 4879.25,3308.37 4911.12,3276.5 4942.71,3276.5 4953.34,3265.87 4970,3249.21 5060.44,3249.21 5106.75,3249.21 5139.17,3216.79 5139.17,3216.71 ; v1@4860.81,3304.55 cw(c4869.82,3295.85) 4869.82,3308.37 cw(c4869.82,3320.9) v1@4860.81,3312.2 ; v1@4863.69,3301.77 cw(c4879.25,3286.74) 4879.25,3308.37 cw(c4879.25,3330.01) v1@4863.69,3314.98 ; 5110.88,3245 5139.17,3216.71 ; v1(5544.7,3239.7) 5571.5,3266.5 5572.5,3267.5 5583.75,3267.5 5602.05,3267.5 5631.86,3237.69 5631.86,3221.37 5645.86,3207.37 5665,3207.37 5677.38,3195 R68.2@5705.82,3195 ; 5544.81,3210.7 ccw(c5544.81,3227.49) v1@5556.68,3215.62 ; 5546.03,3210.7 cw(c5546.03,3191.89) v1@5559.47,3205.05 ; v1@5556.61,3202.25 ccw(c5536.51,3182.56) 5536.51,3210.7 ; v1(5563.4,3208.9) 5561.6,3210.7 5536.51,3210.7 ; R68.2@5699.23,3188.41 ccw(c5683.32,3172.5) 5683.32,3195 ccw(c5683.32,3217.5) R68.2@5699.23,3201.59 ; R68.2@5702.06,3191.24 ccw(c5692.98,3182.16) 5692.98,3195 ccw(c5692.98,3207.84) R68.2@5702.06,3198.76 ; 5139.17,3216.71 5155.67,3200.21 5224.05,3200.21 5227.34,3203.5 5282.34,3203.5 5295.52,3216.68 5336.32,3216.68 5353.84,3234.2 5437.51,3234.2 5439.61,3232.1 5465,3232.1 5490.6,3232.1 5515.11,3232.1 5536.51,3210.7
  other v1: 4185,4310
TSC_3V3: NT42.1 U48.1 U48.9 U48.10 | length 4505.7
  Top Layer w4: v1@5658.47,2593.32 cw(c5642.26,2577.11) 5665.19,2577.11 cw(c5688.13,2577.11) v1@5671.91,2593.32 ; v1@5661.3,2596.15 cw(c5651.91,2586.76) 5665.19,2586.76 cw(c5678.47,2586.76) v1@5669.08,2596.15 ; 5665.19,2518 v1(5665.19,2600.04) ; 5665.69,2518 5724.81,2458.87 5850,2458.87 5955.99,2458.87 6092.11,2595 6126.57,2595 6157.19,2625.63 6157.19,2642.04 6223.52,2708.37 ; v1@6234.51,2702.78 ccw(c6223.52,2694.79) 6223.52,2708.37 ; v1@6234.51,2713.97 cw(c6223.52,2721.96) 6223.52,2708.37 ; v1(6242.19,2708.37) 6223.52,2708.37 ; U48.1@6498.52,3169.57 U48.1@6497.8,3169.57 6559.33,3169.57 v1(6570.52,3158.37) ; U48.1@6527.83,3166.11 cw(c6536.17,3157.76) 6536.17,3169.57 cw(c6536.17,3181.37) U48.1@6527.83,3173.02 ; v1@6668.24,3005.01 ccw(c6663.88,3012.86) 6672.86,3012.86 ; v1@6673.92,2997.77 ccw(c6691.63,3015.48) U48.9@6691.63,2990.43 ; v1@6676.75,3000.6 ccw(c6701.28,3025.13) U48.9@6701.28,2990.43 ; v1@6677.47,3005.01 cw(c6681.83,3012.86) 6672.86,3012.86 ; v1@6679.57,3003.43 ccw(c6710.94,3034.79) U48.9@6710.94,2990.43 ; U48.10@6692.17,3012.57 ccw(c6683.83,3004.22) 6683.83,3016.02 ccw(c6683.83,3027.83) U48.10@6692.17,3019.48 ; U48.9@6722.2,2990.43 6679.13,2990.43 v1(6672.86,2996.71) 6672.86,3012.86 ; U48.10@6722.2,3016.02 6676.02,3016.02 6672.86,3012.86
  MidLayer1 w4: v1@6232.69,2708.37 cw(c6209.76,2708.37) 6225.97,2692.16 cw(c6242.19,2675.94) v1@6242.19,2698.87 ; v1@6236.69,2708.37 cw(c6223.41,2708.37) 6232.8,2698.99 cw(c6242.19,2689.6) v1@6242.19,2702.87 ; v1(6242.19,2708.37) 6223.52,2689.71 6223.52,2562.79 6269.61,2516.71 6331.86,2516.71 6348.52,2533.37 6348.52,2559.34 6365,2575.81 6380.69,2591.5 6410,2591.5 6414.75,2591.5 6445,2591.5 6478.65,2591.5 6522.81,2635.66 6522.81,2662.38 6515.19,2670 6515.19,2816.71 6556.86,2858.37 6556.86,3070 6585,3098.14 6585,3143.9 v1(6570.52,3158.37)
  MidLayer2 w4: v1@4418.14,2515.09 ccw(c4401.92,2531.31) 4424.86,2531.31 ccw(c4447.79,2531.31) v1@4431.57,2515.09 ; v1@4420.97,2512.26 ccw(c4411.58,2521.65) 4424.86,2521.65 ccw(c4438.14,2521.65) v1@4428.75,2512.26 ; v1(4424.86,2508.37) 4424.86,2649.9 4450,2675.04 4939.79,2675.04 4981.46,2716.71 5153.21,2716.71 5178.54,2691.37 5185.17,2691.37 5235.17,2691.37 5240,2696.21 5405.77,2696.21 ; 5405.79,2696.19 5488.81,2696.19 5545,2640 5545,2568.37 5555,2558.37 5623.52,2558.37 v1(5665.19,2600.04) ; v1@5655.69,2600.04 cw(c5632.76,2600.04) 5648.97,2583.82 cw(c5665.19,2567.61) v1@5665.19,2590.54 ; v1@5659.69,2600.04 cw(c5646.41,2600.04) 5655.8,2590.65 cw(c5665.19,2581.26) v1@5665.19,2594.54 ; v1(6570.52,3158.37) 6616.63,3158.37 6639.7,3135.3 6639.7,3089.2 6639.7,3085 6639.7,3045.58 6672.86,3012.42 v1(6672.86,2996.71) ; v1@6574.41,3154.49 cw(c6583.8,3145.1) 6583.8,3158.37 cw(c6583.8,3171.65) v1@6574.41,3162.26 ; v1@6577.24,3151.66 cw(c6593.46,3135.44) 6593.46,3158.37 cw(c6593.46,3181.31) v1@6577.24,3165.09
  Bottom Layer w4: v1(4424.86,2508.37) 4466.63,2508.37 4469.76,2505.24 NT42.1@4469.76,2485.08 NT42.1@4469.76,2483.37 ; v1@4428.75,2504.49 cw(c4438.14,2495.1) 4438.14,2508.37 cw(c4438.14,2521.65) v1@4428.75,2512.26 ; v1@4431.57,2501.66 cw(c4447.79,2485.44) 4447.79,2508.37 cw(c4447.79,2531.31) v1@4431.57,2515.09 ; 4444.97,2508.37 cw(c4444.97,2481.95) NT42.1@4468.23,2494.5 ; 4451.68,2508.37 cw(c4451.68,2485.57) NT42.1@4471.75,2496.4 ; NT42.1@4458.38,2508.37 cw(c4458.38,2489.19) NT42.1@4475.27,2498.3
UIO_PWR.AIN: JP1.1 JP1.4 UH1.1 | length 680
  Bottom Layer w20: JP1.1@675.1,4713.08 JP1.4@775.1,4813.08 823.52,4813.08 923.37,4713.23 UH1.1@976.12,4713.23 ; JP1.1@675.1,4732.6 ccw(c675.1,4779.75) 708.43,4746.41 ccw(c741.77,4713.08) JP1.1@694.62,4713.08 ; JP1.4@755.57,4813.08 cw(c708.43,4813.08) 741.76,4779.74 cw(c775.1,4746.41) JP1.4@775.1,4793.55 ; JP1.4@788.91,4799.27 cw(c822.24,4765.93) 822.24,4813.08 cw(c822.24,4860.22) JP1.4@788.91,4826.89 ; UH1.1@962.31,4699.43 ccw(c928.98,4666.09) 928.98,4713.23 ccw(c928.98,4760.38) UH1.1@962.31,4727.04
UIO_PWR.BIN: JP2.1 JP2.4 UH2.1 | length 668.7
  Top Layer w20: JP2.1@2072.74,4713.08 JP2.4@2172.74,4813.08 2215.19,4813.08 ; JP2.1@2072.74,4732.6 ccw(c2072.74,4779.75) 2106.07,4746.41 ccw(c2139.41,4713.08) JP2.1@2092.26,4713.08 ; JP2.4@2153.21,4813.08 cw(c2106.06,4813.08) 2139.4,4779.74 cw(c2172.74,4746.41) JP2.4@2172.74,4793.55 ; JP2.4@2187.56,4800.37 cw(c2215.19,4776.69) 2215.19,4813.08 ; JP2.4@2187.56,4825.78 ccw(c2215.19,4849.46) 2215.19,4813.08 ; UH2.1@2359.95,4699.43 ccw(c2326.62,4666.09) 2326.62,4713.23 ccw(c2326.62,4760.38) UH2.1@2359.95,4727.04 ; UH2.1@2373.76,4713.23 2315.03,4713.23 2215.19,4813.08