# Altium PCB NB3000AL.PcbDoc (part 77 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Keep-outs
Keep-Out Layer:
  lines w15: -923.8,2295.89 -923.31,2291.51 -921.85,2287.35 -919.5,2283.62 -916.39,2280.5 -912.66,2278.15 -908.49,2276.7 -904.11,2276.2 -612.78,2276.2 -608.4,2275.71 -604.24,2274.25 -600.5,2271.91 -597.39,2268.79 -595.04,2265.06 -593.59,2260.9 -593.09,2256.52 -593.09,2199.42 -593.59,2195.04 -595.04,2190.88 -597.39,2187.15 -600.5,2184.03 -604.24,2181.68 -608.4,2180.23 -612.78,2179.74 -854.9,2179.74 -859.28,2179.24 -863.44,2177.79 -867.17,2175.44 -870.29,2172.32 -872.64,2168.59 -874.09,2164.43 -874.59,2160.05 -874.59,1441.32 -431.67,1441.32 -389.22,1439.23 -347.19,1433 -305.96,1422.67 -265.94,1408.35 -227.52,1390.18 -191.07,1368.33 -156.94,1343.01 -125.45,1314.46 -96.9,1282.97 -71.59,1248.83 -49.74,1212.37 -31.57,1173.95 -17.25,1133.93 -6.92,1092.7 -0.69,1050.65 1.4,1008.2 1.4,63.2 99.82,63.2 108.58,62.22 116.9,59.3 124.37,54.61 130.6,48.38 135.29,40.91 138.21,32.59 139.19,23.83 139.19,-15.55 7540.77,-15.55 7540.77,23.83 7541.76,32.59 7544.67,40.91 7549.36,48.38 7555.59,54.61 7563.06,59.31 7571.38,62.22 7580.14,63.2 7678.56,63.2 7678.56,1008.2 7680.65,1050.65 7686.89,1092.7 7697.21,1133.93 7711.53,1173.95 7729.7,1212.37 7751.55,1248.83 7776.87,1282.97 7805.41,1314.46 7836.9,1343.01 7871.03,1368.33 7907.49,1390.18 7945.91,1408.35 7985.92,1422.67 8027.15,1433 8069.19,1439.23 8111.63,1441.32 8554.55,1441.32 8554.55,2160.05 8554.05,2164.43 8552.6,2168.59 8550.25,2172.32 8547.13,2175.44 8543.4,2177.79 8539.24,2179.24 8534.86,2179.74 8292.74,2179.74 8288.36,2180.23 8284.2,2181.68 8280.47,2184.03 8277.35,2187.15 8275,2190.88 8273.55,2195.04 8273.05,2199.42 8273.05,2256.52 8273.55,2260.9 8275,2265.06 8277.35,2268.79 8280.47,2271.91 8284.2,2274.25 8288.36,2275.71 8292.74,2276.2 8584.08,2276.2 8588.46,2276.7 8592.62,2278.15 8596.35,2280.5 8599.46,2283.62 8601.81,2287.35 8603.27,2291.51 8603.76,2295.89 8603.76,3756.1 8603.27,3760.48 8601.81,3764.64 8599.46,3768.38 8596.35,3771.5 8592.62,3773.84 8588.46,3775.3 8584.08,3775.79 8296.67,3775.79 8288.9,3776.61 8281.46,3779.03 8274.69,3782.93 8268.88,3788.17 8264.28,3794.49 8261.1,3801.64 8259.48,3809.29 8259.48,3817.11 8261.1,3824.76 8264.28,3831.9 8268.88,3838.23 8274.69,3843.46 8281.46,3847.37 8288.9,3849.79 8296.67,3850.6 8584.08,3850.6 8588.46,3851.1 8592.62,3852.55 8596.35,3854.9 8599.46,3858.02 8601.81,3861.75 8603.27,3865.91 8603.76,3870.29 8603.76,4268.57 8603.27,4272.95 8601.81,4277.11 8599.46,4280.84 8596.35,4283.96 8592.62,4286.3 8588.46,4287.76 8584.08,4288.25 8292.74,4288.25 8288.36,4288.75 8284.2,4290.2 8280.47,4292.55 8277.35,4295.67 8275,4299.4 8273.55,4303.56 8273.05,4307.94 8273.05,4365.03 8273.55,4369.41 8275,4373.58 8277.35,4377.31 8280.47,4380.43 8284.2,4382.77 8288.36,4384.23 8292.74,4384.72 8584.08,4384.72 8588.46,4385.21 8592.62,4386.67 8596.35,4389.02 8599.46,4392.13 8601.81,4395.87 8603.27,4400.03 8603.76,4404.41 8603.76,5803 8603.27,5807.38 8601.81,5811.54 8599.46,5815.28 8596.35,5818.39 8592.62,5820.74 8588.46,5822.19 8584.08,5822.69 8292.74,5822.69 8288.36,5823.18 8284.2,5824.64 8280.47,5826.98 8277.35,5830.1 8275,5833.83 8273.55,5837.99 8273.05,5842.37 8273.05,5899.47 8273.55,5903.85 8275,5908.01 8277.35,5911.74 8280.47,5914.86 8284.2,5917.2 8288.36,5918.66 8292.74,5919.16 8534.86,5919.16 8539.24,5919.65 8543.4,5921.1 8547.13,5923.45 8550.25,5926.57 8552.6,5930.3 8554.05,5934.46 8554.55,5938.84 8554.55,6185.98 8110.73,6185.98 8068.37,6188.06 8026.42,6194.28 7985.28,6204.59 7945.35,6218.88 7907.01,6237.01 7870.63,6258.82 7836.57,6284.09 7805.14,6312.57 7776.66,6344 7751.4,6378.07 7729.59,6414.45 7711.46,6452.79 7697.17,6492.73 7686.87,6533.88 7680.65,6575.83 7678.56,6618.2 7678.56,6835.48 7580.14,6835.48 7571.38,6836.46 7563.05,6839.37 7555.59,6844.07 7549.36,6850.3 7544.67,6857.77 7541.76,6866.09 7540.77,6874.85 7540.77,6914.22 139.19,6914.22 139.19,6874.85 138.21,6866.09 135.29,6857.76 130.6,6850.3 124.37,6844.06 116.9,6839.37 108.58,6836.46 99.82,6835.47 1.4,6835.47 1.4,6618.2 -0.68,6575.83 -6.91,6533.87 -17.21,6492.73 -31.5,6452.79 -49.63,6414.45 -71.43,6378.07 -96.7,6344 -125.18,6312.57 -156.61,6284.09 -190.67,6258.82 -227.05,6237.01 -265.39,6218.88 -305.32,6204.59 -346.46,6194.28 -388.41,6188.06 -430.77,6185.98 -874.59,6185.98 -874.59,5938.84 -874.09,5934.46 -872.64,5930.3 -870.29,5926.57 -867.17,5923.45 -863.44,5921.1 -859.28,5919.65 -854.9,5919.15 -612.78,5919.15 -608.4,5918.66 -604.24,5917.2 -600.5,5914.86 -597.39,5911.74 -595.04,5908.01 -593.59,5903.85 -593.09,5899.47 -593.09,5842.37 -593.59,5837.99 -595.04,5833.83 -597.39,5830.1 -600.5,5826.98 -604.24,5824.64 -608.4,5823.18 -612.78,5822.69 -904.11,5822.69 -908.49,5822.19 -912.66,5820.74 -916.39,5818.39 -919.5,5815.27 -921.85,5811.54 -923.31,5807.38 -923.8,5803 -923.8,4404.41 -923.31,4400.03 -921.85,4395.87 -919.5,4392.13 -916.39,4389.02 -912.66,4386.67 -908.49,4385.21 -904.11,4384.72 -612.78,4384.72 -608.4,4384.23 -604.24,4382.77 -600.5,4380.43 -597.39,4377.31 -595.04,4373.58 -593.59,4369.41 -593.09,4365.03 -593.09,4307.94 -593.59,4303.56 -595.04,4299.4 -597.39,4295.67 -600.5,4292.55 -604.24,4290.2 -608.4,4288.75 -612.78,4288.25 -904.11,4288.25 -908.49,4287.76 -912.66,4286.3 -916.39,4283.96 -919.5,4280.84 -921.85,4277.11 -923.31,4272.95 -923.8,4268.56 -923.8,3870.29 -923.31,3865.91 -921.85,3861.75 -919.5,3858.01 -916.39,3854.9 -912.66,3852.55 -908.49,3851.1 -904.11,3850.6 -616.71,3850.6 -608.94,3849.79 -601.5,3847.37 -594.73,3843.46 -588.92,3838.23 -584.32,3831.9 -581.14,3824.76 -579.52,3817.11 -579.52,3809.29 -581.14,3801.64 -584.32,3794.49 -588.92,3788.17 -594.73,3782.93 -601.5,3779.02 -608.94,3776.61 -616.71,3775.79 -904.11,3775.79 -908.49,3775.3 -912.66,3773.84 -916.39,3771.49 -919.5,3768.38 -921.85,3764.64 -923.31,3760.48 -923.8,3756.1 -923.8,2295.89 ; -530.1,1864.15 -530.1,2218.52 -529.11,2227.28 -526.2,2235.6 -521.51,2243.07 -515.27,2249.3 -507.81,2253.99 -499.49,2256.91 -490.73,2257.89 -392.3,2257.89 -383.54,2256.91 -375.22,2253.99 -367.76,2249.3 -361.52,2243.07 -356.83,2235.6 -353.92,2227.28 -352.93,2218.52 -352.93,1864.15 -353.92,1855.38 -356.83,1847.06 -361.52,1839.6 -367.76,1833.36 -375.22,1828.67 -383.54,1825.76 -392.3,1824.77 -490.73,1824.77 -499.49,1825.76 -507.81,1828.67 -515.27,1833.36 -521.51,1839.6 -526.2,1847.06 -529.11,1855.38 -530.1,1864.15 ; -530.1,5407.88 -529.11,5399.11 -526.2,5390.79 -521.51,5383.32 -515.27,5377.09 -507.81,5372.4 -499.49,5369.49 -490.73,5368.5 -392.3,5368.5 -383.54,5369.49 -375.22,5372.4 -367.76,5377.09 -361.52,5383.32 -356.83,5390.79 -353.92,5399.11 -352.93,5407.88 -352.93,5762.25 -353.92,5771.01 -356.83,5779.33 -361.52,5786.8 -367.76,5793.03 -375.22,5797.72 -383.54,5800.64 -392.3,5801.62 -490.73,5801.62 -499.49,5800.64 -507.81,5797.72 -515.27,5793.03 -521.51,5786.8 -526.2,5779.33 -529.11,5771.01 -530.1,5762.25 -530.1,5407.88 ; 3623.45,3616.32 3624.43,3607.56 3627.34,3599.24 3632.03,3591.77 3638.27,3585.54 3645.73,3580.85 3654.05,3577.94 3662.81,3576.95 4017.15,3576.95 4025.91,3577.94 4034.23,3580.85 4041.69,3585.54 4047.93,3591.77 4052.62,3599.24 4055.53,3607.56 4056.52,3616.32 4056.52,3714.76 4055.53,3723.52 4052.62,3731.84 4047.93,3739.31 4041.69,3745.54 4034.23,3750.24 4025.91,3753.15 4017.15,3754.13 3662.81,3754.13 3654.05,3753.15 3645.73,3750.24 3638.27,3745.54 3632.03,3739.31 3627.34,3731.84 3624.43,3723.52 3623.45,3714.76 3623.45,3616.32 ; 4505.53,3715.21 4506.03,3710.83 4507.48,3706.67 4509.83,3702.94 4512.95,3699.82 4516.68,3697.47 4520.84,3696.02 4525.22,3695.52 4631.52,3695.52 4635.9,3696.02 4640.06,3697.47 4643.79,3699.82 4646.91,3702.94 4649.25,3706.67 4650.71,3710.83 4651.21,3715.21 4651.21,3912.08 4650.71,3916.47 4649.25,3920.63 4646.91,3924.36 4643.79,3927.48 4640.06,3929.82 4635.9,3931.28 4631.52,3931.77 4525.22,3931.77 4520.84,3931.28 4516.68,3929.82 4512.95,3927.48 4509.83,3924.36 4507.48,3920.63 4506.03,3916.47 4505.53,3912.08 4505.53,3715.21 ; 5224.07,2182.81 5224.57,2178.43 5226.02,2174.27 5228.37,2170.54 5231.48,2167.42 5235.21,2165.08 5239.37,2163.62 5243.76,2163.13 5350.06,2163.13 5354.43,2163.62 5358.6,2165.08 5362.33,2167.42 5365.45,2170.54 5367.79,2174.27 5369.25,2178.43 5369.74,2182.81 5369.74,2379.69 5369.25,2384.07 5367.79,2388.23 5365.45,2391.96 5362.33,2395.08 5358.6,2397.42 5354.43,2398.88 5350.06,2399.37 5243.76,2399.37 5239.37,2398.88 5235.21,2397.42 5231.48,2395.08 5228.37,2391.96 5226.02,2388.23 5224.57,2384.07 5224.07,2379.69 5224.07,2182.81 ; 7581.87,2182.81 7582.37,2178.43 7583.83,2174.27 7586.17,2170.54 7589.29,2167.42 7593.02,2165.08 7597.18,2163.62 7601.56,2163.13 7707.86,2163.13 7712.24,2163.62 7716.4,2165.08 7720.13,2167.42 7723.25,2170.54 7725.6,2174.27 7727.05,2178.43 7727.54,2182.81 7727.54,2379.69 7727.05,2384.07 7725.6,2388.23 7723.25,2391.96 7720.13,2395.08 7716.4,2397.42 7712.24,2398.88 7707.86,2399.37 7601.56,2399.37 7597.18,2398.88 7593.02,2397.42 7589.29,2395.08 7586.17,2391.96 7583.83,2388.23 7582.37,2384.07 7581.87,2379.69 7581.87,2182.81 ; 7603.95,3715.21 7604.45,3710.83 7605.9,3706.67 7608.25,3702.94 7611.37,3699.82 7615.1,3697.47 7619.26,3696.02 7623.64,3695.52 7729.94,3695.52 7734.32,3696.02 7738.48,3697.47 7742.21,3699.82 7745.33,3702.94 7747.67,3706.67 7749.13,3710.83 7749.62,3715.21 7749.62,3912.08 7749.13,3916.47 7747.67,3920.63 7745.33,3924.36 7742.21,3927.48 7738.48,3929.82 7734.32,3931.28 7729.94,3931.77 7623.64,3931.77 7619.26,3931.28 7615.1,3929.82 7611.37,3927.48 7608.25,3924.36 7605.9,3920.63 7604.45,3916.47 7603.95,3912.08 7603.95,3715.21 ; 8032.89,1864.15 8033.88,1855.39 8036.79,1847.06 8041.48,1839.6 8047.72,1833.36 8055.18,1828.67 8063.5,1825.76 8072.26,1824.77 8170.69,1824.77 8179.45,1825.76 8187.77,1828.67 8195.24,1833.36 8201.47,1839.6 8206.16,1847.06 8209.07,1855.39 8210.06,1864.15 8210.06,2218.52 8209.07,2227.28 8206.16,2235.6 8201.47,2243.07 8195.24,2249.3 8187.77,2254 8179.45,2256.91 8170.69,2257.89 8072.26,2257.89 8063.5,2256.91 8055.18,2254 8047.72,2249.3 8041.48,2243.07 8036.79,2235.6 8033.88,2227.28 8032.89,2218.52 8032.89,1864.15 ; 8032.89,5407.88 8033.88,5399.11 8036.79,5390.79 8041.48,5383.32 8047.72,5377.09 8055.18,5372.4 8063.5,5369.49 8072.26,5368.5 8170.69,5368.5 8179.45,5369.49 8187.77,5372.4 8195.24,5377.09 8201.47,5383.32 8206.16,5390.79 8209.07,5399.11 8210.06,5407.88 8210.06,5762.25 8209.07,5771.01 8206.16,5779.33 8201.47,5786.8 8195.24,5793.03 8187.77,5797.72 8179.45,5800.64 8170.69,5801.62 8072.26,5801.62 8063.5,5800.64 8055.18,5797.72 8047.72,5793.03 8041.48,5786.8 8036.79,5779.33 8033.88,5771.01 8032.89,5762.25 8032.89,5407.88

## Other copper
Top Layer:
  rectangle net GND: 3455,5210 3535,5285
  region net 2V5: 4114.02,1421.93 4114.02,1456.93 4039.02,1456.93 4039.02,1421.93
  region net 2V5: 4114.02,1525.79 4114.02,1560.79 4039.02,1560.79 4039.02,1525.79
  region net 2V5: 4167.01,1686.77 4167.01,1721.77 4092.01,1721.77 4092.01,1686.77
  region net 2V5: 4167.01,1808.82 4167.01,1843.82 4092.01,1843.82 4092.01,1808.82
  rectangle net GND: 3455,5346 3535,5435
  rectangle net GND: 3250,5355 3330,5430
  rectangle net GND: 3250,5210 3330,5285
  rectangle net GND: 115,4495 185,4525
  rectangle net 5V0: 5,1450 40,1525
  rectangle net 5V0: 108.86,1450 143.86,1525
  rectangle net GND: 108.86,1575.98 143.86,1650.98
  rectangle net 5V0: 258.86,1475 293.86,1585
  rectangle net 3V3: 428.86,1475 463.86,1670
  rectangle net 3V3: 454.85,1590 485,1670
  rectangle net GND: 5,1995 145,2070
  rectangle net 3V3: 5,1869.02 145,1944.02
  rectangle net 2V5: 1090,1868.03 1230,1943.03
  rectangle net GND: 1090,1994.02 1230,2069.02
  rectangle net 1V8: 2175,1868.03 2315,1943.03
  rectangle net GND: 2175,1994.02 2315,2069.02
  rectangle net 2V5: 1539.85,1590 1570,1670
  rectangle net 2V5: 1513.86,1475 1548.86,1670
  rectangle net 5V0: 1343.86,1475 1378.86,1585
  rectangle net 1V8: 2624.85,1590 2655,1670
  rectangle net 1V8: 2598.86,1475 2633.86,1670
  rectangle net 3V3: 2428.86,1475 2463.86,1585
  rectangle net GND: 2175,1574.02 2315,1649.02
  rectangle net 3V3: 2175,1448.03 2315,1523.03
  rectangle net 5V0: 648.86,1447.5 683.86,1522.5
  rectangle net 5V0: 704.68,1447.5 739.68,1522.5
  rectangle net GND: 763.03,1447.5 798.03,1522.5
  rectangle net GND: 818.86,1447.5 853.86,1522.5
  rectangle net GND: 1090,1575.98 1125,1650.98
  rectangle net 5V0: 1090,1450 1125,1525
  rectangle net GND: 1193.86,1575.98 1228.86,1650.98
  rectangle net 5V0: 1193.86,1450 1228.86,1525
  region net GND: 807.01,2060.79 807.01,2095.79 732.01,2095.79 732.01,2060.79
  region net GND: 807.01,1938.74 807.01,1973.74 732.01,1973.74 732.01,1938.74
  region net 3V3: 807.01,1808.82 807.01,1843.82 732.01,1843.82 732.01,1808.82
  region net 3V3: 807.01,1686.77 807.01,1721.77 732.01,1721.77 732.01,1686.77
  region net GND: 1892.01,2060.79 1892.01,2095.79 1817.01,2095.79 1817.01,2060.79
  region net GND: 1892.01,1938.74 1892.01,1973.74 1817.01,1973.74 1817.01,1938.74
  region net 2V5: 1862.01,1808.82 1862.01,1843.82 1787.01,1843.82 1787.01,1808.82
  region net 2V5: 1862.01,1686.77 1862.01,1721.77 1787.01,1721.77 1787.01,1686.77
  rectangle net 5V0: 1733.86,1447.5 1768.86,1522.5
  rectangle net 5V0: 1789.68,1447.5 1824.68,1522.5
  rectangle net GND: 1848.03,1447.5 1883.03,1522.5
  rectangle net GND: 1903.86,1447.5 1938.86,1522.5
  region net GND: 2977.01,2060.79 2977.01,2095.79 2902.01,2095.79 2902.01,2060.79
  region net GND: 3017.44,2052.64 2982.44,2052.64 2982.44,1977.64 3017.44,1977.64
  region net 1V8: 2895.39,1800.67 2860.39,1800.67 2860.39,1725.67 2895.39,1725.67
  region net 1V8: 2962.01,1686.77 2962.01,1721.77 2887.01,1721.77 2887.01,1686.77
  rectangle net 3V3: 2818.86,1447.5 2853.86,1522.5
  rectangle net 3V3: 2874.68,1447.5 2909.68,1522.5
  rectangle net GND: 2933.03,1447.5 2968.03,1522.5
  rectangle net GND: 2988.86,1447.5 3023.86,1522.5
  region net GND: 3446.46,2060.79 3446.46,2095.79 3371.46,2095.79 3371.46,2060.79
  region net GND: 3446.46,1938.74 3446.46,1973.74 3371.46,1973.74 3371.46,1938.74
  region net 1V2: 3364.84,1810.67 3329.84,1810.67 3329.84,1735.67 3364.84,1735.67
  region net 1V2: 3486.89,1810.67 3451.89,1810.67 3451.89,1735.67 3486.89,1735.67
  region net GND: 3369.02,1525.79 3369.02,1560.79 3294.02,1560.79 3294.02,1525.79
  region net 1V2: 3495,1525.79 3495,1560.79 3420,1560.79 3420,1525.79
  region net GND: 3369.02,1421.93 3369.02,1456.93 3294.02,1456.93 3294.02,1421.93
  region net 1V2: 3495,1421.93 3495,1456.93 3420,1456.93 3420,1421.93
  region net 1V2: 3680,1421.86 3680,1456.86 3540,1456.86 3540,1421.86
  rectangle net GND: 3753.86,1391.01 3788.86,1466.01
  region net GND: 4240,1421.93 4240,1456.93 4165,1456.93 4165,1421.93
  region net GND: 4240,1523.86 4240,1558.86 4165,1558.86 4165,1523.86
  region net GND: 4167.01,1938.74 4167.01,1973.74 4092.01,1973.74 4092.01,1938.74
  region net GND: 4167.01,2060.79 4167.01,2095.79 4092.01,2095.79 4092.01,2060.79
  region net 3V3: 386,1670 331,1670 331,1590 386,1590
  region net 3V3: 387.14,1670 363,1670 363,1475 387.14,1475
  region net 5V0: 357,1585 331,1585 331,1475 357,1475
  region net 5V0: 1442,1585 1416,1585 1416,1475 1442,1475
  region net 2V5: 1472.14,1670 1448,1670 1448,1475 1472.14,1475
  region net 2V5: 1471,1670 1416,1670 1416,1590 1471,1590
  region net 3V3: 2527,1585 2501,1585 2501,1475 2527,1475
  region net 1V8: 2557.14,1670 2533,1670 2533,1475 2557.14,1475
  region net 1V8: 2556,1670 2500.99,1670 2500.99,1590 2556,1590
  region net GND: 110.08,1648.78 110.08,1683.78 35.08,1683.78 35.08,1648.78
  region net 5V0: 757,3132 757,3155 670,3155 670,3132
  region net 3V3: 820,3131.84 820,3154.84 764.65,3154.84 764.65,3131.84
  region net 2V5: 882.84,3132 882.84,3155 827.48,3155 827.48,3132
  region net 1V8: 945.83,3132 945.83,3155 890.47,3155 890.47,3132
  region net PWMPWR: 3346,5718.96 3346,5741.96 3232.65,5741.96 3232.65,5718.96
  region net 5V0: 4707,5718 4707,5741.96 4622.65,5741.96 4622.65,5718
  rectangle net 5V0: -687.6,2292.5 -648.1,2345.8
  rectangle net +B: 7750,5265 7880,5315
  rectangle net GND: 7749.51,5134.9 7879.51,5184.9
  region net 1V2: 1008.98,3131.84 1008.98,3154.84 953.62,3154.84 953.62,3131.84
  rectangle net AUGND: 1095,560 1125,630
  pour cut-out: 6714.72,2160.28 7305.28,2160.28 7305.28,1569.72 6714.72,1569.72
  pour cut-out: 4860,4720 5920,4720 5920,3660 4860,3660
  pour cut-out: 7691.59,4643.83 8007.48,4642.48 8007.48,4327.52 7692.52,4327.52
MidLayer1:
  rectangle net SHIELD: 5270,365 5470,775
  rectangle net SHIELD: 5590,364.61 5790,774.61
  rectangle net SHIELD: 3540,-15.55 3680,245
  rectangle net SHIELD: 2950,-15.55 3090,245
  rectangle net SHIELD: 3830,-15.55 3935,300
  rectangle net SHIELD: 3235,-15.55 3410,300
MidLayer2:
  rectangle net 2V5: 5379,3616 5401,3650
  rectangle net SHIELD: 7470,6625 7575,6914.22
  rectangle net SHIELD: 7270,6625 7375,6914.22
  rectangle net SHIELD: 6160,6460 6350,6920
  rectangle net SHIELD: 5175,6460 5365,6920
Bottom Layer:
  region net GND: 3863,6337.39 3863,6282.39 3899,6282.39 3899,6337.39
  rectangle net GND: 1165,5780 1220,5805
  rectangle net SHIELD: 7075,-15.55 7160,185
  region net SHIELD: 6502.2,6920 6160,6920 6160,6445 6502.2,6445
  rectangle net SHIELD: 7132,-20 7255,485
  rectangle net SHIELD: 7480,55 7678.56,408
  rectangle net 2V5: 7515,1695 7585,1725
  rectangle net SHIELD: 6055,6710 7060,6920
  region net SHIELD: 6950,6920 6745,6920 6745,6465 6950,6465
  rectangle net SHIELD: 7170,-20 7597.8,200
  rectangle net SHIELD: 7522.8,-20 7597.8,370
  rectangle net SHIELD: 7135,-20 7210,370
  region net 2V5: 4167.01,1691.03 4167.01,1834.96 4092.01,1834.96 4092.01,1691.03
  rectangle net 2V5: 3835,1465 4050,1551.93
  region net 2V5: 4114.02,1426.93 4114.02,1834.96 4039.02,1834.96 4039.02,1426.93
  rectangle net 5V0: 4520,5710 4715,5750
  rectangle net 5V0: 4520,5675 4610,5750
  region net GND: 7879.8,5185 7749.8,5185 7749.8,5125 7879.8,5125
  rectangle net +B: 7750,5265 7880,5325
  region net GND: 3015,1520 2939.17,1520 2939.17,1450 3015,1450
  region net 3V3: 2900.83,1520 2825,1520 2825,1450 2900.83,1450
  region net GND: 1930,1520 1854.17,1520 1854.17,1450 1930,1450
  region net 5V0: 730.83,1520 655,1520 655,1450 730.83,1450
  region net GND: 845,1520 769.17,1520 769.17,1450 845,1450
  region net 5V0: 1815.83,1520 1740,1520 1740,1450 1815.83,1450
  rectangle net 1V2: 3684,1423 3722,1489
  region net 1V2: 3540,1453 3540,1423 3722,1423 3722,1453
  region net GND: 3785,1463 3755,1463 3755,1394 3785,1394
  region net GND: 4167.01,1943 4167.01,2086.93 4092.01,2086.93 4092.01,1943
  region net GND: 3446.46,1943 3446.46,2086.93 3371.46,2086.93 3371.46,1943
  region net 1V2: 3482.63,1810.67 3338.7,1810.67 3338.7,1735.67 3482.63,1735.67
  region net GND: 2977.01,1975 2977.01,2086.93 2902.01,2086.93 2902.01,1975
  region net 1V8: 2977.01,1691.03 2977.01,1834.96 2902.01,1834.96 2902.01,1691.03
  region net GND: 1892.01,1943 1892.01,2086.93 1817.01,2086.93 1817.01,1943
  region net 2V5: 1862.01,1691.03 1862.01,1834.96 1787.01,1834.96 1787.01,1691.03
  region net 3V3: 807.01,1691.03 807.01,1834.96 732.01,1834.96 732.01,1691.03
  region net GND: 807.01,1943 807.01,2086.93 732.01,2086.93 732.01,1943
  rectangle net GND: 35,1575.98 135,1650.98
  region net GND: 2306.14,2070 2181.14,2070 2181.14,1995 2306.14,1995
  region net GND: 1221.14,2070 1096.14,2070 1096.14,1995 1221.14,1995
  region net GND: 4240,1426.93 4240,1551.93 4165,1551.93 4165,1426.93
  region net GND: 3369.02,1426.93 3369.02,1551.93 3294.02,1551.93 3294.02,1426.93
  region net 1V2: 3495,1426.93 3495,1551.93 3420,1551.93 3420,1426.93
  rectangle net 3V3: 2180,1450 2305,1525
  rectangle net GND: 2180,1575.98 2305,1650.98
  rectangle net 5V0: 10,1450 135,1525
  rectangle net 5V0: 1095,1450 1220,1525
  rectangle net GND: 1095,1575.98 1220,1650.98
  rectangle net 3V3: 10,1870 135,1945
  rectangle net GND: 10,1995.98 135,2070.98
  rectangle net 2V5: 1095,1870 1220,1945
  rectangle net 1V8: 2180,1870 2305,1945
  rectangle net SHIELD: 230,-15 305,25
  rectangle net 1V8: 2534,1438 2626,1585
  rectangle net 3V3: 2434,1438 2526,1585
  rectangle net 2V5: 1449,1438 1541,1585
  rectangle net 5V0: 1349,1438 1441,1585
  rectangle net 3V3: 364,1438 456,1585
  rectangle net 5V0: 264,1438 356,1585
  rectangle net GND: -225,5665 -170,5815
  rectangle net AUGND: -497,4158 -484.5,4170
  region net GND: 3017.44,2052.64 2982.44,2052.64 2982.44,1977.64 3017.44,1977.64
  region net 1V8: 2895.39,1800.67 2860.39,1800.67 2860.39,1725.67 2895.39,1725.67
  region net GND: 110.08,1574.92 110.08,1674.92 35.08,1674.92 35.08,1574.92
  rectangle net SHIELD: 2900,6760 4865,6920
  rectangle net SHIELD: -75,1145 505,1215
  rectangle net AUGND: 1095,560 1125,630
  rectangle net AUGND: 70,3445 85,3450.37
  rectangle net AUGND: 70,3466.09 85,3471.47
  rectangle net SHIELD: 400,-15 650,395
  rectangle net SHIELD: 236.66,240.63 649.66,407.36
  rectangle net SHIELD: 236.66,608.63 649.66,663.63
  region net SHIELD: 288.66,663.63 236.66,663.63 236.66,240.63 288.66,240.63
  region net SHIELD: 635.34,201.08 635.34,249.08 467.34,249.08 467.34,201.08
  rectangle net SHIELD: 591.34,240.63 649.66,663.63
  rectangle net 3V3: 5467,3787 5484.25,3805
P2 - 3V3+5V0 (plane layer: these items are gaps in the copper):
  lines w10: 0.1,500.1 2432.5,500.1 cw(c2432.5,467.5) 2465.1,467.5 ; 849.4,1356.3 986.3,1356.3 ccw(c986.3,1435.04) 1065.04,1435.04 1065.04,1510 cw(c1143.78,1510) 1143.78,1588.74 1210,1588.74 ccw(c1210,1648.74) 1252.43,1606.31 1293.55,1647.44 cw(c1335.98,1605.01) 1335.98,1665.01 1365,1665 cw(c1365,1586.26) 1443.74,1586.26 1443.74,1435.04 ccw(c1522.48,1435.04) 1522.48,1356.3 1618.7,1356.3 ccw(c1618.7,1435.04) 1697.44,1435.04 1697.44,1482.44 cw(c1776.18,1482.44) 1776.18,1561.18 cw(c1776.18,1482.44) 1854.92,1482.44 1854.92,1435.04 ccw(c1933.66,1435.04) 1933.66,1356.3 3703.7,1356.3 cw(c3703.7,1277.56) 3782.44,1277.56 3782.44,482.56 ccw(c3861.18,482.56) 3861.18,403.82 4950,403.82 ccw(c4950,482.56) 5028.74,482.56 5028.74,908.74 cw(c5107.48,908.74) 5107.48,987.48 5197.52,987.48 cw(c5197.52,908.74) 5276.26,908.74 ccw(c5331.94,908.74) 5331.94,853.06 5366.94,853.06 ccw(c5366.94,908.74) 5422.63,908.74 cw(c5478.31,908.74) 5478.31,964.43 cw(c5478.31,908.74) 5534,908.74 ccw(c5589.68,908.74) 5589.68,853.06 5616.94,853.06 ccw(c5616.94,908.74) 5672.63,908.74 cw(c5728.31,908.74) 5728.31,964.43 cw(c5728.31,908.74) 5784,908.74 ccw(c5839.68,908.74) 5839.68,853.06 6551.94,853.06 cw(c6551.94,774.32) 6630.68,774.32 6630.68,-14.86 ; 849.96,1356.3 cw(c849.96,1435.04) 771.22,1435.04 771.22,1490 ccw(c692.48,1490) 692.48,1568.74 ccw(c692.48,1490) 613.74,1490 613.74,1435.04 cw(c535,1435.04) 535,1356.3 438.7,1356.3 cw(c438.7,1435.04) 359.96,1435.04 359.96,1625.04 ccw(c281.22,1625.04) 281.22,1703.78 56.22,1703.78 cw(c56.22,1782.52) -22.52,1782.52 -22.52,2317.52 ccw(c-101.26,2317.52) -101.26,2396.26 -430,2396.26 cw(c-430,2475) -508.74,2475 -508.74,2863.78 cw(c-430,2863.78) -430,2942.52 302.52,2942.52 cw(c302.52,2863.78) 381.26,2863.78 381.26,2580 ccw(c460,2580) 460,2501.26 522.52,2501.26 ccw(c522.52,2580) 601.26,2580 601.26,2863.78 cw(c680,2863.78) 680,2942.52 ccw(c680,3021.26) 758.74,3021.26 758.74,3166.26 ccw(c680,3166.26) 680,3245 -430,3245 cw(c-430,3323.74) -508.74,3323.74 -508.74,3877.52 cw(c-430,3877.52) -430,3956.26 85.95,3956.26 ccw(c85.95,4035) 164.69,4035 164.69,4269.69 cw(c243.43,4269.69) 243.43,4348.43 651.61,4348.43 ccw(c651.61,4427.17) 730.35,4427.17 730.35,4832.17 cw(c809.09,4832.17) 809.09,4910.91 819.09,4910.91 cw(c819.09,4832.17) 897.83,4832.17 897.83,4427.17 ccw(c976.57,4427.17) 976.57,4348.43 3041.57,4348.43 cw(c3041.57,4269.69) 3120.31,4269.69 3120.31,3350.58 ccw(c3180.31,3350.58) 3137.89,3308.15 3505.46,2940.58 ccw(c3547.89,2983) 3547.89,2923 ; 1715.32,1762.71 1715.32,1843.7 ; 1715.32,1762.9 ccw(c1728.62,1762.9) 1728.62,1749.6 1757.31,1749.6 ccw(c1757.31,1776.37) 1776.24,1757.44 cw(c1785.3,1748.38) 1785.3,1761.19 2073,1761.19 cw(c2073,1679.58) 2130.71,1737.29 2148.64,1719.36 ccw(c2234,1804.71) 2234,1684 2370,1684 ccw(c2370,1804.71) 2455.36,1719.36 2471.17,1735.17 cw(c2534,1672.34) 2534,1761.19 5576,1761.19 5599.77,1761.19 ccw(c5599.77,1832.23) 5650,1782 cw(c5669.31,1762.69) 5669.31,1790 5752,1790 cw(c5752,1746) 5796,1746 5796,1506.01 ccw(c5916.71,1506.01) 5831.36,1420.65 5839.08,1412.93 ; 1715.31,1842.45 cw(c1734.68,1842.45) 1734.68,1861.82 1760.2,1861.82 ; 1759.7,1861.82 cw(c1759.7,1849.06) 1768.72,1858.08 1784.37,1842.43 ccw(c1790.4,1848.47) 1790.4,1839.93 5444,1839.93 ; 1911.22,5183.63 1911.22,5621.22 cw(c1989.96,5621.22) 1989.96,5699.96 2695.08,5699.96 ccw(c2695.08,5778.7) 2773.82,5778.7 2773.82,5848.7 cw(c2852.56,5848.7) 2852.56,5927.44 cw(c2852.56,5848.7) 2931.3,5848.7 ccw(c3010.04,5848.7) 3010.04,5769.96 3565.04,5769.96 ccw(c3565.04,5848.7) 3643.78,5848.7 3643.78,5974.96 3643.78,6166.26 cw(c3722.52,6166.26) 3722.52,6245 cw(c3722.52,6166.26) 3801.26,6166.26 3801.26,5848.7 ccw(c3880,5848.7) 3880,5769.96 4152.56,5769.96 ccw(c4152.56,5848.7) 4231.3,5848.7 4231.3,6040 cw(c4310.04,6040) 4310.04,6118.74 4356.3,6118.74 cw(c4356.3,6040) 4435.04,6040 4435.04,5490 ccw(c4513.78,5490) 4513.78,5411.26 4560.04,5411.26 ccw(c4560.04,5490) 4638.78,5490 4638.78,5620 cw(c4717.52,5620) 4717.52,5698.74 cw(c4717.52,5620) 4796.26,5620 4796.26,5490 ccw(c4875,5490) 4875,5411.26 4921.26,5411.26 ccw(c4921.26,5490) 5000,5490 5000,5620 cw(c5078.74,5620) 5078.74,5698.74 5268.78,5698.74 cw(c5268.78,5620) 5347.52,5620 5347.52,5465 ccw(c5426.26,5465) 5426.26,5386.26 5541.22,5386.26 ccw(c5541.22,5465) 5619.96,5465 5619.96,5624.96 cw(c5698.7,5624.96) 5698.7,5703.7 6133.78,5703.7 cw(c6133.78,5624.96) 6212.52,5624.96 cw(c6133.78,5624.96) 6133.78,5546.22 6035,5546.22 ccw(c6035,5467.48) 5956.26,5467.48 ccw(c6035,5467.48) 6035,5388.74 6728.74,5388.74 ccw(c6728.74,5467.48) 6807.48,5467.48 6807.48,5752.52 ccw(c6728.74,5752.52) 6728.74,5831.26 6128.74,5831.26 cw(c6128.74,5910) 6050,5910 6050,6345 cw(c6152.5,6347.5) 6150,6450 6863.63,6450 cw(c6863.63,6394.32) 6919.32,6394.32 ; 1911.65,5183.21 ccw(c1971.65,5183.21) 1929.22,5140.78 2105.71,4964.29 cw(c2063.28,4921.87) 2123.28,4921.87 2123.28,4626.72 ccw(c2202.02,4626.72) 2202.02,4547.98 4307.02,4547.98 cw(c4307.02,4469.24) 4385.76,4469.24 4385.76,3279.24 ccw(c4464.5,3279.24) 4464.5,3200.5 5369.5,3195.88 ; 2465,-15 2465,465 ; 3547.91,2923.02 4223.78,2923.02 cw(c4223.78,2844.28) 4302.52,2844.28 4302.52,2690 ccw(c4381.26,2690) 4381.26,2611.26 4532.52,2611.26 ccw(c4532.52,2690) 4611.26,2690 4611.26,2844.28 cw(c4690,2844.28) 4690,2923.02 5028.7,2923.02 cw(c5028.7,2844.28) 5107.44,2844.28 5107.44,2077.56 ccw(c5186.18,2077.56) 5186.18,1998.82 5359.5,1998.82 ccw(c5359.5,2077.56) 5438.24,2077.56 cw(c5516.98,2077.56) 5516.98,2156.3 5656.22,2156.3 ccw(c5656.22,2235.04) 5734.96,2235.04 ccw(c5656.22,2235.04) 5656.22,2313.78 5516.98,2313.78 cw(c5516.98,2392.52) 5438.24,2392.52 5438.24,2402.52 ccw(c5359.5,2402.52) 5359.5,2481.26 cw(c5359.5,2560) 5280.76,2560 5280.76,2844.28 cw(c5359.5,2844.28) 5359.5,2923.02 ccw(c5359.5,3001.76) 5438.24,3001.76 5438.24,3121.76 ccw(c5359.5,3121.76) 5359.5,3200.5 ; 4969,4229.37 4920.63,4229.37 4920.63,4150.63 4969.23,4150.63 cw(c4988.68,4150.47) 5008.14,4150.47 5008.14,4111.26 ; 4969.23,4229.53 ccw(c4988.68,4229.53) 5008.14,4229.53 5008.14,4268.74 ; 5007.99,4111.26 ccw(c5027.67,4111.26) 5027.67,4091.57 ; 5007.99,4268.74 cw(c5027.67,4268.74) 5027.67,4288.43 ; 5027.67,4091.42 5043.67,4091.42 ; 5027.67,4288.58 5043.67,4288.58 ; 5043.67,4091.57 ccw(c5043.67,4111.26) 5063.35,4111.26 ; 5043.67,4288.43 cw(c5043.67,4268.74) 5063.35,4268.74 ; 5063.2,4111.26 5063.2,4150.47 cw(c5082.65,4150.47) 5082.35,4169.93 5094.95,4169.93 5094.95,4150.63 ccw(c5114.41,4150.63) 5133.87,4150.63 ; 5063.2,4268.74 5063.2,4229.53 ccw(c5082.65,4229.53) 5082.35,4210.07 ; 5082.51,4209.91 5153.78,4209.91 ccw(c5153.78,4229.37) 5153.78,4248.83 ; 5134.32,4150.63 ccw(c5153.78,4150.63) 5153.78,4131.17 ; 5153.78,4051.98 cw(c5153.78,4032.52) 5173.24,4032.52 5173.24,3993.2 ccw(c5193.2,3993.2) 5193.2,3973.24 5350.63,3973.24 cw(c5350.63,3953.78) 5350.63,3934.32 ; 5153.78,4052.43 cw(c5153.78,4071.89) 5153.78,4091.35 ; 5153.78,4091.8 ccw(c5153.78,4111.26) 5153.78,4130.72 ; 5153.78,4249.28 cw(c5153.78,4268.74) 5153.78,4288.2 ; 5153.78,4288.65 ccw(c5153.78,4308.11) 5173.24,4308.11 ccw(c5153.78,4308.11) 5153.78,4327.57 ; 5153.78,4328.02 cw(c5153.78,4347.48) 5153.78,4366.94 ; 5153.78,4367.39 ccw(c5153.78,4386.85) 5173.24,4386.85 ; 5173.69,4386.85 cw(c5193.15,4386.85) 5193.15,4406.31 ; 5193.15,4406.76 ccw(c5193.15,4426.22) 5212.61,4426.22 ; 5213.06,4426.22 cw(c5232.52,4426.22) 5251.98,4426.22 ; 5252.43,4426.22 ccw(c5271.89,4426.22) 5271.89,4406.76 5350.63,4406.76 ccw(c5350.63,4426.22) 5350.63,4445.68 ; 5291.42,3827.67 5291.42,3843.67 ; 5291.42,4536.33 5291.42,4552.33 ; 5291.57,3827.67 ccw(c5311.26,3827.67) 5311.26,3807.98 ; 5291.57,3843.67 cw(c5311.26,3843.67) 5311.26,3863.35 ; 5291.57,4536.33 ccw(c5311.26,4536.33) 5311.26,4516.65 ; 5291.57,4552.33 cw(c5311.26,4552.33) 5311.26,4572.01 5350.32,4572.01 ; 5311.26,3808.14 5350.47,3808.14 cw(c5350.47,3788.68) 5350.47,3769.23 ; 5311.26,3863.2 5350.47,3863.2 ccw(c5350.47,3882.65) 5369.93,3882.35 ; 5311.26,4516.8 5350.47,4516.8 cw(c5350.47,4497.35) 5369.84,4499.21 ; 5350.47,4571.86 ccw(c5350.47,4591.32) 5350.57,4610.77 ; 5350.63,3769.23 5350.63,3720.63 5429.37,3720.63 5429.37,3769.23 ; 5350.63,3933.87 cw(c5350.63,3914.41) 5370.09,3914.41 5370.09,3882.51 ; 5350.63,4446.13 ccw(c5350.63,4465.59) 5370.09,4465.59 5370.09,4498.97 ; 5350.63,4610.77 5350.63,4659.37 5429.37,4659.37 5429.37,4610.77 ; 5409.91,3882.51 5409.91,3914.41 cw(c5429.37,3914.41) 5429.37,3933.87 ; 5409.91,4465.59 ccw(c5429.37,4465.59) 5429.37,4446.13 ; 5410.07,3882.35 ccw(c5429.53,3882.65) 5429.53,3863.2 5468.74,3863.2 ; 5410.16,4465.84 5410.16,4499.21 cw(c5429.53,4497.35) 5429.53,4516.8 5468.74,4516.8 ; 5429.37,3934.32 ccw(c5429.37,3953.78) 5448.83,3953.78 ; 5429.37,4445.68 ccw(c5429.37,4426.22) 5429.37,4406.76 5508.11,4406.76 ccw(c5508.11,4426.22) 5527.57,4426.22 ; 5429.43,4610.77 ccw(c5429.53,4591.32) 5429.53,4571.86 ; 5429.53,3769.23 cw(c5429.53,3788.68) 5429.53,3808.14 5468.74,3808.14 ; 5429.68,4572.01 5468.74,4572.01 cw(c5468.74,4552.33) 5488.43,4552.33 ; 5442,1839.93 5550.39,1839.93 ccw(c5550.39,1901.61) 5594,1858 5616.44,1880.44 cw(c5654,1842.89) 5654,1896 5697.44,1896 ccw(c5697.44,1965.9) 5746.87,1916.47 ; 5449.28,3953.78 cw(c5468.74,3953.78) 5468.74,3973.24 5508.11,3973.24 cw(c5508.11,3953.78) 5527.57,3953.78 ; 5468.74,3807.98 ccw(c5468.74,3827.67) 5488.43,3827.67 ; 5468.74,3863.35 cw(c5468.74,3843.67) 5488.43,3843.67 ; 5468.74,4516.65 ccw(c5468.74,4536.33) 5488.43,4536.33 ; 5488.58,3827.67 5488.58,3843.67 ; 5488.58,4536.33 5488.58,4552.33 ; 5528.02,3953.78 ccw(c5547.48,3953.78) 5566.94,3953.78 ; 5528.02,4426.22 cw(c5547.48,4426.22) 5566.94,4426.22 ; 5567.39,3953.78 cw(c5586.85,3953.78) 5586.85,3973.24 ; 5567.39,4426.22 ccw(c5586.85,4426.22) 5586.85,4406.76 5625.77,4406.76 ; 5586.8,3973.24 ccw(c5586.8,3993.2) 5606.76,3993.2 5606.76,4032.52 cw(c5626.22,4032.52) 5626.22,4051.98 ; 5626.22,4052.43 ccw(c5626.22,4071.89) 5645.68,4071.89 5645.68,4150.18 ; 5626.22,4248.83 cw(c5626.22,4229.37) 5645.68,4229.37 ; 5626.22,4249.28 cw(c5626.22,4268.74) 5606.76,4268.74 cw(c5626.22,4268.74) 5626.22,4288.2 ; 5626.22,4288.65 ccw(c5626.22,4308.11) 5626.22,4327.57 ; 5626.22,4328.02 cw(c5626.22,4347.48) 5606.76,4347.48 cw(c5626.22,4347.48) 5626.22,4366.94 ; 5626.22,4367.39 ccw(c5626.22,4386.85) 5626.22,4406.31 ; 5646.13,4150.63 cw(c5665.59,4150.63) 5665.59,4170.09 ; 5646.13,4229.37 ccw(c5665.59,4229.37) 5685.05,4229.37 ; 5665.84,4169.84 5699.22,4169.84 cw(c5697.35,4150.47) 5716.8,4150.47 5716.8,4111.26 ; 5685.5,4229.37 cw(c5704.96,4229.37) 5704.96,4248.83 ccw(c5704.96,4268.29) 5724.42,4268.29 ; 5716.65,4111.26 ccw(c5736.33,4111.26) 5736.33,4091.57 ; 5724.87,4268.74 cw(c5744.33,4268.74) 5763.79,4268.74 5763.79,4229.82 ; 5736.33,4091.42 5752.33,4091.42 ; 5752.33,4091.57 ccw(c5752.33,4111.26) 5772.01,4111.26 ; 5764.24,4229.37 ccw(c5783.7,4229.37) 5803.16,4229.37 5859.37,4229.37 5859.37,4150.63 5810.77,4150.63 ; 5771.86,4111.41 5771.86,4150.47 cw(c5791.32,4150.47) 5810.77,4150.57 ; 5791.47,1961.08 5967.96,2137.57 ccw(c5925.53,2179.99) 5985.53,2179.99 ccw(c5925.53,2179.99) 5967.96,2222.42 5791.47,2398.91 cw(c5833.9,2441.33) 5773.9,2441.33 5773.9,2596.4 ccw(c5713.9,2596.4) 5756.33,2638.82 5579.84,2815.31 cw(c5622.26,2857.74) 5562.26,2857.74 5562.26,3188.03 ccw(c5502.26,3188.03) 5544.69,3230.46 5368.2,3406.94 cw(c5410.63,3449.37) 5350.63,3449.37 5350.63,3680.63 5429.37,3680.63 5429.37,3500 ccw(c5489.37,3500) 5446.94,3457.57 5623.43,3281.09 cw(c5581,3238.66) 5641,3238.66 5641,2897.74 ccw(c5701,2897.74) 5658.58,2855.31 5835.07,2678.82 cw(c5792.64,2636.4) 5852.64,2636.4 5852.64,2481.33 ccw(c5912.64,2481.33) 5870.21,2438.91 6046.7,2262.42 cw(c6004.27,2219.99) 6064.27,2219.99 6064.27,2139.99 cw(c6004.27,2139.99) 6046.7,2097.57 5942.04,1992.91 ccw(c5985.6,1949.35) 5924,1949.35 5924,1644 ccw(c6044.71,1644) 5959.36,1558.64 6018.64,1499.36 ccw(c6104,1584.71) 6104,1464 6306.2,1464 ccw(c6306.2,1511.8) 6340,1478 6350.64,1488.64 cw(c6436,1403.29) 6436,1524 6703.57,1524 ccw(c6703.57,1626.43) 6776,1554 6786.64,1564.64 cw(c6872,1479.29) 6872,1600 7178,1600 ccw(c7178,1720.71) 7263.36,1635.36 7324.64,1696.64 cw(c7410,1611.29) 7410,1732 7546,1732 cw(c7546,1712) 7566,1712 cw(c7548,1712) 7548,1694 7455.25,1694 ccw(c7455.25,1584.75) 7378,1662 7273.36,1557.36 cw(c7188,1642.71) 7188,1522 6942,1522 ccw(c6942,1401.29) 6856.64,1486.64 6807.36,1437.36 cw(c6722,1522.71) 6722,1402 6431.25,1402 ccw(c6431.25,1292.75) 6354,1370 6351.36,1367.36 cw(c6266,1452.71) 6266,1332 5970,1332 cw(c5970,1452.71) 5884.64,1367.36 ; 5838.06,1413.95 5884.64,1367.37 ; 6793.31,1668.31 6793.31,2061.69 cw(c6813.31,2061.69) 6813.31,2081.69 7206.69,2081.69 cw(c7206.69,2061.69) 7226.69,2061.69 7226.69,1904.5 cw(c7206.69,1904.5) 7207.5,1884.52 ; 6793.46,1667.84 ccw(c6812.83,1667.84) 6812.83,1648.47 ; 6813.15,1648.31 7206.69,1648.31 ccw(c7206.69,1668.31) 7226.69,1668.31 7226.69,1825.5 ccw(c7206.69,1825.5) 7207.5,1845.48 ; 7147.8,1904.69 cw(c7167.17,1904.69) 7167.17,1924.06 ; 7147.95,1904.69 7147.95,1865.16 ccw(c7167.95,1865.16) 7167.95,1845.16 7210,1845.16 ; 7167.48,1924.06 cw(c7167.48,1904.37) 7187.16,1904.37 ccw(c7207.16,1904.37) 7207.16,1884.37 ; 7424,3211 ccw(c7460.98,3215.5) 7465.48,3178.52 ; 7424.18,3210.64 ccw(c7392.02,3206.73) 7388.11,3238.89 7041.37,3238.89 ccw(c7041.37,3183.2) 6985.68,3183.2 6985.68,3110.68 cw(c6930,3110.68) 6930,3055 ccw(c6930,2999.32) 6874.32,2999.32 6874.32,2931.8 ccw(c6930,2931.8) 6930,2876.11 7346.11,2876.11 ccw(c7346.11,2931.8) 7401.8,2931.8 7401.8,3028.84 cw(c7457.48,3028.84) 7457.48,3084.53 8200.47,3084.53 8603.29,3084.53 ; 7467,3178.52 8100,3178.52 ccw(c8100,3257.26) 8178.74,3257.26 8178.74,4245.04 8178.74,5140.04 ccw(c8100,5140.04) 8100,5218.78 7981.22,5218.78 cw(c7981.22,5297.52) 7902.48,5297.52 ; 5746.87,1916.47 ccw(c5746.87,1916.47) 5746.87,1916.47 ; 5746.87,1916.47 5746.87,1916.47 ; 5746.87,1916.47 5791.89,1961.49 ; 5791.89,1961.49 ccw(c5791.89,1961.49) 5791.89,1961.49 ; 5884.64,1367.36 ccw(c5884.63,1367.36) 5884.64,1367.37 ; 6919.32,6394.32 cw(c6975,6394.32) 6975,6450 7045,6450 cw(c7042.5,6192.5) 7300,6190 7300,5980 ccw(c7378.74,5980) 7378.74,5901.26 7823.74,5901.26 cw(c7823.74,5822.52) 7902.48,5822.52 7902.48,5297.52 ; 6919.32,6394.32 6919.32,6362.94 ccw(c6975,6362.94) 6975,6307.26 7010,6307.26 cw(c7010,6251.57) 7065.68,6251.57 7065.68,6204.32 ccw(c7121.37,6204.32) 7121.37,6148.63 7161.37,6148.63 cw(c7161.37,6092.95) 7217.05,6092.95 7217.05,5790 ccw(c7295.79,5790) 7295.79,5711.26 7471.94,5711.26 7663.74,5711.26 cw(c7663.74,5647.68) 7727.32,5647.68 7727.32,5297.52 ccw(c7806.06,5297.52) 7806.06,5218.78 7823.74,5218.78 ccw(c7823.74,5297.52) 7902.48,5297.52
  text "5V0" at 7345,6299 h30
  text "+B" at 7160,6245 h30
  text "3V3" at 6955,6150 h30
  text "AUGND" at 75,430 h30