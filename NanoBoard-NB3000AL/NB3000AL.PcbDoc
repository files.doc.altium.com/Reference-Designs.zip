# Altium PCB NB3000AL.PcbDoc (part 76 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
copper on no net: | length 23394.2
  Top Layer w4: 4913.38,4741.18 4913.38,4682.64 ccw(c4923.53,4682.64) 4916.36,4675.46 4916.36,4675.24 4924.27,4667.32 ccw(c4937.24,4682.13) 4937.24,4662.44 cw(c4937.24,4642.75) 4956.93,4642.75 4956.93,4631.31 ccw(c4976.61,4631.31) 4962.69,4617.39 4962.69,4617.31 4964.08,4615.92 ; 4932.05,4726.69 ccw(c4919.52,4739.22) 4937.24,4739.22 ccw(c4954.97,4739.22) 4942.44,4726.69 ; 4937.24,4721.5 4937.24,4741.18 ; v3(4956.93,3796.3) 4976.61,3815.98 ; v3(4956.93,3835.67) 4976.61,3855.35 ; v3(4956.93,3914.41) 4976.61,3934.09 ; v3(4956.93,4111.26) 4976.61,4130.94 ; 4969.27,3815.98 cw(c4951.55,3815.98) 4964.08,3803.45 cw(c4976.61,3790.92) 4976.61,3808.64 ; 4969.27,3855.35 cw(c4951.55,3855.35) 4964.08,3842.82 cw(c4976.61,3830.29) 4976.61,3848.01 ; 4969.27,3934.09 cw(c4951.55,3934.09) 4964.08,3921.56 cw(c4976.61,3909.03) 4976.61,3926.75 ; 4969.27,4130.94 cw(c4951.55,4130.94) 4964.08,4118.41 cw(c4976.61,4105.88) 4976.61,4123.6 ; 4971.42,4726.69 ccw(c4958.89,4739.22) 4976.61,4739.22 ccw(c4994.34,4739.22) 4981.81,4726.69 ; 4976.61,4721.5 4976.61,4741.18 ; v3(4996.3,3835.67) 5015.98,3855.35 ; v3(4996.3,3953.78) 5015.98,3973.46 ; v3(4996.3,4623.07) 5015.98,4603.39 ; 5008.64,3855.35 cw(c4990.92,3855.35) 5003.45,3842.82 cw(c5015.98,3830.29) 5015.98,3848.01 ; 5008.64,3973.46 cw(c4990.92,3973.46) 5003.45,3960.93 cw(c5015.98,3948.4) 5015.98,3966.12 ; 5008.64,4603.39 ccw(c4990.92,4603.39) 5003.45,4615.92 ccw(c5015.98,4628.45) 5015.98,4610.73 ; v3(5035.67,3953.78) 5055.35,3973.46 ; 5048.01,3973.46 cw(c5030.29,3973.46) 5042.82,3960.93 cw(c5055.35,3948.4) 5055.35,3966.12 ; v3(5075.04,4111.26) 5094.72,4130.94 ; 5087.38,4130.94 cw(c5069.66,4130.94) 5082.19,4118.41 cw(c5094.72,4105.88) 5094.72,4123.6 ; v3(5114.41,4268.74) 5134.09,4249.05 ; 5126.75,4249.05 ccw(c5109.03,4249.05) 5121.56,4261.59 ccw(c5134.09,4274.12) 5134.09,4256.4 ; v3(5153.78,3875.04) 5173.46,3894.72 ; 5166.12,3894.72 cw(c5148.4,3894.72) 5160.93,3882.19 cw(c5173.46,3869.66) 5173.46,3887.38 ; v3(5232.52,3756.93) 5252.2,3776.61 ; v3(5232.52,4583.7) 5252.2,4564.02 ; v3(5232.52,4623.07) 5252.2,4603.39 ; 5244.86,3776.61 cw(c5227.14,3776.61) 5239.67,3764.08 cw(c5252.2,3751.55) 5252.2,3769.27 ; 5244.86,4564.02 ccw(c5227.14,4564.02) 5239.67,4576.55 ccw(c5252.2,4589.08) 5252.2,4571.36 ; 5244.86,4603.39 ccw(c5227.14,4603.39) 5239.67,4615.92 ccw(c5252.2,4628.45) 5252.2,4610.73 ; 5247.01,4726.69 ccw(c5234.48,4739.22) 5252.2,4739.22 ccw(c5269.93,4739.22) 5257.4,4726.69 ; 5252.2,4721.5 5252.2,4741.18 ; v3(5271.89,4544.33) 5291.58,4524.65 ; v3(5271.89,4623.07) 5291.58,4603.39 ; 5284.23,4524.65 ccw(c5266.51,4524.65) 5279.04,4537.18 ccw(c5291.57,4549.71) 5291.57,4531.99 ; 5284.23,4603.39 ccw(c5266.51,4603.39) 5279.04,4615.92 ccw(c5291.57,4628.45) 5291.57,4610.73 ; v3(5350.63,3914.41) 5370.31,3934.09 ; v3(5350.63,4426.22) 5370.31,4406.54 ; v3(5350.63,4583.7) 5370.31,4564.02 ; v3(5350.63,4623.07) 5370.31,4603.39 ; 5362.97,3934.09 cw(c5345.25,3934.09) 5357.78,3921.56 cw(c5370.31,3909.03) 5370.31,3926.75 ; 5362.97,4406.54 ccw(c5345.25,4406.54) 5357.78,4419.07 ccw(c5370.31,4431.6) 5370.31,4413.88 ; 5362.97,4564.02 ccw(c5345.25,4564.02) 5357.78,4576.55 ccw(c5370.31,4589.08) 5370.31,4571.36 ; 5362.97,4603.39 ccw(c5345.25,4603.39) 5357.78,4615.92 ccw(c5370.31,4628.45) 5370.31,4610.73 ; 5409.69,3808.64 cw(c5409.69,3790.92) 5422.22,3803.45 cw(c5434.75,3815.98) 5417.03,3815.98 ; 5409.68,3815.98 v3(5429.37,3796.3) ; 5409.69,3848.01 cw(c5409.69,3830.29) 5422.22,3842.82 cw(c5434.75,3855.35) 5417.03,3855.35 ; 5409.68,3855.35 v3(5429.37,3835.67) ; 5409.69,3966.12 cw(c5409.69,3948.4) 5422.22,3960.93 cw(c5434.75,3973.46) 5417.03,3973.46 ; 5409.68,3973.46 v3(5429.37,3953.78) ; 5409.68,4367.17 v3(5429.37,4386.85) ; 5409.69,4374.51 ccw(c5409.69,4392.23) 5422.22,4379.7 ; 5409.68,4445.91 v3(5429.37,4465.59) ; 5409.69,4453.25 ccw(c5409.69,4470.97) 5422.22,4458.44 ccw(c5434.75,4445.91) 5417.03,4445.91 ; 5417.03,4367.17 cw(c5434.75,4367.17) 5422.22,4379.7 ; 5449.05,3769.27 cw(c5449.05,3751.55) 5461.59,3764.08 cw(c5474.12,3776.61) 5456.4,3776.61 ; 5449.05,3776.61 v3(5468.74,3756.93) ; 5449.05,4406.54 v3(5468.74,4426.22) ; 5449.05,4413.88 ccw(c5449.05,4431.6) 5461.59,4419.07 ccw(c5474.12,4406.53) 5456.4,4406.54 ; 5488.42,3769.27 cw(c5488.42,3751.55) 5500.96,3764.08 cw(c5513.49,3776.61) 5495.77,3776.61 ; 5488.42,3776.61 v3(5508.11,3756.93) ; 5488.42,3848.01 cw(c5488.42,3830.29) 5500.96,3842.82 cw(c5513.49,3855.35) 5495.77,3855.35 ; 5488.42,3855.35 v3(5508.11,3835.67) ; 5488.42,4445.91 v3(5508.11,4465.59) ; 5488.42,4453.25 ccw(c5488.42,4470.97) 5500.96,4458.44 ccw(c5513.49,4445.91) 5495.77,4445.91 ; 5488.42,4485.28 v3(5508.11,4504.96) ; 5488.42,4492.62 ccw(c5488.42,4510.34) 5500.96,4497.81 ccw(c5513.49,4485.28) 5495.77,4485.28 ; 5488.42,4689.47 ccw(c5488.42,4707.19) 5500.96,4694.66 ; 5495.77,4682.13 cw(c5513.49,4682.13) 5500.96,4694.66 ; 5503.93,4741.18 5503.93,4701.84 cw(c5493.78,4701.84) 5500.96,4694.66 ; 5522.6,4726.69 ccw(c5510.07,4739.22) 5527.79,4739.22 ccw(c5545.52,4739.22) 5532.99,4726.69 ; 5527.79,4485.28 v3(5547.48,4504.96) ; 5527.8,4492.62 ccw(c5527.8,4510.34) 5540.33,4497.81 ccw(c5552.86,4485.28) 5535.14,4485.28 ; 5527.79,4721.5 5527.79,4741.18 ; 5567.17,3926.75 cw(c5567.17,3909.03) 5579.7,3921.56 cw(c5592.23,3934.09) 5574.51,3934.09 ; 5567.17,3934.09 v3(5586.85,3914.41) ; 5606.54,4044.86 cw(c5606.54,4027.14) 5619.07,4039.67 cw(c5631.6,4052.2) 5613.88,4052.2 ; 5606.54,4052.2 v3(5626.22,4032.52) ; 5645.91,3769.27 cw(c5645.91,3751.55) 5658.44,3764.08 cw(c5670.97,3776.61) 5653.25,3776.61 ; 5645.91,3776.61 v3(5665.59,3756.93) ; 5645.91,3887.38 cw(c5645.91,3869.66) 5658.44,3882.19 cw(c5670.97,3894.72) 5653.25,3894.72 ; 5645.91,3894.72 v3(5665.59,3875.04) ; 5645.91,4445.91 v3(5665.59,4465.59) ; 5645.91,4453.25 ccw(c5645.91,4470.97) 5658.44,4458.44 ccw(c5670.97,4445.91) 5653.25,4445.91 ; 5645.91,4524.65 v3(5665.59,4544.33) ; 5645.91,4531.99 ccw(c5645.91,4549.71) 5658.44,4537.18 ccw(c5670.97,4524.65) 5653.25,4524.65 ; 5685.28,4524.65 v3(5704.96,4544.33) ; 5685.28,4531.99 ccw(c5685.28,4549.71) 5697.81,4537.18 ccw(c5710.34,4524.65) 5692.62,4524.65 ; 5685.28,4603.39 v3(5704.96,4623.07) ; 5685.28,4610.73 ccw(c5685.28,4628.45) 5697.81,4615.92 ccw(c5710.34,4603.39) 5692.62,4603.39 ; 5719.45,4726.69 ccw(c5706.92,4739.22) 5724.65,4739.22 ccw(c5742.37,4739.22) 5729.84,4726.69 ; 5724.65,4044.86 cw(c5724.65,4027.14) 5737.18,4039.67 cw(c5749.71,4052.2) 5731.99,4052.2 ; 5724.65,4052.2 v3(5744.33,4032.52) ; 5724.65,4084.23 cw(c5724.65,4066.51) 5737.18,4079.04 cw(c5749.71,4091.57) 5731.99,4091.57 ; 5724.65,4091.57 v3(5744.33,4071.89) ; 5724.65,4485.28 v3(5744.33,4504.96) ; 5724.65,4492.62 ccw(c5724.65,4510.34) 5737.18,4497.81 ccw(c5749.71,4485.28) 5731.99,4485.28 ; 5724.65,4603.39 v3(5744.33,4623.07) ; 5724.65,4610.73 ccw(c5724.65,4628.45) 5737.18,4615.92 ccw(c5749.71,4603.39) 5731.99,4603.39 ; 5724.65,4721.5 5724.65,4741.18 ; 5764.02,3769.27 cw(c5764.02,3751.55) 5776.55,3764.08 cw(c5789.08,3776.61) 5771.36,3776.61 ; 5764.02,3776.61 v3(5783.7,3756.93) ; 5764.02,3966.12 cw(c5764.02,3948.4) 5776.55,3960.93 cw(c5789.08,3973.46) 5771.36,3973.46 ; 5764.02,3973.46 v3(5783.7,3953.78) ; 5764.02,4084.23 cw(c5764.02,4066.51) 5776.55,4079.04 cw(c5789.08,4091.57) 5771.36,4091.57 ; 5764.02,4091.57 v3(5783.7,4071.89) ; 5764.02,4327.79 v3(5783.7,4347.48) ; 5764.02,4335.14 ccw(c5764.02,4352.86) 5776.55,4340.33 ccw(c5789.08,4327.8) 5771.36,4327.8 ; 5764.02,4406.54 v3(5783.7,4426.22) ; 5764.02,4413.88 ccw(c5764.02,4431.6) 5776.55,4419.07 ccw(c5789.08,4406.54) 5771.36,4406.54 ; 5764.02,4445.91 v3(5783.7,4465.59) ; 5764.02,4453.25 ccw(c5764.02,4470.97) 5776.55,4458.44 ccw(c5789.08,4445.91) 5771.36,4445.91 ; 5764.02,4524.65 v3(5783.7,4544.33) ; 5764.02,4531.99 ccw(c5764.02,4549.71) 5776.55,4537.18 ccw(c5789.08,4524.65) 5771.36,4524.65 ; 5764.02,4564.02 v3(5783.7,4583.7) ; 5764.02,4571.36 ccw(c5764.02,4589.08) 5776.55,4576.55 ccw(c5789.08,4564.02) 5771.36,4564.02 ; 5764.02,4603.39 v3(5783.7,4623.07) ; 5764.02,4610.73 ccw(c5764.02,4628.45) 5776.55,4615.92 ccw(c5789.08,4603.39) 5771.36,4603.39 ; 5803.39,3966.12 cw(c5803.39,3948.4) 5815.92,3960.93 cw(c5828.45,3973.46) 5810.73,3973.46 ; 5803.39,3973.46 v3(5823.07,3953.78) ; 5803.39,4005.49 cw(c5803.39,3987.77) 5815.92,4000.3 cw(c5828.45,4012.83) 5810.73,4012.83 ; 5803.39,4012.83 v3(5823.07,3993.15) ; 5803.39,4123.6 cw(c5803.39,4105.88) 5815.92,4118.41 cw(c5828.45,4130.94) 5810.73,4130.94 ; 5803.39,4130.94 v3(5823.07,4111.26) ; 5803.39,4524.65 v3(5823.07,4544.33) ; 5803.39,4531.99 ccw(c5803.39,4549.71) 5815.92,4537.18 ccw(c5828.45,4524.65) 5810.73,4524.65 ; 6665.67,1727.2 6714.72,1727.2 ; 6695.04,1711.7 6734.38,1711.7 ; 6695.04,2002.79 6714.72,2002.79 ; 6709.53,1722.01 ccw(c6697,1709.48) 6697,1727.2 ccw(c6697,1744.93) 6709.53,1732.4 ; 6709.53,1997.6 ccw(c6697,1985.07) 6697,2002.79 ccw(c6697,2020.52) 6709.53,2007.99 ; v1(6815.19,2508.37) 6826.82,2520 6883.82,2520 6898.66,2505.15 6928.82,2475 ; 6912.07,2491.75 ccw(c6928.82,2508.5) 6928.82,2484.81 ; 6913.26,2490.56 cw(c6898.19,2475.49) 6919.5,2475.49 ; 6918.9,2484.92 ccw(c6928.82,2494.84) 6928.82,2480.81 ; 6920.09,2483.73 cw(c6911.85,2475.49) 6923.5,2475.49 ; v3(6970.63,1628.78) 6990.31,1648.46 ; v3(6970.63,1746.89) 6990.31,1766.57 ; 6982.97,1648.46 cw(c6965.25,1648.46) 6977.78,1635.93 cw(c6990.31,1623.4) 6990.31,1641.12 ; 6982.97,1766.57 cw(c6965.25,1766.57) 6977.78,1754.04 cw(c6990.31,1741.51) 6990.31,1759.23 ; 7029.69,1680.49 cw(c7029.69,1662.77) 7042.22,1675.3 cw(c7054.75,1687.83) 7037.03,1687.83 ; 7029.68,1687.83 v3(7049.37,1668.15) ; 7063.86,1564.53 cw(c7051.33,1552) 7069.05,1552 cw(c7086.78,1552) 7074.25,1564.53 ; 7069,1500.19 7069,1569.67 7069.05,1569.72 ; 7069.06,1719.86 cw(c7069.06,1702.14) 7081.59,1714.67 cw(c7094.12,1727.2) 7076.4,1727.2 ; 7069.06,1727.2 v3(7088.74,1707.52) ; 7069.06,1759.23 cw(c7069.06,1741.51) 7081.59,1754.04 cw(c7094.12,1766.57) 7076.4,1766.57 ; 7069.06,1766.57 v3(7088.74,1746.89) ; 7103.23,1564.53 cw(c7090.7,1552) 7108.42,1552 cw(c7126.15,1552) 7113.62,1564.53 ; 7108.42,1510.7 7108.42,1550.04 7108.42,1569.72 ; 7305.28,1727.2 7324.96,1727.2 7362.29,1727.2 ; 7305.28,2002.79 7324.96,2002.79 7354.33,2002.79 ; 7310.47,1722.01 cw(c7323,1709.48) 7323,1727.2 cw(c7323,1744.93) 7310.47,1732.4 ; 7310.47,1997.6 cw(c7323,1985.07) 7323,2002.79 cw(c7323,2020.52) 7310.47,2007.99 ; 7364.93,1751.07 7312.17,1751.07 7285.62,1751.07 ; 4964.08,4615.92 cw(c4951.55,4603.39) 4969.27,4603.39 ccw(c4951.55,4603.39) 4964.08,4615.92 ; 4964.08,4615.92 ccw(c4976.61,4628.45) 4976.61,4610.73 cw(c4976.61,4628.45) 4964.08,4615.92 ; 4969.73,3809.1 cw(c4956.93,3821.91) 4956.93,3803.8 ccw(c4956.93,3821.91) 4969.73,3809.1 ; 4969.73,3809.1 ccw(c4982.54,3796.3) 4964.43,3796.3 cw(c4982.54,3796.3) 4969.73,3809.1 ; 4969.73,3848.47 cw(c4956.93,3861.28) 4956.93,3843.17 ccw(c4956.93,3861.28) 4969.73,3848.47 ; 4969.73,3848.47 ccw(c4982.54,3835.67) 4964.43,3835.67 cw(c4982.54,3835.67) 4969.73,3848.47 ; 4969.73,3927.21 cw(c4956.93,3940.02) 4956.93,3921.91 ccw(c4956.93,3940.02) 4969.73,3927.21 ; 4969.73,3927.21 ccw(c4982.54,3914.41) 4964.43,3914.41 cw(c4982.54,3914.41) 4969.73,3927.21 ; 4969.73,4124.06 cw(c4956.93,4136.87) 4956.93,4118.76 ccw(c4956.93,4136.87) 4969.73,4124.06 ; 4969.73,4124.06 ccw(c4982.54,4111.26) 4964.43,4111.26 cw(c4982.54,4111.26) 4969.73,4124.06 ; 4992.12,4682.64 ccw(c5030.8,4682.64) 5003.45,4655.29 ; 4992.12,4682.64 ccw(c5030.8,4682.64) 5003.45,4655.29 ; 4992.12,4682.64 4992.12,4741.18 4992.12,4682.64 ; 5003.45,4655.29 cw(c4990.92,4642.76) 5008.64,4642.76 ccw(c4990.92,4642.76) 5003.45,4655.29 ; 5003.45,4655.29 ccw(c5015.98,4667.82) 5015.98,4650.1 cw(c5015.98,4667.82) 5003.45,4655.29 ; 5009.1,3848.47 cw(c4996.3,3861.28) 4996.3,3843.17 ccw(c4996.3,3861.28) 5009.1,3848.47 ; 5009.1,3848.47 ccw(c5021.91,3835.67) 5003.8,3835.67 cw(c5021.91,3835.67) 5009.1,3848.47 ; 5009.1,3966.58 cw(c4996.3,3979.39) 4996.3,3961.28 ccw(c4996.3,3979.39) 5009.1,3966.58 ; 5009.1,3966.58 ccw(c5021.91,3953.78) 5003.8,3953.78 cw(c5021.91,3953.78) 5009.1,3966.58 ; 5009.1,4610.27 cw(c5021.91,4623.07) 5003.8,4623.07 ccw(c5021.91,4623.07) 5009.1,4610.27 ; 5009.1,4610.27 ccw(c4996.3,4597.46) 4996.3,4615.57 cw(c4996.3,4597.46) 5009.1,4610.27 ; 5048.47,3966.58 cw(c5035.67,3979.39) 5035.67,3961.28 ccw(c5035.67,3979.39) 5048.47,3966.58 ; 5048.47,3966.58 ccw(c5061.28,3953.78) 5043.17,3953.78 cw(c5061.28,3953.78) 5048.47,3966.58 ; 5087.84,4124.06 cw(c5075.04,4136.87) 5075.04,4118.76 ccw(c5075.04,4136.87) 5087.84,4124.06 ; 5087.84,4124.06 ccw(c5100.65,4111.26) 5082.54,4111.26 cw(c5100.65,4111.26) 5087.84,4124.06 ; 5094.72,4739.22 cw(c5077,4739.22) 5089.53,4726.69 ccw(c5077,4739.22) 5094.72,4739.22 ; 5094.72,4739.22 ccw(c5112.45,4739.22) 5099.92,4726.69 cw(c5112.45,4739.22) 5094.72,4739.22 ; 5127.21,4255.94 cw(c5140.02,4268.74) 5121.91,4268.74 ccw(c5140.02,4268.74) 5127.21,4255.94 ; 5127.21,4255.94 ccw(c5114.41,4243.13) 5114.41,4261.24 cw(c5114.41,4243.13) 5127.21,4255.94 ; 5166.58,3887.84 cw(c5153.78,3900.65) 5153.78,3882.54 ccw(c5153.78,3900.65) 5166.58,3887.84 ; 5166.58,3887.84 ccw(c5179.39,3875.04) 5161.28,3875.04 cw(c5179.39,3875.04) 5166.58,3887.84 ; 5245.32,3769.73 cw(c5232.52,3782.54) 5232.52,3764.43 ccw(c5232.52,3782.54) 5245.32,3769.73 ; 5245.32,3769.73 ccw(c5258.13,3756.93) 5240.02,3756.93 cw(c5258.13,3756.93) 5245.32,3769.73 ; 5245.32,4570.9 cw(c5258.13,4583.7) 5240.02,4583.7 ccw(c5258.13,4583.7) 5245.32,4570.9 ; 5245.32,4570.9 ccw(c5232.52,4558.09) 5232.52,4576.2 cw(c5232.52,4558.09) 5245.32,4570.9 ; 5245.32,4610.27 cw(c5258.13,4623.07) 5240.02,4623.07 ccw(c5258.13,4623.07) 5245.32,4610.27 ; 5245.32,4610.27 ccw(c5232.52,4597.46) 5232.52,4615.57 cw(c5232.52,4597.46) 5245.32,4610.27 ; 5284.69,4531.53 cw(c5297.5,4544.33) 5279.39,4544.33 ccw(c5297.5,4544.33) 5284.69,4531.53 ; 5284.69,4531.53 ccw(c5271.89,4518.72) 5271.89,4536.83 cw(c5271.89,4518.72) 5284.69,4531.53 ; 5284.69,4610.27 cw(c5297.5,4623.07) 5279.39,4623.07 ccw(c5297.5,4623.07) 5284.69,4610.27 ; 5284.69,4610.27 ccw(c5271.89,4597.46) 5271.89,4615.57 cw(c5271.89,4597.46) 5284.69,4610.27 ; 5363.43,3927.21 cw(c5350.63,3940.02) 5350.63,3921.91 ccw(c5350.63,3940.02) 5363.43,3927.21 ; 5363.43,3927.21 ccw(c5376.24,3914.41) 5358.13,3914.41 cw(c5376.24,3914.41) 5363.43,3927.21 ; 5363.43,4413.42 cw(c5376.24,4426.22) 5358.13,4426.22 ccw(c5376.24,4426.22) 5363.43,4413.42 ; 5363.43,4413.42 ccw(c5350.63,4400.61) 5350.63,4418.72 cw(c5350.63,4400.61) 5363.43,4413.42 ; 5363.43,4570.9 cw(c5376.24,4583.7) 5358.13,4583.7 ccw(c5376.24,4583.7) 5363.43,4570.9 ; 5363.43,4570.9 ccw(c5350.63,4558.09) 5350.63,4576.2 cw(c5350.63,4558.09) 5363.43,4570.9 ; 5363.43,4610.27 cw(c5376.24,4623.07) 5358.13,4623.07 ccw(c5376.24,4623.07) 5363.43,4610.27 ; 5363.43,4610.27 ccw(c5350.63,4597.46) 5350.63,4615.57 cw(c5350.63,4597.46) 5363.43,4610.27 ; 5416.57,3809.1 cw(c5403.76,3796.3) 5421.87,3796.3 ccw(c5403.76,3796.3) 5416.57,3809.1 ; 5416.57,3809.1 ccw(c5429.37,3821.91) 5429.37,3803.8 cw(c5429.37,3821.91) 5416.57,3809.1 ; 5416.57,3848.47 cw(c5403.76,3835.67) 5421.87,3835.67 ccw(c5403.76,3835.67) 5416.57,3848.47 ; 5416.57,3848.47 ccw(c5429.37,3861.28) 5429.37,3843.17 cw(c5429.37,3861.28) 5416.57,3848.47 ; 5416.57,3966.58 cw(c5403.76,3953.78) 5421.87,3953.78 ccw(c5403.76,3953.78) 5416.57,3966.58 ; 5416.57,3966.58 ccw(c5429.37,3979.39) 5429.37,3961.28 cw(c5429.37,3979.39) 5416.57,3966.58 ; 5416.57,4374.05 cw(c5429.37,4361.24) 5429.37,4379.35 ccw(c5429.37,4361.24) 5416.57,4374.05 ; 5416.57,4374.05 ccw(c5403.76,4386.85) 5421.87,4386.85 cw(c5403.76,4386.85) 5416.57,4374.05 ; 5416.57,4452.79 cw(c5429.37,4439.98) 5429.37,4458.09 ccw(c5429.37,4439.98) 5416.57,4452.79 ; 5416.57,4452.79 ccw(c5403.76,4465.59) 5421.87,4465.59 cw(c5403.76,4465.59) 5416.57,4452.79 ; 5455.94,3769.73 cw(c5443.13,3756.93) 5461.24,3756.93 ccw(c5443.13,3756.93) 5455.94,3769.73 ; 5455.94,3769.73 ccw(c5468.74,3782.54) 5468.74,3764.43 cw(c5468.74,3782.54) 5455.94,3769.73 ; 5455.94,4413.42 cw(c5468.74,4400.61) 5468.74,4418.72 ccw(c5468.74,4400.61) 5455.94,4413.42 ; 5455.94,4413.42 ccw(c5443.13,4426.22) 5461.24,4426.22 cw(c5443.13,4426.22) 5455.94,4413.42 ; 5495.31,3769.73 cw(c5482.5,3756.93) 5500.61,3756.93 ccw(c5482.5,3756.93) 5495.31,3769.73 ; 5495.31,3769.73 ccw(c5508.11,3782.54) 5508.11,3764.43 cw(c5508.11,3782.54) 5495.31,3769.73 ; 5495.31,3848.47 cw(c5482.5,3835.67) 5500.61,3835.67 ccw(c5482.5,3835.67) 5495.31,3848.47 ; 5495.31,3848.47 ccw(c5508.11,3861.28) 5508.11,3843.17 cw(c5508.11,3861.28) 5495.31,3848.47 ; 5495.31,4452.79 cw(c5508.11,4439.98) 5508.11,4458.09 ccw(c5508.11,4439.98) 5495.31,4452.79 ; 5495.31,4452.79 ccw(c5482.5,4465.59) 5500.61,4465.59 cw(c5482.5,4465.59) 5495.31,4452.79 ; 5495.31,4492.16 cw(c5508.11,4479.35) 5508.11,4497.46 ccw(c5508.11,4479.35) 5495.31,4492.16 ; 5495.31,4492.16 ccw(c5482.5,4504.96) 5500.61,4504.96 cw(c5482.5,4504.96) 5495.31,4492.16 ; 5534.68,4492.16 cw(c5547.48,4479.35) 5547.48,4497.46 ccw(c5547.48,4479.35) 5534.68,4492.16 ; 5534.68,4492.16 ccw(c5521.87,4504.96) 5539.98,4504.96 cw(c5521.87,4504.96) 5534.68,4492.16 ; 5574.05,3927.21 cw(c5561.24,3914.41) 5579.35,3914.41 ccw(c5561.24,3914.41) 5574.05,3927.21 ; 5574.05,3927.21 ccw(c5586.85,3940.02) 5586.85,3921.91 cw(c5586.85,3940.02) 5574.05,3927.21 ; 5613.42,4045.32 cw(c5600.61,4032.52) 5618.72,4032.52 ccw(c5600.61,4032.52) 5613.42,4045.32 ; 5613.42,4045.32 ccw(c5626.22,4058.13) 5626.22,4040.02 cw(c5626.22,4058.13) 5613.42,4045.32 ; 5652.79,3769.73 cw(c5639.98,3756.93) 5658.09,3756.93 ccw(c5639.98,3756.93) 5652.79,3769.73 ; 5652.79,3769.73 ccw(c5665.59,3782.54) 5665.59,3764.43 cw(c5665.59,3782.54) 5652.79,3769.73 ; 5652.79,3887.84 cw(c5639.98,3875.04) 5658.09,3875.04 ccw(c5639.98,3875.04) 5652.79,3887.84 ; 5652.79,3887.84 ccw(c5665.59,3900.65) 5665.59,3882.54 cw(c5665.59,3900.65) 5652.79,3887.84 ; 5652.79,4452.79 cw(c5665.59,4439.98) 5665.59,4458.09 ccw(c5665.59,4439.98) 5652.79,4452.79 ; 5652.79,4452.79 ccw(c5639.98,4465.59) 5658.09,4465.59 cw(c5639.98,4465.59) 5652.79,4452.79 ; 5652.79,4531.53 cw(c5665.59,4518.72) 5665.59,4536.83 ccw(c5665.59,4518.72) 5652.79,4531.53 ; 5652.79,4531.53 ccw(c5639.98,4544.33) 5658.09,4544.33 cw(c5639.98,4544.33) 5652.79,4531.53 ; 5685.28,4739.22 ccw(c5703,4739.22) 5690.47,4726.69 cw(c5703,4739.22) 5685.28,4739.22 ; 5685.28,4739.22 cw(c5667.55,4739.22) 5680.08,4726.69 ccw(c5667.55,4739.22) 5685.28,4739.22 ; 5692.16,4531.53 cw(c5704.96,4518.72) 5704.96,4536.83 ccw(c5704.96,4518.72) 5692.16,4531.53 ; 5692.16,4531.53 ccw(c5679.35,4544.33) 5697.46,4544.33 cw(c5679.35,4544.33) 5692.16,4531.53 ; 5692.16,4610.27 cw(c5704.96,4597.46) 5704.96,4615.57 ccw(c5704.96,4597.46) 5692.16,4610.27 ; 5692.16,4610.27 ccw(c5679.35,4623.07) 5697.46,4623.07 cw(c5679.35,4623.07) 5692.16,4610.27 ; 5697.81,4655.29 ccw(c5710.34,4642.76) 5692.62,4642.76 cw(c5710.34,4642.76) 5697.81,4655.29 ; 5697.81,4655.29 cw(c5685.28,4667.82) 5685.28,4650.1 ccw(c5685.28,4667.82) 5697.81,4655.29 ; 5697.81,4655.29 ccw(c5670.46,4682.64) 5709.14,4682.64 ; 5697.81,4655.29 ccw(c5670.46,4682.64) 5709.14,4682.64 ; 5697.81,4694.66 cw(c5685.28,4707.19) 5685.28,4689.47 ccw(c5685.28,4707.19) 5697.81,4694.66 ; 5697.81,4694.66 ccw(c5710.34,4682.13) 5692.62,4682.13 cw(c5710.34,4682.13) 5697.81,4694.66 ; 5697.81,4694.66 ccw(c5690.63,4701.84) 5700.78,4701.84 ; 5697.81,4694.66 ccw(c5690.63,4701.84) 5700.78,4701.84 ; 5700.78,4701.84 5700.78,4741.18 5700.78,4701.84 ; 5709.14,4682.64 5709.14,4741.18 5709.14,4682.64 ; 5731.53,4045.32 cw(c5718.72,4032.52) 5736.83,4032.52 ccw(c5718.72,4032.52) 5731.53,4045.32 ; 5731.53,4045.32 ccw(c5744.33,4058.13) 5744.33,4040.02 cw(c5744.33,4058.13) 5731.53,4045.32 ; 5731.53,4084.69 cw(c5718.72,4071.89) 5736.83,4071.89 ccw(c5718.72,4071.89) 5731.53,4084.69 ; 5731.53,4084.69 ccw(c5744.33,4097.5) 5744.33,4079.39 cw(c5744.33,4097.5) 5731.53,4084.69 ; 5731.53,4492.16 cw(c5744.33,4479.35) 5744.33,4497.46 ccw(c5744.33,4479.35) 5731.53,4492.16 ; 5731.53,4492.16 ccw(c5718.72,4504.96) 5736.83,4504.96 cw(c5718.72,4504.96) 5731.53,4492.16 ; 5731.53,4610.27 cw(c5744.33,4597.46) 5744.33,4615.57 ccw(c5744.33,4597.46) 5731.53,4610.27 ; 5731.53,4610.27 ccw(c5718.72,4623.07) 5736.83,4623.07 cw(c5718.72,4623.07) 5731.53,4610.27 ; 5770.9,3769.73 cw(c5758.09,3756.93) 5776.2,3756.93 ccw(c5758.09,3756.93) 5770.9,3769.73 ; 5770.9,3769.73 ccw(c5783.7,3782.54) 5783.7,3764.43 cw(c5783.7,3782.54) 5770.9,3769.73 ; 5770.9,3966.58 cw(c5758.09,3953.78) 5776.2,3953.78 ccw(c5758.09,3953.78) 5770.9,3966.58 ; 5770.9,3966.58 ccw(c5783.7,3979.39) 5783.7,3961.28 cw(c5783.7,3979.39) 5770.9,3966.58 ; 5770.9,4084.69 cw(c5758.09,4071.89) 5776.2,4071.89 ccw(c5758.09,4071.89) 5770.9,4084.69 ; 5770.9,4084.69 ccw(c5783.7,4097.5) 5783.7,4079.39 cw(c5783.7,4097.5) 5770.9,4084.69 ; 5770.9,4334.68 cw(c5783.7,4321.87) 5783.7,4339.98 ccw(c5783.7,4321.87) 5770.9,4334.68 ; 5770.9,4334.68 ccw(c5758.09,4347.48) 5776.2,4347.48 cw(c5758.09,4347.48) 5770.9,4334.68 ; 5770.9,4413.42 cw(c5783.7,4400.61) 5783.7,4418.72 ccw(c5783.7,4400.61) 5770.9,4413.42 ; 5770.9,4413.42 ccw(c5758.09,4426.22) 5776.2,4426.22 cw(c5758.09,4426.22) 5770.9,4413.42 ; 5770.9,4452.79 cw(c5783.7,4439.98) 5783.7,4458.09 ccw(c5783.7,4439.98) 5770.9,4452.79 ; 5770.9,4452.79 ccw(c5758.09,4465.59) 5776.2,4465.59 cw(c5758.09,4465.59) 5770.9,4452.79 ; 5770.9,4531.53 cw(c5783.7,4518.72) 5783.7,4536.83 ccw(c5783.7,4518.72) 5770.9,4531.53 ; 5770.9,4531.53 ccw(c5758.09,4544.33) 5776.2,4544.33 cw(c5758.09,4544.33) 5770.9,4531.53 ; 5770.9,4570.9 cw(c5783.7,4558.09) 5783.7,4576.2 ccw(c5783.7,4558.09) 5770.9,4570.9 ; 5770.9,4570.9 ccw(c5758.09,4583.7) 5776.2,4583.7 cw(c5758.09,4583.7) 5770.9,4570.9 ; 5770.9,4610.27 cw(c5783.7,4597.46) 5783.7,4615.57 ccw(c5783.7,4597.46) 5770.9,4610.27 ; 5770.9,4610.27 ccw(c5758.09,4623.07) 5776.2,4623.07 cw(c5758.09,4623.07) 5770.9,4610.27 ; 5776.55,4655.29 ccw(c5789.08,4642.76) 5771.36,4642.76 cw(c5789.08,4642.76) 5776.55,4655.29 ; 5776.55,4655.29 cw(c5764.02,4667.82) 5764.02,4650.1 ccw(c5764.02,4667.82) 5776.55,4655.29 ; 5776.55,4655.29 ccw(c5749.2,4682.64) 5787.88,4682.64 ; 5776.55,4655.29 ccw(c5749.2,4682.64) 5787.88,4682.64 ; 5787.88,4682.64 5787.88,4741.18 5787.88,4682.64 ; 5810.27,3966.58 cw(c5797.46,3953.78) 5815.57,3953.78 ccw(c5797.46,3953.78) 5810.27,3966.58 ; 5810.27,3966.58 ccw(c5823.07,3979.39) 5823.07,3961.28 cw(c5823.07,3979.39) 5810.27,3966.58 ; 5810.27,4005.95 cw(c5797.46,3993.15) 5815.57,3993.15 ccw(c5797.46,3993.15) 5810.27,4005.95 ; 5810.27,4005.95 ccw(c5823.07,4018.76) 5823.07,4000.65 cw(c5823.07,4018.76) 5810.27,4005.95 ; 5810.27,4124.06 cw(c5797.46,4111.26) 5815.57,4111.26 ccw(c5797.46,4111.26) 5810.27,4124.06 ; 5810.27,4124.06 ccw(c5823.07,4136.87) 5823.07,4118.76 cw(c5823.07,4136.87) 5810.27,4124.06 ; 5810.27,4531.53 cw(c5823.07,4518.72) 5823.07,4536.83 ccw(c5823.07,4518.72) 5810.27,4531.53 ; 5810.27,4531.53 ccw(c5797.46,4544.33) 5815.57,4544.33 cw(c5797.46,4544.33) 5810.27,4531.53 ; 5855.29,4694.66 cw(c5842.76,4707.19) 5842.76,4689.47 ccw(c5842.76,4707.19) 5855.29,4694.66 ; 5855.29,4694.66 ccw(c5867.82,4682.13) 5850.1,4682.13 cw(c5867.82,4682.13) 5855.29,4694.66 ; 5855.29,4694.66 ccw(c5848.11,4701.84) 5858.26,4701.84 ; 5855.29,4694.66 ccw(c5848.11,4701.84) 5858.26,4701.84 ; 5858.26,4701.84 5858.26,4741.18 5858.26,4701.84 ; 5939.22,4485.28 cw(c5939.22,4503) 5926.69,4490.47 ccw(c5939.22,4503) 5939.22,4485.28 ; 5939.22,4485.28 ccw(c5939.22,4467.55) 5926.69,4480.08 cw(c5939.22,4467.55) 5939.22,4485.28 ; 6734.38,1711.7 ccw(c6734.38,1721.85) 6741.56,1714.67 ; 6734.38,1711.7 ccw(c6734.38,1721.85) 6741.56,1714.67 ; 6741.56,1714.67 ccw(c6729.03,1727.2) 6746.75,1727.2 cw(c6729.03,1727.2) 6741.56,1714.67 ; 6741.56,1714.67 cw(c6754.09,1702.14) 6754.09,1719.86 ccw(c6754.09,1702.14) 6741.56,1714.67 ; 6983.43,1641.58 cw(c6970.63,1654.39) 6970.63,1636.28 ccw(c6970.63,1654.39) 6983.43,1641.58 ; 6983.43,1641.58 ccw(c6996.24,1628.78) 6978.13,1628.78 cw(c6996.24,1628.78) 6983.43,1641.58 ; 6983.43,1759.69 cw(c6970.63,1772.5) 6970.63,1754.39 ccw(c6970.63,1772.5) 6983.43,1759.69 ; 6983.43,1759.69 ccw(c6996.24,1746.89) 6978.13,1746.89 cw(c6996.24,1746.89) 6983.43,1759.69 ; 7036.57,1680.95 cw(c7023.76,1668.15) 7041.87,1668.15 ccw(c7023.76,1668.15) 7036.57,1680.95 ; 7036.57,1680.95 ccw(c7049.37,1693.76) 7049.37,1675.65 cw(c7049.37,1693.76) 7036.57,1680.95 ; 7075.94,1720.32 cw(c7063.13,1707.52) 7081.24,1707.52 ccw(c7063.13,1707.52) 7075.94,1720.32 ; 7075.94,1720.32 ccw(c7088.74,1733.13) 7088.74,1715.02 cw(c7088.74,1733.13) 7075.94,1720.32 ; 7075.94,1759.69 cw(c7063.13,1746.89) 7081.24,1746.89 ccw(c7063.13,1746.89) 7075.94,1759.69 ; 7075.94,1759.69 ccw(c7088.74,1772.5) 7088.74,1754.39 cw(c7088.74,1772.5) 7075.94,1759.69 ; 7278.44,1754.04 ccw(c7285.62,1761.22) 7285.62,1751.07 ; 7278.44,1754.04 ccw(c7285.62,1761.22) 7285.62,1751.07 ; 7278.44,1754.04 cw(c7290.97,1766.57) 7273.25,1766.57 ccw(c7290.97,1766.57) 7278.44,1754.04 ; 7278.44,1754.04 ccw(c7265.91,1741.51) 7265.91,1759.23 cw(c7265.91,1741.51) 7278.44,1754.04 ; 5094.72,4721.5 5094.72,4741.18 5094.72,4721.5 ; 5685.28,4721.5 5685.28,4741.18 5685.28,4721.5 ; 5921.5,4485.28 5941.18,4485.28 5921.5,4485.28
  Top Layer w8: v5(7692.52,4327.52) 7712.2,4347.2 ; v5@7692.52,4336.52 ccw(c7692.52,4358.25) 7707.88,4342.88 ccw(c7723.25,4327.52) v5@7701.52,4327.52 ; v5@7692.52,4633.48 cw(c7692.52,4611.75) 7707.88,4627.12 cw(c7723.25,4642.48) v5@7701.52,4642.48 ; v5(7692.52,4642.48) 7712.2,4622.8 ; v5(7731.89,4327.52) 7751.58,4347.2 ; v5@7731.89,4336.52 ccw(c7731.89,4358.25) 7747.25,4342.88 ccw(c7762.62,4327.52) v5@7740.89,4327.52 ; v5@7731.89,4633.48 cw(c7731.89,4611.75) 7747.25,4627.12 cw(c7762.62,4642.48) v5@7740.89,4642.48 ; v5(7731.89,4642.48) 7751.58,4622.8 ; v5(7771.26,4327.52) 7790.95,4347.2 ; v5@7771.26,4336.52 ccw(c7771.26,4358.25) 7786.62,4342.88 ccw(c7801.99,4327.52) v5@7780.26,4327.52 ; v5@7810.63,4633.48 cw(c7810.63,4611.75) 7825.99,4627.12 cw(c7841.36,4642.48) v5@7819.63,4642.48 ; v5(7810.63,4642.48) 7830.32,4622.8 ; 7869.69,4622.8 v5(7889.37,4642.48) ; v5@7880.37,4642.48 cw(c7858.64,4642.48) 7874.01,4627.12 cw(c7889.37,4611.75) v5@7889.37,4633.48 ; 7909.06,4622.8 v5(7928.74,4642.48) ; v5@7919.74,4642.48 cw(c7898.01,4642.48) 7913.38,4627.12 cw(c7928.74,4611.75) v5@7928.74,4633.48 ; 7948.43,4504.69 v5(7968.11,4524.37) ; 7948.43,4622.8 v5(7968.11,4642.48) ; v5@7959.11,4524.37 cw(c7937.38,4524.37) 7952.75,4509.01 cw(c7968.11,4493.64) v5@7968.11,4515.37 ; v5@7959.11,4642.48 cw(c7937.38,4642.48) 7952.75,4627.12 cw(c7968.11,4611.75) v5@7968.11,4633.48 ; 7987.8,4347.2 v5(8007.48,4327.52) ; 7987.8,4622.8 v5(8007.48,4642.48) ; v5@7998.48,4327.52 ccw(c7976.75,4327.52) 7992.12,4342.88 ccw(c8007.48,4358.25) v5@8007.48,4336.52 ; v5@7998.48,4642.48 cw(c7976.75,4642.48) 7992.12,4627.12 cw(c8007.48,4611.75) v5@8007.48,4633.48
  MidLayer1 w4: 4838.82,3796.3 4879.25,3796.3 4898.67,3796.3 v3(4956.93,3796.3) ; 4838.82,3820.16 4879.25,3820.16 4898.67,3820.16 4958.86,3820.16 4963.62,3820.16 ccw(c4963.79,3853.29) 4981.44,3825.25 ; 4838.82,3835.67 4879.25,3835.67 4898.67,3835.67 v3(4956.93,3835.67) ; 4838.82,3914.41 4879.25,3914.41 4898.67,3914.41 v3(4956.93,3914.41) ; 4838.82,3929.92 4879.25,3929.92 4898.67,3929.92 4972.79,3929.92 ; 4838.82,3938.27 4879.25,3938.27 4898.67,3938.27 4958.86,3938.27 4972.79,3938.27 ccw(c4972.79,3952.32) 4982.72,3942.39 ; 4838.82,4111.26 4879.25,4111.26 4898.67,4111.26 v3(4956.93,4111.26) ; v3@4951.63,3909.11 ccw(c4938.82,3896.3) 4938.82,3914.41 ccw(c4938.82,3932.52) v3@4951.63,3919.71 ; v3@4951.74,3791.11 ccw(c4939.2,3778.57) 4939.2,3796.3 ccw(c4939.2,3814.03) v3@4951.74,3801.49 ; v3@4951.74,3830.48 ccw(c4939.2,3817.94) 4939.2,3835.67 ccw(c4939.2,3853.4) v3@4951.74,3840.86 ; v3@4951.74,3909.22 ccw(c4939.2,3896.68) 4939.2,3914.41 ccw(c4939.2,3932.14) v3@4951.74,3919.6 ; v3@4951.74,4106.07 ccw(c4939.2,4093.53) 4939.2,4111.26 ccw(c4939.2,4128.99) v3@4951.74,4116.45 ; 4958.86,3929.92 4972.79,3929.92 ; v3@4988.83,3954.43 cw(c4970.79,3956.01) 4982.43,3942.14 cw(c4994.07,3928.27) v3@4995.65,3946.31 ; v3@4988.91,3836.97 cw(c4971.08,3840.12) 4981.47,3825.28 cw(c4991.85,3810.45) v3@4995,3828.28 ; v3@4991.11,4628.26 ccw(c4978.57,4640.8) 4996.3,4640.8 ccw(c5014.03,4640.8) v3@5001.49,4628.26 ; v3(4996.3,4623.07) 4996.3,4681.33 4996.3,4700.75 4996.3,4741.18 ; v3@5028.2,3954.43 cw(c5010.16,3956.01) 5021.8,3942.14 ; v3@5035.02,3946.31 ccw(c5033.44,3928.27) 5021.8,3942.14 ; 5217.01,4741.18 5217.01,4700.75 5217.01,4681.33 5217.01,4621.14 5217.01,4607.21 ccw(c5231.06,4607.21) 5221.13,4597.28 ; v3@5225.05,4584.35 ccw(c5207.01,4585.93) 5220.88,4597.57 ccw(c5234.75,4609.21) v3@5233.17,4591.17 ; v3@5227.22,3751.63 cw(c5214.41,3738.82) 5232.52,3738.82 cw(c5250.63,3738.82) v3@5237.82,3751.63 ; v3@5227.22,4628.37 ccw(c5214.41,4641.18) 5232.52,4641.18 ccw(c5250.63,4641.18) v3@5237.82,4628.37 ; v3@5227.33,3751.74 cw(c5214.79,3739.2) 5232.52,3739.2 cw(c5250.25,3739.2) v3@5237.71,3751.74 ; v3@5227.33,4628.26 ccw(c5214.79,4640.8) 5232.52,4640.8 ccw(c5250.25,4640.8) v3@5237.71,4628.26 ; 5232.52,3638.82 5232.52,3679.25 v3(5232.52,3756.93) ; v3(5232.52,4623.07) 5232.52,4700.75 5232.52,4741.18 ; 5248.03,4621.14 5248.03,4607.21 ; 5248.03,4741.18 5248.03,4700.75 5248.03,4681.33 5248.03,4607.21 ; v3@5264.42,4544.98 ccw(c5246.38,4546.56) 5260.25,4558.2 ; v3@5266.59,4628.37 ccw(c5253.78,4641.18) 5271.89,4641.18 ccw(c5290,4641.18) v3@5277.19,4628.37 ; v3@5266.7,4628.26 ccw(c5254.16,4640.8) 5271.89,4640.8 ccw(c5289.62,4640.8) v3@5277.08,4628.26 ; v3(5271.89,4623.07) 5271.89,4741.18 ; v3@5272.54,4551.8 cw(c5274.12,4569.84) 5260.25,4558.2 ; 5335.12,4741.18 5335.12,4700.75 5335.12,4681.33 5335.12,4621.14 5335.12,4607.21 ccw(c5349.17,4607.21) 5339.24,4597.28 ; v3@5343.16,4584.35 ccw(c5325.12,4585.93) 5338.99,4597.57 ccw(c5352.86,4609.21) v3@5351.28,4591.17 ; v3@5345.44,4628.26 ccw(c5332.9,4640.8) 5350.63,4640.8 ccw(c5368.36,4640.8) v3@5355.82,4628.26 ; v3(5350.63,4623.07) 5350.63,4681.33 5350.63,4700.75 5350.63,4741.18 ; v3@5428.72,3788.83 cw(c5427.14,3770.79) 5441.01,3782.43 cw(c5454.88,3794.07) v3@5436.84,3795.65 ; v3@5428.72,3828.2 cw(c5427.14,3810.16) 5441.01,3821.8 ; v3@5436.84,3835.02 ccw(c5454.88,3833.44) 5441.01,3821.8 ; 5440.76,3782.72 cw(c5430.83,3772.79) 5444.88,3772.79 5444.88,3758.86 5444.88,3698.67 5444.88,3679.25 5444.88,3638.82 ; 5453.23,3638.82 5453.23,3679.25 5453.23,3698.67 5453.23,3772.79 5453.23,3792.29 ccw(c5411.5,3792.29) 5441.01,3821.8 ; v3@5463.55,3751.74 cw(c5451.01,3739.2) 5468.74,3739.2 cw(c5486.47,3739.2) v3@5473.93,3751.74 ; 5468.74,3638.82 5468.74,3679.25 v3(5468.74,3756.93) ; v3@5502.81,3751.63 cw(c5490,3738.82) 5508.11,3738.82 cw(c5526.22,3738.82) v3@5513.41,3751.63 ; v3@5502.92,3751.74 cw(c5490.38,3739.2) 5508.11,3739.2 cw(c5525.84,3739.2) v3@5513.3,3751.74 ; v3@5507.46,3828.2 cw(c5505.88,3810.16) 5519.75,3821.8 ; 5508.11,3638.82 v3(5508.11,3756.93) ; v3@5515.58,3835.02 ccw(c5533.62,3833.44) 5519.75,3821.8 ; 5531.97,3638.82 5531.97,3679.25 5531.97,3698.67 5531.97,3772.79 ; 5531.97,3758.86 5531.97,3772.79 ; v3@5660.29,3751.63 cw(c5647.48,3738.82) 5665.59,3738.82 cw(c5683.7,3738.82) v3@5670.89,3751.63 ; v3@5660.4,3751.74 cw(c5647.86,3739.2) 5665.59,3739.2 cw(c5683.32,3739.2) v3@5670.78,3751.74 ; v3@5664.94,4551.8 ccw(c5663.36,4569.84) 5677.23,4558.2 ; 5665.59,3638.82 5665.59,3679.25 v3(5665.59,3756.93) ; v3@5673.06,4544.98 cw(c5691.1,4546.56) 5677.23,4558.2 ; 5689.45,4621.14 5689.45,4607.21 ; 5689.45,4741.18 5689.45,4700.75 5689.45,4681.33 5689.45,4607.21 ; v3@5699.77,4628.26 ccw(c5687.23,4640.8) 5704.96,4640.8 ccw(c5722.69,4640.8) v3@5710.15,4628.26 ; v3@5703.66,4551.72 ccw(c5700.51,4569.55) 5715.35,4559.16 ; v3(5704.96,4623.07) 5704.96,4700.75 5704.96,4741.18 ; v3@5712.35,4545.63 cw(c5730.18,4548.78) 5715.35,4559.16 ; 5728.82,4621.14 5728.82,4607.21 ; 5728.82,4741.18 5728.82,4700.75 5728.82,4681.33 5728.82,4607.21 ; v3@5739.14,4628.26 ccw(c5726.6,4640.8) 5744.33,4640.8 ccw(c5762.06,4640.8) v3@5749.52,4628.26 ; v3(5744.33,4623.07) 5744.33,4700.75 5744.33,4741.18 ; v3@5744.98,4025.05 cw(c5746.56,4007.01) 5758.2,4020.88 ; v3@5744.98,4064.42 cw(c5746.56,4046.38) 5758.2,4060.25 ; v3@5745.63,4512.35 ccw(c5748.78,4530.18) 5759.16,4515.35 ; v3@5751.72,4503.66 cw(c5769.55,4500.51) 5759.16,4515.35 ; v3@5751.8,4033.17 ccw(c5769.84,4034.75) 5758.2,4020.88 ; v3@5751.8,4072.54 ccw(c5769.84,4074.12) 5758.2,4060.25 ; v3@5778.51,3751.74 cw(c5765.97,3739.2) 5783.7,3739.2 cw(c5801.43,3739.2) v3@5788.89,3751.74 ; v3@5778.51,4628.26 ccw(c5765.97,4640.8) 5783.7,4640.8 ccw(c5801.43,4640.8) v3@5788.89,4628.26 ; 5783.7,3638.82 5783.7,3679.25 5783.7,3698.67 v3(5783.7,3756.93) ; v3(5783.7,4623.07) 5783.7,4681.33 5783.7,4700.75 5783.7,4741.18 ; 5783.79,4528.82 5807.21,4528.82 ; 5783.96,4528.82 ccw(c5783.96,4505.05) 5767.74,4522.43 5759.16,4515.35 ; v3@5784.35,3946.31 cw(c5785.93,3928.27) 5797.57,3942.14 cw(c5809.21,3956.01) v3@5791.17,3954.43 ; v3@5784.35,4064.42 cw(c5785.93,4046.38) 5797.57,4060.25 cw(c5809.21,4074.12) v3@5791.17,4072.54 ; v3@5784.35,4354.95 ccw(c5785.93,4372.99) 5797.57,4359.12 ccw(c5809.21,4345.25) v3@5791.17,4346.83 ; v3@5784.35,4433.69 ccw(c5785.93,4451.73) 5797.57,4437.86 ccw(c5809.21,4423.99) v3@5791.17,4425.57 ; v3@5784.35,4473.06 ccw(c5785.93,4491.1) 5797.57,4477.23 ccw(c5809.21,4463.36) v3@5791.17,4464.94 ; v3@5785,4551.72 ccw(c5788.15,4569.55) 5798.53,4554.72 ccw(c5808.92,4539.88) v3@5791.09,4543.03 ; 5797.28,3942.39 ccw(c5807.21,3952.32) 5807.21,3938.27 5821.14,3938.27 5881.33,3938.27 5900.75,3938.27 5941.18,3938.27 ; 5797.28,4060.5 ccw(c5807.21,4070.43) 5807.21,4056.38 5821.14,4056.38 5881.33,4056.38 5900.75,4056.38 5941.18,4056.38 ; 5797.28,4358.87 cw(c5807.21,4348.94) 5807.21,4362.99 5821.14,4362.99 5881.33,4362.99 5900.75,4362.99 5941.18,4362.99 ; 5797.28,4437.61 cw(c5807.21,4427.68) 5807.21,4441.73 5821.14,4441.73 5881.33,4441.73 5900.75,4441.73 5941.18,4441.73 ; 5797.28,4476.98 cw(c5807.21,4467.05) 5807.21,4481.1 5821.14,4481.1 5881.33,4481.1 5900.75,4481.1 5941.18,4481.1 ; 5798.56,4554.75 cw(c5816.21,4526.71) 5816.38,4559.84 5821.14,4559.84 5881.33,4559.84 5900.75,4559.84 5941.18,4559.84 ; 5821.14,4008.66 5807.21,4008.66 ; 5821.14,4048.03 5807.21,4048.03 ; 5821.14,4528.82 5807.21,4528.82 ; v3(5823.07,3953.78) 5881.33,3953.78 5900.75,3953.78 5941.18,3953.78 ; v3(5823.07,3993.15) 5881.33,3993.15 5900.75,3993.15 5941.18,3993.15 ; v3(5823.07,4111.26) 5881.33,4111.26 5900.75,4111.26 5941.18,4111.26 ; v3(5823.07,4544.33) 5881.33,4544.33 5900.75,4544.33 5941.18,4544.33 ; v3@5828.26,3948.59 cw(c5840.8,3936.05) 5840.8,3953.78 cw(c5840.8,3971.51) v3@5828.26,3958.97 ; v3@5828.26,3987.96 cw(c5840.8,3975.42) 5840.8,3993.15 cw(c5840.8,4010.88) v3@5828.26,3998.34 ; v3@5828.26,4106.07 cw(c5840.8,4093.53) 5840.8,4111.26 cw(c5840.8,4128.99) v3@5828.26,4116.45 ; v3@5828.26,4539.14 cw(c5840.8,4526.6) 5840.8,4544.33 cw(c5840.8,4562.06) v3@5828.26,4549.52 ; v3@5828.37,3948.48 cw(c5841.18,3935.67) 5841.18,3953.78 cw(c5841.18,3971.89) v3@5828.37,3959.08 ; 5941.18,4008.66 5900.75,4008.66 5881.33,4008.66 5807.21,4008.66 ; 5941.18,4048.03 5900.75,4048.03 5881.33,4048.03 5807.21,4048.03 ; 5941.18,4528.82 5900.75,4528.82 5881.33,4528.82 5807.21,4528.82 ; 6955.12,1510.67 6955.12,1511.73 6955.12,1596.1 cw(c6988.25,1596.27) 6960.21,1613.92 ; v3@6963.24,1627.48 cw(c6945.41,1624.33) 6960.24,1613.95 ; v3@6971.93,1621.39 ccw(c6975.08,1603.56) 6960.24,1613.95 ; v3@7048.07,1660.76 cw(c7044.92,1642.93) 7059.76,1653.32 ; v3@7056.76,1666.85 ccw(c7074.59,1663.7) 7059.76,1653.32 ; 7073.23,1511.73 7073.23,1531.15 7073.23,1605.27 7073.23,1628.52 ccw(c7049.46,1628.52) 7066.84,1644.74 7059.76,1653.32 ; 4938.82,3796.3 cw(c4938.82,3778.19) 4951.63,3791 ccw(c4938.82,3778.19) 4938.82,3796.3 ; 4938.82,3796.3 ccw(c4938.82,3814.41) 4951.63,3801.6 cw(c4938.82,3814.41) 4938.82,3796.3 ; 4938.82,3835.67 cw(c4938.82,3817.56) 4951.63,3830.37 ccw(c4938.82,3817.56) 4938.82,3835.67 ; 4938.82,3835.67 ccw(c4938.82,3853.78) 4951.63,3840.97 cw(c4938.82,3853.78) 4938.82,3835.67 ; 4938.82,4111.26 cw(c4938.82,4093.15) 4951.63,4105.96 ccw(c4938.82,4093.15) 4938.82,4111.26 ; 4938.82,4111.26 ccw(c4938.82,4129.37) 4951.63,4116.56 cw(c4938.82,4129.37) 4938.82,4111.26 ; 4972.79,3929.92 4992.29,3929.92 ccw(c4992.29,3971.65) 5021.8,3942.14 ; 4996.3,4641.18 cw(c4978.19,4641.18) 4991,4628.37 ccw(c4978.19,4641.18) 4996.3,4641.18 ; 4996.3,4641.18 ccw(c5014.41,4641.18) 5001.6,4628.37 cw(c5014.41,4641.18) 4996.3,4641.18 ; 5248.03,4607.21 5248.03,4587.71 ccw(c5289.76,4587.71) 5260.25,4558.2 ; 5350.63,4641.18 cw(c5332.52,4641.18) 5345.33,4628.37 ccw(c5332.52,4641.18) 5350.63,4641.18 ; 5350.63,4641.18 ccw(c5368.74,4641.18) 5355.93,4628.37 cw(c5368.74,4641.18) 5350.63,4641.18 ; 5468.74,3738.82 cw(c5486.85,3738.82) 5474.04,3751.63 ccw(c5486.85,3738.82) 5468.74,3738.82 ; 5468.74,3738.82 ccw(c5450.63,3738.82) 5463.44,3751.63 cw(c5450.63,3738.82) 5468.74,3738.82 ; 5519.75,3821.8 cw(c5490.24,3792.29) 5531.97,3792.29 5531.97,3772.79 ; 5677.23,4558.2 ccw(c5647.72,4587.71) 5689.45,4587.71 5689.45,4607.21 ; 5704.96,4641.18 cw(c5686.85,4641.18) 5699.66,4628.37 ccw(c5686.85,4641.18) 5704.96,4641.18 ; 5704.96,4641.18 ccw(c5723.07,4641.18) 5710.26,4628.37 cw(c5723.07,4641.18) 5704.96,4641.18 ; 5715.35,4559.16 5722.43,4567.74 ccw(c5705.05,4583.96) 5728.82,4583.96 5728.82,4607.21 ; 5744.33,4641.18 cw(c5726.22,4641.18) 5739.03,4628.37 ccw(c5726.22,4641.18) 5744.33,4641.18 ; 5744.33,4641.18 ccw(c5762.44,4641.18) 5749.63,4628.37 cw(c5762.44,4641.18) 5744.33,4641.18 ; 5758.2,4020.88 ccw(c5787.71,4050.39) 5787.71,4008.66 5807.21,4008.66 ; 5758.2,4060.25 ccw(c5787.71,4089.76) 5787.71,4048.03 5807.21,4048.03 ; 5783.7,3738.82 cw(c5801.81,3738.82) 5789,3751.63 ccw(c5801.81,3738.82) 5783.7,3738.82 ; 5783.7,3738.82 ccw(c5765.59,3738.82) 5778.4,3751.63 cw(c5765.59,3738.82) 5783.7,3738.82 ; 5783.7,4641.18 cw(c5765.59,4641.18) 5778.4,4628.37 ccw(c5765.59,4641.18) 5783.7,4641.18 ; 5783.7,4641.18 ccw(c5801.81,4641.18) 5789,4628.37 cw(c5801.81,4641.18) 5783.7,4641.18 ; 5841.18,3993.15 cw(c5841.18,4011.26) 5828.37,3998.45 ccw(c5841.18,4011.26) 5841.18,3993.15 ; 5841.18,3993.15 ccw(c5841.18,3975.04) 5828.37,3987.85 cw(c5841.18,3975.04) 5841.18,3993.15 ; 5841.18,4111.26 cw(c5841.18,4129.37) 5828.37,4116.56 ccw(c5841.18,4129.37) 5841.18,4111.26 ; 5841.18,4111.26 ccw(c5841.18,4093.15) 5828.37,4105.96 cw(c5841.18,4093.15) 5841.18,4111.26 ; 5841.18,4544.33 cw(c5841.18,4562.44) 5828.37,4549.63 ccw(c5841.18,4562.44) 5841.18,4544.33 ; 5841.18,4544.33 ccw(c5841.18,4526.22) 5828.37,4539.03 cw(c5841.18,4526.22) 5841.18,4544.33
  MidLayer2 w4: 4838.82,4095.75 4841.47,4095.75 4899.73,4095.75 4957.99,4095.75 4977.41,4095.75 5037.6,4095.75 5051.53,4095.75 ccw(c5051.53,4109.8) 5061.46,4099.87 ; 4838.82,4292.6 4841.47,4292.6 4899.73,4292.6 4957.99,4292.6 4977.41,4292.6 5051.53,4292.6 5071.03,4292.6 cw(c5071.03,4250.87) 5100.54,4280.38 ; v3@5067.57,4111.91 cw(c5049.53,4113.49) 5061.17,4099.62 cw(c5072.81,4085.75) v3@5074.39,4103.79 ; v3@5106.94,4268.09 ccw(c5088.9,4266.51) 5100.54,4280.38 ; v3@5113.76,4276.21 cw(c5112.18,4294.25) 5100.54,4280.38 ; 5138.27,3638.82 5138.27,3757.99 5138.27,3851.53 ; 5138.27,3837.6 5138.27,3851.53 ; 5142.39,3861.46 ccw(c5152.32,3851.53) 5138.27,3851.53 ; v3@5146.31,3874.39 cw(c5128.27,3872.81) 5142.14,3861.17 cw(c5156.01,3849.53) v3@5154.43,3867.57 ; 5326.77,3638.82 5326.77,3641.47 5326.77,3699.73 5326.77,3757.99 5326.77,3777.41 5326.77,3851.53 5326.77,3871.03 cw(c5368.5,3871.03) 5338.99,3900.54 ; v3@5343.16,3913.76 cw(c5325.12,3912.18) 5338.99,3900.54 ; v3@5351.28,3906.94 ccw(c5352.86,3888.9) 5338.99,3900.54 ; v3@5428.72,4473.06 ccw(c5427.14,4491.1) 5441.01,4479.46 ; v3@5436.84,4466.24 cw(c5454.88,4467.82) 5441.01,4479.46 ; 5453.23,4741.18 5453.23,4738.53 5453.23,4680.27 5453.23,4622.01 5453.23,4602.59 5453.23,4528.47 5453.23,4508.97 cw(c5411.5,4508.97) 5441.01,4479.46 ; v3@5507.46,4473.06 ccw(c5505.88,4491.1) 5519.75,4479.46 ; v3@5507.46,4512.43 ccw(c5505.88,4530.47) 5519.75,4518.83 ccw(c5533.62,4507.19) v3@5515.58,4505.61 ; v3@5515.58,4466.24 cw(c5533.62,4467.82) 5519.75,4479.46 ; 5519.5,4518.54 ccw(c5509.57,4528.47) 5523.62,4528.47 ; 5523.62,4542.4 5523.62,4528.47 ; 5523.62,4738.53 5523.62,4680.27 ; 5523.62,4741.18 5523.62,4680.27 ; 5531.97,4738.53 5531.97,4680.27 ; 5531.97,4741.18 5531.97,4680.27 ; v3@5546.83,4512.43 ccw(c5545.25,4530.47) 5559.12,4518.83 ccw(c5572.99,4507.19) v3@5554.95,4505.61 ; 5558.87,4518.54 ccw(c5548.94,4528.47) 5562.99,4528.47 ; 5562.99,4542.4 5562.99,4528.47 ; 5562.99,4741.18 5562.99,4622.01 5562.99,4528.47 ; v3@5586.2,3906.94 cw(c5584.62,3888.9) 5598.49,3900.54 ; v3@5594.32,3913.76 ccw(c5612.36,3912.18) 5598.49,3900.54 ; 5610.71,3638.82 5610.71,3699.73 ; 5610.71,3641.47 5610.71,3699.73 ; 6946.77,1510.67 6946.77,1590.47 6946.77,1609.89 6946.77,1684.01 6946.77,1703.51 cw(c6988.5,1703.51) 6958.99,1733.02 ; v3@6963.16,1746.24 cw(c6945.12,1744.66) 6958.99,1733.02 ; v3@6971.28,1739.42 ccw(c6972.86,1721.38) 6958.99,1733.02 ; v3@7088.09,1700.05 cw(c7086.51,1682.01) 7100.38,1693.65 cw(c7114.25,1705.29) v3@7096.21,1706.87 ; v3@7088.09,1739.42 cw(c7086.51,1721.38) 7100.38,1733.02 ; v3@7096.21,1746.24 ccw(c7114.25,1744.66) 7100.38,1733.02 ; 7100.13,1693.94 cw(c7090.2,1684.01) 7104.25,1684.01 7104.25,1590.47 ; 7112.6,1511.81 7112.6,1516 7112.6,1590.47 7112.6,1609.89 7112.6,1684.01 7112.6,1703.51 ccw(c7070.87,1703.51) 7100.38,1733.02 ; 5519.75,4479.46 ccw(c5490.24,4508.97) 5531.97,4508.97 5531.97,4528.47 5531.97,4602.59 5531.97,4622.01 5531.97,4680.27 ; 5523.62,4528.47 5523.62,4622.01 5523.62,4680.27 ; 5598.49,3900.54 cw(c5568.98,3871.03) 5610.71,3871.03 5610.71,3851.53 5610.71,3777.41 5610.71,3757.99 5610.71,3699.73
  Bottom Layer w4: v3@5468.09,4433.69 ccw(c5466.51,4451.73) 5480.38,4440.09 ccw(c5494.25,4428.45) v3@5476.21,4426.87 ; 5480.13,4439.8 ccw(c5470.2,4449.73) 5484.25,4449.73 5484.25,4463.66 5484.25,4523.85 5484.25,4543.27 5484.25,4601.53 5484.25,4659.79 5484.25,4718.05 5484.25,4741.18 ; v3@5626.87,4025.05 cw(c5628.45,4007.01) 5640.09,4020.88 cw(c5651.73,4034.75) v3@5633.69,4033.17 ; 5639.8,4021.13 ccw(c5649.73,4031.06) 5649.73,4017.01 5663.66,4017.01 5723.85,4017.01 5743.27,4017.01 5801.53,4017.01 5859.79,4017.01 5918.05,4017.01 5941.18,4017.01 ; v3@5664.29,3867.65 cw(c5661.14,3849.82) 5675.98,3860.21 ; v3@5666.89,4472.98 ccw(c5670.04,4490.81) 5680.42,4475.98 ccw(c5690.81,4461.14) v3@5672.98,4464.29 ; v3@5672.98,3873.74 ccw(c5690.81,3870.59) 5675.98,3860.21 ; 5680.39,4476.02 cw(c5695.18,4457.42) 5696.79,4481.14 ; 5696.84,4481.19 5704.96,4481.19 ccw(c5704.96,4504.96) 5728.73,4504.96 cw(c5744.33,4504.96) 5744.33,4520.56 ccw(c5744.33,4544.33) 5768.1,4544.33 cw(c5783.7,4544.33) 5783.7,4559.93 ccw(c5783.7,4583.7) 5807.47,4583.7 cw(c5823.07,4583.7) 5823.07,4599.3 5881.33,4599.3 5939.59,4599.3 5941.18,4599.3 ; 5768.1,3638.82 5768.1,3640.41 5768.1,3698.67 5768.1,3756.93 ccw(c5744.33,3756.93) 5744.33,3780.7 cw(c5744.33,3796.3) 5728.73,3796.3 ccw(c5704.96,3796.3) 5704.96,3820.07 cw(c5704.96,3835.67) 5689.36,3835.67 ccw(c5665.59,3835.67) 5682.4,3852.48 5675.98,3860.21 ; v3@5782.4,4591.09 ccw(c5779.25,4608.92) 5794.09,4598.53 ; v3@5791.09,4585 cw(c5808.92,4588.15) 5794.09,4598.53 ; 5807.47,4741.18 5807.47,4739.59 5807.47,4681.33 5807.47,4623.07 cw(c5783.7,4623.07) 5800.51,4606.26 5794.09,4598.53

## Polygon pours and split planes (outlines as drawn)
1V8 on Top Layer "Bottom Layer-No Net" (solid, remove dead copper, pour order 1002): 2567.37,1400 2070,1400 2070,2300 2074.45,2304.02 3120,2304.02 3120,1400
2V5 on Top Layer "Bottom Layer-No Net" (solid, remove dead copper, pour order 1001): 1482.37,1400 985,1400 985,2300 989.45,2304.02 2035,2304.02 2035,1400
3V3 on Top Layer "Bottom Layer-No Net" (solid, remove dead copper, pour order 1000): 397.37,1400 -100,1400 -100,2300 -95.55,2304.02 950,2304.02 950,1400
GND on Top Layer "TOP POLY POUR" (solid, remove dead copper, pour order 1012): 369 vertices, not listed, extent -923.8,-15.55 8603.76,6914.22
GND on MidLayer1 "Keep-Out Layer-No Net" (solid, remove dead copper, pour order 1013): 369 vertices, not listed, extent -923.8,-15.55 8603.76,6914.22
1V8 on MidLayer1 "Bottom Layer-No Net" (solid, remove dead copper, pour order 1005): 2567.37,1400 2070,1400 2070,2300 2074.45,2304.02 3120,2304.02 3120,1400
2V5 on MidLayer1 "Bottom Layer-No Net" (solid, remove dead copper, pour order 1004): 1482.37,1400 985,1400 985,2300 989.45,2304.02 2035,2304.02 2035,1400
3V3 on MidLayer1 "Bottom Layer-No Net" (solid, remove dead copper, pour order 1003): 397.37,1400 -100,1400 -100,2300 -95.55,2304.02 950,2304.02 950,1400
GND on MidLayer2 "Keep-Out Layer-No Net" (solid, remove dead copper, pour order 1014): 369 vertices, not listed, extent -923.8,-15.55 8603.76,6914.22
1V8 on MidLayer2 "Bottom Layer-No Net" (solid, remove dead copper, pour order 1008): 2567.37,1400 2070,1400 2070,2300 2074.45,2304.02 3120,2304.02 3120,1400
2V5 on MidLayer2 "Bottom Layer-No Net" (solid, remove dead copper, pour order 1007): 1482.37,1400 985,1400 985,2300 989.45,2304.02 2035,2304.02 2035,1400
3V3 on MidLayer2 "Bottom Layer-No Net" (solid, remove dead copper, pour order 1006): 397.37,1400 -100,1400 -100,2300 -95.55,2304.02 950,2304.02 950,1400
GND on Bottom Layer "Keep-Out Layer-No Net" (solid, remove dead copper, pour order 1015): 369 vertices, not listed, extent -923.8,-15.55 8603.76,6914.22
1V8 on Bottom Layer "Bottom Layer-No Net" (solid, remove dead copper, pour order 1011): 2567.37,1400 2070,1400 2070,2300 2074.45,2304.02 3120,2304.02 3120,1400
2V5 on Bottom Layer "Bottom Layer-No Net" (solid, remove dead copper, pour order 1010): 1482.37,1400 985,1400 985,2300 989.45,2304.02 2035,2304.02 2035,1400
3V3 on Bottom Layer "Bottom Layer-No Net" (solid, pour order 1009): 397.37,1400 -100,1400 -100,2300 -95.55,2304.02 950,2304.02 950,1400
no net on Top Overlay "PIN 1 Top Overlay" (solid, pour order 1000): 4805.67,4774.59 4774.78,4824.98 4755.28,4805.48
no net on Top Overlay "PIN 1 Top Overlay" (solid, pour order 1000): 5580.22,2305.48 5529.83,2274.59 5549.33,2255.09
no net on Top Overlay "PIN 1 Top Overlay" (solid, pour order 1000): 6660,2215 6629.11,2265.39 6609.61,2245.89
AGND on GND+SHIELD (split plane): 112 vertices, not listed, extent 1560.87,5202.44 2735.82,5930.69
1V8 on GND+SHIELD (split plane): 204 vertices, not listed, extent 892.53,1435.03 2995.52,3162.48
AGND on GND+SHIELD (split plane): 111 vertices, not listed, extent 114.84,5202.44 1289.74,5930.69
1V2 on GND+SHIELD (split plane): 1805 vertices, not listed, extent 955.03,1287.04 7734.36,5073.71
2V5 on GND+SHIELD (split plane): 381 vertices, not listed, extent 740.09,1255 4119.97,3444.28
AUGND on GND+SHIELD (split plane): 80 vertices, not listed, extent -424.96,2235.04 219.96,2999.96
AUGND on GND+SHIELD (split plane): 151 vertices, not listed, extent -521.1,3180.3 104.71,5764.7
GND on GND+SHIELD (split plane): 1764 vertices, not listed, extent -525.07,83.3 8583.66,6669.97
SHIELD on GND+SHIELD (split plane): 1852 vertices, not listed, extent -903.7,4.55 7675.65,6894.13
+B on P2 - 3V3+5V0 (split plane): 238 vertices, not listed, extent 6924.35,5223.81 7897.45,6444.96
GND on P2 - 3V3+5V0 (split plane): 1144 vertices, not listed, extent 4925.73,3725.73 5854.27,4654.27
2V5 on P2 - 3V3+5V0 (split plane): 556 vertices, not listed, extent 1720.39,1337.03 7560.95,3675.53
GND on P2 - 3V3+5V0 (split plane): 118 vertices, not listed, extent 6798.36,1653.36 7221.64,2076.64
3V3 on P2 - 3V3+5V0 (split plane): 2548 vertices, not listed, extent -503.71,4.55 8583.66,6444.96
5V0 on P2 - 3V3+5V0 (split plane): 3289 vertices, not listed, extent -903.7,4.55 8583.66,6894.13
AUGND on P2 - 3V3+5V0 (split plane): 68 vertices, not listed, extent 21.5,4.55 2460.2,495.06