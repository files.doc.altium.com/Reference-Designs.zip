# Altium PCB NB3000AL.PcbDoc (part 51 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
HOST_LED1.GREEN: R288.2 U30.K8 U31.5 | length 8464.3
  Top Layer w4: U31.5@3920,3372.64 v1@3967.45,3372.64 ; U31.5@3943.12,3372.64 ccw(c3943.12,3403.78) v1@3965.14,3381.76 ; U31.5@3949.31,3369.81 cw(c3956.14,3362.98) 3956.14,3372.64 cw(c3956.14,3382.3) U31.5@3949.31,3375.47 ; 3952.78,3372.64 ccw(c3952.78,3394.12) v1@3967.97,3378.93 ; 3954.72,3372.64 cw(c3954.72,3357.91) v1@3965.14,3368.32 ; v2(5806.36,1475.73) 5818,1487.37 5818,1615.82 5806.52,1627.3 5806.52,1684.3 ; 5806.52,1684.3 5806.52,1792.21 5856.31,1842 5975,1842 5986.87,1830.13 v2@6009.87,1830.13 ; v3(6970.63,1786.26) U30.K8@6990.32,1805.94 ; U30.K8@6982.97,1805.94 cw(c6965.25,1805.94) 6977.78,1793.41 cw(c6990.31,1780.88) U30.K8@6990.31,1798.6 ; 6983.43,1799.06 cw(c6970.63,1811.87) 6970.63,1793.76 ccw(c6970.63,1811.87) 6983.43,1799.06 ; 6983.43,1799.06 ccw(c6996.24,1786.26) 6978.13,1786.26 cw(c6996.24,1786.26) 6983.43,1799.06
  MidLayer1 w4: v1@3758.47,2880.76 ccw(c3742.26,2896.98) 3765.19,2896.98 ccw(c3788.13,2896.98) v1@3771.91,2880.76 ; v1@3761.3,2877.93 ccw(c3751.91,2887.32) 3765.19,2887.32 ccw(c3778.47,2887.32) v1@3769.08,2877.93 ; v1(3765.19,2874.04) 3765.19,3168.37 v1(3971.86,3375.04) ; v1@3962.36,3375.04 cw(c3939.42,3375.04) 3955.64,3358.82 cw(c3971.86,3342.61) v1@3971.86,3365.54 ; v1@3966.36,3375.04 cw(c3953.08,3375.04) 3962.47,3365.65 cw(c3971.86,3356.26) v1@3971.86,3369.54 ; v2@5979.06,2075.06 cw(c5962.31,2058.31) 5986,2058.31 cw(c6009.69,2058.31) v2@5992.94,2075.06 ; v2@5981.89,2077.89 cw(c5971.97,2067.97) 5986,2067.97 cw(c6000.03,2067.97) v2@5990.11,2077.89 ; v2(5986,2082) 5986,1959 6007.02,1937.98 6007.02,1882.98 6010,1880 v2(6010,1830) ; v2@6003.06,1836.94 ccw(c5986.31,1853.69) 6010,1853.69 ccw(c6033.69,1853.69) v2@6016.94,1836.94 ; v2@6005.89,1834.11 ccw(c5995.97,1844.03) 6010,1844.03 ccw(c6024.03,1844.03) v2@6014.11,1834.11 ; v2@6829.13,1355 cw(c6811.34,1337.21) 6836.49,1337.21 ; v2@6831.95,1357.83 cw(c6821,1346.87) 6836.49,1346.87 ; 6836.49,1339.29 cw(c6858.71,1339.29) v2@6843,1355 ; 6836.49,1348.95 cw(c6849.05,1348.95) v2@6840.17,1357.83 ; v2@6836.49,1357.51 6836.49,1332.7 6860.19,1309 6860.19,1220.06 6872.75,1207.5 6912.5,1207.5 v2(7000,1120) ; v2@6990.19,1120 ccw(c6966.5,1120) 6983.25,1136.75 ccw(c7000,1153.5) v2@7000,1129.81 ; v2@6994.19,1120 ccw(c6980.16,1120) 6990.08,1129.92 ccw(c7000,1139.84) v2@7000,1125.81
  MidLayer2 w4: v1@4225.14,2651.66 ccw(c4208.92,2635.44) 4208.92,2658.37 ccw(c4208.92,2681.31) v1@4225.14,2665.09 ; v1@4227.97,2654.49 ccw(c4218.58,2645.1) 4218.58,2658.37 ccw(c4218.58,2671.65) v1@4227.97,2662.26 ; v1(4231.86,2658.37) 4021.86,2658.37 4006.86,2643.37 4006.86,2491.71 4020.56,2478 4332.25,2478 4352.75,2457.5 4427.5,2457.5 4481.69,2511.69 4481.69,2513.92 4501.31,2533.54 4593.13,2533.54 4651.19,2591.6 4651.19,2601.19 4691.71,2641.71 4896.52,2641.71 4937.86,2600.37 5111.44,2600.37 5119.44,2608.37 5168.37,2608.37 5176.71,2616.71 5189.94,2616.71 5265.27,2541.37 5644.48,2541.37 5690.86,2495 5690.86,2209.4 5730.07,2170.19 5908.19,2170.19 5934,2196 v2(5970,2196) ; v2(5806.36,1475.73) 5816.17,1465.92 5830.32,1465.92 5835.97,1460.27 5932.24,1364 6176,1364 6211.19,1328.81 6267.82,1328.81 6555.42,1041.21 6948.58,1041.21 7000,1092.63 v2(7000,1120) ; v2@5963.06,2189.06 ccw(c5946.31,2172.31) 5946.31,2196 ccw(c5946.31,2219.69) v2@5963.06,2202.94 ; v2@5965.89,2191.89 ccw(c5955.97,2181.97) 5955.97,2196 ccw(c5955.97,2210.03) v2@5965.89,2200.11 ; v2(6836.06,1361.94) 6861.94,1361.94 6920,1420 6941.19,1420 6972,1450.81 v2(6972,1499) ; v2@6840.17,1357.83 cw(c6850.09,1347.91) 6850.09,1361.94 cw(c6850.09,1375.97) v2@6840.17,1366.05 ; v2@6843,1355 cw(c6859.75,1338.25) 6859.75,1361.94 cw(c6859.75,1385.62) v2@6843,1368.87 ; v2@6965.06,1492.06 cw(c6948.31,1475.31) 6972,1475.31 cw(c6995.69,1475.31) v2@6978.94,1492.06 ; v2@6967.89,1494.89 cw(c6957.97,1484.97) 6972,1484.97 cw(c6986.03,1484.97) v2@6976.11,1494.89 ; v2@6993.06,1113.06 cw(c6976.31,1096.31) 7000,1096.31 cw(c7023.69,1096.31) v2@7006.94,1113.06 ; v2@6995.89,1115.89 cw(c6985.97,1105.97) 7000,1105.97 cw(c7014.03,1105.97) v2@7004.11,1115.89
  Bottom Layer w4: v1(3765.19,2874.04) 3866.44,2874.04 3891.28,2849.21 3999.48,2849.21 4072.15,2776.54 4183.46,2776.54 4200,2760 4200,2690.23 v1(4231.86,2658.37) ; v1@3769.08,2870.15 cw(c3778.47,2860.76) 3778.47,2874.04 cw(c3778.47,2887.32) v1@3769.08,2877.93 ; v1@3771.91,2867.32 cw(c3788.13,2851.11) 3788.13,2874.04 cw(c3788.13,2896.98) v1@3771.91,2880.76 ; v1@4222.36,2658.37 ccw(c4199.42,2658.37) 4215.64,2674.59 ccw(c4231.86,2690.81) v1@4231.86,2667.87 ; v1@4226.36,2658.37 ccw(c4213.08,2658.37) 4222.47,2667.76 ccw(c4231.86,2677.15) v1@4231.86,2663.87 ; R288.2@5906.18,2135 5959,2135 5970,2146 ; v2@5963.06,2189.06 cw(c5946.31,2172.31) 5970,2172.31 cw(c5993.69,2172.31) v2@5976.94,2189.06 ; v2@5965.89,2191.89 cw(c5955.97,2181.97) 5970,2181.97 cw(c5984.03,2181.97) v2@5974.11,2191.89 ; v2(5970,2196) 5970,2146 ; v2@5979.06,2088.94 ccw(c5962.31,2105.69) 5986,2105.69 ccw(c6009.69,2105.69) v2@5992.94,2088.94 ; v2@5981.89,2086.11 ccw(c5971.97,2096.03) 5986,2096.03 ccw(c6000.03,2096.03) v2@5990.11,2086.11 ; v2(5986,2082) 5986,2130 5970,2146 ; 6960.21,1771.4 ccw(c6988.25,1753.75) 6955.12,1753.58 6955.12,1669.21 6955.12,1515.88 v2(6972,1499) ; v2@6962.19,1499 ccw(c6938.5,1499) 6955.25,1515.75 ccw(c6972,1532.5) v2@6972,1508.81 ; v3@6963.24,1784.96 cw(c6945.41,1781.81) 6960.24,1771.43 cw(c6975.08,1761.04) v3@6971.93,1778.87 ; v2@6966.19,1499 ccw(c6952.16,1499) 6962.08,1508.92 ccw(c6972,1518.84) v2@6972,1504.81
HOST_LED1.RED: R289.2 U30.F5 U31.1 | length 5438.4
  Top Layer w4: U31.1@3917.17,3477.83 ccw(c3910.34,3484.66) 3920,3484.66 ccw(c3929.66,3484.66) U31.1@3922.83,3477.83 ; U31.1@3920,3475 3920,3511.9 3906.86,3525.04 3885,3525.04 3860,3525 3845,3510 3845,3430 3856.52,3418.48 3856.52,2942.04 3925.43,2873.13 3925.43,2824.41 4280,2469.84 v2(4280,2345) ; v2@4273.06,2351.94 ccw(c4256.31,2368.69) 4280,2368.69 ccw(c4303.69,2368.69) v2@4286.94,2351.94 ; v2@4275.89,2349.11 ccw(c4265.97,2359.03) 4280,2359.03 ccw(c4294.03,2359.03) v2@4284.11,2349.11 ; v3(6852.52,1983.11) U30.F5@6872.2,1963.43 ; U30.F5@6864.86,1963.42 ccw(c6847.14,1963.42) 6859.67,1975.96 ccw(c6872.2,1988.49) U30.F5@6872.2,1970.77 ; 6865.32,1970.31 cw(c6878.13,1983.11) 6860.02,1983.11 ccw(c6878.13,1983.11) 6865.32,1970.31 ; 6865.32,1970.31 ccw(c6852.52,1957.5) 6852.52,1975.61 cw(c6852.52,1957.5) 6865.32,1970.31
  MidLayer1 w4: v1@4545,2335.5 cw(c4545,2312.56) 4561.22,2328.78 cw(c4577.43,2345) v1@4554.5,2345 ; v1@4545,2339.5 cw(c4545,2326.22) 4554.39,2335.61 cw(c4563.78,2345) v1@4550.5,2345 ; v1(4545,2345) 4570,2320 v1(4570,2120) ; v1@4563.28,2126.72 ccw(c4547.06,2142.93) 4570,2142.93 ccw(c4592.93,2142.93) v1@4576.72,2126.72 ; v1@4566.11,2123.89 ccw(c4556.72,2133.28) 4570,2133.28 ccw(c4583.28,2133.28) v1@4573.89,2123.89
  MidLayer2 w4: v2(4280,2345) 4316.63,2345 4330,2358.37 4531.63,2358.37 v1(4545,2345) 4558.37,2358.37 4881.86,2358.37 4891.02,2349.21 4916.11,2349.21 4926.36,2359.46 4926.36,2521.11 4955.25,2550 4972.37,2550 4981,2541.37 5215,2541.37 5239.67,2516.71 5571.54,2516.71 5666.86,2421.39 5666.86,2199.46 5720.12,2146.19 5972.31,2146.19 6012.5,2106 6012.5,2077.75 6022.75,2067.5 6037.5,2067.5 6072.81,2102.81 6198.69,2102.81 6209,2092.5 6240.75,2092.5 6252.68,2104.43 6259.31,2111.06 6393.94,2111.06 6409.69,2095.31 6409.69,2092.79 6467.94,2034.54 6560.21,2034.54 6598.19,1996.56 6598.19,1980.62 6608.81,1970 6637.05,1970 6665.67,1998.62 6735.47,1998.62 6829.01,1998.62 cw(c6829.01,1984.57) 6838.94,1994.5 ; v2@4284.11,2340.89 cw(c4294.03,2330.97) 4294.03,2345 cw(c4294.03,2359.03) v2@4284.11,2349.11 ; v2@4286.94,2338.06 cw(c4303.69,2321.31) 4303.69,2345 cw(c4303.69,2368.69) v2@4286.94,2351.94 ; v3@6845.05,1982.46 ccw(c6827.01,1980.88) 6838.65,1994.75 ccw(c6850.29,2008.62) v3@6851.87,1990.58
  Bottom Layer w4: R289.2@4562.17,2084.14 cw(c4598.43,2084.14) v1@4575.9,2112.56 ; R289.2@4562.17,2085 4562.17,2112.17 v1(4570,2120) ; R289.2@4562.17,2092.41 cw(c4591.87,2092.41) v1@4573.42,2115.69 ; 4562.17,2100.69 cw(c4585.31,2100.69) v1@4570.93,2118.82 ; 4562.17,2108.96 cw(c4578.75,2108.96) v1@4568.45,2121.96
HOST_LED2.BLUE: R284.2 U30.B1 U31.11 | length 4868.8
  Top Layer w4: U31.11@4138.5,3398.23 4171.77,3398.23 ; v1@4141.81,2740.09 ccw(c4125.59,2756.31) 4148.52,2756.31 ccw(c4171.46,2756.31) v1@4155.24,2740.09 ; v1@4144.64,2737.26 ccw(c4135.25,2746.65) 4148.52,2746.65 ccw(c4161.8,2746.65) v1@4152.41,2737.26 ; v1(4148.52,2733.37) 4148.52,3033.33 4131.86,3050 4131.86,3080 4181.86,3130 4181.86,3388.14 4171.77,3398.23 ; U31.11@4167.56,3395.16 cw(c4171.18,3390.85) 4175.17,3394.83 ; U31.11@4168.48,3396.29 cw(c4171.77,3394.47) 4171.77,3398.23 ; U31.11@4168.48,3400.17 ccw(c4171.77,3401.99) 4171.77,3398.23 ; 4172.08,3397.92 ccw(c4168.36,3394.2) 4164.98,3398.23 cw(c4164.98,3381.84) 4176.57,3393.43 ; v2@6631.09,2120.91 6695.04,2120.91 U30.B1@6714.72,2120.91 ; v2@6634.73,2117.27 cw(c6643.52,2108.48) 6643.52,2120.91 ; v2@6634.73,2125.48 ccw(c6645.79,2136.54) 6645.79,2120.91 ; v2@6637.56,2114.44 cw(c6653.18,2098.82) 6653.18,2120.91 ; v2@6637.56,2128.31 ccw(c6655.44,2146.19) 6655.44,2120.91 ; U30.B1@6709.53,2115.71 ccw(c6697,2103.18) 6697,2120.91 ccw(c6697,2138.63) U30.B1@6709.53,2126.1
  MidLayer1 w4: v1(5565.19,2583.37) 5598.52,2583.37 5623.52,2558.37 5623.52,2475.04 5665.19,2433.37 5665.19,2176.12 5691.27,2150.04 5870,2150.04 ; v1@5569.08,2579.49 cw(c5578.47,2570.1) 5578.47,2583.37 cw(c5578.47,2596.65) v1@5569.08,2587.26 ; v1@5571.91,2576.66 cw(c5588.13,2560.44) 5588.13,2583.37 cw(c5588.13,2606.31) v1@5571.91,2590.09 ; v1(5835,1915) 5835,1927.93 5840,1932.93 5840,2033.69 5870,2063.69 5870,2150.04 ; v1@6023.28,2091.72 ccw(c6007.06,2107.93) 6030,2107.93 ccw(c6052.93,2107.93) v1@6036.72,2091.72 ; v1@6026.11,2088.89 ccw(c6016.72,2098.28) 6030,2098.28 ccw(c6043.28,2098.28) v1@6033.89,2088.89 ; v1(6030,2085) 6030,2125 6008.81,2146.19 5949.37,2146.19 5945.52,2150.04 5870,2150.04
  MidLayer2 w4: v1(4148.52,2733.37) 4191.67,2733.37 4232.54,2692.5 4837.98,2692.5 4914.52,2769.04 5112.19,2769.04 5181.86,2699.37 5231.86,2699.37 5236.69,2704.21 5409.09,2704.21 ; v1@4152.41,2729.49 cw(c4161.8,2720.1) 4161.8,2733.37 cw(c4161.8,2746.65) v1@4152.41,2737.26 ; v1@4155.24,2726.66 cw(c4171.46,2710.44) 4171.46,2733.37 cw(c4171.46,2756.31) v1@4155.24,2740.09 ; 5409.11,2704.19 5492.12,2704.19 5565.19,2631.12 v1(5565.19,2583.37) ; v1@5558.47,2590.09 ccw(c5542.26,2606.31) 5565.19,2606.31 ccw(c5588.13,2606.31) v1@5571.91,2590.09 ; v1@5561.3,2587.26 ccw(c5551.91,2596.65) 5565.19,2596.65 ccw(c5578.47,2596.65) v1@5569.08,2587.26 ; v1(6030,2085) 6055.81,2110.81 6202,2110.81 6212.31,2100.5 6237.44,2100.5 6251.46,2114.52 6256,2119.06 6408.17,2119.06 v1(6427.19,2100.04) ; v1@6030,2090.5 ccw(c6030,2103.78) 6039.39,2094.39 ccw(c6048.78,2085) v1@6035.5,2085 ; v1@6030,2094.5 ccw(c6030,2117.43) 6046.22,2101.22 ccw(c6062.43,2085) v1@6039.5,2085 ; v1@6417.69,2100.04 ccw(c6394.76,2100.04) 6410.97,2116.26 ccw(c6427.19,2132.48) v1@6427.19,2109.54 ; v1@6421.69,2100.04 ccw(c6408.41,2100.04) 6417.8,2109.43 ccw(c6427.19,2118.82) v1@6427.19,2105.54
  Bottom Layer w4: v1(5835,1915) R284.2@5853.82,1915 ; v1@5842.64,1909.36 cw(c5853.82,1901.11) R284.2@5853.82,1915 ; v1@5842.64,1920.64 ccw(c5853.82,1928.89) R284.2@5853.82,1915 ; R284.2@5863.82,1905 R284.2@5853.82,1915 ; v1(6427.19,2100.04) 6566.23,2100.04 6587.56,2121.37 v2(6630.63,2121.37) ; v1@6431.08,2096.15 cw(c6440.47,2086.76) 6440.47,2100.04 cw(c6440.47,2113.32) v1@6431.08,2103.93 ; v1@6433.91,2093.32 cw(c6450.13,2077.11) 6450.13,2100.04 cw(c6450.13,2122.98) v1@6433.91,2106.76 ; v2@6623.69,2114.44 ccw(c6606.94,2097.69) 6606.94,2121.37 ccw(c6606.94,2145.06) v2@6623.69,2128.31 ; v2@6626.52,2117.27 ccw(c6616.6,2107.35) 6616.6,2121.37 ccw(c6616.6,2135.4) v2@6626.52,2125.48
HOST_LED2.GREEN: R285.2 U30.R9 U31.13 | length 6722.8
  Top Layer w4: v1@4089.81,2808.76 ccw(c4073.59,2824.98) 4096.52,2824.98 ccw(c4119.46,2824.98) v1@4103.24,2808.76 ; v1@4092.64,2805.93 ccw(c4083.25,2815.32) 4096.52,2815.32 ccw(c4109.8,2815.32) v1@4100.41,2805.93 ; v1(4096.52,2802.04) 4096.52,3273.48 3994.36,3375.64 3994.36,3423.96 4012.94,3442.54 4024.73,3442.54 4040.23,3458.04 4089.89,3458.04 4098.52,3449.41 U31.13@4138.5,3449.41 ; U31.13@4109.2,3446.58 ccw(c4102.37,3439.75) 4102.37,3449.41 ccw(c4102.37,3459.07) U31.13@4109.2,3452.24 ; 7045.19,1502.37 ccw(c7053.93,1502.37) v2@7052.33,1493.78 ; 7045.19,1507.19 ccw(c7054.83,1507.19) v2@7053.06,1497.71 ; 7045.19,1510.7 7045.19,1512 ; 7045.19,1512 ccw(c7055.73,1512) v2@7053.8,1501.65 ; v2(7052,1492) 7045.19,1498.81 7045.19,1512 ; 7042.22,1596.56 cw(c7035.04,1589.38) 7045.19,1589.38 ; 7042.22,1596.56 cw(c7035.04,1589.38) 7045.19,1589.38 ; 7042.22,1596.56 ccw(c7029.68,1584.03) 7029.68,1601.75 cw(c7029.68,1584.03) 7042.22,1596.56 ; 7042.22,1596.56 cw(c7054.75,1609.09) 7037.03,1609.09 ccw(c7054.75,1609.09) 7042.22,1596.56 ; 7045.19,1512 7045.19,1589.38
  MidLayer1 w4: v2@5806.06,2062.06 cw(c5789.31,2045.31) 5813,2045.31 cw(c5836.69,2045.31) v2@5819.94,2062.06 ; v2@5808.89,2064.89 cw(c5798.97,2054.97) 5813,2054.97 cw(c5827.03,2054.97) v2@5817.11,2064.89 ; v2@5812,2059.51 v2@5813,2060.51 ; v2(5813,2069) v2@5813,2060.51 ; v2@5814,2069 5819,2069 5819,2066.51 v2@5813,2060.51 ; v2@6148.04,1334.91 ccw(c6131.29,1351.66) 6154.97,1351.66 ccw(c6178.66,1351.66) v2@6161.91,1334.91 ; v2@6150.86,1332.08 ccw(c6140.94,1342) 6154.97,1342 ccw(c6169,1342) v2@6159.08,1332.08 ; v2(6154.97,1327.97) 6154.97,1393.84 6052.46,1496.35 6013.27,1496.35 5892.31,1617.32 5892.31,1617.69 5825,1685 5825,1858.52 5819.7,1863.81 5800.71,1882.81 5780.15,1882.81 5778.81,1884.15 5768.38,1894.58 5768.38,1909.33 5813,1953.96 5813,1965 v2@5813,2060.51 ; v2@7045.06,1485.06 cw(c7034.51,1474.51) 7049.43,1474.51 ; v2@7046.19,1314.24 ccw(c7024.39,1314.77) 7039.81,1330.19 ; 7049.43,1469.11 cw(c7066.98,1469.11) v2@7057.37,1483.79 ; 7049.43,1476.5 cw(c7062.14,1476.5) v2@7055.18,1487.14 ; v2@7050.19,1314.14 ccw(c7037.28,1314.46) 7046.41,1323.59 ccw(c7055.54,1332.72) v2@7055.86,1319.81 ; v2(7052,1492) 7049.43,1489.43 7049.43,1469.25 7040.19,1460 7040.19,1440.44 6998.47,1398.72 6998.47,1383.97 7039.81,1342.62 7039.81,1330.19 ; v2@7055.76,1323.81 cw(c7055.23,1345.61) 7039.81,1330.19 ; v2(7056,1314) 7039.81,1330.19
  MidLayer2 w4: v1(4480,2718) 4611.82,2718 4632.76,2738.95 4703.19,2809.37 4770.63,2809.37 4786.96,2793.04 5236.96,2793.04 5280,2750 5345,2750 5375,2780 5406.19,2780 5421.19,2795 5465,2795 5470,2800 5490,2800 5505,2785 5505,2745 5513.81,2736.19 5553.62,2736.19 5559.62,2730.19 5576.28,2730.19 5583.96,2737.87 5605.09,2737.87 5612.77,2730.19 5728.81,2730.19 5798.52,2660.47 5798.52,2518.54 5875,2442.06 v2(5875,2441) ; v1@4483.89,2714.11 cw(c4493.28,2704.72) 4493.28,2718 cw(c4493.28,2731.28) v1@4483.89,2721.89 ; v1@4486.72,2711.28 cw(c4502.93,2695.06) 4502.93,2718 cw(c4502.93,2740.93) v1@4486.72,2724.72 ; v2(5813,2069) v2@5814,2069 ; v2(6154.97,1327.97) 6183.21,1327.97 6190.37,1320.81 6264.5,1320.81 6552.11,1033.21 6951.89,1033.21 7076.43,1157.75 7076.43,1217.38 7072.81,1221 7072.81,1297.19 v2(7056,1314) ; v2@6159.08,1323.86 cw(c6169,1313.94) 6169,1327.97 cw(c6169,1342) v2@6159.08,1332.08 ; v2@6161.91,1321.04 cw(c6178.66,1304.29) 6178.66,1327.97 cw(c6178.66,1351.66) v2@6161.91,1334.91 ; v2@7056,1304.19 cw(c7056,1280.5) 7072.75,1297.25 cw(c7089.5,1314) v2@7065.81,1314 ; v2@7056,1308.19 cw(c7056,1294.16) 7065.92,1304.08 cw(c7075.84,1314) v2@7061.81,1314
  Bottom Layer w4: v1(4096.52,2802.04) 4113.48,2819 4324.69,2819 4369.15,2774.54 4424.02,2774.54 4480,2718.56 v1(4480,2718) ; v1@4096.52,2807.54 ccw(c4096.52,2820.82) 4105.91,2811.43 ccw(c4115.3,2802.04) v1@4102.02,2802.04 ; v1@4096.52,2811.54 ccw(c4096.52,2834.48) 4112.74,2818.26 ccw(c4128.96,2802.04) v1@4106.02,2802.04 ; v2@5806.06,2075.94 ccw(c5789.31,2092.69) 5813,2092.69 ccw(c5836.69,2092.69) v2@5819.94,2075.94 ; v2@5808.89,2073.11 ccw(c5798.97,2083.03) 5813,2083.03 ccw(c5827.03,2083.03) v2@5817.11,2073.11 ; v2(5813,2069) 5813,2159.93 5863.82,2210.74 R285.2@5863.82,2285 ; R285.2@5863.82,2294.35 R285.2@5863.82,2285 ; v2@5868.06,2434.06 cw(c5852.87,2418.87) 5874.36,2418.87 ; v2@5870.89,2436.89 cw(c5862.52,2428.52) 5874.36,2428.52 ; 5874.36,2415.76 cw(c5900.24,2415.76) v2@5881.94,2434.06 ; 5874.36,2425.42 cw(c5890.58,2425.42) v2@5879.11,2436.89 ; v2@5875,2433.69 v2(5875,2441) 5874.36,2440.36 5874.36,2351.13 5864.36,2341.13 5864.36,2285.54 R285.2@5863.82,2285
HOST_LED2.RED: R286.2 U30.C2 U31.9 | length 4084.8
  Top Layer w4: v1(4090.19,3333.37) 4103.86,3347.05 ; U31.9@4108.86,3344.6 ccw(c4103.86,3340.73) 4103.86,3347.05 ; U31.9@4108.86,3349.5 cw(c4103.86,3353.37) 4103.86,3347.05 ; U31.9@4140.19,3347.05 U31.9@4138.5,3347.05 4103.86,3347.05 ; v2(6644,2096) 6644,2096.76 v2@6644.62,2097.38 ; v2@6644.96,2097.04 v2@6644.62,2097.38 ; v2@6648.11,2091.89 cw(c6661.36,2078.64) 6661.36,2097.38 ; v2@6650.94,2089.06 cw(c6671.01,2068.99) 6671.01,2097.38 ; v2@6650.94,2102.94 ccw(c6664.36,2116.36) 6664.36,2097.38 ; v2@6644.62,2097.38 6734.05,2097.38 6734.38,2097.04 ; 6734.38,2097.04 cw(c6734.38,2086.89) 6741.56,2094.07 ; 6734.38,2097.04 cw(c6734.38,2086.89) 6741.56,2094.07 ; 6741.56,2094.07 cw(c6729.03,2081.53) 6746.75,2081.53 ccw(c6729.03,2081.53) 6741.56,2094.07 ; 6741.56,2094.07 ccw(c6754.09,2106.6) 6754.09,2088.88 cw(c6754.09,2106.6) 6741.56,2094.07
  MidLayer1 w4: v1@5408.71,2891.41 cw(c5394.8,2876.51) 5415.19,2876.51 ; v1@5411.44,2894.34 cw(c5403.38,2885.71) 5415.19,2885.71 cw(c5427,2885.71) v1@5418.94,2894.34 ; v1(5415.19,2898.36) 5415.19,2876.5 ; v1@5421.67,2891.41 ccw(c5435.58,2876.51) 5415.19,2876.51 ; v1@5422.36,2775.04 ccw(c5399.42,2775.04) 5415.64,2791.26 ccw(c5431.86,2807.48) v1@5431.86,2784.54 ; v1@5426.36,2775.04 ccw(c5413.08,2775.04) 5422.47,2784.43 ccw(c5431.86,2793.82) v1@5431.86,2780.54 ; v1(5431.86,2775.04) 5405.52,2801.37 5405.52,2866.84 5415.19,2876.5
  MidLayer2 w4: v1@5431.86,2765.54 cw(c5431.86,2742.61) 5448.07,2758.82 cw(c5464.29,2775.04) v1@5441.36,2775.04 ; v1@5431.86,2769.54 cw(c5431.86,2756.26) 5441.25,2765.65 cw(c5450.64,2775.04) v1@5437.36,2775.04 ; v1(5431.86,2775.04) 5450,2756.9 5450,2735 5456.81,2728.19 5550.31,2728.19 5556.31,2722.19 5579.59,2722.19 5587.28,2729.87 5601.77,2729.87 5611.27,2720.37 5727.31,2720.37 5790.52,2657.16 5790.52,2479.48 6078,2192 6252.81,2192 6274.62,2170.19 6289.38,2170.19 6310.69,2191.5 6416.01,2191.5 6511.51,2096 v2(6644,2096) ; v2@6637.06,2089.06 ccw(c6620.31,2072.31) 6620.31,2096 ccw(c6620.31,2119.69) v2@6637.06,2102.94 ; v2@6639.89,2091.89 ccw(c6629.97,2081.97) 6629.97,2096 ccw(c6629.97,2110.03) v2@6639.89,2100.11
  Bottom Layer w4: v1(4090.19,3333.37) 4076.19,3319.37 4076.19,3036.67 4124.32,2988.54 4359.4,2988.54 4361.9,2991.04 4418.48,2991.04 ; R286.2@4421.18,3028.12 4421.18,2993.74 4418.48,2991.04 ; v1(5415.19,2898.36) 5402.37,2885.54 5318.98,2885.54 5316.72,2887.8 5231.64,2887.8 5184.88,2841.04 5121.15,2841.04 5103.82,2858.37 5088.19,2858.37 5080.19,2850.37 5027,2850.37 5018.88,2858.5 4991.12,2858.5 4982.66,2850.04 4870.8,2850.04 4848.02,2872.81 4848.02,2875.54 4801.69,2921.87 4487.65,2921.87 4418.48,2991.04
HOST_RTC.CLKOE: U27.12 U30.C3 | length 7939.5
  Top Layer w4: v1@3733.47,4190.09 ccw(c3717.26,4206.31) 3740.19,4206.31 ccw(c3763.13,4206.31) v1@3746.91,4190.09 ; v1@3736.3,4187.26 ccw(c3726.91,4196.65) 3740.19,4196.65 ccw(c3753.47,4196.65) v1@3744.08,4187.26 ; v1(3740.19,4183.37) 3740.19,4300.78 3754.62,4315.21 3775,4335.59 U27.12@3817.2,4335.59 ; U27.12@3787.17,4332.13 ccw(c3778.82,4323.79) 3778.82,4335.59 ccw(c3778.83,4347.39) U27.12@3787.17,4339.05 ; v3(6773.78,2101.22) U30.C3@6793.46,2081.54 ; U30.C3@6786.12,2081.54 ccw(c6768.4,2081.54) 6780.93,2094.07 ccw(c6793.46,2106.6) U30.C3@6793.46,2088.88 ; 6786.58,2088.42 cw(c6799.39,2101.22) 6781.28,2101.22 ccw(c6799.39,2101.22) 6786.58,2088.42 ; 6786.58,2088.42 ccw(c6773.78,2075.61) 6773.78,2093.72 cw(c6773.78,2075.61) 6786.58,2088.42
  MidLayer1 w4: v1@3054.81,2828.43 ccw(c3038.59,2844.64) 3061.52,2844.64 ccw(c3084.46,2844.64) v1@3068.24,2828.43 ; v1@3057.64,2825.6 ccw(c3048.25,2834.99) 3061.52,2834.99 ccw(c3074.8,2834.99) v1@3065.41,2825.6 ; v1(3061.52,2821.71) 3061.52,2966.02 3456.86,3361.36 3456.86,3781 3525.9,3850.04 3698.52,3850.04 3740.19,3891.71 v1(3740.19,4183.37) ; v1@3733.47,4176.66 cw(c3717.26,4160.44) 3740.19,4160.44 cw(c3763.13,4160.44) v1@3746.91,4176.66 ; v1@3736.3,4179.49 cw(c3726.91,4170.1) 3740.19,4170.1 cw(c3753.47,4170.1) v1@3744.08,4179.49 ; v2@6598.19,2024 ccw(c6574.5,2024) 6591.25,2040.75 ccw(c6608,2057.5) v2@6608,2033.81 ; v2@6602.19,2024 ccw(c6588.16,2024) 6598.08,2033.92 ccw(c6608,2043.84) v2@6608,2029.81 ; v2(6608,2024) 6572,2060 6572,2096 6622,2146 6622,2196 6674,2248 6740.81,2248 6758.27,2230.54 6758.27,2218.27 6758.27,2133.9 ccw(c6791.4,2133.73) 6763.36,2116.08 ; v3@6766.39,2102.52 ccw(c6748.56,2105.67) 6763.39,2116.05 ; v3@6775.08,2108.61 cw(c6778.23,2126.44) 6763.39,2116.05
  MidLayer2 w4: v1(4478.86,2638.04) 4563,2638.04 4570,2631.04 4618.96,2631.04 v1(4620,2630) ; v1@4482.75,2634.15 cw(c4492.14,2624.76) 4492.14,2638.04 cw(c4492.14,2651.32) v1@4482.75,2641.93 ; v1@4485.57,2631.32 cw(c4501.79,2615.11) 4501.79,2638.04 cw(c4501.79,2660.98) v1@4485.57,2644.76 ; 4594.55,2631.04 cw(c4594.55,2604.55) v1@4613.28,2623.28 ; 4599.58,2631.04 ccw(c4599.58,2650.42) v1@4613.28,2636.72 ; 4604.21,2631.04 cw(c4604.21,2614.21) v1@4616.11,2626.11 ; v1@5582,1915.37 5688.85,1915.37 v1(5723.52,1950.04) ; v1@5585.89,1912.11 cw(c5593.76,1904.24) 5593.76,1915.37 ; v1@5585.89,1919.89 ccw(c5596.8,1930.8) 5596.8,1915.37 ; v1@5588.72,1909.28 cw(c5603.41,1894.59) 5603.41,1915.37 ; v1@5588.72,1922.72 ccw(c5606.46,1940.46) 5606.46,1915.37 ; v1@5714.02,1950.04 cw(c5691.09,1950.04) 5707.31,1933.82 cw(c5723.52,1917.61) v1@5723.52,1940.54 ; v1@5718.02,1950.04 cw(c5704.75,1950.04) 5714.14,1940.65 cw(c5723.52,1931.26) v1@5723.52,1944.54
  Bottom Layer w4: v1@3061.52,2812.21 cw(c3061.52,2789.27) 3077.74,2805.49 cw(c3093.96,2821.71) v1@3071.02,2821.71 ; v1@3061.52,2816.21 cw(c3061.52,2802.93) 3070.91,2812.32 cw(c3080.3,2821.71) v1@3067.02,2821.71 ; v1(3061.52,2821.71) 3091.52,2791.71 3290.19,2791.71 3310.81,2812.32 3310.81,2845.81 3399.37,2934.37 3925.63,2934.37 4075.46,2784.54 4103.77,2784.54 4130.23,2811 4321.37,2811 4365.83,2766.54 4420.71,2766.54 4462.5,2724.75 4462.5,2710.75 4478.86,2694.39 v1(4478.86,2638.04) ; v1@4472.14,2644.76 ccw(c4455.92,2660.98) 4478.86,2660.98 ccw(c4501.79,2660.98) v1@4485.57,2644.76 ; v1@4474.97,2641.93 ccw(c4465.58,2651.32) 4478.86,2651.32 ccw(c4492.14,2651.32) v1@4482.75,2641.93 ; v1(4620,2630) 4617.9,2630 4616.86,2631.04 4761.56,2631.04 4832.19,2560.41 4832.19,2049.18 4840,2041.37 5108.52,2041.37 5116.52,2033.37 5151.52,1998.37 5301.15,1998.37 5391.15,1908.37 5425.82,1873.71 5539.71,1873.71 v1(5582,1916) ; v1@4623.89,2626.11 cw(c4635.79,2614.21) 4635.79,2631.04 ; v1@4626.72,2623.28 cw(c4645.45,2604.55) 4645.45,2631.04 ; v1@4626.72,2636.72 ccw(c4640.42,2650.42) 4640.42,2631.04 ; v1@5572.5,1916 cw(c5549.56,1916) 5565.78,1899.78 cw(c5582,1883.56) v1@5582,1906.5 ; v1@5576.5,1916 cw(c5563.22,1916) 5572.61,1906.61 cw(c5582,1897.22) v1@5582,1910.5 ; v1(5723.52,1950.04) 5729.5,1956.01 5781.5,1956.01 5803.29,1977.81 6324.12,1977.81 6396.43,2050.11 6534.89,2050.11 6561,2024 v2(6608,2024) ; v1@5724.58,1948.98 cw(c5741.56,1932) 5741.56,1956.01 ; v1@5727.41,1946.15 cw(c5751.22,1922.35) 5751.22,1956.01 ; v1@5730.24,1943.32 cw(c5760.88,1912.69) 5760.88,1956.01 ; v2@6601.06,2017.06 ccw(c6584.31,2000.31) 6584.31,2024 ccw(c6584.31,2047.69) v2@6601.06,2030.94 ; v2@6603.89,2019.89 ccw(c6593.97,2009.97) 6593.97,2024 ccw(c6593.97,2038.03) v2@6603.89,2028.11
HOST_RTC.CLKOUT: U27.13 U30.K1 | length 7702
  Top Layer w4: v1@2907.69,3368.71 cw(c2884.76,3368.71) 2900.97,3352.49 cw(c2917.19,3336.27) v1@2917.19,3359.21 ; v1@2911.69,3368.71 cw(c2898.41,3368.71) 2907.8,3359.32 cw(c2917.19,3349.93) v1@2917.19,3363.21 ; v1(2917.19,3368.71) 2898.52,3350.04 2898.52,2850.04 2999.02,2749.54 3490.46,2749.54 3507.19,2732.81 3507.19,2383.71 v1(3469.52,2346.04) ; v1@3469.52,2351.54 ccw(c3469.52,2364.82) 3478.91,2355.43 ccw(c3488.3,2346.04) v1@3475.02,2346.04 ; v1@3469.52,2355.54 ccw(c3469.52,2378.48) 3485.74,2362.26 ccw(c3501.96,2346.04) v1@3479.02,2346.04 ; v1(3747.52,4340.37) 3755.52,4340.37 3773.52,4358.37 ; v1@3747.71,4341.86 ccw(c3749.78,4358.89) 3761.91,4346.76 ; v1@3748.19,4345.83 ccw(c3751.04,4369.24) 3767.72,4352.57 ; v1@3748.67,4349.81 ccw(c3752.3,4379.59) 3773.52,4358.37 ; 3782.42,4358.37 ccw(c3782.42,4368.46) U27.13@3789.96,4361.77 ; U27.13@3786.97,4364.42 cw(c3773.53,4376.34) 3773.53,4358.37 ; U27.13@3817.2,4361.18 3790.63,4361.17 3790.63,4358.37 3773.52,4358.37 ; v2(6624.69,1804.38) 6624.69,1805.31 v2@6624.06,1805.94 ; v2@6628.79,1800.27 cw(c6642.5,1786.57) 6642.5,1805.94 ; v2@6631.62,1797.44 cw(c6652.15,1776.91) 6652.15,1805.94 ; v2@6631.62,1811.32 ccw(c6644.59,1824.28) 6644.59,1805.94 ; U30.K1@6709.53,1800.75 ccw(c6697,1788.22) 6697,1805.94 ccw(c6697,1823.67) U30.K1@6709.53,1811.14 ; U30.K1@6714.72,1805.94 v2@6624.06,1805.94 ; v2@6624.06,1805.94 6622.81,1805.94 6622.87,1806 6624,1806 v2@6624.06,1805.94
  MidLayer1 w4: v1@2910.47,3375.43 ccw(c2894.26,3391.64) 2917.19,3391.64 ccw(c2940.13,3391.64) v1@2923.91,3375.43 ; v1@2913.3,3372.6 ccw(c2903.91,3381.99) 2917.19,3381.99 ccw(c2930.47,3381.99) v1@2921.08,3372.6 ; v1(2917.19,3368.71) 2917.19,3402.04 2940.19,3425.04 2940.19,3466.71 2931.86,3475.04 2931.86,3950.04 2948.52,3966.71 2998.52,3966.71 3015.19,3983.37 3015.19,4241.71 3031.86,4258.37 v1(3075.86,4258.37) ; v1@3069.14,4251.66 ccw(c3052.92,4235.44) 3052.92,4258.37 ccw(c3052.92,4281.31) v1@3069.14,4265.09 ; v1@3071.97,4254.49 ccw(c3062.58,4245.1) 3062.58,4258.37 ccw(c3062.58,4271.65) v1@3071.97,4262.26
  MidLayer2 w4: v1(3075.86,4258.37) 3098.52,4258.37 ; v1@3079.78,4254.52 cw(c3088.98,4245.47) 3088.98,4258.37 cw(c3088.98,4271.28) v1@3079.78,4262.23 ; v1@3082.63,4251.71 cw(c3098.52,4236.09) 3098.52,4258.37 ; v1@3082.63,4265.04 ccw(c3098.52,4280.66) 3098.52,4258.37 ; 3721.37,4341.71 cw(c3721.37,4314.22) v1@3740.81,4333.66 ; 3727.81,4341.71 ccw(c3727.81,4360.09) v1@3740.81,4347.09 ; 3731.03,4341.71 cw(c3731.03,4323.88) v1@3743.64,4336.49 ; v1(3747.52,4340.37) 3746.19,4341.71 3181.86,4341.71 3098.52,4258.37
  Bottom Layer w4: v1(3469.52,2346.04) 3515.19,2391.71 3515.4,2391.5 4335.05,2391.5 4406.52,2320.02 4406.52,2033.16 4422.98,2016.71 5099.25,2016.71 5141.58,1974.37 5290.86,1974.37 5415.52,1849.71 5748.92,1849.71 5759.43,1839.19 5795.69,1839.19 5798.69,1842.19 5890.69,1842.19 5928.69,1804.19 6020.69,1804.19 6033.21,1816.71 6081.86,1816.71 6106.86,1791.71 6349.27,1791.71 6375.38,1817.81 6518.62,1817.81 6520.62,1819.81 6535.38,1819.81 6565,1790.19 6594,1790.19 6608.19,1804.38 ; v1@3469.52,2351.54 ccw(c3469.52,2364.82) 3478.91,2355.43 ccw(c3488.3,2346.04) v1@3475.02,2346.04 ; v1@3469.52,2355.54 ccw(c3469.52,2378.48) 3485.74,2362.26 ccw(c3501.96,2346.04) v1@3479.02,2346.04 ; v2@6616.06,1799.69 ccw(c6608.19,1795.42) 6608.19,1804.38 ; v2@6616.06,1809.06 cw(c6608.19,1813.34) 6608.19,1804.38 ; v2@6622.38,1806.37 6622.81,1805.94 6622.87,1806 v2@6624,1806 ; 6608.19,1804.38 v2@6622.38,1804.38 ; v2@6622.38,1804.38 v2@6624,1806 ; v2@6622.38,1804.38 v2(6624.69,1804.38) 6624.69,1805.31 v2@6624,1806
HOST_RTC.CS_N: U27.6 U30.G5 | length 6131
  Top Layer w4: U27.6@3592.8,4258.82 3631.41,4258.82 3648.52,4241.71 3648.52,4186.73 3749.19,4086.06 3749.19,3998.34 3557.19,3806.34 3557.19,3470.33 3531.86,3445 3531.86,2450.04 v1(3673.52,2308.37) ; U27.6@3622.83,4255.36 cw(c3631.17,4247.01) 3631.17,4258.82 cw(c3631.18,4270.62) U27.6@3622.83,4262.28 ; v1@3664.02,2308.37 ccw(c3641.09,2308.37) 3657.31,2324.59 ccw(c3673.52,2340.81) v1@3673.52,2317.87 ; v1@3668.02,2308.37 ccw(c3654.75,2308.37) 3664.14,2317.76 ccw(c3673.52,2327.15) v1@3673.52,2313.87 ; v3(6852.52,1943.74) U30.G5@6872.2,1924.05 ; U30.G5@6864.86,1924.05 ccw(c6847.14,1924.05) 6859.67,1936.59 ccw(c6872.2,1949.12) U30.G5@6872.2,1931.4 ; 6865.32,1930.94 cw(c6878.13,1943.74) 6860.02,1943.74 ccw(c6878.13,1943.74) 6865.32,1930.94 ; 6865.32,1930.94 ccw(c6852.52,1918.13) 6852.52,1936.24 cw(c6852.52,1918.13) 6865.32,1930.94
  MidLayer2 w4: v1@3673.52,2298.87 cw(c3673.52,2275.94) 3689.74,2292.16 cw(c3705.96,2308.37) v1@3683.02,2308.37 ; v1@3673.52,2302.87 cw(c3673.52,2289.6) 3682.91,2298.99 cw(c3692.3,2308.37) v1@3679.02,2308.37 ; v1(3673.52,2308.37) 3707.19,2274.71 5001.84,2274.71 5057.53,2219.02 5132.88,2219.02 5210.19,2141.71 5366.9,2141.71 5456.02,2230.83 5456.02,2280.96 5466.28,2291.21 5467.68,2291.21 5468.17,2291.71 5534.29,2291.71 5575,2251 5575,2019.02 5644.02,1950 5698.73,1950 5716.28,1967.54 5730.77,1967.54 5750.3,1948.01 5773.11,1948.01 5784.43,1948.01 5784.81,1948.01 5789.8,1953 5791.34,1954.54 5812.4,1954.54 5818.86,1961 5982.06,1961 5995.31,1961 6176.25,1961 6202.88,1987.62 6256.11,1987.62 6274.68,2006.19 6385.28,2006.19 6388.29,2009.21 6429.89,2009.21 6432.61,2006.49 6453.99,2006.49 6460.31,2012.81 6529.34,2012.81 6556.15,1986 6574,1986 6598,1962 6624,1962 6626.75,1959.25 6735.47,1959.25 6829.01,1959.25 cw(c6829.01,1945.2) 6838.94,1955.13 ; v3@6845.05,1943.09 ccw(c6827.01,1941.51) 6838.65,1955.38 ccw(c6850.29,1969.25) v3@6851.87,1951.21
HOST_RTC.DIN: U27.9 U30.D1 | length 6904.2
  Top Layer w4: U27.9@3787.17,4255.36 ccw(c3778.83,4247.01) 3778.83,4258.82 ; U27.9@3787.17,4262.28 cw(c3778.82,4270.62) 3778.82,4258.82 ; U27.9@3817.2,4258.82 3778.82,4258.82 ; v1(4285,1615) 4303.2,1633.2 4303.2,1905.16 4313.46,1915.41 4313.46,1929.91 4282.52,1960.84 4282.52,2187.48 4140,2330 4140,2575.9 3832,2883.9 3832,3282.56 3581.19,3533.37 3581.19,3796.39 3773.52,3988.73 3773.52,4253.52 3778.82,4258.82 ; v1@4285,1620.5 ccw(c4285,1633.78) 4294.39,1624.39 ccw(c4303.78,1615) v1@4290.5,1615 ; v1@4285,1624.5 ccw(c4285,1647.43) 4301.22,1631.22 ccw(c4317.43,1615) v1@4294.5,1615 ; v1@5476.5,1552 ccw(c5453.56,1552) 5469.78,1568.22 ccw(c5486,1584.43) v1@5486,1561.5 ; v1@5480.5,1552 ccw(c5467.22,1552) 5476.61,1561.39 ccw(c5486,1570.78) v1@5486,1557.5 ; v1(5486,1552) 5468,1570 5468,1652.85 5552.19,1737.04 5725.1,1737.04 5747,1758.94 5747,1899.27 5762.19,1914.46 5762.19,1956.81 5756.31,1962.69 5756.31,1981.2 5780.02,2004.92 5781.5,2004.92 5804.95,2028.37 5843.86,2028.37 5845.52,2026.71 5845.52,1993.37 5847.19,1991.71 5948.52,1991.71 5965.19,2008.37 v1(5965.19,2033.37) ; v1@5958.47,2026.66 cw(c5942.26,2010.44) 5965.19,2010.44 cw(c5988.13,2010.44) v1@5971.91,2026.66 ; v1@5961.3,2029.49 cw(c5951.91,2020.1) 5965.19,2020.1 cw(c5978.47,2020.1) v1@5969.08,2029.49 ; v2(6634,2052) 6643.83,2042.16 U30.D1@6714.72,2042.17 ; U30.D1@6709.53,2036.97 ccw(c6697,2024.44) 6697,2042.16 ccw(c6697,2059.89) U30.D1@6709.53,2047.36
  Bottom Layer w4: v1(4285,1615) 4495,1615 4510,1600 4510,1450 4520,1440 4536.63,1440 4550,1453.37 4550,1578.69 4580.02,1608.71 4979.63,1608.71 5040.11,1669.19 5390,1669.19 5400,1659.19 5400,1595.25 5443.25,1552 v1(5486,1552) ; v1@4288.89,1611.11 cw(c4298.28,1601.72) 4298.28,1615 cw(c4298.28,1628.28) v1@4288.89,1618.89 ; v1@4291.72,1608.28 cw(c4307.93,1592.06) 4307.93,1615 cw(c4307.93,1637.93) v1@4291.72,1621.72 ; v1@5479.28,1545.28 ccw(c5463.06,1529.06) 5463.06,1552 ccw(c5463.06,1574.93) v1@5479.28,1558.72 ; v1@5482.11,1548.11 ccw(c5472.72,1538.72) 5472.72,1552 ccw(c5472.72,1565.28) v1@5482.11,1555.89 ; v1@5965.19,2023.87 cw(c5965.19,2000.94) 5981.41,2017.16 cw(c5997.63,2033.37) v1@5974.69,2033.37 ; v1@5965.19,2027.87 cw(c5965.19,2014.6) 5974.58,2023.99 cw(c5983.97,2033.37) v1@5970.69,2033.37 ; v1(5965.19,2033.37) 6012.75,1985.81 6320.81,1985.81 6393.11,2058.11 6538.2,2058.11 6551.31,2045 6605,2045 6612,2052 ; v2@6626.7,2045.44 ccw(c6612,2032.24) 6612,2052 ; v2@6626.7,2058.56 cw(c6612,2071.76) 6612,2052 ; v2@6629.68,2048.12 ccw(c6620.97,2040.3) 6620.97,2052 ccw(c6620.97,2063.7) v2@6629.68,2055.88 ; v2(6634,2052) 6612,2052
HOST_RTC.DOUT: U27.8 U30.K10 | length 7710.4
  Top Layer w4: U27.8@3786.55,4230.53 ccw(c3781.52,4227.19) 3781.52,4233.23 ; U27.8@3786.55,4235.93 cw(c3781.52,4239.26) 3781.52,4233.23 ; U27.8@3817.2,4233.23 3781.52,4233.23 ; 3840,3205 3840,3285.88 3589.19,3536.69 3589.19,3793.08 3781.52,3985.41 3781.52,4233.23 ; 3840.19,3205 3840.19,2887.02 4165.19,2562.02 v1(4165.19,2333.37) ; v1@4158.47,2340.09 ccw(c4142.26,2356.31) 4165.19,2356.31 ccw(c4188.13,2356.31) v1@4171.91,2340.09 ; v1@4161.3,2337.26 ccw(c4151.91,2346.65) 4165.19,2346.65 ccw(c4178.47,2346.65) v1@4169.08,2337.26 ; v2(6487,1691) 6480.86,1684.86 6480.86,1647.7 6485.7,1642.86 6508.95,1642.86 6527.14,1642.86 6536.19,1633.81 6536.19,1585 6536.19,1568 6531.5,1563.31 6531.5,1533.9 6540.5,1524.9 6540.5,1066.75 6570.56,1036.69 7097.91,1036.69 7131.01,1069.78 7138.9,1077.68 7138.9,1084.26 7138.9,1100 7138.9,1220 7138.9,1220.9 v2(7138,1220) ; U30.K10@7069.06,1798.6 cw(c7069.06,1780.88) 7081.59,1793.41 cw(c7094.12,1805.94) U30.K10@7076.4,1805.94 ; U30.K10@7069.06,1805.94 v3(7088.74,1786.26) ; v2@7131.06,1213.06 cw(c7112.14,1194.14) 7138.9,1194.14 ; v2@7133.89,1215.89 cw(c7121.8,1203.8) 7138.9,1203.8 ; 7138.9,1198.49 cw(c7159.51,1198.49) v2@7144.94,1213.06 ; 7138.9,1208.14 cw(c7149.86,1208.14) v2@7142.11,1215.89 ; 7075.94,1799.06 cw(c7063.13,1786.26) 7081.24,1786.26 ccw(c7063.13,1786.26) 7075.94,1799.06 ; 7075.94,1799.06 ccw(c7088.74,1811.87) 7088.74,1793.76 cw(c7088.74,1811.87) 7075.94,1799.06
  MidLayer1 w4: v1@6235.28,2041.28 cw(c6219.06,2025.06) 6242,2025.06 cw(c6264.93,2025.06) v1@6248.72,2041.28 ; v1@6238.11,2044.11 cw(c6228.72,2034.72) 6242,2034.72 cw(c6255.28,2034.72) v1@6245.89,2044.11 ; v1(6242,2048) 6242,2011.81 6484.19,1769.62 6484.19,1720.81 6487,1718 v2(6487,1691) ; v2@6480.06,1697.94 ccw(c6463.31,1714.69) 6487,1714.69 ccw(c6510.69,1714.69) v2@6493.94,1697.94 ; v2@6482.89,1695.11 ccw(c6472.97,1705.03) 6487,1705.03 ccw(c6501.03,1705.03) v2@6491.11,1695.11
  MidLayer2 w4: v1(4165.19,2333.37) v1@4166.44,2333.37 ; v1@4165.82,2334 v1@4166.44,2333.37 ; v1@4169.08,2329.49 cw(c4178.47,2320.1) 4178.47,2333.37 cw(c4178.47,2346.65) v1@4169.08,2337.26 ; v1@4171.91,2326.66 cw(c4188.13,2310.44) 4188.13,2333.37 cw(c4188.13,2356.31) v1@4171.91,2340.09 ; v1@6234.64,2042 ccw(c6222,2031.7) 6222,2048 ; v1@6234.64,2054 cw(c6222,2064.3) 6222,2048 ; v1@6237.74,2044.53 ccw(c6230.42,2038.56) 6230.42,2048 ccw(c6230.42,2057.44) v1@6237.74,2051.47 ; v1(6242,2048) 6222,2048 ; v1@4166.44,2333.37 4248.81,2333.37 4255,2327.19 4322.44,2327.19 4322.75,2327.5 4337.25,2327.5 4337.56,2327.19 5043.5,2327.19 5158.18,2441.87 5508.13,2441.87 5602.19,2347.81 5602.19,2252.81 5716.81,2138.19 5969,2138.19 6004.5,2102.69 6004.5,2074.44 6019.44,2059.5 6040.81,2059.5 6076.12,2094.81 6175.19,2094.81 6222,2048
  Bottom Layer w4: v3@7087.44,1778.87 cw(c7084.29,1761.04) 7099.13,1771.43 cw(c7113.96,1781.81) v3@7096.13,1784.96 ; 7099.16,1771.4 cw(c7071.12,1753.75) 7104.25,1753.58 7104.25,1513.44 7088.19,1497.38 7088.19,1485.38 7056.19,1453.38 7056.19,1438.62 7093.81,1401 7093.81,1364 7118.81,1339 7118.81,1265.62 7118.19,1265 7118.19,1239.81 v2(7138,1220) ; v2@7128.19,1220 ccw(c7104.5,1220) 7121.25,1236.75 ccw(c7138,1253.5) v2@7138,1229.81 ; v2@7132.19,1220 ccw(c7118.16,1220) 7128.08,1229.92 ccw(c7138,1239.84) v2@7138,1225.81
HOST_RTC.INT_N: R148.2 U27.5 U30.M12 | length 8844.5
  Top Layer w4: U27.5@3562.29,4281.5 ccw(c3556.52,4277.24) 3556.52,4284.41 ; U27.5@3562.29,4287.32 cw(c3556.52,4291.58) 3556.52,4284.41 ; U27.5@3622.83,4280.95 cw(c3631.17,4272.61) 3631.17,4284.41 cw(c3631.18,4296.22) U27.5@3622.83,4287.87 ; v1@3652.02,4312.37 cw(c3629.09,4312.37) 3645.31,4296.16 cw(c3661.52,4279.94) v1@3661.52,4302.87 ; v1@3656.02,4312.37 cw(c3642.75,4312.37) 3652.14,4302.99 cw(c3661.52,4293.6) v1@3661.52,4306.87 ; v1(3661.52,4312.37) 3633.56,4284.41 3556.52,4284.41 ; v1@3682.47,1343.32 ccw(c3666.26,1327.11) 3666.26,1350.04 ccw(c3666.26,1372.98) v1@3682.47,1356.76 ; v1@3685.3,1346.15 ccw(c3675.91,1336.76) 3675.91,1350.04 ccw(c3675.91,1363.32) v1@3685.3,1353.93 ; v1(3689.19,1350.04) 3419.96,1350.04 3400,1370 3400,1815 3418,1833 3476.69,1833 3495,1851.31 3495,2329.81 3515.19,2350 3515.19,4033.37 3548.52,4066.71 3590.19,4066.71 3615.19,4091.71 3615.19,4141.71 3548.52,4208.37 3548.52,4276.41 3556.52,4284.41 ; v1(3944.52,4329.37) 3956.18,4317.72 ; R148.2@3949.65,4302.14 ccw(c3934.34,4317.72) 3956.18,4317.72 ; R148.2@3952.45,4299.29 ccw(c3943.71,4308.18) 3956.18,4308.18 ccw(c3968.65,4308.18) R148.2@3959.91,4299.29 ; R148.2@3956.18,4295 3956.18,4317.72 ; R148.2@3962.71,4302.14 cw(c3978.02,4317.72) 3956.18,4317.72 ; U30.M12@7147.8,1719.86 cw(c7147.8,1702.14) 7160.33,1714.67 cw(c7172.86,1727.2) U30.M12@7155.14,1727.2 ; U30.M12@7147.8,1727.2 v3(7167.48,1707.52) ; 7154.68,1720.32 cw(c7141.87,1707.52) 7159.98,1707.52 ccw(c7141.87,1707.52) 7154.68,1720.32 ; 7154.68,1720.32 ccw(c7167.48,1733.13) 7167.48,1715.02 cw(c7167.48,1733.13) 7154.68,1720.32
  MidLayer2 w4: v1(3661.52,4312.37) 3927.52,4312.37 v1(3944.52,4329.37) ; v1@3665.41,4308.49 cw(c3674.8,4299.1) 3674.8,4312.37 cw(c3674.8,4325.65) v1@3665.41,4316.26 ; v1@3668.24,4305.66 cw(c3684.46,4289.44) 3684.46,4312.37 cw(c3684.46,4335.31) v1@3668.24,4319.09 ; v1@3935.02,4329.37 cw(c3912.09,4329.37) 3928.31,4313.16 cw(c3944.52,4296.94) v1@3944.52,4319.87 ; v1@3939.02,4329.37 cw(c3925.75,4329.37) 3935.14,4319.99 cw(c3944.52,4310.6) v1@3944.52,4323.87
  Bottom Layer w4: v1(3689.19,1350.04) 3706.19,1367.04 4761.88,1367.04 4856.92,1272 5003.31,1272 5014.69,1283.37 5475.9,1283.37 5632.27,1127 5765.6,1127 5778.92,1113.69 5783.6,1109 5794.5,1098.1 5845.6,1047 5979.56,1047 6075.86,950.71 6470.48,950.71 6494.82,975.04 7059.04,975.04 7176.19,1092.19 7176.19,1244.62 7138.19,1282.62 7138.19,1297.38 7154.43,1313.62 7154.43,1360.82 7136.19,1379.06 7136.19,1447.38 7196.81,1508 7242,1508 7269.99,1535.99 7269.99,1589.41 ccw(c7246.22,1589.41) 7246.22,1613.18 cw(c7246.22,1628.78) 7230.62,1628.78 ccw(c7206.85,1628.78) 7206.85,1652.55 cw(c7206.85,1668.15) 7191.25,1668.15 ccw(c7167.48,1668.15) 7184.29,1684.96 7177.87,1692.69 ; v1@3689.19,1355.54 ccw(c3689.19,1368.82) 3698.58,1359.43 ccw(c3707.97,1350.04) v1@3694.69,1350.04 ; v1@3689.19,1359.54 ccw(c3689.19,1382.48) 3705.41,1366.26 ccw(c3721.63,1350.04) v1@3698.69,1350.04 ; v3@7166.18,1700.13 cw(c7163.03,1682.3) 7177.87,1692.69 ; v3@7174.87,1706.22 ccw(c7192.7,1703.07) 7177.87,1692.69
HOST_RTC.SCLK: U27.10 U30.M6 | length 6232.1
  Top Layer w4: 3769.07,4270.59 cw(c3790.63,4249.03) U27.10@3790.63,4279.52 ; 3775.9,4277.42 cw(c3790.63,4262.69) U27.10@3790.63,4283.52 ; 3777.99,4279.51 cw(c3783.45,4274.05) U27.10@3787.84,4280.39 ; 3781.38,4282.89 cw(c3786.22,4278.05) U27.10@3790.12,4283.68 ; 3782.73,4284.25 cw(c3790.63,4276.35) U27.10@3790.63,4287.52 ; U27.10@3786.09,4286.24 cw(c3781.86,4287.94) 3781.86,4283.37 ; U27.10@3787.03,4281.1 ccw(c3781.86,4276.36) 3781.86,4283.37 ; U27.10@3817.2,4284.41 3823.52,4284.41 3823.52,4283.37 3817.2,4283.37 3781.86,4283.37 ; v1@4286.46,1922.66 ccw(c4263.52,1922.66) 4279.74,1938.88 ccw(c4295.96,1955.1) v1@4295.96,1932.16 ; v1@4290.46,1922.66 ccw(c4277.18,1922.66) 4286.57,1932.05 ccw(c4295.96,1941.44) v1@4295.96,1928.16 ; v1(4295.96,1922.66) 4274.52,1944.09 4274.52,2184.16 4132,2326.69 4132,2572.58 3824,2880.58 3824,3279.25 3573.19,3530.06 3573.19,3799.71 3765.19,3991.71 3765.19,4266.71 3781.86,4283.37 ; v3(6891.89,1707.52) U30.M6@6911.57,1727.2 ; U30.M6@6904.23,1727.2 cw(c6886.51,1727.2) 6899.04,1714.67 cw(c6911.57,1702.14) U30.M6@6911.57,1719.86 ; 6904.69,1720.32 cw(c6891.89,1733.13) 6891.89,1715.02 ccw(c6891.89,1733.13) 6904.69,1720.32 ; 6904.69,1720.32 ccw(c6917.5,1707.52) 6899.39,1707.52 cw(c6917.5,1707.52) 6904.69,1720.32
  MidLayer2 w4: v1(4295.96,1922.66) v1@4291.48,1927.14 ; v1@4295.96,1928.16 ccw(c4295.96,1941.44) 4305.34,1932.05 ccw(c4314.73,1922.66) v1@4301.46,1922.66 ; v1@4295.96,1932.16 ccw(c4295.96,1955.1) 4312.17,1938.88 ccw(c4328.39,1922.66) v1@4305.46,1922.66 ; 6876.1,1683.7 cw(c6890.14,1683.7) 6880.21,1693.63 ; 6876.2,1683.9 6876.2,1609.78 6876.03,1609.61 6876.03,1520 6850,1493.97 6850,1460.81 6837.38,1448.19 6796.19,1448.19 6770.19,1422.19 6729.31,1422.19 6722.69,1428.81 6311.19,1428.81 6307.12,1432.88 6256.62,1483.38 6214.19,1525.81 6196.69,1525.81 6191.69,1530.81 6168.31,1530.81 6163.31,1525.81 6056.69,1525.81 6040.69,1541.81 6019.31,1541.81 6002.54,1525.04 5893.46,1525.04 5876.96,1541.54 5751.6,1541.54 5739.56,1529.5 5624.94,1529.5 5533.92,1620.52 5470.63,1683.81 5011.44,1683.81 4722.44,1972.81 4346.1,1972.81 4300.43,1927.14 4295.96,1927.14 v1@4291.48,1927.14 ; v3@6884.42,1706.87 cw(c6866.38,1705.29) 6880.25,1693.65 cw(c6894.12,1682.01) v3@6892.54,1700.05 ; v1@4291.48,1927.14 4291.36,1927.26 v1@4291.48,1927.14
HOST_SD.CLK: J29.5 U30.N12 | length 1671.4
  Top Layer w4: U30.N12@7147.8,1680.49 cw(c7147.8,1662.77) 7160.33,1675.3 cw(c7172.86,1687.83) U30.N12@7155.14,1687.83 ; U30.N12@7147.8,1687.83 v3(7167.48,1668.15) ; 7154.68,1680.95 cw(c7141.87,1668.15) 7159.98,1668.15 ccw(c7141.87,1668.15) 7154.68,1680.95 ; 7154.68,1680.95 ccw(c7167.48,1693.76) 7167.48,1675.65 cw(c7167.48,1693.76) 7154.68,1680.95
  MidLayer1 w4: v1@7148.36,1398.42 ccw(c7132.95,1414.19) 7155,1414.19 ; v1@7151.16,1395.56 ccw(c7142.24,1404.68) 7155,1404.68 ccw(c7167.76,1404.69) v1@7158.84,1395.56 ; v1(7155,1391.62) 7155,1414.19 ; v1@7161.64,1398.42 cw(c7177.04,1414.19) 7155,1414.19 ; v3@7166.18,1660.76 cw(c7163.03,1642.93) 7177.87,1653.32 ; v3@7174.87,1666.85 ccw(c7192.7,1663.7) 7177.87,1653.32 ; 7191.34,1591.34 7191.34,1605.27 ; 7155,1414.19 7178.38,1437.57 7178.38,1471.38 7191.19,1484.19 7191.19,1511.58 7191.34,1511.73 7191.34,1531.15 7191.34,1605.27 ; 7177.87,1653.32 7184.95,1644.74 cw(c7167.57,1628.52) 7191.34,1628.52 7191.34,1605.27
  MidLayer2 w4: v1@6453.23,1404.77 cw(c6471.9,1386.1) 6471.9,1412.5 ; v1(6455,1403) 6464.5,1412.5 6705,1412.5 6714.5,1403 6759.5,1358 6814.81,1358 6828.69,1344.13 6855.44,1344.13 6895.31,1384 6946.18,1384 6961.97,1399.78 6982.65,1399.78 7030.43,1352 7047,1352 7055,1360 7075,1360 7085.95,1370.95 7134.32,1370.95 v1(7155,1391.62) ; v1@6456.06,1401.94 cw(c6481.56,1376.44) 6481.56,1412.5 ; v1@6458.89,1399.11 cw(c6491.21,1366.79) 6491.21,1412.5 ; v1@6461.72,1396.28 cw(c6500.87,1357.13) 6500.87,1412.5 ; v1@7145.5,1391.62 cw(c7122.56,1391.62) 7138.78,1375.41 cw(c7155,1359.19) v1@7155,1382.12 ; v1@7149.5,1391.62 cw(c7136.22,1391.62) 7145.61,1382.23 cw(c7155,1372.85) v1@7155,1386.12
  Bottom Layer w4: J29.5@6403.32,1404.65 6404.98,1403 v1(6455,1403) ; J29.5@6409.79,1410.67 ccw(c6427.42,1427.1) 6427.42,1403 ; J29.5@6412.4,1395.58 cw(c6430.32,1377.66) 6430.32,1403 ; J29.5@6412.71,1413.4 ccw(c6436.61,1435.66) 6436.61,1403 ; J29.5@6415.23,1392.75 cw(c6439.97,1368) 6439.97,1403 ; v1@6448.28,1396.28 ccw(c6432.06,1380.06) 6432.06,1403 ccw(c6432.06,1425.93) v1@6448.28,1409.72 ; v1@6451.11,1399.11 ccw(c6441.72,1389.72) 6441.72,1403 ccw(c6441.72,1416.28) v1@6451.11,1406.89
HOST_SD.CMD: J29.2 U30.R3 | length 433.4
  Top Layer w4: v2(6722,1478.6) 6754.6,1478.6 6777.96,1501.96 6777.96,1589.38 ; v2@6726.11,1474.49 cw(c6736.03,1464.57) 6736.03,1478.6 cw(c6736.03,1492.63) v2@6726.11,1482.71 ; v2@6728.94,1471.67 cw(c6745.69,1454.92) 6745.69,1478.6 cw(c6745.69,1502.29) v2@6728.94,1485.54 ; 6777.96,1589.38 cw(c6788.11,1589.38) 6780.93,1596.56 ; 6777.96,1589.38 cw(c6788.11,1589.38) 6780.93,1596.56 ; 6780.93,1596.56 cw(c6793.46,1584.03) 6793.46,1601.75 ccw(c6793.46,1584.03) 6780.93,1596.56 ; 6780.93,1596.56 ccw(c6768.4,1609.09) 6786.12,1609.09 cw(c6768.4,1609.09) 6780.93,1596.56
  Bottom Layer w4: J29.2@6698.99,1404.65 6698.99,1460.99 6716.6,1478.6 v2(6722,1478.6) ; J29.2@6698.99,1435.88 J29.2@6713.11,1450 ; 6703.05,1465.05 cw(c6721.75,1446.35) v2@6721.95,1472.79 ; 6709.07,1471.07 ccw(c6701.53,1478.6) v2@6712.19,1478.6 ; 6709.8,1471.8 cw(c6721.85,1459.75) v2@6721.99,1476.79
HOST_SD.DAT0: J29.7 U30.P3 | length 1408.6
  Top Layer w4: v3(6773.78,1628.78) U30.P3@6793.46,1648.46 ; U30.P3@6786.12,1648.46 cw(c6768.4,1648.46) 6780.93,1635.93 cw(c6793.46,1623.4) U30.P3@6793.46,1641.12 ; 6786.58,1641.58 cw(c6773.78,1654.39) 6773.78,1636.28 ccw(c6773.78,1654.39) 6786.58,1641.58 ; 6786.58,1641.58 ccw(c6799.39,1628.78) 6781.28,1628.78 cw(c6799.39,1628.78) 6786.58,1641.58
  MidLayer1 w4: v1(6574,1304) 6594,1324 6594,1367.69 6594,1419 6612.61,1437.61 6630,1455 6725,1455 6758.27,1488.27 6758.27,1505 6758.27,1511.73 6758.27,1596.1 cw(c6791.4,1596.27) 6763.36,1613.92 ; v1@6574,1309.5 ccw(c6574,1322.78) 6583.39,1313.39 ccw(c6592.78,1304) v1@6579.5,1304 ; v1@6574,1313.5 ccw(c6574,1336.43) 6590.22,1320.22 ccw(c6606.43,1304) v1@6583.5,1304 ; v3@6766.39,1627.48 cw(c6748.56,1624.33) 6763.39,1613.95 ; v3@6775.08,1621.39 ccw(c6778.23,1603.56) 6763.39,1613.95
  Bottom Layer w4: J29.7@6194.89,1363.54 cw(c6159.32,1327.98) 6209.62,1327.98 cw(c6259.92,1327.98) J29.7@6224.35,1363.54 ; J29.7@6197.72,1366.37 cw(c6168.98,1337.63) 6209.62,1337.63 cw(c6250.26,1337.63) J29.7@6221.53,1366.37 ; J29.7@6200.55,1369.2 cw(c6178.64,1347.29) 6209.62,1347.29 cw(c6240.61,1347.29) J29.7@6218.7,1369.2 ; J29.7@6209.62,1404.65 6209.62,1298.75 6225,1283.37 6336.19,1283.37 6352.62,1299.81 6396.37,1299.81 6438,1258.19 6466,1258.19 6491.19,1283.37 6553.86,1283.37 v1@6574,1303.52 ; 6557.44,1286.96 ccw(c6540.4,1304) v1@6564.5,1304 ; 6558.61,1288.12 cw(c6574,1272.73) v1@6574,1294.5 ; 6564.27,1293.79 ccw(c6554.06,1304) v1@6568.5,1304 ; 6565.43,1294.95 cw(c6574,1286.39) v1@6574,1298.5