# Altium PCB NB3000AL.PcbDoc (part 61 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetLED16_3: LED16.3 R165.1 | length 1225.2
  Top Layer w4: R165.1@-303.82,4603 -287.69,4586.87 -148.13,4586.87 -126.48,4608.52 v1(-126.48,4691.71) ; R165.1@-303.73,4597.19 cw(c-303.51,4583.91) R165.1@-294.12,4593.3 ; R165.1@-303.66,4593.19 cw(c-303.29,4570.78) -287.45,4586.63 ; R165.1@-298.5,4602.51 ccw(c-286.85,4602.51) R165.1@-295.09,4594.27 ; R165.1@-294.5,4602.51 ccw(c-273.19,4602.51) -288.26,4587.44 ; v1@-133.19,4684.99 cw(c-149.41,4668.77) -126.48,4668.77 cw(c-103.54,4668.77) v1@-119.76,4684.99 ; v1@-130.36,4687.82 cw(c-139.75,4678.43) -126.48,4678.43 cw(c-113.2,4678.43) v1@-122.59,4687.82 ; LED16.3@332.24,4821.55 cw(c315.61,4804.92) LED16.3@339.13,4804.92 ; LED16.3@335.07,4824.38 cw(c325.26,4814.57) LED16.3@339.13,4814.57 ; 339.13,4804.3 ccw(c356.58,4804.3) v1@347.18,4789.6 ; LED16.3@339.13,4811.61 ccw(c361.25,4811.61) v1@349.33,4792.97 ; LED16.3@339.13,4814.77 cw(c348.72,4814.77) LED16.3@341.94,4821.55 ; LED16.3@339.13,4818.91 ccw(c365.92,4818.91) v1@351.49,4796.34 ; v1(348.52,4791.71) 339.13,4801.1 339.13,4826.22 ccw(c370.59,4826.22) v1@353.64,4799.71
  Bottom Layer w4: v1(-126.48,4691.71) 306.86,4691.71 348.52,4733.37 v1(348.52,4791.71) ; v1@-122.59,4687.82 cw(c-113.2,4678.43) -113.2,4691.71 cw(c-113.2,4704.99) v1@-122.59,4695.6 ; v1@-119.76,4684.99 cw(c-103.54,4668.77) -103.54,4691.71 cw(c-103.54,4714.64) v1@-119.76,4698.43 ; v1@341.81,4784.99 cw(c325.59,4768.77) 348.52,4768.77 cw(c371.46,4768.77) v1@355.24,4784.99 ; v1@344.64,4787.82 cw(c335.25,4778.43) 348.52,4778.43 cw(c361.8,4778.43) v1@352.41,4787.82
NetLED16_4: LED16.4 R166.1 | length 962.9
  Top Layer w4: R166.1@-303.82,4659 -267.48,4659 ; R166.1@-300.06,4655.24 cw(c-290.98,4646.16) -290.98,4659 cw(c-290.98,4671.84) R166.1@-300.06,4662.76 ; R166.1@-297.23,4652.41 cw(c-281.32,4636.5) -281.32,4659 cw(c-281.32,4681.5) R166.1@-297.23,4665.59 ; -266.85,4658.37 v1(-251.48,4658.37) ; v1(100,4840) 100.12,4840.12 125.12,4840.12 139.01,4826.22 146.74,4818.5 LED16.4@240.6,4818.5 ; v1@103.89,4836.11 cw(c113.56,4826.44) 113.56,4840.12 ; v1@103.89,4843.89 ccw(c113,4853) 113,4840.12 ; v1@106.72,4833.28 cw(c123.21,4816.79) 123.21,4840.12 ; v1@106.72,4846.72 ccw(c122.66,4862.66) 122.66,4840.12
  Bottom Layer w4: v1@-258.19,4665.09 ccw(c-274.41,4681.31) -251.48,4681.31 ccw(c-228.54,4681.31) v1@-244.76,4665.09 ; v1@-255.36,4662.26 ccw(c-264.75,4671.65) -251.48,4671.65 ccw(c-238.2,4671.65) v1@-247.59,4662.26 ; v1(-251.48,4658.37) -251.48,4703.52 -220,4735 100,4735 125,4760 125,4815 v1(100,4840) ; v1@100,4830.5 cw(c100,4807.56) 116.22,4823.78 cw(c132.43,4840) v1@109.5,4840 ; v1@100,4834.5 cw(c100,4821.22) 109.39,4830.61 cw(c118.78,4840) v1@105.5,4840
NetLED17_1: LED17.1 R167.1 | length 620.3
  Top Layer w4: R167.1@-303.82,4547 -240,4547 -223.22,4563.78 LED17.1@241.49,4563.78 ; R167.1@-300.06,4543.24 cw(c-290.98,4534.16) -290.98,4547 cw(c-290.98,4559.84) R167.1@-300.06,4550.76 ; R167.1@-297.23,4540.41 cw(c-281.32,4524.5) -281.32,4547 cw(c-281.32,4569.5) R167.1@-297.23,4553.59 ; 217.56,4563.78 ccw(c217.56,4579.73) LED17.1@228.84,4568.45
NetLED17_3: LED17.3 R168.1 | length 991.6
  Top Layer w4: R168.1@-303.82,4435 -265,4435 -259.81,4440.19 ; R168.1@-300.06,4431.24 cw(c-290.98,4422.16) -290.98,4435 cw(c-290.98,4447.84) R168.1@-300.06,4438.76 ; R168.1@-297.23,4428.41 cw(c-281.32,4412.5) -281.32,4435 cw(c-281.32,4457.5) R168.1@-297.23,4441.59 ; v1@-265.24,4450.58 cw(c-272.46,4440.19) -259.81,4440.19 ; v1(-259.81,4458.37) -259.81,4440.19 ; v1@-254.38,4450.58 ccw(c-247.16,4440.19) -259.81,4440.19 ; LED17.3@339.13,4536.22 363.01,4536.22 ; LED17.3@351.79,4531.56 cw(c363.01,4520.38) 363.01,4536.22 ; v1(377.19,4533.37) 365.86,4533.37 363.01,4536.22
  MidLayer2 w4: v1(-259.81,4458.37) -168.14,4550.04 -80,4550.04 -50.04,4550 -50,4550.04 360.52,4550.04 v1(377.19,4533.37) ; v1@-259.81,4463.87 ccw(c-259.81,4477.15) -250.42,4467.76 ccw(c-241.03,4458.37) v1@-254.31,4458.37 ; v1@-259.81,4467.87 ccw(c-259.81,4490.81) -243.59,4474.59 ccw(c-227.37,4458.37) v1@-250.31,4458.37 ; v1@367.69,4533.37 ccw(c344.76,4533.37) 360.97,4549.59 ccw(c377.19,4565.81) v1@377.19,4542.87 ; v1@371.69,4533.37 ccw(c358.41,4533.37) 367.8,4542.76 ccw(c377.19,4552.15) v1@377.19,4538.87
NetLED17_4: LED17.4 R169.1 | length 870.2
  Top Layer w4: R169.1@-303.82,4491 -239,4491 -204.96,4525.04 v1(-143.14,4525.04) ; R169.1@-300.06,4487.24 cw(c-290.98,4478.16) -290.98,4491 cw(c-290.98,4503.84) R169.1@-300.06,4494.76 ; R169.1@-297.23,4484.41 cw(c-281.32,4468.5) -281.32,4491 cw(c-281.32,4513.5) R169.1@-297.23,4497.59 ; v1@-149.86,4518.32 ccw(c-166.08,4502.11) -166.08,4525.04 ccw(c-166.08,4547.98) v1@-149.86,4531.76 ; v1@-147.03,4521.15 ccw(c-156.42,4511.76) -156.42,4525.04 ccw(c-156.42,4538.32) v1@-147.03,4528.93 ; v1@200.9,4515.77 ccw(c190.88,4528.22) 206.86,4528.22 ; v1(206.86,4508.37) 206.86,4528.22 ; v1@212.81,4515.77 cw(c222.83,4528.22) 206.86,4528.22 ; 217.81,4536.22 cw(c217.81,4520.62) LED17.4@228.84,4531.65 ; LED17.4@241.49,4536.22 214.86,4536.22 206.86,4528.22
  MidLayer2 w4: v1(-143.14,4525.04) -126.48,4541.71 173.52,4541.71 v1(206.86,4508.37) ; v1@-143.14,4530.54 ccw(c-143.14,4543.82) -133.75,4534.43 ccw(c-124.36,4525.04) v1@-137.64,4525.04 ; v1@-143.14,4534.54 ccw(c-143.14,4557.48) -126.93,4541.26 ccw(c-110.71,4525.04) v1@-133.64,4525.04 ; v1@197.36,4508.37 ccw(c174.42,4508.37) 190.64,4524.59 ccw(c206.86,4540.81) v1@206.86,4517.87 ; v1@201.36,4508.37 ccw(c188.08,4508.37) 197.47,4517.76 ccw(c206.86,4527.15) v1@206.86,4513.87
NetLED18_1: LED18.1 R170.1 | length 5395.1
  Top Layer w4: v1@4475.14,3401.66 cw(c4458.92,3385.44) 4481.86,3385.44 cw(c4504.79,3385.44) v1@4488.57,3401.66 ; R170.1@4475.45,3381.59 ccw(c4467.59,3393.5) 4481.86,3393.5 ; v1@4477.97,3404.49 cw(c4468.58,3395.1) 4481.86,3395.1 cw(c4495.14,3395.1) v1@4485.75,3404.49 ; R170.1@4481.86,3383.37 v1(4481.86,3408.37) ; v1@5686.19,291.71 5797.44,291.71 5804.73,299 LED18.1@5804.73,321.33 ; v1@5688.89,286.11 cw(c5702.4,272.6) 5702.4,291.71 ; v1@5691.72,283.28 cw(c5712.06,262.94) 5712.06,291.71 ; v1@5691.72,296.72 ccw(c5703.81,308.81) 5703.81,291.71 ; 5804.73,303.16 cw(c5820.68,303.16) LED18.1@5809.4,314.44
  MidLayer1 w4: v1(4245,220) 4278,253 4278,1128 4378.81,1228.81 4378.81,1982.44 4206.86,2154.4 4206.86,2480.39 4336.5,2610.04 4336.5,2613.88 4356.12,2633.5 4369.56,2633.5 4415.19,2679.13 4415.19,2715 4415.19,3101.12 4406.86,3109.46 4406.86,3333.37 v1(4481.86,3408.37) ; v1@4245,225.5 ccw(c4245,238.78) 4254.39,229.39 ccw(c4263.78,220) v1@4250.5,220 ; v1@4245,229.5 ccw(c4245,252.43) 4261.22,236.22 ccw(c4277.43,220) v1@4254.5,220 ; v1@4472.36,3408.37 cw(c4449.42,3408.37) 4465.64,3392.16 cw(c4481.86,3375.94) v1@4481.86,3398.87 ; v1@4476.36,3408.37 cw(c4463.08,3408.37) 4472.47,3398.99 cw(c4481.86,3389.6) v1@4481.86,3402.87
  Bottom Layer w4: v1(4245,220) 4258.37,233.37 4604.69,233.37 4658.5,287.19 5147.38,287.19 5160.23,300.04 5644.96,300.04 5655,290 v1(5685,290) ; v1@5678.28,283.28 ccw(c5662.06,267.06) 5662.06,290 ccw(c5662.06,312.93) v1@5678.28,296.72 ; v1@5681.11,286.11 ccw(c5671.72,276.72) 5671.72,290 ccw(c5671.72,303.28) v1@5681.11,293.89
NetLED18_3: LED18.3 R171.1 | length 4272.9
  Top Layer w4: R171.1@4469.9,3257.63 cw(c4456.88,3243.38) 4476.18,3243.38 ; R171.1@4472.59,3260.58 cw(c4465.17,3252.45) 4476.18,3252.45 cw(c4487.2,3252.45) R171.1@4479.77,3260.58 ; R171.1@4476.18,3265 4476.18,3243.37 ; R171.1@4482.47,3257.63 ccw(c4495.48,3243.38) 4476.18,3243.38 ; 4515.19,3166.71 4498.52,3183.37 ; v1@4749.36,1056.37 ccw(c4726.42,1056.37) 4742.64,1072.59 ccw(c4758.86,1088.81) v1@4758.86,1065.87 ; v1@4753.36,1056.37 ccw(c4740.08,1056.37) 4749.47,1065.76 ccw(c4758.86,1075.15) v1@4758.86,1061.87 ; v1(4758.86,1056.37) 4672.71,1142.52 4672.71,1959.18 4488,2143.9 4488,2589.52 4515.19,2616.71 4516.02,2617.54 4516.02,3056.6 4516.02,3080 4516.02,3165.88 4498.52,3183.37 ; v1@5481.86,263.87 cw(c5481.86,240.94) 5498.07,257.16 cw(c5514.29,273.37) v1@5491.36,273.37 ; v1@5481.86,267.87 cw(c5481.86,254.6) 5491.25,263.99 cw(c5500.64,273.37) v1@5487.36,273.37 ; v1(5481.86,273.37) 5534.42,220.81 LED18.3@5777.35,220.81 ; LED18.3@5772.51,215.96 ccw(c5760.8,204.25) 5760.8,220.81 ccw(c5760.8,237.36) LED18.3@5772.51,225.66 ; 4476.18,3243.37 4498.52,3221.03 4498.52,3183.37
  MidLayer2 w4: v1@4752.14,1049.66 cw(c4735.92,1033.44) 4758.86,1033.44 cw(c4781.79,1033.44) v1@4765.57,1049.66 ; v1@4754.97,1052.49 cw(c4745.58,1043.1) 4758.86,1043.1 cw(c4772.14,1043.1) v1@4762.75,1052.49 ; v1(4758.86,1056.37) 4758.86,1021.14 5030,750 5030,389.43 5049.43,370 5212.25,370 5308.88,273.37 v1(5481.86,273.37) ; v1@5475.14,266.66 ccw(c5458.92,250.44) 5458.92,273.37 ccw(c5458.92,296.31) v1@5475.14,280.09 ; v1@5477.97,269.49 ccw(c5468.58,260.1) 5468.58,273.37 ccw(c5468.58,286.65) v1@5477.97,277.26
NetLED18_4: LED18.4 R172.1 | length 4927.5
  Top Layer w4: 4459.43,3305.75 cw(c4476.18,3289) R172.1@4476.18,3312.69 ; 4460.62,3306.94 ccw(c4445.55,3322.01) R172.1@4466.86,3322.01 ; R172.1@4466.26,3312.58 cw(c4476.18,3302.66) R172.1@4476.18,3316.69 ; R172.1@4467.45,3313.77 ccw(c4459.21,3322.01) R172.1@4470.86,3322.01 ; R172.1@4476.18,3322.5 4453.72,3300.04 4416.86,3300.04 4406.86,3290.04 4406.86,3161.36 4500.02,3068.19 4500.02,3063.22 4500.02,2624.16 4499.19,2623.34 4472,2596.14 4472,2137.27 4656.71,1952.56 4656.71,1067.85 v1(4674.52,1050.04) ; v1@4665.02,1050.04 ccw(c4642.09,1050.04) 4658.31,1066.26 ccw(c4674.52,1082.48) v1@4674.52,1059.54 ; v1@4669.02,1050.04 ccw(c4655.75,1050.04) 4665.14,1059.43 ccw(c4674.52,1068.82) v1@4674.52,1055.54 ; v1(5697.52,316.71) 5702.14,321.33 5750,321.33 5752.88,324.21 LED18.4@5777.45,324.21 ; v1@5698.58,315.65 cw(c5712.29,301.94) 5712.29,321.33 ; v1@5701.41,312.82 cw(c5721.95,292.28) 5721.95,321.33 ; v1@5704.24,309.99 cw(c5731.61,282.62) 5731.61,321.33 ; v1@5704.24,323.43 ccw(c5709.31,328.49) 5709.31,321.33 ; LED18.4@5772.61,319.36 ccw(c5760.9,307.65) 5760.9,324.21 ccw(c5760.9,340.76) LED18.4@5772.61,329.06
  MidLayer1 w4: v1(4674.52,1050.04) 4794.48,1170 4875.58,1170 5040.19,1005.39 5040.19,297.44 5149.82,187.81 5530,187.81 ; v1@4674.52,1055.54 ccw(c4674.52,1068.82) 4683.91,1059.43 ccw(c4693.3,1050.04) v1@4680.02,1050.04 ; v1@4674.52,1059.54 ccw(c4674.52,1082.48) 4690.74,1066.26 ccw(c4706.96,1050.04) v1@4684.02,1050.04 ; 5590,187.81 5530,187.81 ; v1@5690.81,309.99 ccw(c5674.59,293.77) 5674.59,316.71 ccw(c5674.59,339.64) v1@5690.81,323.43 ; v1@5693.64,312.82 ccw(c5684.25,303.43) 5684.25,316.71 ccw(c5684.25,329.99) v1@5693.64,320.6 ; v1(5697.52,316.71) 5660,316.71 5645,301.71 5645,210 5622.81,187.81 5530,187.81
NetLED19_1: LED19.1 R173.1 | length 4138.2
  Top Layer w4: v1@5156.86,2857.21 cw(c5156.86,2834.27) 5173.07,2850.49 cw(c5189.29,2866.71) v1@5166.36,2866.71 ; v1@5156.86,2861.21 cw(c5156.86,2847.93) 5166.25,2857.32 cw(c5175.64,2866.71) v1@5162.36,2866.71 ; v1(5156.86,2866.71) 5186.18,2837.38 ; R173.1@5181.21,2828.38 ccw(c5175.53,2837.38) 5186.18,2837.38 ; R173.1@5186.18,2820 5186.18,2837.38 ; R173.1@5191.15,2828.38 cw(c5196.83,2837.38) 5186.18,2837.38 ; LED19.1@5912.51,313.27 cw(c5909.48,307.72) LED19.1@5915.8,307.72 ; LED19.1@5915.8,324.21 LED19.1@5915.8,307.72 ; v1@5918.7,291.56 ccw(c5913.73,300) 5923.52,300 ccw(c5933.32,300) v1@5928.35,291.56 ; LED19.1@5919.09,313.27 ccw(c5922.12,307.72) LED19.1@5915.8,307.72 ; v1(5923.52,283.37) 5923.52,300 LED19.1@5915.8,307.72
  MidLayer1 w4: v1@5150.14,2859.99 cw(c5133.92,2843.77) 5156.86,2843.77 cw(c5179.79,2843.77) v1@5163.57,2859.99 ; v1@5152.97,2862.82 cw(c5143.58,2853.43) 5156.86,2853.43 cw(c5170.14,2853.43) v1@5160.75,2862.82 ; v1(5156.86,2866.71) 5156.86,2734.04 5241.81,2649.09 5241.81,2595.62 5161.19,2515 5161.19,2486.19 5176.4,2470.97 5176.4,1885.16 5124.02,1832.78 5124.02,1399.54 5279.33,1244.23 5314.45,1244.23 5490.65,1068.04 5699.21,1068.04 5752.25,1015 5774.68,1015 5790.19,1030.51 v1(5790.19,1033.37) ; 5776.11,1016.43 ccw(c5764,1028.55) v1@5780.85,1031.65 ; 5778.86,1019.18 cw(c5790.19,1007.86) v1@5790.19,1023.87 ; 5781.5,1021.82 ccw(c5773.09,1030.22) v1@5784.78,1032.38 ; v1(5923.52,283.37) 5953.19,313.04 6138.04,313.04 6148.86,323.86 6148.86,756.14 6120,785 6041.86,785 6031.86,795 v1(6031.86,826.04) ; v1@5923.52,288.87 ccw(c5923.52,302.15) 5932.91,292.76 ccw(c5942.3,283.37) v1@5929.02,283.37 ; v1@5923.52,292.87 ccw(c5923.52,315.81) 5939.74,299.59 ccw(c5955.96,283.37) v1@5933.02,283.37 ; v1@6025.14,819.32 cw(c6008.92,803.11) 6031.86,803.11 cw(c6054.79,803.11) v1@6038.57,819.32 ; v1@6027.97,822.15 cw(c6018.58,812.76) 6031.86,812.76 cw(c6045.14,812.76) v1@6035.75,822.15
  Bottom Layer w4: v1(5790.19,1033.37) 5813.97,1033.37 5832.35,1015 5900,1015 6031.86,883.14 v1(6031.86,826.04) ; v1@5794.08,1029.49 cw(c5803.47,1020.1) 5803.47,1033.37 cw(c5803.47,1046.65) v1@5794.08,1037.26 ; v1@5796.91,1026.66 cw(c5813.13,1010.44) 5813.13,1033.37 cw(c5813.13,1056.31) v1@5796.91,1040.09 ; v1@6025.14,832.76 ccw(c6008.92,848.98) 6031.86,848.98 ccw(c6054.79,848.98) v1@6038.57,832.76 ; v1@6027.97,829.93 ccw(c6018.58,839.32) 6031.86,839.32 ccw(c6045.14,839.32) v1@6035.75,829.93
NetLED19_3: LED19.3 R174.1 | length 3603.8
  Top Layer w4: R174.1@5186.18,2695 5215.86,2695 ; R174.1@5189.94,2691.24 cw(c5199.02,2682.16) 5199.02,2695 cw(c5199.02,2707.84) R174.1@5189.94,2698.76 ; R174.1@5192.77,2688.41 cw(c5208.68,2672.5) 5208.68,2695 cw(c5208.68,2717.5) R174.1@5192.77,2701.59 ; 5215,2695 5224.38,2695 5232.19,2687.19 5232.19,2461.69 5198.52,2428.02 5198.52,2066.08 5144.5,2012.06 5144.5,1445.5 5198.52,1391.48 5242.19,1347.81 v1(5242.19,1309.71) ; v1@5235.47,1316.43 ccw(c5219.26,1332.64) 5242.19,1332.64 ccw(c5265.13,1332.64) v1@5248.91,1316.43 ; v1@5238.3,1313.6 ccw(c5228.91,1322.99) 5242.19,1322.99 ccw(c5255.47,1322.99) v1@5246.08,1313.6 ; LED19.3@5883.75,230.58 ccw(c5872.04,242.29) 5888.6,242.29 ; LED19.3@5888.42,220.81 LED19.3@5888.42,223.69 ; LED19.3@5888.6,220.81 5888.6,253.6 5895,260 5990,260 6024.65,294.65 6045.71,294.65 6055.03,303.98 6055.03,357.22 6040,372.25 6040,790.19 6010.19,820 v1(6010.19,975.04) ; v1@6003.47,968.32 cw(c5987.26,952.11) 6010.19,952.11 cw(c6033.13,952.11) v1@6016.91,968.32 ; v1@6006.3,971.15 cw(c5996.91,961.76) 6010.19,961.76 cw(c6023.47,961.76) v1@6014.08,971.15
  MidLayer1 w4: v1(5242.19,1309.71) 5260.29,1309.71 ; v1@5250.01,1304.31 cw(c5260.29,1297.21) 5260.29,1309.71 ; v1@5250.01,1315.1 ccw(c5260.29,1322.2) 5260.29,1309.71 ; v1@6000.69,975.04 ccw(c5977.76,975.04) 5993.97,991.26 ccw(c6010.19,1007.48) v1@6010.19,984.54 ; v1@6004.69,975.04 ccw(c5991.41,975.04) 6000.8,984.43 ccw(c6010.19,993.82) v1@6010.19,980.54 ; v1(6010.19,975.04) 5901.86,1083.37 5782.12,1083.37 5767.25,1068.5 5750.75,1068.5 5737.75,1081.5 5720.75,1081.5 5715.29,1076.04 5493.96,1076.04 5260.29,1309.71
NetLED19_4: LED19.4 R175.1 | length 4586.5
  Top Layer w4: R175.1@5186.18,2751.69 cw(c5186.18,2725.87) 5204.44,2744.13 ; R175.1@5186.18,2755.69 cw(c5186.18,2739.53) 5197.61,2750.95 ; R175.1@5186.18,2757.5 5186.18,2750.04 5198.52,2750.04 5215.19,2733.37 v1(5215.19,2725.04) ; R175.1@5188.75,2752.35 cw(c5192.28,2745.95) R175.1@5197.45,2751.12 ; R175.1@5190.68,2748.85 cw(c5194.95,2741.09) 5201.21,2747.35 ; 5200.85,2747.71 cw(c5179.47,2726.32) v1@5209.69,2725.24 ; 5207.35,2741.21 cw(c5192.01,2725.87) v1@5213.69,2725.09 ; LED19.4@5880.7,322.21 5848,289.52 5848,132 5860,120 6393.69,120 6399.44,125.75 6399.44,270.75 6390.19,280 v1(6390.19,475.04) ; v1@6383.47,468.32 cw(c6367.26,452.11) 6390.19,452.11 cw(c6413.13,452.11) v1@6396.91,468.32 ; v1@6386.3,471.15 cw(c6376.91,461.76) 6390.19,461.76 cw(c6403.47,461.76) v1@6394.08,471.15 ; R175.1@5195.5,2757.01 ccw(c5205.02,2757.01) 5198.29,2750.28 cw(c5205.02,2757.01) R175.1@5195.5,2757.01
  MidLayer1 w4: v1@5208.47,2718.32 cw(c5192.71,2702.56) 5215,2702.56 ; v1@5211.3,2721.15 cw(c5202.37,2712.22) 5215,2712.22 ; 5215,2701.65 cw(c5238.58,2701.65) v1@5221.91,2718.32 ; 5215,2711.3 cw(c5228.93,2711.3) v1@5219.08,2721.15 ; v1@5215,2725 5215,2698.52 5257.81,2655.71 5257.81,2588.99 5177.19,2508.37 5177.19,2492.81 5192.4,2477.6 5192.4,1878.53 5187.5,1873.62 5187.5,1765 5148.02,1725.52 5148.02,1457.2 5505.19,1100.04 5703.04,1100.04 5714.5,1111.5 5768.56,1111.5 5779.86,1100.2 5995.38,1100.2 6390.19,705.39 v1(6390.19,475.04) ; v1@6383.47,481.76 ccw(c6367.26,497.98) 6390.19,497.98 ccw(c6413.13,497.98) v1@6396.91,481.76 ; v1@6386.3,478.93 ccw(c6376.91,488.32) 6390.19,488.32 ccw(c6403.47,488.32) v1@6394.08,478.93
NetLED20_1: LED20.1 R176.1 | length 6329.5
  Top Layer w4: v2@5133.06,298.06 cw(c5116.31,281.31) 5140,281.31 cw(c5163.69,281.31) v2@5146.94,298.06 ; v2@5135.89,300.89 cw(c5125.97,290.97) 5140,290.97 cw(c5154.03,290.97) v2@5144.11,300.89 ; v2(5140,305) 5140,205 5150,195 5239.45,195 5314.45,120 5825,120 5840,135 5840,340 5850,350 5955,350 5960,345 5960,315 5980,295 6008.04,295 LED20.1@6035.25,322.21
  MidLayer1 w4: v2(3990,945) 4080,1035 4080,1235.04 4124.96,1280 4225,1280 4238,1293 4238,1328.26 4248,1338.26 4248,1575.69 4223.81,1599.88 4223.81,1809.38 4210,1823.19 4210,2083.37 4006.86,2286.52 4006.86,3041.1 4174.13,3208.37 v1(4253.52,3208.37) ; v2@3990,950.81 ccw(c3990,964.84) 3999.92,954.92 ccw(c4009.84,945) v2@3995.81,945 ; v2@3990,954.81 ccw(c3990,978.5) 4006.75,961.75 ccw(c4023.5,945) v2@3999.81,945 ; v1@4246.81,3201.66 ccw(c4230.59,3185.44) 4230.59,3208.37 ccw(c4230.59,3231.31) v1@4246.81,3215.09 ; v1@4249.64,3204.49 ccw(c4240.25,3195.1) 4240.25,3208.37 ccw(c4240.25,3221.65) v1@4249.64,3212.26
  MidLayer2 w4: v2(3990,945) 4080,945 4095,930 4406,930 4443,967 4790.37,967 5014,743.37 5014,524 4990,500 4920,500 4915.27,495.27 4915.27,429.73 4929.19,415.81 4958.36,415.81 5069.17,305 v2(5140,305) ; v2@3994.11,940.89 cw(c4004.03,930.97) 4004.03,945 cw(c4004.03,959.03) v2@3994.11,949.11 ; v2@3996.94,938.06 cw(c4013.69,921.31) 4013.69,945 cw(c4013.69,968.69) v2@3996.94,951.94 ; v2@5133.06,298.06 ccw(c5116.31,281.31) 5116.31,305 ccw(c5116.31,328.69) v2@5133.06,311.94 ; v2@5135.89,300.89 ccw(c5125.97,290.97) 5125.97,305 ccw(c5125.97,319.03) v2@5135.89,309.11
  Bottom Layer w4: v1@4254.52,3207.37 4366.19,3207.37 4373.52,3200.04 4378.82,3200.04 R176.1@4378.82,3198.75 ; v1@4257.41,3212.26 ccw(c4269.22,3224.07) 4269.22,3207.37 ; v1@4260.24,3201.66 cw(c4274.04,3187.85) 4274.04,3207.37 ; v1@4260.24,3215.09 ccw(c4278.87,3233.72) 4278.87,3207.37 ; 4346.34,3207.37 cw(c4346.34,3166.77) R176.1@4375.06,3195.48 ; 4356,3207.37 cw(c4356,3176.42) R176.1@4377.89,3198.31 ; 4365.66,3207.37 cw(c4365.66,3186.08) R176.1@4380.71,3201.14
NetLED20_3: LED20.3 R177.1 | length 5826.6
  Top Layer w4: v1(5948.94,185.44) 5949.5,186 5991,186 5999.67,194.67 5999.67,220.81 LED20.3@5999.67,221.19 ; v1@5952.83,181.55 cw(c5963.56,170.82) 5963.56,186 ; v1@5952.83,189.33 ccw(c5960.87,197.37) 5960.87,186 ; v1@5955.66,178.72 cw(c5973.22,161.16) 5973.22,186 ; v1@5955.66,192.16 ccw(c5970.53,207.03) 5970.53,186 ; LED20.3@5995,211.04 cw(c5983.73,199.76) 5999.67,199.76 ; LED20.3@5999.67,221.19 5999.67,223.69 LED20.3@5999.67,221.19
  MidLayer1 w4: v1@4053.28,266.72 ccw(c4037.06,282.93) 4060,282.93 ccw(c4082.93,282.93) v1@4066.72,266.72 ; v1@4056.11,263.89 ccw(c4046.72,273.28) 4060,273.28 ccw(c4073.28,273.28) v1@4063.89,263.89 ; v1(4060,260) 4060,773 4145,858 4226.69,858 4262,893.31 4262,1318.31 4272,1328.31 4272,1585.63 4248.02,1609.6 4248.02,1740.65 4318.5,1811.12 4318.5,1838.88 4242,1915.38 4242,2096.63 4140.19,2198.44 4140.19,2436.35 4320.5,2616.66 4320.5,2620.5 4349.5,2649.5 4353.34,2649.5 4370,2666.16 4370,2725.25 4367.5,2727.75 4367.5,2811.64 4398.86,2843 4398.86,2968.71 v1(4345.52,3022.04) ; v1@4345.52,3012.54 cw(c4345.52,2989.6) 4361.74,3005.82 cw(c4377.96,3022.04) v1@4355.02,3022.04 ; v1@4345.52,3016.54 cw(c4345.52,3003.26) 4354.91,3012.65 cw(c4364.3,3022.04) v1@4351.02,3022.04
  MidLayer2 w4: v1@4053.28,253.28 cw(c4037.06,237.06) 4060,237.06 cw(c4082.93,237.06) v1@4066.72,253.28 ; v1@4056.11,256.11 cw(c4046.72,246.72) 4060,246.72 cw(c4073.28,246.72) v1@4063.89,256.11 ; v1(4060,260) 4060,225 4093.29,191.71 4615.19,191.71 4765.19,341.71 4998.52,341.71 5230.23,110 5334.09,110 5441.8,217.71 5937.29,217.71 5948.94,206.06 ; v1@5942.77,192.66 ccw(c5931.31,206.06) 5948.94,206.06 ; v1@5945.37,189.62 ccw(c5938.73,197.38) 5948.94,197.38 ccw(c5959.15,197.38) v1@5952.51,189.62 ; v1(5948.94,185.44) 5948.94,206.06 ; v1@5955.11,192.66 cw(c5966.57,206.06) 5948.94,206.06
  Bottom Layer w4: v1@4338.81,3028.76 ccw(c4322.59,3044.97) 4345.52,3044.97 ccw(c4368.46,3044.97) v1@4352.24,3028.76 ; v1@4341.63,3025.93 ccw(c4332.25,3035.32) 4345.52,3035.32 ccw(c4358.8,3035.32) v1@4349.41,3025.93 ; v1(4345.52,3022.04) 4345.52,3058.41 R177.1@4375.46,3088.35 ; R177.1@4378.82,3085 R177.1@4378.82,3091.71
NetLED20_4: LED20.4 R178.1 | length 4421.5
  Top Layer w4: v1@4348.52,3122.21 cw(c4348.52,3099.27) 4364.74,3115.49 cw(c4380.96,3131.71) v1@4358.02,3131.71 ; v1@4348.52,3126.21 cw(c4348.52,3112.93) 4357.91,3122.32 cw(c4367.3,3131.71) v1@4354.02,3131.71 ; v1(4348.52,3131.71) 4411.5,3068.73 4411.5,2582.81 4406.86,2578.17 4406.86,2501.63 4409.5,2498.98 4409.5,2454.5 4406.03,2451.03 4406.03,2443.97 4409.5,2440.5 4409.5,2399.5 4406.03,2396.03 4406.03,1900.87 v1(4425.52,1881.37) ; v1@4416.02,1881.37 ccw(c4393.09,1881.37) 4409.31,1897.59 ccw(c4425.52,1913.81) v1@4425.52,1890.87 ; v1@4420.02,1881.37 ccw(c4406.75,1881.37) 4416.14,1890.76 ccw(c4425.52,1900.15) v1@4425.52,1886.87 ; v1@5791.81,1259.99 cw(c5775.59,1243.77) 5798.52,1243.77 cw(c5821.46,1243.77) v1@5805.24,1259.99 ; v1@5794.64,1262.82 cw(c5785.25,1253.43) 5798.52,1253.43 cw(c5811.8,1253.43) v1@5802.41,1262.82 ; v1(5798.52,1266.71) 5798.52,1229.54 5990.19,1037.87 5990.19,927.37 6000.86,916.71 6000.86,818.02 6032,786.88 6032,362.27 LED20.4@5991.95,322.21
  MidLayer2 w4: v1(4425.52,1881.37) 4718.86,1881.37 4736.5,1863.73 4736.5,1863.44 4783.17,1816.77 4821.92,1816.77 4975.48,1663.21 4994.88,1643.81 5313.75,1643.81 5504.65,1452.9 5671.1,1452.9 5702.52,1421.48 5777.05,1421.48 5798.52,1400 v1(5798.52,1266.71) ; v1@4429.41,1877.49 cw(c4438.8,1868.1) 4438.8,1881.37 cw(c4438.8,1894.65) v1@4429.41,1885.26 ; v1@4432.24,1874.66 cw(c4448.46,1858.44) 4448.46,1881.37 cw(c4448.46,1904.31) v1@4432.24,1888.09 ; v1@5791.81,1273.43 ccw(c5775.59,1289.64) 5798.52,1289.64 ccw(c5821.46,1289.64) v1@5805.24,1273.43 ; v1@5794.64,1270.6 ccw(c5785.25,1279.99) 5798.52,1279.99 ccw(c5811.8,1279.99) v1@5802.41,1270.6
  Bottom Layer w4: v1(4348.52,3131.71) 4358.52,3141.71 ; 4367.08,3141.71 ccw(c4367.08,3151.69) R178.1@4374.74,3145.29 ; 4367.4,3141.71 cw(c4367.4,3131.79) R178.1@4374.83,3138.35 ; R178.1@4371.67,3147.85 cw(c4358.53,3158.84) 4358.53,3141.71 ; R178.1@4371.83,3135.71 ccw(c4358.53,3123.95) 4358.53,3141.71 ; R178.1@4378.82,3141.71 4358.52,3141.71
NetLED21_1: LED21.1 R179.1 | length 5978.3
  Top Layer w4: v1@4150.14,3051.66 cw(c4133.92,3035.44) 4156.86,3035.44 cw(c4179.79,3035.44) v1@4163.57,3051.66 ; v1@4152.97,3054.49 cw(c4143.58,3045.1) 4156.86,3045.1 cw(c4170.14,3045.1) v1@4160.75,3054.49 ; v1(4156.86,3058.37) 4156.86,2915.77 4387.5,2685.12 4387.5,2592.75 4382.5,2587.75 4382.5,2492.04 4385.5,2489.04 4385.5,2464.44 4381.36,2460.3 4381.36,2434.7 4385.5,2430.56 4385.5,2409.44 4381.36,2405.3 4381.36,1672.56 4382.19,1671.73 4382.19,1267.19 4340.04,1225.04 v1(4290.19,1225.04) ; v1@4294.08,1221.15 cw(c4303.47,1211.76) 4303.47,1225.04 cw(c4303.47,1238.32) v1@4294.08,1228.93 ; v1@4296.91,1218.32 cw(c4313.13,1202.11) 4313.13,1225.04 cw(c4313.13,1247.98) v1@4296.91,1231.76 ; v1@6069.86,702.54 cw(c6069.86,679.61) 6086.07,695.82 cw(c6102.29,712.04) v1@6079.36,712.04 ; v1@6069.86,706.54 cw(c6069.86,693.26) 6079.25,702.65 cw(c6088.64,712.04) v1@6075.36,712.04 ; v1(6069.86,712.04) 6138.2,643.7 6138.2,321.6 LED21.1@6138.48,321.33 ; 6138.2,345.92 ccw(c6155.08,345.92) LED21.1@6143.15,333.98
  MidLayer1 w4: v1(4156.86,3058.37) 4208.37,3058.37 4294.19,3144.19 v1(4294.19,3235.37) ; v1@4160.75,3054.49 cw(c4170.14,3045.1) 4170.14,3058.37 cw(c4170.14,3071.65) v1@4160.75,3062.26 ; v1@4163.57,3051.66 cw(c4179.79,3035.44) 4179.79,3058.37 cw(c4179.79,3081.31) v1@4163.57,3065.09 ; v1@4287.47,3228.66 cw(c4271.26,3212.44) 4294.19,3212.44 cw(c4317.13,3212.44) v1@4300.91,3228.66 ; v1@4290.3,3231.49 cw(c4280.91,3222.1) 4294.19,3222.1 cw(c4307.47,3222.1) v1@4298.08,3231.49
  MidLayer2 w4: v1@4290.19,1215.54 cw(c4290.19,1192.61) 4306.41,1208.82 cw(c4322.63,1225.04) v1@4299.69,1225.04 ; v1@4290.19,1219.54 cw(c4290.19,1206.26) 4299.58,1215.65 cw(c4308.97,1225.04) v1@4295.69,1225.04 ; v1(4290.19,1225.04) 4406.86,1108.37 4801.5,1108.37 4810.5,1099.37 5274.19,1099.37 5298.52,1075.04 5298.52,875.04 5310.56,863 6025.88,863 6069.86,819.02 v1(6069.86,712.04) ; v1@6063.14,718.76 ccw(c6046.92,734.98) 6069.86,734.98 ccw(c6092.79,734.98) v1@6076.57,718.76 ; v1@6065.97,715.93 ccw(c6056.58,725.32) 6069.86,725.32 ccw(c6083.14,725.32) v1@6073.75,715.93
  Bottom Layer w4: v1@4284.69,3235.37 ccw(c4261.76,3235.37) 4277.97,3251.59 ccw(c4294.19,3267.81) v1@4294.19,3244.87 ; v1@4288.69,3235.37 ccw(c4275.41,3235.37) 4284.8,3244.76 ccw(c4294.19,3254.15) v1@4294.19,3240.87 ; v1(4294.19,3235.37) 4271.19,3258.37 4190.19,3258.37 4172.86,3275.71 4172.86,3447.41 4192.15,3466.71 4215,3466.71 4230,3451.71 4230,3400 4260.63,3369.37 R179.1@4378.82,3369.38 ; R179.1@4372.23,3362.79 ccw(c4356.32,3346.88) 4356.32,3369.37 ccw(c4356.32,3391.87) R179.1@4372.23,3375.96 ; R179.1@4375.06,3365.61 ccw(c4365.98,3356.53) 4365.98,3369.37 ccw(c4365.98,3382.22) R179.1@4375.06,3373.14
NetLED21_3: LED21.3 R180.1 | length 4915.1
  Top Layer w4: v1@4339.02,3225.04 cw(c4316.09,3225.04) 4332.31,3208.82 cw(c4348.52,3192.61) v1@4348.52,3215.54 ; v1@4343.02,3225.04 cw(c4329.75,3225.04) 4339.13,3215.65 cw(c4348.52,3206.26) v1@4348.52,3219.54 ; v1(4348.52,3225.04) 4315.19,3191.71 4315.19,2780.06 4403.5,2691.75 4403.5,2586.12 4398.5,2581.12 4398.5,2498.67 4401.5,2495.67 4401.5,2457.81 4398.03,2454.34 4398.03,2440.66 4401.5,2437.19 4401.5,2402.81 4398.03,2399.34 4398.03,1897.56 4398.52,1897.06 4398.52,1678.02 4518.17,1558.37 v1(4576.52,1558.37) ; v1@4569.81,1551.66 ccw(c4553.59,1535.44) 4553.59,1558.37 ccw(c4553.59,1581.31) v1@4569.81,1565.09 ; v1@4572.64,1554.49 ccw(c4563.25,1545.1) 4563.25,1558.37 ccw(c4563.25,1571.65) v1@4572.64,1562.26 ; 6100.71,602.51 cw(c6120,583.22) v1@6120,610.5 ; 6105.06,606.86 ccw(c6091.91,620) v1@6110.5,620 ; LED21.3@6106.25,230.58 ccw(c6094.54,242.29) 6111.1,242.29 ; 6107.54,609.34 cw(c6120,596.88) v1@6120,614.5 ; LED21.3@6111.1,220.81 6111.1,265 6082.8,293.3 6082.8,340.77 6048,375.56 6048,549.8 v1@6118.2,620
  MidLayer2 w4: v1(4576.52,1558.37) 4917.56,1558.37 5214.69,1261.25 5214.69,1206.15 5230.84,1190 5566.06,1190 5597.35,1221.29 5673.69,1221.29 5710.76,1184.21 5907.95,1184.21 5932.94,1209.21 6025.79,1209.21 6097.36,1137.64 6097.36,1000.6 6106.52,991.43 6106.52,633.48 v1(6120,620) ; v1@4580.41,1554.49 cw(c4589.8,1545.1) 4589.8,1558.37 cw(c4589.8,1571.65) v1@4580.41,1562.26 ; v1@4583.24,1551.66 cw(c4599.46,1535.44) 4599.46,1558.37 cw(c4599.46,1581.31) v1@4583.24,1565.09
  Bottom Layer w4: v1@4343.68,3233.22 ccw(c4338.65,3241.71) 4348.52,3241.71 ; v1(4348.52,3225.04) 4348.52,3241.71 ; v1@4353.36,3233.22 cw(c4358.39,3241.71) 4348.52,3241.71 ; R180.1@4370.81,3250.86 ccw(c4362.44,3245.89) 4362.44,3255.62 ; R180.1@4370.81,3260.39 cw(c4362.44,3265.36) 4362.44,3255.62 ; R180.1@4378.82,3255.62 4362.44,3255.62 ; 4348.52,3241.71 4362.44,3255.62
NetLED21_4: LED21.4 R181.1 | length 5135
  Top Layer w4: v1@4200.14,3293.99 cw(c4183.92,3277.77) 4206.86,3277.77 cw(c4229.79,3277.77) v1@4213.57,3293.99 ; v1@4202.97,3296.82 cw(c4193.58,3287.43) 4206.86,3287.43 cw(c4220.14,3287.43) v1@4210.75,3296.82 ; v1(4206.86,3300.71) 4206.86,2877.08 4365.31,2718.62 4395.5,2688.44 4395.5,2589.44 4390.5,2584.44 4390.5,2495.36 4393.5,2492.36 4393.5,2461.12 4390.03,2457.65 4390.03,2437.35 4393.5,2433.88 4393.5,2406.12 4390.03,2402.65 4390.03,1894.24 4390.19,1894.08 4390.19,1675.04 4556.86,1508.37 v1(4556.86,1228.71) ; v1@4550.14,1235.43 ccw(c4533.92,1251.64) 4556.86,1251.64 ccw(c4579.79,1251.64) v1@4563.57,1235.43 ; v1@4552.97,1232.6 ccw(c4543.58,1241.99) 4556.86,1241.99 ccw(c4570.14,1241.99) v1@4560.75,1232.6 ; v1@6083.47,518.32 cw(c6067.26,502.11) 6090.19,502.11 cw(c6113.13,502.11) v1@6096.91,518.32 ; v1@6086.3,521.15 cw(c6076.91,511.76) 6090.19,511.76 cw(c6103.47,511.76) v1@6094.08,521.15 ; v1(6090.19,525.04) 6090.19,479.51 6110.92,458.78 6110.92,324.21 LED21.4@6110.92,321.33 ; LED21.4@6106.35,333.98 ccw(c6095.31,345.01) 6110.92,345.01
  MidLayer2 w4: v1@4556.86,1219.21 cw(c4556.86,1196.27) 4573.07,1212.49 cw(c4589.29,1228.71) v1@4566.36,1228.71 ; v1@4556.86,1223.21 cw(c4556.86,1209.93) 4566.25,1219.32 cw(c4575.64,1228.71) v1@4562.36,1228.71 ; v1(4556.86,1228.71) 4668.86,1116.71 4804.48,1116.71 4813.82,1107.37 5278.86,1107.37 5306.52,1079.71 5306.52,878.48 5314,871 6029.19,871 6090.19,810 v1(6090.19,525.04) v1@6090,525.23 ; v1@6083.47,531.76 ccw(c6067.26,547.98) 6090.19,547.98 ccw(c6113.13,547.98) v1@6096.91,531.76 ; v1@6086.3,528.93 ccw(c6076.91,538.32) 6090.19,538.32 ccw(c6103.47,538.32) v1@6094.08,528.93
  Bottom Layer w4: v1(4206.86,3300.71) 4278.21,3300.71 4290,3312.5 R181.1@4378.82,3312.5 ; v1@4210.75,3296.82 cw(c4220.14,3287.43) 4220.14,3300.71 cw(c4220.14,3313.99) v1@4210.75,3304.6 ; v1@4213.57,3293.99 cw(c4229.79,3277.77) 4229.79,3300.71 cw(c4229.79,3323.64) v1@4213.57,3307.43 ; R181.1@4372.23,3305.91 ccw(c4356.32,3290) 4356.32,3312.5 ccw(c4356.32,3335) R181.1@4372.23,3319.09 ; R181.1@4375.06,3308.74 ccw(c4365.98,3299.66) 4365.98,3312.5 ccw(c4365.98,3325.34) R181.1@4375.06,3316.26
NetLED22_1: LED22.1 R182.1 | length 5765.3
  Top Layer w4: v1@4240.19,2715.54 cw(c4240.19,2692.61) 4256.41,2708.82 cw(c4272.63,2725.04) v1@4249.69,2725.04 ; v1@4240.19,2719.54 cw(c4240.19,2706.26) 4249.58,2715.65 cw(c4258.97,2725.04) v1@4245.69,2725.04 ; v1(4240.19,2725.04) 4298.52,2666.71 4298.52,1967.47 4329.46,1936.54 4329.46,1908.79 4320,1899.33 v1(4320,1285) ; v1@4313.28,1291.72 ccw(c4297.06,1307.93) 4320,1307.93 ccw(c4342.93,1307.93) v1@4326.72,1291.72 ; v1@4316.11,1288.89 ccw(c4306.72,1298.28) 4320,1298.28 ccw(c4333.28,1298.28) v1@4323.89,1288.89 ; v1@6241.81,509.99 cw(c6225.59,493.77) 6248.52,493.77 cw(c6271.46,493.77) v1@6255.24,509.99 ; v1@6244.64,512.82 cw(c6235.25,503.43) 6248.52,503.43 cw(c6261.8,503.43) v1@6252.41,512.82 ; 6248.52,338.49 ccw(c6258.9,338.49) LED22.1@6251.56,331.15 ; 6248.52,348.15 ccw(c6268.56,348.15) LED22.1@6254.39,333.98 ; v1(6248.52,516.71) 6248.52,324.21 6248.52,322.52 LED22.1@6249.72,321.33
  MidLayer1 w4: v1@4233.47,2731.76 ccw(c4217.26,2747.98) 4240.19,2747.98 ccw(c4263.13,2747.98) v1@4246.91,2731.76 ; v1@4236.3,2728.93 ccw(c4226.91,2738.32) 4240.19,2738.32 ccw(c4253.47,2738.32) v1@4244.08,2728.93 ; v1(4240.19,2725.04) 4240.19,2968.73 4381.86,3110.39 4381.86,3341.71 4344.52,3379.04 4344.52,3549.71 v1(4373.52,3578.71) ; v1@4364.02,3578.71 cw(c4341.09,3578.71) 4357.31,3562.49 cw(c4373.52,3546.27) v1@4373.52,3569.21 ; v1@4368.02,3578.71 cw(c4354.75,3578.71) 4364.14,3569.32 cw(c4373.52,3559.93) v1@4373.52,3573.21
  MidLayer2 w4: v1@4320,1275.5 cw(c4320,1252.56) 4336.22,1268.78 cw(c4352.43,1285) v1@4329.5,1285 ; v1@4320,1279.5 cw(c4320,1266.22) 4329.39,1275.61 cw(c4338.78,1285) v1@4325.5,1285 ; v1(4320,1285) 4338.63,1266.37 4885.17,1266.37 4984.84,1166.71 5230,1166.71 5245.29,1182 5569.37,1182 5600.66,1213.29 5670.38,1213.29 5707.45,1176.21 5911.26,1176.21 5936.26,1201.21 6022.48,1201.21 6089.36,1134.33 6089.36,997.29 6098.52,988.12 6098.52,650 6098.52,545.71 6127.52,516.71 v1(6248.52,516.71) ; v1@6241.81,509.99 ccw(c6225.59,493.77) 6225.59,516.71 ccw(c6225.59,539.64) v1@6241.81,523.43 ; v1@6244.64,512.82 ccw(c6235.25,503.43) 6235.25,516.71 ccw(c6235.25,529.99) v1@6244.64,520.6
  Bottom Layer w4: v1@4368.98,3570.37 cw(c4364.8,3562.71) 4373.52,3562.71 ; v1(4373.52,3578.71) 4373.52,3562.71 ; R182.1@4373.84,3548.37 ccw(c4368.12,3557.41) 4378.82,3557.41 ; v1@4378.07,3570.37 ccw(c4382.25,3562.71) 4373.52,3562.71 ; R182.1@4378.82,3540 4378.82,3557.41 ; R182.1@4383.8,3548.37 cw(c4389.52,3557.41) 4378.82,3557.41 ; 4373.52,3562.71 4378.82,3557.41
NetLED22_3: LED22.3 R183.1 | length 6050.9
  Top Layer w4: v1(6190.19,207.37) 6203.62,220.81 LED22.3@6222.34,220.81 ; LED22.3@6217.49,215.96 ccw(c6205.79,204.25) 6205.79,220.81 ccw(c6205.79,237.36) LED22.3@6217.49,225.66 ; LED22.3@6220.81,222.34 LED22.3@6222.16,223.69
  MidLayer1 w4: v1@4375.14,3391.66 cw(c4358.92,3375.44) 4381.86,3375.44 cw(c4404.79,3375.44) v1@4388.57,3391.66 ; v1@4377.97,3394.49 cw(c4368.58,3385.1) 4381.86,3385.1 cw(c4395.14,3385.1) v1@4385.75,3394.49 ; v1(4381.86,3398.37) 4381.86,3365.35 4398.52,3348.69 4398.52,3106.48 4406.86,3098.14 4406.86,3075 ; 4406.86,3085 4406.86,3075 ; v1@6180.69,207.37 ccw(c6157.76,207.37) 6173.97,223.59 ccw(c6190.19,239.81) v1@6190.19,216.87 ; v1@6184.69,207.37 ccw(c6171.41,207.37) 6180.8,216.76 ccw(c6190.19,226.15) v1@6190.19,212.87 ; v1(6190.19,207.37) 6170.56,227 5737,227 5610,100 5203.69,100 5048.69,255 4850,255 4785,190 4135,190 4085,240 4085,285 4068,302 4068,769.69 4148.31,850 4230,850 4270,890 4270,1315 4280,1325 4280,1588.94 4256.02,1612.92 4256.02,1737.33 4326.5,1807.81 4326.5,1842.19 4250,1918.69 4250,2099.94 4198.52,2151.42 4198.52,2483.37 4328.5,2613.35 4328.5,2617.19 4352.81,2641.5 4366.24,2641.5 4406.86,2682.11 4406.86,3075
  Bottom Layer w4: v1@4375.14,3405.09 ccw(c4358.92,3421.31) 4381.86,3421.31 ccw(c4404.79,3421.31) v1@4388.57,3405.09 ; v1@4377.97,3402.26 ccw(c4368.58,3411.65) 4381.86,3411.65 ccw(c4395.14,3411.65) v1@4385.75,3402.26 ; R183.1@4378.82,3425.04 R183.1@4378.82,3426.25 ; R183.1@4378.86,3425.04 4381.86,3422.04 v1(4381.86,3398.37)
NetLED22_4: LED22.4 R184.1 | length 5160.5
  Top Layer w4: v1@4373.52,3445.54 cw(c4373.52,3422.61) 4389.74,3438.82 cw(c4405.96,3455.04) v1@4383.02,3455.04 ; v1@4373.52,3449.54 cw(c4373.52,3436.26) 4382.91,3445.65 cw(c4392.3,3455.04) v1@4379.02,3455.04 ; v1(4373.52,3455.04) 4415.19,3413.37 4415.19,3388.73 4398.52,3372.06 4398.52,3228.34 4398.69,3228.17 4398.69,3158.54 4398.52,3158.37 4491.19,3065.71 4492.02,3064.88 4492.02,2772.02 4458,2738 4458,1926.18 v1(4456.86,1925.04) ; v1@4450.14,1931.76 ccw(c4431.16,1950.73) 4458,1950.73 ; v1@4452.97,1928.93 ccw(c4440.82,1941.08) 4458,1941.08 ; 4458,1945.22 ccw(c4477.03,1945.22) v1@4463.57,1931.76 ; v1@5986.5,1476 cw(c5963.56,1476) 5979.78,1459.78 cw(c5996,1443.56) v1@5996,1466.5 ; v1@5990.5,1476 cw(c5977.22,1476) 5986.61,1466.61 cw(c5996,1457.22) v1@5996,1470.5 ; v1(5996,1476) 5970.04,1450.04 5889.1,1450.04 5881.28,1442.23 5881.28,1372.81 5915,1339.09 5915,1124.38 6040.19,999.19 6160.81,999.19 6222.16,937.84 LED22.4@6222.16,324.21 ; LED22.4@6217.59,333.98 ccw(c6206.56,345.01) 6222.16,345.01
  MidLayer2 w4: v1(4456.86,1925.04) 4473.86,1942.04 4674.98,1942.04 4687.83,1929.19 4732.12,1929.19 5001.5,1659.81 5460.69,1659.81 5506.67,1613.83 5615,1505.5 5749.5,1505.5 5761.54,1517.54 5823.96,1517.54 5857.31,1484.19 5880.69,1484.19 5888.21,1491.71 5980.29,1491.71 v1(5996,1476) ; v1@4456.86,1930.54 ccw(c4456.86,1943.82) 4466.25,1934.43 ccw(c4475.64,1925.04) v1@4462.36,1925.04 ; v1@4456.86,1934.54 ccw(c4456.86,1957.48) 4473.07,1941.26 ccw(c4489.29,1925.04) v1@4466.36,1925.04
  Bottom Layer w4: v1@4368.15,3462.88 ccw(c4354.27,3483.12) 4378.82,3483.12 4378.82,3460.34 v1(4373.52,3455.04) ; v1@4370.41,3459.58 ccw(c4359.48,3475.53) R184.1@4378.82,3475.53 ; v1@4372.68,3456.28 ccw(c4364.68,3467.94) 4378.82,3467.94 ; R184.1@4375.08,3478.85 cw(c4366.26,3469.91) 4378.82,3469.91 cw(c4391.38,3469.91) R184.1@4382.56,3478.85
NetLED23_1: LED23.1 R185.1 | length 5763.1
  Top Layer w4: v1@4483.52,3140.54 cw(c4483.52,3117.61) 4499.74,3133.82 cw(c4515.96,3150.04) v1@4493.02,3150.04 ; v1@4483.52,3144.54 cw(c4483.52,3131.26) 4492.91,3140.65 cw(c4502.3,3150.04) v1@4489.02,3150.04 ; v1(4483.52,3150.04) 4508.02,3125.55 4508.02,2620.85 4480,2592.83 4480,2140.58 4664.71,1955.87 4664.71,1108.85 4765.19,1008.37 4840.19,1008.37 4856.86,1025.04 v1(4856.86,1125.04) ; v1@4850.14,1118.32 cw(c4833.92,1102.11) 4856.86,1102.11 cw(c4879.79,1102.11) v1@4863.57,1118.32 ; v1@4852.97,1121.15 cw(c4843.58,1111.76) 4856.86,1111.76 cw(c4870.14,1111.76) v1@4860.75,1121.15 ; v1(6265,145) 6381.44,145 6391.44,155 6391.44,265.36 6368.99,287.81 LED23.1@6368.99,322.21 ; v1@6268.89,141.11 cw(c6278.28,131.72) 6278.28,145 cw(c6278.28,158.28) v1@6268.89,148.89 ; v1@6271.72,138.28 cw(c6287.93,122.06) 6287.93,145 cw(c6287.93,167.93) v1@6271.72,151.72
  MidLayer1 w4: v1(4856.86,1125.04) 4897.92,1125.04 5024.19,998.77 5024.19,290.81 5185,130 v1(5250,130) ; v1@4860.75,1121.15 cw(c4870.14,1111.76) 4870.14,1125.04 cw(c4870.14,1138.32) v1@4860.75,1128.93 ; v1@4863.57,1118.32 cw(c4879.79,1102.11) 4879.79,1125.04 cw(c4879.79,1147.98) v1@4863.57,1131.76 ; v1@5243.28,123.28 ccw(c5227.06,107.06) 5227.06,130 ccw(c5227.06,152.93) v1@5243.28,136.72 ; v1@5246.11,126.11 ccw(c5236.72,116.72) 5236.72,130 ccw(c5236.72,143.28) v1@5246.11,133.89
  MidLayer2 w4: v1(5250,130) 5342.78,130 5438.48,225.71 6139.29,225.71 6220,145 v1(6265,145) ; v1@5253.89,126.11 cw(c5263.28,116.72) 5263.28,130 cw(c5263.28,143.28) v1@5253.89,133.89 ; v1@5256.72,123.28 cw(c5272.93,107.06) 5272.93,130 cw(c5272.93,152.93) v1@5256.72,136.72 ; v1@6258.28,138.28 ccw(c6242.06,122.06) 6242.06,145 ccw(c6242.06,167.93) v1@6258.28,151.72 ; v1@6261.11,141.11 ccw(c6251.72,131.72) 6251.72,145 ccw(c6251.72,158.28) v1@6261.11,148.89
  Bottom Layer w4: v1(4483.52,3150.04) 4590.19,3150.04 4615.19,3175.04 ; v1@4487.41,3146.15 cw(c4496.8,3136.76) 4496.8,3150.04 cw(c4496.8,3163.32) v1@4487.41,3153.93 ; v1@4490.24,3143.32 cw(c4506.46,3127.11) 4506.46,3150.04 cw(c4506.46,3172.98) v1@4490.24,3156.76 ; R185.1@4607.75,3191.19 cw(c4593.87,3175) 4615.19,3175 ; R185.1@4610.36,3194.22 cw(c4601.33,3183.7) 4615.19,3183.7 ; R185.1@4613.82,3198.75 4613.82,3200.04 R185.1@4615.19,3200.04 ; 4615.19,3179.07 cw(c4633.01,3179.07) R185.1@4620.41,3191.67 ; R185.1@4615.19,3198.75 4615.19,3175.04
NetLED23_3: LED23.3 R186.1 | length 4522
  Top Layer w4: v1@4605.69,2983.37 cw(c4582.76,2983.37) 4598.97,2967.16 cw(c4615.19,2950.94) v1@4615.19,2973.87 ; v1@4609.69,2983.37 cw(c4596.41,2983.37) 4605.8,2973.99 cw(c4615.19,2964.6) v1@4615.19,2977.87 ; v1(4615.19,2983.37) 4590.19,2958.37 4590.19,2866.71 4706.86,2750.04 4706.86,1971.86 4762,1916.71 v1(4762,1874) ; v1@4755.28,1880.72 ccw(c4739.06,1896.93) 4762,1896.93 ccw(c4784.93,1896.93) v1@4768.72,1880.72 ; v1@4758.11,1877.89 ccw(c4748.72,1887.28) 4762,1887.28 ccw(c4775.28,1887.28) v1@4765.89,1877.89 ; v1@6308.47,576.66 cw(c6292.26,560.44) 6315.19,560.44 cw(c6338.13,560.44) v1@6321.91,576.66 ; v1@6311.3,579.49 cw(c6301.91,570.1) 6315.19,570.1 cw(c6328.47,570.1) v1@6319.08,579.49 ; v1(6315.19,583.37) 6315.19,361 6302,347.81 6302,298.19 6333.59,266.6 LED23.3@6333.59,220.81 ; LED23.3@6328.74,230.58 ccw(c6317.03,242.29) 6333.59,242.29
  MidLayer1 w4: v1@4755.28,1867.28 cw(c4732.56,1844.56) 4764.7,1844.56 ; v1@4758.11,1870.11 cw(c4742.21,1854.21) 4764.7,1854.21 ; v1(4762,1874) 4762,1872.9 4768.19,1866.71 4764.7,1863.21 4764.7,1326.14 5180.84,910 5290,910 5324,876 6085.31,876 6314.69,646.62 6314.69,583.87 v1(6315.19,583.37) ; 4764.7,1857.57 cw(c4778.43,1857.57) v1@4768.72,1867.28 ; v1@6308.47,590.09 ccw(c6293.46,605.1) 6314.69,605.1 ; v1@6311.3,587.26 ccw(c6303.12,595.45) 6314.69,595.45 ; 6314.69,597.86 ccw(c6329.68,597.86) v1@6319.08,587.26 ; 6314.69,607.52 ccw(c6339.33,607.52) v1@6321.91,590.09
  Bottom Layer w4: R186.1@4607.23,3077.92 cw(c4588.01,3058.7) 4615.19,3058.7 ; v1@4608.47,2990.09 ccw(c4592.26,3006.31) 4615.19,3006.31 ccw(c4638.13,3006.31) v1@4621.91,2990.09 ; R186.1@4610.06,3080.75 cw(c4597.67,3068.36) 4615.19,3068.36 ; v1@4611.3,2987.26 ccw(c4601.91,2996.65) 4615.19,2996.65 ccw(c4628.47,2996.65) v1@4619.08,2987.26 ; R186.1@4613.82,3085 4613.82,3084.51 4615.19,3084.51 v1(4615.19,2983.37) ; 4615.19,3065.32 cw(c4633.01,3065.32) R186.1@4620.41,3077.92
NetLED23_4: LED23.4 R187.1 | length 5459.3
  Top Layer w4: LED23.4@6328.84,333.98 ccw(c6317.81,345.01) 6333.41,345.01 ; LED23.4@6333.41,321.33 6333.41,570 6340.19,576.78 v1(6340.19,625.04) ; v1@6333.47,618.32 cw(c6317.26,602.11) 6340.19,602.11 cw(c6363.13,602.11) v1@6346.91,618.32 ; v1@6336.3,621.15 cw(c6326.91,611.76) 6340.19,611.76 cw(c6353.47,611.76) v1@6344.08,621.15
  MidLayer1 w4: v1@4475.14,1006.76 ccw(c4458.92,1022.98) 4481.86,1022.98 ccw(c4504.79,1022.98) v1@4488.57,1006.76 ; v1@4477.97,1003.93 ccw(c4468.58,1013.32) 4481.86,1013.32 ccw(c4495.14,1013.32) v1@4485.75,1003.93 ; v1(4481.86,1000.04) 4481.86,2547.67 4623.86,2689.67 4623.86,2864.04 4593.19,2894.71 4593.19,3104.04 v1(4573.52,3123.71) ; v1@4573.52,3114.21 cw(c4573.52,3091.27) 4589.74,3107.49 cw(c4605.96,3123.71) v1@4583.02,3123.71 ; v1@4573.52,3118.21 cw(c4573.52,3104.93) 4582.91,3114.32 cw(c4592.3,3123.71) v1@4579.02,3123.71
  MidLayer2 w4: v1(4481.86,1000.04) 4583.19,1000.04 4674.86,1091.71 4795.54,1091.71 4828.88,1058.37 v1(5073.52,1058.37) ; v1@4485.75,996.15 cw(c4495.14,986.76) 4495.14,1000.04 cw(c4495.14,1013.32) v1@4485.75,1003.93 ; v1@4488.57,993.32 cw(c4504.79,977.11) 4504.79,1000.04 cw(c4504.79,1022.98) v1@4488.57,1006.76 ; v1@5066.81,1051.66 ccw(c5050.59,1035.44) 5050.59,1058.37 ccw(c5050.59,1081.31) v1@5066.81,1065.09 ; v1@5069.64,1054.49 ccw(c5060.25,1045.1) 5060.25,1058.37 ccw(c5060.25,1071.65) v1@5069.64,1062.26
  Bottom Layer w4: v1(4573.52,3123.71) 4591.69,3141.87 ; v1@4573.52,3129.21 ccw(c4573.52,3142.49) 4582.91,3133.1 ccw(c4592.3,3123.71) v1@4579.02,3123.71 ; v1@4573.52,3133.21 ccw(c4573.52,3156.14) 4589.74,3139.93 ccw(c4605.96,3123.71) v1@4583.02,3123.71 ; R187.1@4607.15,3135.36 ccw(c4591.69,3120.26) 4591.69,3141.87 ; R187.1@4607.15,3148.39 cw(c4591.69,3163.48) 4591.69,3141.87 ; R187.1@4610.01,3138.16 ccw(c4601.19,3129.54) 4601.19,3141.87 ccw(c4601.19,3154.21) R187.1@4610.01,3145.59 ; R187.1@4613.82,3141.88 4591.69,3141.87 ; v1@5066.81,1065.09 ccw(c5050.59,1081.31) 5073.52,1081.31 ccw(c5096.46,1081.31) v1@5080.24,1065.09 ; v1@5069.64,1062.26 ccw(c5060.25,1071.65) 5073.52,1071.65 ccw(c5086.8,1071.65) v1@5077.41,1062.26 ; v1(5073.52,1058.37) 5073.52,1133.52 5090,1150 5564.02,1150 5619.02,1095 5672.25,1095 5720.75,1046.5 5741.59,1046.5 5749.25,1054.16 5804.5,1054.16 5835.66,1023 5903.31,1023 6000.61,925.71 6320,925.71 6340.19,905.52 v1(6340.19,625.04) ; v1@6333.47,631.76 ccw(c6317.26,647.98) 6340.19,647.98 ccw(c6363.13,647.98) v1@6346.91,631.76 ; v1@6336.3,628.93 ccw(c6326.91,638.32) 6340.19,638.32 ccw(c6353.47,638.32) v1@6344.08,628.93
NetLED24_1: LED24.1 R188.1 | length 6453.5
  Top Layer w4: v1(4273.52,210) 4595,210 4598.57,206.43 4646.58,206.43 4830.15,390 v2(4910,390) ; v1@4277.41,206.11 cw(c4286.8,196.72) 4286.8,210 cw(c4286.8,223.28) v1@4277.41,213.89 ; v1@4280.24,203.28 cw(c4296.46,187.06) 4296.46,210 cw(c4296.46,232.93) v1@4280.24,216.72 ; v2@4903.06,383.06 ccw(c4886.31,366.31) 4886.31,390 ccw(c4886.31,413.69) v2@4903.06,396.94 ; v2@4905.89,385.89 ccw(c4895.97,375.97) 4895.97,390 ccw(c4895.97,404.03) v2@4905.89,394.11 ; v2(5215,170) 5253.14,170 5311.14,112 6397,112 6410,125 6410,270 6417.07,277.07 6458.89,277.07 6472.22,290.4 LED24.1@6472.22,321.33 ; v2@5219.11,165.89 cw(c5229.03,155.97) 5229.03,170 cw(c5229.03,184.03) v2@5219.11,174.11 ; v2@5221.94,163.06 cw(c5238.69,146.31) 5238.69,170 cw(c5238.69,193.69) v2@5221.94,176.94 ; 6472.22,303.16 cw(c6488.16,303.16) LED24.1@6476.89,314.44
  MidLayer1 w4: v1@4266.81,216.72 ccw(c4250.59,232.93) 4273.52,232.93 ccw(c4296.46,232.93) v1@4280.24,216.72 ; v1@4269.64,213.89 ccw(c4260.25,223.28) 4273.52,223.28 ccw(c4286.8,223.28) v1@4277.41,213.89 ; v1(4273.52,210) 4273.52,236.9 4286,249.37 4286,1124.69 4386.81,1225.5 4386.81,2393.29 4447.19,2453.67 4447.19,2811.71 4577.19,2941.71 4577.19,2986.5 4540.19,3023.5 4540.19,3159.71 4547.19,3166.71 4547.19,3326.37 v1(4581.86,3361.04) ; v1@4572.36,3361.04 cw(c4549.42,3361.04) 4565.64,3344.82 cw(c4581.86,3328.61) v1@4581.86,3351.54 ; v1@4576.36,3361.04 cw(c4563.08,3361.04) 4572.47,3351.65 cw(c4581.86,3342.26) v1@4581.86,3355.54
  MidLayer2 w4: v2(4910,390) 4961.55,390 5181.55,170 v2(5215,170) ; v2@4914.11,385.89 cw(c4924.03,375.97) 4924.03,390 cw(c4924.03,404.03) v2@4914.11,394.11 ; v2@4916.94,383.06 cw(c4933.69,366.31) 4933.69,390 cw(c4933.69,413.69) v2@4916.94,396.94 ; v2@5208.06,163.06 ccw(c5191.31,146.31) 5191.31,170 ccw(c5191.31,193.69) v2@5208.06,176.94 ; v2@5210.89,165.89 ccw(c5200.97,155.97) 5200.97,170 ccw(c5200.97,184.03) v2@5210.89,174.11
  Bottom Layer w4: v1@4579.73,3362.35 cw(c4592.31,3354.59) 4592.31,3369.37 ; v1(4581.86,3361.04) 4590.19,3369.37 R188.1@4613.82,3369.38 ccw(c4613.82,3341.32) v1@4589.94,3356.05 ; v1@4583.13,3360.25 cw(c4599.48,3350.17) 4599.48,3369.37 ; v1@4586.54,3358.15 cw(c4606.65,3345.74) R188.1@4606.65,3369.37 ; R188.1@4610.06,3365.61 ccw(c4600.98,3356.53) 4600.98,3369.37 ccw(c4600.98,3382.22) R188.1@4610.06,3373.14
NetLED24_3: LED24.3 R189.1 | length 4987.8
  Top Layer w4: v1@6435.37,191.56 ccw(c6430.39,200) 6440.19,200 ccw(c6449.99,200) v1@6445.01,191.56 ; v1(6440.19,183.37) 6440.19,200 LED24.3@6444.84,204.65 ; LED24.3@6441.7,209.79 cw(c6439.06,204.65) LED24.3@6444.84,204.65 ; LED24.3@6443.31,222.34 LED24.3@6444.66,223.69 ; LED24.3@6444.84,220.81 LED24.3@6444.84,204.65 ; LED24.3@6447.97,209.79 ccw(c6450.62,204.65) LED24.3@6444.84,204.65
  MidLayer1 w4: v1(4748.52,3183.37) 4790.52,3183.37 4815.52,3158.37 4815.52,2772.39 4715.19,2672.06 4715.19,1963.52 4716.34,1962.38 4716.34,1947.62 4715.19,1946.48 4715.19,1341.71 5095.75,961.15 5204.9,852 6075.37,852 6156.86,770.52 6156.86,366.71 6340.19,183.37 v1(6440.19,183.37) ; v1@4752.41,3179.49 cw(c4761.8,3170.1) 4761.8,3183.37 cw(c4761.8,3196.65) v1@4752.41,3187.26 ; v1@4755.24,3176.66 cw(c4771.46,3160.44) 4771.46,3183.37 cw(c4771.46,3206.31) v1@4755.24,3190.09 ; v1@6433.47,176.66 ccw(c6417.26,160.44) 6417.26,183.37 ccw(c6417.26,206.31) v1@6433.47,190.09 ; v1@6436.3,179.49 ccw(c6426.91,170.1) 6426.91,183.37 ccw(c6426.91,196.65) v1@6436.3,187.26
  MidLayer2 w4: v1(4581.86,3187.37) 4632,3187.37 4645,3200.37 4700,3200.37 4717,3183.37 v1(4748.52,3183.37) ; v1@4585.75,3183.49 cw(c4595.14,3174.1) 4595.14,3187.37 cw(c4595.14,3200.65) v1@4585.75,3191.26 ; v1@4588.57,3180.66 cw(c4604.79,3164.44) 4604.79,3187.37 cw(c4604.79,3210.31) v1@4588.57,3194.09 ; v1@4741.81,3176.66 ccw(c4725.59,3160.44) 4725.59,3183.37 ccw(c4725.59,3206.31) v1@4741.81,3190.09 ; v1@4744.64,3179.49 ccw(c4735.25,3170.1) 4735.25,3183.37 ccw(c4735.25,3196.65) v1@4744.64,3187.26
  Bottom Layer w4: v1@4577.1,3195.6 ccw(c4572.32,3203.85) 4581.86,3203.85 ; v1(4581.86,3187.37) 4581.86,3203.85 ; v1@4586.62,3195.6 cw(c4591.4,3203.85) 4581.86,3203.85 ; R189.1@4608.02,3247.84 cw(c4598.46,3235.81) 4613.82,3235.81 ; R189.1@4613.82,3255.62 4613.82,3235.81 ; R189.1@4619.62,3247.84 ccw(c4629.18,3235.81) 4613.82,3235.81 ; 4581.86,3203.85 4613.82,3235.81