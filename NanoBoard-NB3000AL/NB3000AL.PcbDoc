# Altium PCB NB3000AL.PcbDoc (part 64 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NSTATUS: R80.1 U8.M6 | length 2067.4
  Top Layer w4: v3(5035.67,4308.11) U8.M6@5055.35,4288.42 ; U8.M6@5048.01,4288.42 ccw(c5030.29,4288.42) 5042.82,4300.96 ccw(c5055.35,4313.49) U8.M6@5055.35,4295.77 ; 5048.47,4295.31 cw(c5061.28,4308.11) 5043.17,4308.11 ccw(c5061.28,4308.11) 5048.47,4295.31 ; 5048.47,4295.31 ccw(c5035.67,4282.5) 5035.67,4300.61 cw(c5035.67,4282.5) 5048.47,4295.31
  MidLayer1 w4: v2(4698.78,4388.78) 4755.78,4388.78 4780,4364.56 4812.59,4331.97 4828.03,4331.97 4838.82,4331.97 4879.25,4331.97 4898.67,4331.97 4972.79,4331.97 ; v2@4702.89,4384.67 cw(c4712.81,4374.75) 4712.81,4388.78 cw(c4712.81,4402.81) v2@4702.89,4392.89 ; v2@4705.72,4381.84 cw(c4722.47,4365.1) 4722.47,4388.78 cw(c4722.47,4412.47) v2@4705.72,4395.72 ; 4958.86,4331.97 4972.79,4331.97 ; v3@5028.2,4307.46 ccw(c5010.16,4305.88) 5021.8,4319.75 ; v3@5035.02,4315.58 cw(c5033.44,4333.62) 5021.8,4319.75 ; 4972.79,4331.97 4992.29,4331.97 cw(c4992.29,4290.24) 5021.8,4319.75
  MidLayer2 w4: 4695.08,4499.01 4696.92,4500.86 ; v2(4698.78,4388.78) 4685.5,4402.07 4685.5,4489.44 4696.92,4500.86 ; v2@4743.06,5003.06 cw(c4726.31,4986.31) 4750,4986.31 cw(c4773.69,4986.31) v2@4756.94,5003.06 ; v2@4745.89,5005.89 cw(c4735.97,4995.97) 4750,4995.97 cw(c4764.03,4995.97) v2@4754.11,5005.89 ; v2(4750,5010) 4750,4969.84 4757.35,4962.48 4757.35,4822.56 4687,4752.2 4672.69,4737.89 4672.69,4649.57 4675,4647.26 4720.5,4601.76 4720.5,4524.44 4696.92,4500.86
  Bottom Layer w4: v2(4750,5010) 4932.1,5010 ; 4930,5010 4936,5010 4971.46,4974.54 5023.48,4974.54 ; 5024.4,4974.5 5058.03,4940.87 5075.94,4940.87 5090.44,4940.87 5100.69,4951.13 5100.69,4957.01 5154.51,5010.82 5316.92,5010.82 5376.32,5070.22 ; R80.1@5372.56,5075.98 cw(c5370.03,5070.22) 5376.32,5070.22 ; R80.1@5376.32,5085 5376.32,5070.22 ; R80.1@5380.08,5075.98 ccw(c5382.61,5070.22) 5376.32,5070.22
ONE_WIRE_DB_PB: EXTHDR1.67 R283.2 U8.U2 | length 6973.6
  Top Layer w4: R283.2@1055.38,3150.19 cw(c1055.38,3126.5) 1072.13,3143.25 ; R283.2@1055.38,3154.19 cw(c1055.38,3140.16) R283.2@1065.3,3150.08 ; R283.2@1055.38,3160 1091.95,3123.43 EXTHDR1.67@1091.95,3071.85 1091.95,3075.04 1090.19,3075.04 1090.19,3071.85 v1(1090.19,3001.04) ; R283.2@1060.7,3159.5 ccw(c1072.35,3159.5) R283.2@1064.11,3151.27 ; R283.2@1064.7,3159.5 ccw(c1086.01,3159.5) 1070.94,3144.44 ; 1073.73,3141.65 cw(c1049.04,3116.97) EXTHDR1.67@1083.95,3116.97 ; 1080.55,3134.83 cw(c1062.7,3116.97) EXTHDR1.67@1087.95,3116.97 ; v1@1083.47,3007.76 ccw(c1067.26,3023.98) 1090.19,3023.98 ccw(c1113.13,3023.98) v1@1096.91,3007.76 ; v1@1086.3,3004.93 ccw(c1076.91,3014.32) 1090.19,3014.32 ccw(c1103.47,3014.32) v1@1094.08,3004.93 ; 1087.38,3128 cw(c1076.35,3116.97) EXTHDR1.67@1091.95,3116.97 ; v1@4586,4127.5 cw(c4586,4104.56) 4602.22,4120.78 cw(c4618.43,4137) v1@4595.5,4137 ; v1@4586,4131.5 cw(c4586,4118.22) 4595.39,4127.61 cw(c4604.78,4137) v1@4591.5,4137 ; v1(4586,4137) 4615.29,4107.71 4632.1,4107.71 ; 4691.53,4095 4700,4095 ; 4741.53,4094.97 4744.29,4092.21 4751,4085.5 4772.56,4085.5 4774.56,4087.5 4813.81,4087.5 4825.25,4076.07 4830.82,4076.07 4838.82,4076.07 4878.16,4076.07 ccw(c4878.16,4086.22) 4885.34,4079.04 ; 4741.5,4095 4700,4095 ; U8.U2@4890.53,4091.57 cw(c4872.81,4091.57) 4885.34,4079.04 ; U8.U2@4897.87,4084.23 ccw(c4897.87,4066.51) 4885.34,4079.04 ; 4632.1,4107.71 4650,4107.71 ; 4632.1,4107.71 4650,4107.71 ; 4650,4107.71 4678.42,4107.71 4691.13,4095 4700,4095
  MidLayer1 w4: v1@1083.47,3007.76 ccw(c1067.26,3023.98) 1090.19,3023.98 ccw(c1113.13,3023.98) v1@1096.91,3007.76 ; v1@1086.3,3004.93 ccw(c1076.91,3014.32) 1090.19,3014.32 ccw(c1103.47,3014.32) v1@1094.08,3004.93 ; v1(1090.19,3001.04) 1090.19,3183.37 1098.52,3191.71 1606.86,3191.71 1656.86,3141.71 1745.19,3141.71 1795.19,3191.71 2158.29,3191.71 2178,3172 2178,2996.48 2131.52,2950 2131.52,2811.69 2178.09,2765.13 2826.69,2765.13 3220,3158.44 3220,4045 3233.04,4058.04 3303.04,4058.04 3323.52,4078.52 3323.52,4523.52 3342.04,4542.04 4087.96,4542.04 4120,4510 4120,4386.9 v1(4140.19,4366.71) ; v1@4130.69,4366.71 ccw(c4107.76,4366.71) 4123.97,4382.93 ccw(c4140.19,4399.14) v1@4140.19,4376.21 ; v1@4134.69,4366.71 ccw(c4121.41,4366.71) 4130.8,4376.1 ccw(c4140.19,4385.49) v1@4140.19,4372.21
  MidLayer2 w4: v1@4133.47,4359.99 cw(c4117.26,4343.77) 4140.19,4343.77 cw(c4163.13,4343.77) v1@4146.91,4359.99 ; v1@4136.3,4362.82 cw(c4126.91,4353.43) 4140.19,4353.43 cw(c4153.47,4353.43) v1@4144.08,4362.82 ; v1(4140.19,4366.71) 4140.19,4314.81 4157,4298 4157,4297.84 4179.84,4275 4270.5,4275 4305.31,4309.81 4397.73,4309.81 4399.5,4308.04 4427.86,4308.04 4490.09,4245.81 4510.69,4245.81 4525.81,4230.69 4525.81,4195.5 v1@4584.31,4137
PB_AIN.L: C6.2 EXTHDR1.33 R22.1 | length 5337.5
  Top Layer w4: EXTHDR1.33@1624.99,3018.78 cw(c1619.21,3013) 1627.39,3013 cw(c1635.56,3013) EXTHDR1.33@1629.78,3018.78 ; v1(1625,2940) 1627.39,2942.39 EXTHDR1.33@1627.39,3071.85
  MidLayer1 w4: v1(-9.81,2658.37) -32.5,2635.68 -32.5,2421.4 v1(20.19,2368.71) ; v1(765,2575) 708.02,2518.02 708.02,2208.02 627,2127 627,1076.18 711.48,991.71 v1(1081.86,991.71)
  Bottom Layer w4: R22.1@-53.82,2640 -28.18,2640 v1(-9.81,2658.37) ; R22.1@-50.06,2636.24 cw(c-40.98,2627.16) -40.98,2640 cw(c-40.98,2652.84) R22.1@-50.06,2643.76 ; v1(20.19,2368.71) 43.37,2345.52 725.52,2345.52 740,2360 740,2495 765.19,2520.19 v1@765.19,2574.04 ; v1@765.19,2575 765.19,2592 765.19,2670 756.02,2679.17 756.02,2772.35 611.52,2916.85 611.52,2993.82 621.52,3003.81 778.09,3003.81 877.81,2904.09 1210.91,2904.09 1238.19,2931.37 1238.19,2961.22 1254.01,2977.04 1276.37,2977.04 1292.19,2961.22 1292.19,2928.12 1308.88,2911.43 1492.97,2911.43 1509.03,2895.37 1580.37,2895.37 v1(1625,2940) ; v1(1081.86,991.71) 1148.29,991.71 1154.33,985.67 C6.2@1154.33,950 ; C6.2@1150.22,954.11 ccw(c1140.3,964.03) 1154.33,964.03 ccw(c1168.36,964.03) C6.2@1158.44,954.11
PB_AIN.MIC: EXTHDR1.37
PB_AIN.R: C5.2 EXTHDR1.35 R26.1 | length 4950.9
  Top Layer w4: v1@1593.57,3000 v1(1590,3000) 1595.89,3005.89 EXTHDR1.35@1595.89,3071.85
  MidLayer1 w4: v1(-18.14,2901.71) -18.14,2813.14 50,2745 270.04,2745 290,2725.04 v1(690.19,2725.04) 645,2679.85 645,2581.02 681.02,2545 681.02,2219.21 600,2138.18 600,1065 735,930 1295.15,930 v1(1356.86,991.71)
  Bottom Layer w4: R26.1@-53.82,2891.25 -28.6,2891.25 v1(-18.14,2901.71) ; R26.1@-50.06,2887.49 cw(c-40.98,2878.41) -40.98,2891.25 cw(c-40.98,2904.09) R26.1@-50.06,2895.01 ; v1(690.19,2725.04) 690.19,2800 584.52,2905.67 584.52,3005 610.33,3030.81 1559.19,3030.81 v1(1590,3000) ; C5.2@1350.21,954.11 ccw(c1340.29,964.03) 1354.32,964.03 ccw(c1368.34,964.03) C5.2@1358.43,954.11 ; C5.2@1354.32,950 v1@1354.32,989.17
PB_AOUT.L: C9.2 EXTHDR1.31 | length 2968.6
  Top Layer w4: EXTHDR1.31@1656.49,3125.22 ccw(c1650.71,3131) 1658.88,3131 ccw(c1667.06,3131) EXTHDR1.31@1661.28,3125.22 ; EXTHDR1.31@1658.88,3071.85 1658.88,3189.4 1660,3190.52 v1(1660,3270) v1@1664.48,3265.52
  MidLayer2 w4: v1@-251.48,3675.04 -255,3671.52 v1(-255,3670) -30,3670 -1.27,3698.73 -1.27,3838.73 14.73,3854.73 855,3854.73 ; 790,3854.73 855,3854.73 ; v1(1660,3270) 1660.25,3270 1660.31,3270.06 1660.31,3270.59 1629.62,3301.28 1629.62,3820.5 1595.38,3854.73 855,3854.73
  Bottom Layer w4: C9.2@-279.33,3685 -261.44,3685 ; C9.2@-271.06,3679.72 cw(c-261.44,3673.59) -261.44,3685 ; C9.2@-271.06,3690.28 ccw(c-261.44,3696.41) -261.44,3685 ; v1(-255,3670) -255,3678.56 -261.43,3685
PB_AOUT.R: C16.2 EXTHDR1.29 | length 3831.1
  Top Layer w4: EXTHDR1.29@1687.98,3125.22 ccw(c1682.2,3131) 1690.38,3131 ccw(c1698.55,3131) EXTHDR1.29@1692.77,3125.22 ; EXTHDR1.29@1690.38,3071.85 1690.38,3155.19 v1(1715.19,3180)
  MidLayer1 w4: v1(1149.86,4635.71) 1345.56,4440 1695,4440 1723.52,4411.48 1723.52,3188.33 v1(1715.19,3180)
  Bottom Layer w4: C16.2@-179.33,4184.09 -100,4184.09 -75,4209.09 -75,4320.04 -89.96,4335 -120,4335 -135,4350 -135,4390 -120,4405 50,4405 115.5,4470.5 695.5,4470.5 719.06,4494.06 794.06,4494.06 835,4535 835,4610 870,4645 975,4645 984.29,4635.71 v1(1149.86,4635.71) ; C16.2@-175.22,4179.98 cw(c-165.3,4170.06) -165.3,4184.09 cw(c-165.3,4198.12) C16.2@-175.22,4188.2
PB_SPI.DIN: EXTHDR1.55 U30.L2 | length 7534.1
  Top Layer w4: EXTHDR1.55@1275.27,3122.62 ccw(c1261.61,3136.28) 1280.93,3136.28 ccw(c1300.24,3136.28) EXTHDR1.55@1286.58,3122.62 ; EXTHDR1.55@1280.93,3071.85 1280.93,3149.11 1356.86,3225.04 1484.84,3225.04 1593.17,3333.37 2270.54,3333.37 2775,2828.92 2775,2430 v1(2750,2405) ; v1@2750,2410.5 ccw(c2750,2423.78) 2759.39,2414.39 ccw(c2768.78,2405) v1@2755.5,2405 ; v1@2750,2414.5 ccw(c2750,2437.43) 2766.22,2421.22 ccw(c2782.43,2405) v1@2759.5,2405 ; v2@6654.73,1750.73 6736.05,1750.73 6736.38,1751.07 ; v2@6656.11,1743.89 cw(c6672.63,1727.37) 6672.63,1750.73 ; v2@6658.94,1741.06 cw(c6682.28,1717.72) 6682.28,1750.73 ; v2@6658.94,1754.94 ccw(c6669.09,1765.09) 6669.09,1750.73 ; 6741.56,1754.04 cw(c6734.38,1761.22) 6734.38,1751.07 ccw(c6734.38,1761.22) 6741.56,1754.04 ; 6741.56,1754.04 ccw(c6729.03,1766.57) 6746.75,1766.57 cw(c6729.03,1766.57) 6741.56,1754.04 ; 6741.56,1754.04 cw(c6754.09,1741.51) 6754.09,1759.23 ccw(c6754.09,1741.51) 6741.56,1754.04
  MidLayer2 w4: v1(6107.52,1724.37) 6141.96,1758.81 6243.61,1758.81 6260.3,1775.5 6481.69,1775.5 6519.81,1737.38 6519.81,1729 6548.62,1700.19 6563.44,1700.19 6573.07,1709.81 6600,1709.81 ; v1@6107.52,1729.87 ccw(c6107.52,1743.15) 6116.91,1733.76 ccw(c6126.3,1724.37) v1@6113.02,1724.37 ; v1@6107.52,1733.87 ccw(c6107.52,1756.81) 6123.74,1740.59 ccw(c6139.96,1724.37) v1@6117.02,1724.37 ; v2@6645.79,1740.4 cw(c6635.1,1727.31) 6652,1727.31 ; v2@6648.32,1743.5 cw(c6641.99,1735.75) 6652,1735.75 cw(c6662.01,1735.75) v2@6655.68,1743.5 ; v2(6652,1748) 6652,1727.31 ; v2@6658.21,1740.4 ccw(c6668.9,1727.31) 6652,1727.31 ; 6600,1709.81 6628.69,1709.81 ; 6600,1709.81 6628.69,1709.81 ; 6628.69,1709.81 6634.5,1709.81 6652,1727.31
  Bottom Layer w4: v1@2750,2395.5 cw(c2750,2372.56) 2766.22,2388.78 cw(c2782.43,2405) v1@2759.5,2405 ; v1@2750,2399.5 cw(c2750,2386.22) 2759.39,2395.61 cw(c2768.78,2405) v1@2755.5,2405 ; v1(2750,2405) 2770,2385 2980,2385 3049.5,2315.5 3278.71,2315.5 3307.71,2286.5 3372.19,2286.5 3375.69,2283 3662.84,2283 3662.96,2282.87 4310,2282.87 ; v1@6098.02,1724.28 cw(c6075.83,1724.07) 6091.53,1708.38 ; v1@6102.02,1724.32 cw(c6089.18,1724.2) 6098.26,1715.11 cw(c6107.35,1706.03) v1@6107.47,1718.88 ; v1@6107.43,1714.88 ccw(c6107.22,1692.68) 6091.53,1708.38 ; v1(6107.52,1724.37) 6091.52,1708.37 ; 4310,2282.87 4354.38,2282.87 ; 4310,2282.87 4354.38,2282.87 ; 4354.38,2282.87 4365.81,2282.87 4382.52,2266.16 4382.52,2023.22 4413.37,1992.37 4931.19,1992.37 4942.75,1980.81 4965.19,1958.37 5095,1958.37 ; 5095,1958.37 5194.86,1958.37 ; 5095,1958.37 5194.86,1958.37 ; 5194.86,1958.37 5284.23,1958.37 5409.23,1833.37 ; 5409.23,1833.37 5535,1833.37 ; 5409.23,1833.37 5535,1833.37 ; 5535,1833.37 5742.62,1833.37 5752.81,1823.19 5802.32,1823.19 5805.32,1826.19 5884.07,1826.19 6001.88,1708.37 6091.52,1708.37
PB_SPI.DOUT: EXTHDR1.53 U30.P1 | length 7368.2
  Top Layer w4: v1@1290.87,3000.04 1304.42,3000.04 1312.42,3008.04 ; EXTHDR1.53@1306.9,3020.94 cw(c1294.6,3008.04) 1312.42,3008.04 ; EXTHDR1.53@1312.42,3071.85 1312.42,3008.04 ; EXTHDR1.53@1317.95,3020.94 ccw(c1330.25,3008.04) 1312.42,3008.04 ; v2@6636.46,1648.46 U30.P1@6714.72,1648.46 ; v2@6637.28,1642.72 cw(c6651.15,1628.85) 6651.15,1648.46 ; v2@6640.11,1639.89 cw(c6660.81,1619.19) 6660.81,1648.46 ; v2@6642.94,1637.06 cw(c6670.46,1609.54) 6670.46,1648.46 ; v2@6642.94,1650.94 ccw(c6648.91,1656.91) 6648.91,1648.46 ; U30.P1@6709.53,1643.27 ccw(c6697,1630.74) 6697,1648.46 ccw(c6697,1666.19) U30.P1@6709.53,1653.66
  MidLayer1 w4: v1(1290.87,3000.72) 1315.19,3025.04 1460,3025.04 1484.96,3050 1703.31,3050 1719,3034.31 1719,2821 1735,2805 ; v1@1290.87,3006.22 ccw(c1290.87,3019.5) 1300.26,3010.11 ccw(c1309.65,3000.72) v1@1296.37,3000.72 ; v1@1290.87,3010.22 ccw(c1290.87,3033.16) 1307.09,3016.94 ccw(c1323.31,3000.72) v1@1300.37,3000.72 ; 1735.12,2805.12 2031.86,2508.37 v1(2031.86,2255) ; v1@2025.14,2261.72 ccw(c2008.92,2277.93) 2031.86,2277.93 ccw(c2054.79,2277.93) v1@2038.57,2261.72 ; v1@2027.97,2258.89 ccw(c2018.58,2268.28) 2031.86,2268.28 ccw(c2045.14,2268.28) v1@2035.75,2258.89
  Bottom Layer w4: v1(2031.86,2255) 2064.88,2288.02 2216.98,2288.02 2242.5,2262.5 3362.25,2262.5 3365.87,2258.87 4285,2258.87 4357.52,2186.35 4366.52,2177.35 4366.52,1993.12 4357.52,1984.12 4322,1948.6 4322,1762 4310,1750 4270,1750 4248.86,1728.86 4248.86,1658.35 4265,1642.2 ; v1@2031.86,2260.5 ccw(c2031.86,2273.78) 2041.25,2264.39 ccw(c2050.64,2255) v1@2037.36,2255 ; v1@2031.86,2264.5 ccw(c2031.86,2287.43) 2048.07,2271.22 ccw(c2064.29,2255) v1@2041.36,2255 ; 4265,1641.71 4565.19,1641.71 4574.19,1632.71 4969.69,1632.71 5030.17,1693.19 5676.81,1693.19 5687,1683 5687,1655 5687,1644.38 5687,1642.17 5762.5,1566.67 5784.17,1545 5785,1545 5835,1545 6180,1545 6190,1545 6211.69,1545 6224.09,1545 6253.79,1574.71 6290,1574.71 6415,1574.71 6420,1574.71 6424.88,1574.71 6467.88,1617.71 6600,1617.71 6610.48,1628.19 6620.19,1628.19 v2(6636,1644)
PB_SPI.SCLK: EXTHDR1.57 U30.G1 | length 7235.1
  Top Layer w4: v1@1232.79,3007.44 ccw(c1192.61,3047.62) EXTHDR1.57@1249.43,3047.62 ; v1@1235.62,3004.61 ccw(c1202.27,3037.97) EXTHDR1.57@1249.43,3037.97 ; v1@1238.45,3001.79 ccw(c1211.92,3028.31) EXTHDR1.57@1249.43,3028.31 ; v1(1239.51,3000.72) 1240.19,3000.04 1249.43,3009.28 EXTHDR1.57@1249.43,3071.85 ; v1@1241.27,2998.96 ccw(c1221.58,3018.65) EXTHDR1.57@1249.43,3018.65 ; v1@1244.1,2996.13 ccw(c1231.24,3008.99) 1249.43,3008.99 ; v2@6610,1940 6625.95,1924.05 6668,1924.05 U30.G1@6714.72,1924.05 ; v2@6618.45,1940.27 ccw(c6623.64,1935.93) 6618.86,1931.14 ; v2@6621.52,1937.7 ccw(c6627,1933.11) 6621.94,1928.06 ; U30.G1@6709.53,1918.86 ccw(c6697,1906.33) 6697,1924.05 ccw(c6697,1941.78) U30.G1@6709.53,1929.25
  MidLayer1 w4: v1(1123.52,2285.04) 1148.86,2310.37 1148.86,2888 1090,2946.86 1090,2965 1145,3020 1220.23,3020 v1(1239.51,3000.72) ; v1@1123.52,2290.54 ccw(c1123.52,2303.82) 1132.91,2294.43 ccw(c1142.3,2285.04) v1@1129.02,2285.04 ; v1@1123.52,2294.54 ccw(c1123.52,2317.48) 1139.74,2301.26 ccw(c1155.96,2285.04) v1@1133.02,2285.04 ; v1@1230.01,3000.72 ccw(c1207.07,3000.72) 1223.29,3016.94 ccw(c1239.51,3033.16) v1@1239.51,3010.22 ; v1@1234.01,3000.72 ccw(c1220.73,3000.72) 1230.12,3010.11 ccw(c1239.51,3019.5) v1@1239.51,3006.22
  MidLayer2 w4: v1(1123.52,2285.04) 1170.04,2285.04 1185.37,2300.37 1469.63,2300.37 1503.29,2266.71 1560,2266.71 1585.29,2292 1636.92,2292 1637.7,2291.21 1642.68,2291.21 1643.46,2292 2223.25,2292 2232.75,2282.5 2247.25,2282.5 2259.25,2294.5 3375.5,2294.5 3403.3,2266.71 4998.52,2266.71 5098.52,2166.71 5156.86,2166.71 5425.7,1897.87 5707.28,1897.87 5710.51,1901.1 5737.51,1901.1 5776.43,1940.01 5788.12,1940.01 5794.65,1946.54 5815.71,1946.54 5822.17,1953 5978.75,1953 6179.57,1953 6206.19,1979.62 6236.84,1979.62 6250.75,1965.71 6305.65,1965.71 6325.75,1985.81 6375.5,1985.81 6395.11,1966.21 6420,1966.21 6428.83,1975.04 6449.52,1975.04 6545,1975.04 6559.96,1975.04 6591,1944 6598,1944 ; v1@1127.41,2281.15 cw(c1136.8,2271.76) 1136.8,2285.04 cw(c1136.8,2298.32) v1@1127.41,2288.93 ; v1@1130.24,2278.32 cw(c1146.46,2262.11) 1146.46,2285.04 cw(c1146.46,2307.98) v1@1130.24,2291.76 ; v2@6605.26,1939.55 ccw(c6598,1935.86) 6598,1944 ; v2@6605.26,1948.45 cw(c6598,1952.14) 6598,1944 ; v2(6614,1944) 6598,1944
PBCTRL.1W.ID: EXTHDR1.61 R234.1 U30.R6 | length 9128.3
  Top Layer w4: R234.1@1179.59,3152.92 cw(c1163.06,3136.38) 1186.44,3136.38 ; R234.1@1179.59,3167.08 ccw(c1163.68,3182.99) 1186.18,3182.99 ccw(c1208.68,3182.99) R234.1@1192.77,3167.08 ; EXTHDR1.61@1180.78,3122.62 ccw(c1167.12,3136.28) 1186.44,3136.28 ccw(c1205.75,3136.28) EXTHDR1.61@1192.1,3122.62 ; R234.1@1182.42,3155.75 cw(c1172.71,3146.04) 1186.44,3146.04 ; R234.1@1182.42,3164.25 ccw(c1173.34,3173.33) 1186.18,3173.33 ccw(c1199.02,3173.33) R234.1@1189.94,3164.25 ; EXTHDR1.61@1186.44,3071.85 1186.44,3159.74 R234.1@1186.18,3160 1186.18,3258.71 1194.18,3266.71 1515.19,3266.71 1590.19,3341.71 2273.52,3341.71 3112.7,2502.53 3173.19,2442.04 3173.19,2153.38 3172.8,2152.99 3172.8,2133.89 3173.3,2133.39 3173.3,2066.14 3173.19,2066.03 3173.19,1340.35 3305.17,1208.37 4271.63,1208.37 4280,1200 4373.48,1200 4400.9,1227.42 4531.86,1358.37 v1(4531.86,1466.71) ; 1186.44,3137.64 cw(c1208.05,3137.64) R234.1@1192.77,3152.92 ; 1186.44,3147.29 cw(c1198.4,3147.29) R234.1@1189.94,3155.75 ; v1@4525.14,1459.99 cw(c4508.92,1443.77) 4531.86,1443.77 cw(c4554.79,1443.77) v1@4538.57,1459.99 ; v1@4527.97,1462.82 cw(c4518.58,1453.43) 4531.86,1453.43 cw(c4545.14,1453.43) v1@4535.75,1462.82 ; v2(6896,1470) 6896,1471.69 6877.44,1490.24 6877.44,1505 6887.88,1515.43 6892,1515.43 6896.07,1519.5 6896.07,1589.38 ; 6896.07,1589.38 cw(c6906.22,1589.38) 6899.04,1596.56 ; 6896.07,1589.38 cw(c6906.22,1589.38) 6899.04,1596.56 ; 6899.04,1596.56 cw(c6911.57,1584.03) 6911.57,1601.75 ccw(c6911.57,1584.03) 6899.04,1596.56 ; 6899.04,1596.56 ccw(c6886.51,1609.09) 6904.23,1609.09 cw(c6886.51,1609.09) 6899.04,1596.56
  MidLayer1 w4: v2(6896,1470) 6896,1368.12 6896,1361 6896,1360.5 6872.19,1336.69 ; v2(6905,1282) 6872.19,1314.81 6872.19,1330 ; 6872.19,1330 6872.19,1336.69 ; 6872.19,1330 6872.19,1336.69
  MidLayer2 w4: v2(6030,1516) 6032.81,1516 6068.81,1480 6094,1480 6107.79,1466.21 6196.54,1466.21 6204.54,1458.21 6229.35,1458.21 6254.75,1432.81 6272.32,1432.81 6328.94,1376.2 6350.92,1376.2 6351.53,1376.81 6391.54,1376.81 6442.47,1325.88 6482.06,1325.88 6500.13,1307.81 6534.19,1307.81 6555.5,1286.5 6595.5,1286.5 6622.5,1259.5 6676.44,1259.5 6691.94,1244 6740.81,1244 6752.62,1232.19 6807.38,1232.19 6816.69,1241.5 6871.75,1241.5 6872.75,1242.5 6889.69,1242.5 6905,1257.81 v2(6905,1282) ; v2@6898.06,1275.06 cw(c6881.31,1258.31) 6905,1258.31 cw(c6928.69,1258.31) v2@6911.94,1275.06 ; v2@6900.89,1277.89 cw(c6890.97,1267.97) 6905,1267.97 cw(c6919.03,1267.97) v2@6909.11,1277.89
  Bottom Layer w4: v1@4525.14,1473.43 ccw(c4508.92,1489.64) 4531.86,1489.64 ccw(c4554.79,1489.64) v1@4538.57,1473.43 ; v1@4527.97,1470.6 ccw(c4518.58,1479.99) 4531.86,1479.99 ccw(c4545.14,1479.99) v1@4535.75,1470.6 ; v1(4531.86,1466.71) 4531.86,1571.86 4576.71,1616.71 4976.31,1616.71 5036.79,1677.19 5430,1677.19 ; v2@6023.06,1509.06 ccw(c6006.31,1492.31) 6006.31,1516 ccw(c6006.31,1539.69) v2@6023.06,1522.94 ; v2@6025.89,1511.89 ccw(c6015.97,1501.97) 6015.97,1516 ccw(c6015.97,1530.03) v2@6025.89,1520.11 ; v2(6030,1516) 5974,1516 5966,1524 5883.19,1524 5878.19,1529 ; 5430,1677.19 5535,1677.19 ; 5430,1677.19 5535,1677.19 ; 5535,1677.19 5651.98,1677.19 5663.81,1677.19 5671,1670 ; 5671,1635.54 5777.54,1529 ; 5671,1635.54 5671,1637.75 ; 5671,1635.54 5671,1670 ; 5671,1637.75 5671,1645 ; 5671,1637.75 5671,1645 ; 5671,1645 5671,1658.17 ; 5671,1645 5671,1658.17 ; 5671,1658.17 5671,1670 ; 5777.54,1529 5778.37,1529 ; 5777.54,1529 5810,1529 ; 5778.37,1529 5810,1529 ; 5778.37,1529 5810,1529 ; 5810,1529 5878.19,1529 ; 5810,1529 5878.19,1529
PBCTRL.1W.PIO1: EXTHDR1.69 U30.N1 | length 7970.1
  Top Layer w4: v1@1053.74,3007.17 ccw(c1037.52,3023.39) 1060.46,3023.39 ccw(c1083.39,3023.39) v1@1067.17,3007.17 ; v1@1056.57,3004.34 ccw(c1047.18,3013.73) 1060.46,3013.73 ccw(c1073.73,3013.73) v1@1064.34,3004.34 ; v1(1060.46,3000.46) EXTHDR1.69@1060.46,3071.85 ; v2@6644.45,1681.55 cw(c6659.63,1666.37) 6659.63,1687.83 ; v2(6646,1680) 6653.83,1687.83 6695.04,1687.83 U30.N1@6714.72,1687.83 ; v2@6647.28,1678.72 cw(c6669.29,1656.71) 6669.29,1687.83 ; v2@6650.11,1675.89 cw(c6678.94,1647.06) 6678.94,1687.83 ; v2@6652.94,1673.06 cw(c6688.6,1637.4) 6688.6,1687.83 ; U30.N1@6709.53,1682.64 ccw(c6697,1670.11) 6697,1687.83 ccw(c6697,1705.56) U30.N1@6709.53,1693.03
  MidLayer1 w4: v1@978.28,1998.28 ccw(c962.06,1982.06) 962.06,2005 ccw(c962.06,2027.93) v1@978.28,2011.72 ; v1@981.11,2001.11 ccw(c971.72,1991.72) 971.72,2005 ccw(c971.72,2018.28) v1@981.11,2008.89 ; v1(985,2005) 895,2005 881.86,2018.14 881.86,2970.71 886.19,2975.04 886.19,3031.19 896.71,3041.71 1053.29,3041.71 1060.46,3034.54 v1(1060.46,3000.46) ; v1@1053.74,3007.17 ccw(c1037.52,3023.39) 1060.46,3023.39 ccw(c1083.39,3023.39) v1@1067.17,3007.17 ; v1@1056.57,3004.34 ccw(c1047.18,3013.73) 1060.46,3013.73 ccw(c1073.73,3013.73) v1@1064.34,3004.34
  MidLayer2 w4: v1(985,2005) 1055,2005 1086.69,1973.31 1358.27,1973.31 1385,2000.04 2055,2000.04 2065.04,1990 2078.54,1976.5 2688.32,1976.5 2850.82,2139 2998.62,2139 3050.12,2087.5 3101.73,2087.5 3184.42,2004.81 4978.09,2004.81 5167.02,1815.88 5231.38,1815.88 5240.55,1825.04 5690.19,1825.04 5758.03,1757.21 5763.52,1751.71 5781.69,1733.54 5926.31,1733.54 5970.38,1733.54 5978.92,1725 6009.48,1725 6009.52,1725.04 ; v1@988.89,2001.11 cw(c998.28,1991.72) 998.28,2005 cw(c998.28,2018.28) v1@988.89,2008.89 ; v1@991.72,1998.28 cw(c1007.93,1982.06) 1007.93,2005 cw(c1007.93,2027.93) v1@991.72,2011.72 ; v2@6636.19,1679.76 cw(c6614.39,1679.23) 6629.81,1663.81 ; v2@6640.19,1679.86 cw(c6627.28,1679.54) 6636.41,1670.41 cw(c6645.54,1661.28) v2@6645.86,1674.19 ; v2@6645.76,1670.19 ccw(c6645.23,1648.39) 6629.81,1663.81 ; v2(6646,1680) 6629.81,1663.81 ; 6009.52,1725.04 6012.29,1727.81 ; 6009.52,1725.04 6012.29,1727.81 ; 6012.29,1727.81 6013.35,1728.87 ; 6012.29,1727.81 6013.35,1728.87 ; 6013.35,1728.87 6037.19,1752.71 6057.86,1752.71 6090.19,1720.37 6090.19,1715.04 6098.52,1706.71 6116.71,1706.71 6160.81,1750.81 6246.92,1750.81 6263.61,1767.5 6452.69,1767.5 6478.19,1742 6478.19,1728.62 6495.31,1711.5 6508.5,1711.5 6556.19,1663.81 6629.81,1663.81
PBCTRL.1W.PIO2: EXTHDR1.71 U30.M8 | length 11415.8
  Top Layer w4: EXTHDR1.71@1023.3,3021.07 cw(c1009.65,3007.42) 1028.96,3007.42 cw(c1048.27,3007.42) EXTHDR1.71@1034.62,3021.07 ; EXTHDR1.71@1031.86,3075.04 1028.96,3075.04 EXTHDR1.71@1028.96,3071.85 1028.96,2980.48 1015.19,2966.71 894.52,2966.71 886.19,2975.04 886.19,3000.04 877.86,3008.37 568.37,3008.37 548.52,2988.52 548.52,2760 563.52,2745 600,2745 610,2755 750,2755 810,2695 870,2695 881.86,2683.14 881.86,2588.14 915,2555 915,2143.9 944.9,2114 1271.63,2114 1346.63,2189 1552.94,2189 1678.94,2315 2101.06,2315 2284.06,2132 2963,2132 3053.5,2041.5 3053.5,2041.36 3148.86,1946 3148.86,1281.14 3195,1235 3243.92,1235 3578.54,900.37 4875.37,900.37 5137.5,1162.5 5137.5,1218.4 5106.86,1249.04 5106.86,1441.71 5120.5,1455.35 5120.5,1764.73 v1(5098.52,1786.71) ; v1@5098.52,1777.21 cw(c5098.52,1754.27) 5114.74,1770.49 cw(c5130.96,1786.71) v1@5108.02,1786.71 ; v1@5098.52,1781.21 cw(c5098.52,1767.93) 5107.91,1777.32 cw(c5117.3,1786.71) v1@5104.02,1786.71 ; v2@6566.43,1575.32 cw(c6562.45,1567.75) 6571,1567.75 ; v2(6571,1584) 6571,1567.75 ; v2@6575.57,1575.32 ccw(c6579.55,1567.75) 6571,1567.75 ; v2@6936.6,1207.06 ccw(c6919.85,1190.31) 6919.85,1214 ccw(c6919.85,1237.69) v2@6936.6,1220.94 ; v2@6939.42,1209.89 ccw(c6929.5,1199.97) 6929.5,1214 ccw(c6929.5,1228.03) v2@6939.42,1218.11 ; v2@6943.77,1213.77 6944,1214 v2(6943.53,1214) 6913.57,1214 6862.07,1162.5 6839.44,1162.5 6781.75,1220.19 6747.65,1220.19 6727.42,1240.42 6727.42,1271.33 6705.25,1293.5 6704.31,1293.5 6691.81,1306 6691.81,1313.38 6691.5,1313.69 6691.5,1356.5 6584.19,1463.81 6584.19,1554.56 6571,1567.75 ; v3(6970.63,1707.52) U30.M8@6990.32,1727.2 ; U30.M8@6982.97,1727.2 cw(c6965.25,1727.2) 6977.78,1714.67 cw(c6990.31,1702.14) U30.M8@6990.31,1719.86 ; 6983.43,1720.32 cw(c6970.63,1733.13) 6970.63,1715.02 ccw(c6970.63,1733.13) 6983.43,1720.32 ; 6983.43,1720.32 ccw(c6996.24,1707.52) 6978.13,1707.52 cw(c6996.24,1707.52) 6983.43,1720.32
  MidLayer1 w4: v2@6936.6,1220.94 ccw(c6913.89,1243.64) 6946,1243.64 ; v2@6939.42,1218.11 ccw(c6923.55,1233.99) 6946,1233.99 ; v2(6943.53,1214) 6946,1214 6946,1246.43 6966.19,1266.62 6966.19,1275.69 6977.81,1287.31 6977.81,1316.38 6957.48,1336.71 6957.48,1385.98 6962.19,1390.69 6962.19,1442.69 6991.5,1472 v2(6996,1472) ; 6946,1231.73 ccw(c6961.26,1231.73) v2@6950.47,1220.94
  MidLayer2 w4: v1@5091.81,1779.99 cw(c5075.59,1763.77) 5098.52,1763.77 cw(c5121.46,1763.77) v1@5105.24,1779.99 ; v1@5094.64,1782.82 cw(c5085.25,1773.43) 5098.52,1773.43 cw(c5111.8,1773.43) v1@5102.41,1782.82 ; v1(5098.52,1786.71) 5098.52,1709.48 5108.19,1699.81 5477.26,1699.81 5577.03,1600.04 6210,1600.04 6240.04,1570 6311.27,1570 6366.31,1625.04 6554.96,1625.04 ; 6390,1625.04 6554.96,1625.04 ; v2@6564.06,1590.94 ccw(c6547.31,1607.69) 6571,1607.69 ccw(c6594.69,1607.69) v2@6577.94,1590.94 ; v2@6566.89,1588.11 ccw(c6556.97,1598.03) 6571,1598.03 ccw(c6585.03,1598.03) v2@6575.11,1588.11 ; v2(6571,1584) 6571,1609 6554.96,1625.04 ; 6959.24,1693.94 ccw(c6969.17,1684.01) 6955.12,1684.01 6955.12,1590.47 6955.12,1541.07 6996,1500.19 v2(6996,1472) ; v3@6963.16,1706.87 cw(c6945.12,1705.29) 6958.99,1693.65 cw(c6972.86,1682.01) v3@6971.28,1700.05 ; v2@6989.06,1478.94 ccw(c6972.31,1495.69) 6996,1495.69 ccw(c7019.69,1495.69) v2@7002.94,1478.94 ; v2@6991.89,1476.11 ccw(c6981.97,1486.03) 6996,1486.03 ccw(c7010.03,1486.03) v2@7000.11,1476.11
PBCTRL.CLK.CLK0: EXTHDR1.51 U30.K6 | length 7512.2
  Top Layer w4: EXTHDR1.51@1338.26,3122.62 ccw(c1324.61,3136.28) 1343.92,3136.28 ccw(c1363.23,3136.28) EXTHDR1.51@1349.58,3122.62 ; EXTHDR1.51@1343.92,3071.85 1343.92,3200.79 1360.17,3217.04 1488.15,3217.04 1596.15,3325.04 2267.56,3325.04 2467.3,3125.3 2480,3112.6 v1(2480,2390) ; v1@2473.28,2396.72 ccw(c2457.06,2412.93) 2480,2412.93 ccw(c2502.93,2412.93) v1@2486.72,2396.72 ; v1@2476.11,2393.89 ccw(c2466.72,2403.28) 2480,2403.28 ccw(c2493.28,2403.28) v1@2483.89,2393.89 ; v3(6891.89,1786.26) U30.K6@6911.57,1805.94 ; U30.K6@6904.23,1805.94 cw(c6886.51,1805.94) 6899.04,1793.41 cw(c6911.57,1780.88) U30.K6@6911.57,1798.6 ; 6904.69,1799.06 cw(c6891.89,1811.87) 6891.89,1793.76 ccw(c6891.89,1811.87) 6904.69,1799.06 ; 6904.69,1799.06 ccw(c6917.5,1786.26) 6899.39,1786.26 cw(c6917.5,1786.26) 6904.69,1799.06
  MidLayer2 w4: v2(6621.31,1727.63) 6621.31,1742.5 6644.62,1765.81 6659.38,1765.81 6662.79,1762.4 6735.47,1762.4 6754.89,1762.4 6829.01,1762.4 6848.51,1762.4 ccw(c6848.51,1804.13) 6878.02,1774.62 ; v3@6884.42,1786.91 cw(c6866.38,1788.49) 6878.02,1774.62 ; v3@6891.24,1778.79 ccw(c6889.66,1760.75) 6878.02,1774.62
  Bottom Layer w4: v1(2480,2390) 2523.37,2433.37 2971.67,2433.37 3073.54,2331.5 3285.34,2331.5 3314.34,2302.5 3378.82,2302.5 3381.28,2300.04 3490.19,2300.04 3573.52,2383.37 4331.86,2383.37 4398.52,2316.71 4398.52,2050 ; v1@2480,2395.5 ccw(c2480,2408.78) 2489.39,2399.39 ccw(c2498.78,2390) v1@2485.5,2390 ; v1@2480,2399.5 ccw(c2480,2422.43) 2496.22,2406.22 ccw(c2512.43,2390) v1@2489.5,2390 ; 4398.52,2035 4398.52,2050 ; v2@6614.37,1720.69 ccw(c6597.63,1703.94) 6597.63,1727.63 ccw(c6597.63,1751.31) v2@6614.37,1734.56 ; v2@6617.2,1723.52 ccw(c6607.28,1713.6) 6607.28,1727.63 ccw(c6607.28,1741.65) v2@6617.2,1731.73 ; v2(6621.31,1727.63) 6593.56,1727.63 6548.76,1772.43 6295.63,1772.43 6292.56,1775.5 6117.32,1775.5 6114.24,1772.43 6058.52,1716.71 6004.86,1716.71 5887.38,1834.19 5802,1834.19 5799,1831.19 5756.12,1831.19 5745.6,1841.71 5412.21,1841.71 5287.54,1966.37 5138.27,1966.37 5096.27,2008.37 4420,2008.37 4398.52,2029.85 4398.52,2050
PBCTRL.CLK.CLK1: EXTHDR1.45 U30.L3 | length 7226.7
  Top Layer w4: v1@1433.47,3136.32 cw(c1421.55,3124.41) EXTHDR1.45@1438.41,3124.41 ; EXTHDR1.45@1438.41,3071.85 v1@1438.41,3141.26 ; EXTHDR1.45@1438.41,3115.81 cw(c1467.42,3115.81) v1@1446.91,3136.32 ; EXTHDR1.45@1438.41,3125.46 cw(c1457.77,3125.46) v1@1444.08,3139.15 ; v3(6773.78,1746.89) U30.L3@6793.46,1766.57 ; U30.L3@6786.12,1766.57 cw(c6768.4,1766.57) 6780.93,1754.04 cw(c6793.46,1741.51) U30.L3@6793.46,1759.23 ; 6786.58,1759.69 cw(c6773.78,1772.5) 6773.78,1754.39 ccw(c6773.78,1772.5) 6786.58,1759.69 ; 6786.58,1759.69 ccw(c6799.39,1746.89) 6781.28,1746.89 cw(c6799.39,1746.89) 6786.58,1759.69
  MidLayer1 w4: v1(1440.19,3143.04) 1472.19,3175.04 1600.9,3175.04 1735,3040.94 1735,2827.86 1771.25,2791.61 2100,2462.86 2100,2280 2120.63,2259.37 2199.37,2259.37 v1(2240,2300) ; v1@1440.19,3148.54 ccw(c1440.19,3161.82) 1449.58,3152.43 ccw(c1458.97,3143.04) v1@1445.69,3143.04 ; v1@1440.19,3152.54 ccw(c1440.19,3175.48) 1456.41,3159.26 ccw(c1472.63,3143.04) v1@1449.69,3143.04 ; v1@2230.5,2300 cw(c2207.56,2300) 2223.78,2283.78 cw(c2240,2267.56) v1@2240,2290.5 ; v1@2234.5,2300 cw(c2221.22,2300) 2230.61,2290.61 cw(c2240,2281.22) v1@2240,2294.5 ; v2(6542,1754) 6544,1752 6566,1752 ; v2@6546.6,1757.54 ccw(c6557.87,1766.22) 6557.87,1752 ; v2@6548.94,1747.06 cw(c6560.86,1735.14) 6560.86,1752 ; v2@6549.77,1759.99 ccw(c6566,1772.48) 6566,1752 ; 6758.92,1736.47 cw(c6741.27,1764.51) 6741.1,1731.38 6658.41,1731.38 6634.83,1707.8 6610.2,1707.8 6566,1752 ; v3@6766.39,1748.19 cw(c6748.56,1751.34) 6758.95,1736.5 cw(c6769.33,1721.67) v3@6772.48,1739.5
  Bottom Layer w4: v1(2240,2300) 2748.94,2300 2749.44,2299.5 3272.08,2299.5 3301.08,2270.5 3365.56,2270.5 3369.19,2266.87 4288.31,2266.87 4305.35,2249.84 4350.09,2205.09 4365.52,2189.66 4374.52,2180.66 4374.52,1989.81 4365.52,1980.81 4330,1945.29 4330,1755.24 4340.33,1744.92 4385.21,1700.04 4867.56,1700.04 4992.56,1825.04 5739.64,1825.04 5749.49,1815.19 5805.63,1815.19 5808.63,1818.19 5880.75,1818.19 5998.9,1700.04 6115.19,1700.04 6182.65,1767.5 6289.25,1767.5 6292.94,1763.81 6508.19,1763.81 6518,1754 v2(6542,1754) ; v1@2243.89,2296.11 cw(c2253.28,2286.72) 2253.28,2300 cw(c2253.28,2313.28) v1@2243.89,2303.89 ; v1@2246.72,2293.28 cw(c2262.93,2277.06) 2262.93,2300 cw(c2262.93,2322.93) v1@2246.72,2306.72 ; v2@6535.06,1747.06 ccw(c6518.31,1730.31) 6518.31,1754 ccw(c6518.31,1777.69) v2@6535.06,1760.94 ; v2@6537.89,1749.89 ccw(c6527.97,1739.97) 6527.97,1754 ccw(c6527.97,1768.03) v2@6537.89,1758.11
PBCTRL.CLK.CLK2: EXTHDR1.47 U30.L4 | length 6937.9
  Top Layer w4: EXTHDR1.47@1405.05,3018.95 cw(c1404.49,3016.65) 1406.86,3016.65 ; EXTHDR1.47@1405.14,3018.93 cw(c1404.63,3016.71) 1406.91,3016.71 ; v1(1406.86,3001.04) 1406.86,3016.65 ; EXTHDR1.47@1406.91,3071.85 1406.91,3016.71 ; v3(6813.15,1746.89) U30.L4@6832.83,1766.57 ; U30.L4@6825.49,1766.57 cw(c6807.77,1766.57) 6820.3,1754.04 cw(c6832.83,1741.51) U30.L4@6832.83,1759.23 ; 1406.86,3016.65 cw(c1409.19,3016.65) 1408.68,3018.93 ccw(c1409.19,3016.71) 1406.91,3016.71 ; 1406.86,3016.65 1406.91,3016.71 ; 6825.95,1759.69 cw(c6813.15,1772.5) 6813.15,1754.39 ccw(c6813.15,1772.5) 6825.95,1759.69 ; 6825.95,1759.69 ccw(c6838.76,1746.89) 6820.65,1746.89 cw(c6838.76,1746.89) 6825.95,1759.69
  MidLayer1 w4: v1@1397.36,3001.04 cw(c1374.42,3001.04) 1390.64,2984.82 cw(c1406.86,2968.61) v1@1406.86,2991.54 ; v1@1401.36,3001.04 cw(c1388.08,3001.04) 1397.47,2991.65 cw(c1406.86,2982.26) v1@1406.86,2995.54 ; v1(1406.86,3001.04) 1381.86,2976.04 1381.86,2955 1396.86,2940 1422.25,2940 1590.19,2772.06 1590.19,2308.5 1762.7,2135.99 1762.7,2060.87 v1(1790.19,2033.37) ; v1@1780.69,2033.37 ccw(c1757.76,2033.37) 1773.97,2049.59 ccw(c1790.19,2065.81) v1@1790.19,2042.87 ; v1@1784.69,2033.37 ccw(c1771.41,2033.37) 1780.8,2042.76 ccw(c1790.19,2052.15) v1@1790.19,2038.87 ; v2(6556,1718) 6574.75,1718 6592.95,1699.8 6641.3,1699.8 6664.53,1723.03 6676.15,1723.03 6750.27,1723.03 ; v2@6564.06,1712.41 cw(c6574.75,1704.99) 6574.75,1718 cw(c6574.75,1731.01) v2@6564.06,1723.59 ; 6736.34,1723.03 6750.27,1723.03 ; v3@6805.76,1748.19 cw(c6787.93,1751.34) 6798.32,1736.5 ; v3@6811.85,1739.5 ccw(c6808.7,1721.67) 6798.32,1736.5 ; 6750.27,1723.03 6773.52,1723.03 ccw(c6773.52,1746.8) 6789.74,1729.42 6798.32,1736.5
  MidLayer2 w4: v1@1790.19,2023.87 cw(c1790.19,2000.94) 1806.41,2017.16 cw(c1822.63,2033.37) v1@1799.69,2033.37 ; v1@1790.19,2027.87 cw(c1790.19,2014.6) 1799.58,2023.99 cw(c1808.97,2033.37) v1@1795.69,2033.37 ; v1(1790.19,2033.37) 1813.56,2010 2056.35,2010 2081.85,1984.5 2685,1984.5 2847.5,2147 3001.94,2147 3053.44,2095.5 3105.05,2095.5 3150.51,2050.04 3187.74,2012.81 4981.42,2012.81 5170.35,1823.88 5228.07,1823.88 5238.06,1833.87 5694.03,1833.87 5694.52,1833.37 5786.19,1741.71 5973.52,1741.71 5981.86,1733.37 6006.54,1733.37 6041.36,1768.19 6241.67,1768.19 6256.98,1783.5 6485,1783.5 6488.69,1779.81 6538.47,1730.03 6540.31,1728.19 v2@6552.53,1715.97
PBCTRL.CLK.EN: EXTHDR1.49 U30.M9 | length 10314.2
  Top Layer w4: EXTHDR1.49@1369.76,3021.07 cw(c1356.1,3007.42) 1375.42,3007.42 cw(c1394.73,3007.42) EXTHDR1.49@1381.07,3021.07 ; EXTHDR1.49@1375.42,3071.85 1375.42,2998.15 v1(1406.86,2966.71) ; v1@1397.36,2966.71 ccw(c1374.42,2966.71) 1390.64,2982.93 ccw(c1406.86,2999.14) v1@1406.86,2976.21 ; v1@1401.36,2966.71 ccw(c1388.08,2966.71) 1397.47,2976.1 ccw(c1406.86,2985.49) v1@1406.86,2972.21 ; v2@5415.09,1633.5 cw(c5410.18,1625) 5420,1625 ; v2@5422.5,1639.5 v2(5420,1642) 5420,1625 ; v2@5424.91,1633.5 ccw(c5429.82,1625) 5420,1625 ; v1@5975.14,840.09 ccw(c5958.92,856.31) 5981.86,856.31 ccw(c6004.79,856.31) v1@5988.57,840.09 ; v1@5977.97,837.26 ccw(c5968.58,846.65) 5981.86,846.65 ccw(c5995.14,846.65) v1@5985.75,837.26 ; v1(5981.86,833.37) 5981.86,1034.89 5512.75,1504 5491.25,1504 5422.5,1572.75 5422.5,1622.5 5420,1625 ; v2@6819.06,1207.06 cw(c6802.31,1190.31) 6826,1190.31 cw(c6849.69,1190.31) v2@6832.94,1207.06 ; v2@6821.89,1209.89 cw(c6811.97,1199.97) 6826,1199.97 cw(c6840.03,1199.97) v2@6830.11,1209.89 ; v2(6826,1214) 6826,1187.25 6842.75,1170.5 6858.75,1170.5 6969.81,1281.56 6969.81,1312.66 7001.1,1343.95 7001.1,1376.17 v2(7016.28,1391.34) ; U30.M9@7029.68,1719.86 cw(c7029.68,1702.14) 7042.22,1714.67 cw(c7054.75,1727.2) U30.M9@7037.03,1727.2 ; U30.M9@7029.69,1727.2 v3(7049.37,1707.52) ; 7036.57,1720.32 cw(c7023.76,1707.52) 7041.87,1707.52 ccw(c7023.76,1707.52) 7036.57,1720.32 ; 7036.57,1720.32 ccw(c7049.37,1733.13) 7049.37,1715.02 cw(c7049.37,1733.13) 7036.57,1720.32
  MidLayer1 w4: v1@1406.86,2957.21 cw(c1406.86,2934.27) 1423.07,2950.49 cw(c1439.29,2966.71) v1@1416.36,2966.71 ; v1@1406.86,2961.21 cw(c1406.86,2947.93) 1416.25,2957.32 cw(c1425.64,2966.71) v1@1412.36,2966.71 ; v1(1406.86,2966.71) 1598.19,2775.37 1598.19,2311.81 1790,2120 1915,2120 1930,2105 1930,1910.23 1975.23,1865 v1(2035,1865)
  MidLayer2 w4: v1@2028.28,1858.28 cw(c2012.06,1842.06) 2035,1842.06 cw(c2057.93,1842.06) v1@2041.72,1858.28 ; v1@2031.11,1861.11 cw(c2021.72,1851.72) 2035,1851.72 cw(c2048.28,1851.72) v1@2038.89,1861.11 ; v1(2035,1865) 2035,1805.23 2055,1785.23 2055,1397 2064,1388 2105.82,1388 2125.99,1367.83 2510.45,983.37 3598.52,983.37 3623.19,1008.04 4340,1008.04 4431.96,1100 4550,1100 4798.52,1100.04 4807.19,1091.37 5270.88,1091.37 5290.19,1072.06 5290.19,869.81 5305,855 5960.23,855 v1(5981.86,833.37) ; v2(5420,1642) 5467.19,1642 5501.98,1607.21 5611.69,1497.5 5752.82,1497.5 5764.86,1509.54 5820.64,1509.54 5871.68,1458.5 6041.54,1458.5 6047.04,1464 6087.37,1464 6101.16,1450.21 6189.92,1450.21 6197.92,1442.21 6222.72,1442.21 6248.12,1416.81 6265.7,1416.81 6322.31,1360.2 6357.55,1360.2 6358.16,1360.81 6384.91,1360.81 6435.84,1309.88 6475.43,1309.88 6493.5,1291.81 6527.56,1291.81 6548.87,1270.5 6588.87,1270.5 6615.87,1243.5 6669.81,1243.5 6685.62,1227.69 6734.49,1227.69 6748.18,1214 v2(6826,1214) ; v2@5424.11,1637.89 cw(c5434.03,1627.97) 5434.03,1642 cw(c5434.03,1656.03) v2@5424.11,1646.11 ; v2@5426.94,1635.06 cw(c5443.69,1618.31) 5443.69,1642 cw(c5443.69,1665.69) v2@5426.94,1648.94 ; v2(7016.28,1391.34) 7016.28,1428.03 7069.81,1481.56 7069.81,1503.38 7064.88,1508.31 7064.88,1590.47 7064.88,1684.01 ccw(c7050.83,1684.01) 7060.76,1693.94 ; v3@7048.72,1700.05 cw(c7047.14,1682.01) 7061.01,1693.65 cw(c7074.88,1705.29) v3@7056.84,1706.87
PBCTRL.JTAG.DETECT: R232.1 R233.1 U30.R1 | length 5971.8
  Top Layer w4: 3189,2140.32 3189,2146.56 ; 3189.19,2059.4 3189.19,1376.81 3349.29,1216.71 4256.67,1216.71 4290,1250.04 4323.52,1250.04 4348.52,1275.04 v1(4348.52,1516.71) ; 3189.19,2146.75 3189.19,2321.04 v1(3231.86,2363.71) ; 3189.3,2059.51 3189.3,2140.02 ; v1@3222.36,2363.71 cw(c3199.42,2363.71) 3215.64,2347.49 cw(c3231.86,2331.27) v1@3231.86,2354.21 ; v1@3226.36,2363.71 cw(c3213.08,2363.71) 3222.47,2354.32 cw(c3231.86,2344.93) v1@3231.86,2358.21 ; v1@4341.81,1509.99 cw(c4325.59,1493.77) 4348.52,1493.77 cw(c4371.46,1493.77) v1@4355.24,1509.99 ; v1@4344.64,1512.82 cw(c4335.25,1503.43) 4348.52,1503.43 cw(c4361.8,1503.43) v1@4352.41,1512.82 ; U30.R1@6709.53,1603.9 ccw(c6697,1591.37) 6697,1609.09 ccw(c6697,1626.82) U30.R1@6709.53,1614.29 ; U30.R1@6714.72,1609.09 6681.09,1609.09 6667,1595 6637,1595 v2(6624,1608) ; v2(6624,1608) 6624,1609.42 6623.71,1609.71 6623.71,1608.29 v2(6624,1608)
  Bottom Layer w4: R233.1@3146.18,2450 R232.1@3228.82,2450 3228.82,2425.08 3231.86,2422.04 v1(3231.86,2363.71) ; R233.1@3149.94,2446.24 cw(c3159.02,2437.16) 3159.02,2450 cw(c3159.02,2462.84) R233.1@3149.94,2453.76 ; R233.1@3152.77,2443.41 cw(c3168.68,2427.5) 3168.68,2450 cw(c3168.68,2472.5) R233.1@3152.77,2456.59 ; R232.1@3222.23,2442.92 cw(c3206.32,2427.01) 3228.82,2427.01 cw(c3251.32,2427.01) R232.1@3235.41,2442.92 ; R232.1@3222.23,2443.41 ccw(c3206.32,2427.5) 3206.32,2450 ccw(c3206.32,2472.5) R232.1@3222.23,2456.59 ; R232.1@3225.06,2445.75 cw(c3215.98,2436.67) 3228.82,2436.67 cw(c3241.66,2436.67) R232.1@3232.58,2445.75 ; R232.1@3225.06,2446.24 ccw(c3215.98,2437.16) 3215.98,2450 ccw(c3215.98,2462.84) R232.1@3225.06,2453.76 ; v1@3225.14,2370.43 ccw(c3208.92,2386.64) 3231.86,2386.64 ccw(c3254.79,2386.64) v1@3238.57,2370.43 ; v1@3227.97,2367.6 ccw(c3218.58,2376.99) 3231.86,2376.99 ccw(c3245.14,2376.99) v1@3235.75,2367.6 ; v1@4341.81,1509.99 ccw(c4325.59,1493.77) 4325.59,1516.71 ccw(c4325.59,1539.64) v1@4341.81,1523.43 ; v1@4344.64,1512.82 ccw(c4335.25,1503.43) 4335.25,1516.71 ccw(c4335.25,1529.99) v1@4344.64,1520.6 ; v1(4348.52,1516.71) 4265.19,1516.71 4248.52,1533.37 4248.52,1616.71 4265.19,1633.37 4562.21,1633.37 4570.58,1625 ; 4570.58,1624.71 4973,1624.71 5033.48,1685.19 5655.29,1685.19 5668.81,1685.19 5679,1675 5679,1661.48 5679,1638.85 ; 5679,1641.06 5679,1638.85 ; 5781.69,1537 5790,1537 ; 6596.19,1609.71 cw(c6596.19,1580.19) v2@6617.06,1601.06 ; 6604.44,1609.71 ccw(c6604.44,1627.56) v2@6617.06,1614.94 ; 6605.85,1609.71 cw(c6605.85,1589.85) v2@6619.89,1603.89 ; v2(6624,1608) 6624,1609.42 6623.71,1609.71 6471.19,1609.71 6428.19,1566.71 6265,1566.71 6257.11,1566.71 6227.4,1537 6215,1537 6195,1537 5790,1537 ; 5679,1638.85 5754.5,1563.35 5778.85,1539 5780.85,1537 5790,1537
PBCTRL.JTAG.HARD.TCK: R219.1 R223.1 U30.F3 | length 4903.1
  Top Layer w4: v3(6773.78,1983.11) U30.F3@6793.46,1963.43 ; U30.F3@6786.12,1963.43 ccw(c6768.4,1963.43) 6780.93,1975.96 ccw(c6793.46,1988.49) U30.F3@6793.46,1970.77 ; 6786.58,1970.31 cw(c6799.39,1983.11) 6781.28,1983.11 ccw(c6799.39,1983.11) 6786.58,1970.31 ; 6786.58,1970.31 ccw(c6773.78,1957.5) 6773.78,1975.61 cw(c6773.78,1957.5) 6786.58,1970.31
  MidLayer1 w4: v2(6644,2014) 6659.38,1998.62 6741.1,1998.62 cw(c6741.27,1965.49) 6758.92,1993.53 ; v3@6766.39,1981.81 ccw(c6748.56,1978.66) 6758.95,1993.5 ccw(c6769.33,2008.33) v3@6772.48,1990.5
  Bottom Layer w4: R223.1@3146.18,2885 R219.1@3228.82,2885 3260.53,2916.71 3330,2916.71 3355.67,2942.37 3928.94,2942.37 4044.31,2827 4238.23,2827 4328,2827 4372.46,2782.54 4621.38,2782.54 4840.19,2563.73 4840.19,2052.5 4843.31,2049.37 5089.37,2049.37 ; R223.1@3149.94,2881.24 cw(c3159.02,2872.16) 3159.02,2885 cw(c3159.02,2897.84) R223.1@3149.94,2888.76 ; R223.1@3152.77,2878.41 cw(c3168.68,2862.5) 3168.68,2885 cw(c3168.68,2907.5) R223.1@3152.77,2891.59 ; R219.1@3222.23,2878.41 ccw(c3206.32,2862.5) 3206.32,2885 ccw(c3206.32,2907.5) R219.1@3222.23,2891.59 ; R219.1@3225.06,2881.24 ccw(c3215.98,2872.16) 3215.98,2885 ccw(c3215.98,2897.84) R219.1@3225.06,2888.76 ; R219.1@3228.82,2890.81 ccw(c3228.82,2904.84) R219.1@3238.74,2894.92 ; R219.1@3228.82,2894.81 ccw(c3228.82,2918.5) 3245.57,2901.75 ; R219.1@3234.14,2885.49 cw(c3245.79,2885.49) R219.1@3237.55,2893.73 ; R219.1@3238.14,2885.49 cw(c3259.45,2885.49) 3244.38,2900.56 ; 5089.71,2049.71 5115,2075 5556.86,2075.04 5573.52,2058.37 5573.52,1950 5599.25,1924.27 5599.25,1923.74 5599.5,1923.49 5599.5,1885.5 5611.29,1873.71 5721.82,1873.71 5809.92,1961.81 6255.37,1961.81 6287,1930.19 6459,1930.19 6474.62,1945.81 6537.81,1945.81 6598.19,2006.19 6620,2006.19 6627.81,2014 ; v2@6635.3,2009.46 ccw(c6627.81,2005.55) 6627.81,2014 ; v2@6635.3,2018.54 cw(c6627.81,2022.45) 6627.81,2014 ; v2(6644,2014) 6627.81,2014
PBCTRL.JTAG.HARD.TDI: R216.1 R220.1 U30.F1 | length 5053.4
  Top Layer w4: v1@4328.81,2846.99 cw(c4312.59,2830.77) 4335.52,2830.77 cw(c4358.46,2830.77) v1@4342.24,2846.99 ; v1@4331.64,2849.82 cw(c4322.25,2840.43) 4335.52,2840.43 cw(c4348.8,2840.43) v1@4339.41,2849.82 ; v1(4335.52,2853.71) 4335.52,2819.48 4354.96,2800.04 v1(4389.19,2800.04) ; v1@4382.47,2793.32 ccw(c4366.26,2777.11) 4366.26,2800.04 ccw(c4366.26,2822.98) v1@4382.47,2806.76 ; v1@4385.3,2796.15 ccw(c4375.91,2786.76) 4375.91,2800.04 ccw(c4375.91,2813.32) v1@4385.3,2803.93 ; v1@6564,1996.5 cw(c6564,1981.05) 6574.92,1991.98 ; v1@6564,2002.9 6597.09,1969.81 6624.69,1969.81 6631.5,1963 6714.3,1963 U30.F1@6714.72,1963.43 ; v1@6569.5,2006 ccw(c6590.26,2006) 6575.58,1991.32 ; v1@6573.5,2006 ccw(c6603.92,2006) 6582.41,1984.49 ; U30.F1@6709.53,1958.23 ccw(c6697,1945.7) 6697,1963.42 ccw(c6697,1981.15) U30.F1@6709.53,1968.62
  MidLayer2 w4: v1@5151.14,2390.09 ccw(c5134.92,2406.31) 5157.86,2406.31 ccw(c5180.79,2406.31) v1@5164.57,2390.09 ; v1@5153.97,2387.26 ccw(c5144.58,2396.65) 5157.86,2396.65 ccw(c5171.14,2396.65) v1@5161.75,2387.26 ; v1(5157.86,2383.37) 5157.86,2418.92 5163.98,2425.04 5367.65,2425.04 5448.52,2344.16 5448.52,2316.71 5465.19,2300.04 5579.15,2300.04 5594.19,2285 5594.19,2215 5584.46,2205.27 5584.46,2020.88 5647.34,1958 5695.42,1958 5712.96,1975.54 5734.46,1975.54 5753.99,1956.01 5781.5,1956.01 5788.02,1962.54 5809.09,1962.54 5815.55,1969 6172.94,1969 6199.56,1995.62 6252.79,1995.62 6271.36,2014.19 6381.96,2014.19 6384.98,2017.21 6433.21,2017.21 6435.92,2014.49 6450.68,2014.49 6457,2020.81 6546.09,2020.81 v1@6560.9,2006 ; 6547.64,2019.26 ccw(c6558.32,2029.94) v1@6561.81,2015.24 ; 6549.98,2016.92 cw(c6539.05,2006) v1@6554.5,2006 ; 6552.71,2014.19 ccw(c6560.26,2021.75) v1@6562.73,2011.35
  Bottom Layer w4: R220.1@3146.18,3030 R216.1@3228.82,3030 3228.82,3046.71 ; R220.1@3149.94,3026.24 cw(c3159.02,3017.16) 3159.02,3030 cw(c3159.02,3042.84) R220.1@3149.94,3033.76 ; R220.1@3152.77,3023.41 cw(c3168.68,3007.5) 3168.68,3030 cw(c3168.68,3052.5) R220.1@3152.77,3036.59 ; R216.1@3222.23,3023.41 ccw(c3206.32,3007.5) 3206.32,3030 ccw(c3206.32,3052.5) R216.1@3222.23,3036.59 ; R216.1@3224.13,3038.54 ccw(c3219.37,3046.71) 3228.82,3046.71 ; R216.1@3225.06,3026.24 ccw(c3215.98,3017.16) 3215.98,3030 ccw(c3215.98,3042.84) R216.1@3225.06,3033.76 ; R216.1@3233.51,3038.54 cw(c3238.27,3046.71) 3228.82,3046.71 ; v1@4328.81,2846.99 ccw(c4312.59,2830.77) 4312.59,2853.71 ccw(c4312.59,2876.64) v1@4328.81,2860.43 ; v1@4331.64,2849.82 ccw(c4322.25,2840.43) 4322.25,2853.71 ccw(c4322.25,2866.99) v1@4331.64,2857.6 ; v1(4335.52,2853.71) 4310,2853.71 4303.71,2860 4033.94,2860 3935.57,2958.37 3520,2958.37 3430,3048.37 3230.49,3048.37 3228.82,3046.71 ; v1(4389.19,2800.04) 4416.15,2827 4588.23,2827 4909.01,2506.22 4909.01,2505.97 4925.36,2489.62 4925.36,2475.13 4925,2474.77 4925,2425 4941.63,2408.37 5031.86,2408.37 5040.19,2400.04 5040.19,2366.71 5048.52,2358.37 5132.86,2358.37 v1(5157.86,2383.37) ; v1@4389.19,2805.54 ccw(c4389.19,2818.82) 4398.58,2809.43 ccw(c4407.97,2800.04) v1@4394.69,2800.04 ; v1@4389.19,2809.54 ccw(c4389.19,2832.48) 4405.41,2816.26 ccw(c4421.63,2800.04) v1@4398.69,2800.04 ; v1@5148.36,2383.37 cw(c5125.42,2383.37) 5141.64,2367.16 cw(c5157.86,2350.94) v1@5157.86,2373.87 ; v1@5152.36,2383.37 cw(c5139.08,2383.37) 5148.47,2373.99 cw(c5157.86,2364.6) v1@5157.86,2377.87
  other v1: 6564,2006
PBCTRL.JTAG.HARD.TDO: R217.1 R221.1 U30.D3 | length 4822.5
  Top Layer w4: v3(6773.78,2061.85) U30.D3@6793.46,2042.17 ; U30.D3@6786.12,2042.17 ccw(c6768.4,2042.17) 6780.93,2054.7 ccw(c6793.46,2067.23) U30.D3@6793.46,2049.51 ; 6786.58,2049.05 cw(c6799.39,2061.85) 6781.28,2061.85 ccw(c6799.39,2061.85) 6786.58,2049.05 ; 6786.58,2049.05 ccw(c6773.78,2036.24) 6773.78,2054.35 cw(c6773.78,2036.24) 6786.58,2049.05
  MidLayer1 w4: v2(6596,2064) 6596,2062 6597,2061 6617.81,2061 ; v2@6601.08,2066.83 ccw(c6611,2072.36) 6611,2061 ; v2@6602.94,2057.06 cw(c6612.44,2047.56) 6612.44,2061 ; v2@6604.57,2068.78 ccw(c6617.81,2076.16) 6617.81,2061 ; 6696.97,2085.71 6710.9,2085.71 ; v3@6766.39,2060.55 ccw(c6748.56,2057.4) 6758.95,2072.24 ; v3@6772.48,2069.24 cw(c6769.33,2087.07) 6758.95,2072.24 ; 6617.81,2061 6626.62,2069.81 6649.77,2069.81 6665.67,2085.71 6710.9,2085.71 ; 6710.9,2085.71 6734.15,2085.71 cw(c6734.15,2061.94) 6750.37,2079.32 6758.95,2072.24
  MidLayer2 w4: v1(4856.86,2750.04) 4883.86,2777.04 5115.51,2777.04 5185,2707.54 5228.71,2707.54 5233.38,2712.21 5412.4,2712.21 ; v1@4856.86,2755.54 ccw(c4856.86,2768.82) 4866.25,2759.43 ccw(c4875.64,2750.04) v1@4862.36,2750.04 ; v1@4856.86,2759.54 ccw(c4856.86,2782.48) 4873.07,2766.26 ccw(c4889.29,2750.04) v1@4866.36,2750.04 ; 5412.42,2712.19 5496.5,2712.19 5566.98,2641.71 5648.27,2641.71 5698.86,2591.12 5698.86,2212.71 5733.38,2178.19 5904.88,2178.19 5950.69,2224 5982.92,2224 6022.92,2184 6249.5,2184 6271.31,2162.19 6292.69,2162.19 6314,2183.5 6412.69,2183.5 6532.19,2064 v2(6596,2064) ; v2@6589.06,2057.06 ccw(c6572.31,2040.31) 6572.31,2064 ccw(c6572.31,2087.69) v2@6589.06,2070.94 ; v2@6591.89,2059.89 ccw(c6581.97,2049.97) 6581.97,2064 ccw(c6581.97,2078.03) v2@6591.89,2068.11
  Bottom Layer w4: R221.1@3146.18,2957.5 R217.1@3228.82,2957.5 3228.82,2973.37 ; R221.1@3149.94,2953.74 cw(c3159.02,2944.66) 3159.02,2957.5 cw(c3159.02,2970.34) R221.1@3149.94,2961.26 ; R221.1@3152.77,2950.91 cw(c3168.68,2935) 3168.68,2957.5 cw(c3168.68,2980) R221.1@3152.77,2964.09 ; R217.1@3222.23,2950.91 ccw(c3206.32,2935) 3206.32,2957.5 ccw(c3206.32,2980) R217.1@3222.23,2964.09 ; R217.1@3224.5,2966.25 ccw(c3220.78,2973.37) 3228.82,2973.37 ; R217.1@3225.06,2953.74 ccw(c3215.98,2944.66) 3215.98,2957.5 ccw(c3215.98,2970.34) R217.1@3225.06,2961.26 ; R217.1@3233.13,2966.25 cw(c3236.86,2973.37) 3228.82,2973.37 ; v1@4850.14,2743.32 ccw(c4833.92,2727.11) 4833.92,2750.04 ccw(c4833.92,2772.98) v1@4850.14,2756.76 ; v1@4852.97,2746.15 ccw(c4843.58,2736.76) 4843.58,2750.04 ccw(c4843.58,2763.32) v1@4852.97,2753.93 ; v1(4856.86,2750.04) 4690.19,2750.04 4648.52,2791.71 4605.23,2835 4241.55,2835 4047.63,2835 3932.25,2950.37 3375,2950.37 3350,2975.37 3230.82,2975.37 3228.82,2973.37