# Altium PCB NB3000AL.PcbDoc (part 24 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
BASEA: Q5.1 R123.2 | length 1500.2
  Top Layer w4: v1(3254.52,5462.71) 3259.22,5467.4 Q5.1@3290.79,5467.4 ; v1@3255.58,5461.65 cw(c3269.48,5447.75) 3269.48,5467.4 ; v1@3258.41,5458.82 cw(c3279.13,5438.1) Q5.1@3279.13,5467.4 ; v1@3261.24,5455.99 cw(c3288.79,5428.44) Q5.1@3288.79,5467.4 ; v1@3261.24,5469.43 ccw(c3266.13,5474.31) 3266.13,5467.4 ; v1@4171.65,5479.7 cw(c4167.48,5472.05) 4176.19,5472.05 ; R123.2@4172.42,5464.25 ccw(c4163.32,5473.35) 4176.19,5473.35 ; R123.2@4176.18,5460 4176.18,5472.04 ; 4176.19,5473.31 ccw(c4189,5473.31) R123.2@4179.94,5464.25 ; v1(4176.19,5488.04) 4176.19,5472.05 ; R123.2@4178.17,5469.6 cw(c4178.7,5472.05) 4176.19,5472.05 ; R123.2@4178.15,5469.6 cw(c4178.68,5472.04) 4176.18,5472.04 ; v1@4180.73,5479.7 ccw(c4184.9,5472.05) 4176.19,5472.05 ; 4176.18,5472.04 cw(c4173.68,5472.04) 4174.21,5469.6 ccw(c4173.68,5472.05) 4176.19,5472.05
  MidLayer2 w4: v1(4033.19,5383.37) 4137.86,5488.04 v1(4176.19,5488.04) ; v1@4033.19,5388.87 ccw(c4033.19,5402.15) 4042.58,5392.76 ccw(c4051.97,5383.37) v1@4038.69,5383.37 ; v1@4033.19,5392.87 ccw(c4033.19,5415.81) 4049.41,5399.59 ccw(c4065.63,5383.37) v1@4042.69,5383.37 ; v1@4169.47,5481.32 ccw(c4153.26,5465.11) 4153.26,5488.04 ccw(c4153.26,5510.98) v1@4169.47,5494.76 ; v1@4172.3,5484.15 ccw(c4162.91,5474.76) 4162.91,5488.04 ccw(c4162.91,5501.32) v1@4172.3,5491.93
  Bottom Layer w4: v1@3254.52,5453.21 cw(c3254.52,5430.27) 3270.74,5446.49 cw(c3286.96,5462.71) v1@3264.02,5462.71 ; v1@3254.52,5457.21 cw(c3254.52,5443.93) 3263.91,5453.32 cw(c3273.3,5462.71) v1@3260.02,5462.71 ; v1(3254.52,5462.71) 3272.23,5445 3345,5445 3361.76,5428.24 3361.76,5358.24 3385.72,5334.28 3559.28,5334.28 3608.37,5383.37 v1(4033.19,5383.37) ; v1@4026.47,5376.66 ccw(c4010.26,5360.44) 4010.26,5383.37 ccw(c4010.26,5406.31) v1@4026.47,5390.09 ; v1@4029.3,5379.49 ccw(c4019.91,5370.1) 4019.91,5383.37 ccw(c4019.91,5396.65) v1@4029.3,5387.26
BASEB: Q1.1 R90.2 | length 1610.4
  Top Layer w4: Q1.1@3290.79,5322.4 3337.6,5322.4 3350,5310 3350,5260 3358.29,5251.71 v1(3415.19,5251.71) v1@3414.19,5252.71 ; Q1.1@3297.23,5316.95 cw(c3310.4,5303.77) 3310.4,5322.4 cw(c3310.4,5341.03) Q1.1@3297.23,5327.86 ; Q1.1@3300.06,5314.12 cw(c3320.06,5294.12) 3320.06,5322.4 cw(c3320.06,5350.69) Q1.1@3300.06,5330.69 ; Q1.1@3302.88,5311.29 cw(c3329.71,5284.46) 3329.71,5322.4 cw(c3329.71,5360.34) Q1.1@3302.88,5333.51 ; v1@3408.47,5244.99 ccw(c3392.26,5228.77) 3392.26,5251.71 ccw(c3392.26,5274.64) v1@3408.47,5258.43 ; v1@3411.3,5247.82 ccw(c3401.91,5238.43) 3401.91,5251.71 ccw(c3401.91,5264.99) v1@3411.3,5255.6 ; v1@4170.81,5369.43 ccw(c4157.83,5382.4) R90.2@4176.18,5382.4 ; R90.2@4172.42,5387.41 cw(c4163.34,5378.33) 4176.18,5378.33 cw(c4189.02,5378.33) R90.2@4179.94,5387.41 ; 4176.18,5379.23 ccw(c4194.04,5379.23) v1@4181.41,5366.6 ; R90.2@4176.18,5388.89 ccw(c4203.7,5388.89) v1@4184.24,5369.43 ; R90.2@4176.18,5391.67 4176.18,5364.05 v1(4177.52,5362.71)
  Bottom Layer w4: v1@3408.47,5244.99 cw(c3392.26,5228.77) 3415.19,5228.77 cw(c3438.13,5228.77) v1@3421.91,5244.99 ; v1@3411.3,5247.82 cw(c3401.91,5238.43) 3415.19,5238.43 cw(c3428.47,5238.43) v1@3419.08,5247.82 ; v1(3415.19,5251.71) 3415.19,5164.81 3429.81,5150.19 4099.81,5150.19 4115,5165.38 4115,5300.18 v1(4177.52,5362.71) ; v1@4168.02,5362.71 cw(c4145.09,5362.71) 4161.31,5346.49 cw(c4177.52,5330.27) v1@4177.52,5353.21 ; v1@4172.02,5362.71 cw(c4158.75,5362.71) 4168.14,5353.32 cw(c4177.52,5343.93) v1@4177.52,5357.21
BASEC: Q2.1 R92.2 | length 1135.8
  Top Layer w4: Q2.1@3495.79,5462.4 3526.22,5462.4 v1(3530.52,5466.71) ; Q2.1@3497.19,5462.4 ccw(c3497.19,5500.04) v1@3523.81,5473.43 ; Q2.1@3506.85,5462.4 ccw(c3506.85,5490.38) v1@3526.64,5470.6 ; 3516.51,5462.4 ccw(c3516.51,5480.72) v1@3529.46,5467.77 ; 3517.98,5462.4 cw(c3517.98,5454.17) v1@3523.81,5459.99 ; v1(4135.19,5215.04) 4158.19,5238.04 4158.19,5287.72 4176.18,5305.71 ; v1@4135.19,5220.54 ccw(c4135.19,5233.82) 4144.58,5224.43 ccw(c4153.97,5215.04) v1@4140.69,5215.04 ; v1@4135.19,5224.54 ccw(c4135.19,5247.48) 4151.41,5231.26 ccw(c4167.63,5215.04) v1@4144.69,5215.04 ; R92.2@4171.12,5315.02 cw(c4165.09,5305.71) 4176.18,5305.71 ; R92.2@4176.18,5323.33 4176.18,5305.71 ; R92.2@4181.24,5315.02 ccw(c4187.27,5305.71) 4176.18,5305.71
  MidLayer1 w4: v1@3530.52,5457.21 cw(c3530.52,5434.27) 3546.74,5450.49 cw(c3562.96,5466.71) v1@3540.02,5466.71 ; v1@3530.52,5461.21 cw(c3530.52,5447.93) 3539.91,5457.32 cw(c3549.3,5466.71) v1@3536.02,5466.71 ; v1(3530.52,5466.71) 3782.19,5215.04 v1(4135.19,5215.04) ; v1@4128.47,5208.32 ccw(c4112.26,5192.11) 4112.26,5215.04 ccw(c4112.26,5237.98) v1@4128.47,5221.76 ; v1@4131.3,5211.15 ccw(c4121.91,5201.76) 4121.91,5215.04 ccw(c4121.91,5228.32) v1@4131.3,5218.93
BASED: Q3.1 R94.2 | length 1411.5
  Top Layer w4: Q3.1@3481.24,5314.47 ccw(c3467.4,5306.37) 3467.4,5322.4 ; Q3.1@3481.24,5330.34 cw(c3467.4,5338.43) 3467.4,5322.4 ; Q3.1@3484.69,5316.49 ccw(c3474.38,5310.45) 3474.38,5322.4 ccw(c3474.38,5334.35) Q3.1@3484.69,5328.32 ; Q3.1@3495.79,5322.4 3467.4,5322.4 ; v1@3625.14,5209.99 ccw(c3608.92,5193.77) 3608.92,5216.71 ccw(c3608.92,5239.64) v1@3625.14,5223.43 ; v1@3627.97,5212.82 ccw(c3618.58,5203.43) 3618.58,5216.71 ccw(c3618.58,5229.99) v1@3627.97,5220.6 ; v1(3631.86,5216.71) 3586.71,5216.71 3557,5187 3448,5187 3445,5190 3445,5300 3467.4,5322.4 ; R94.2@4169.59,5247.92 cw(c4153.68,5232.01) 4176.18,5232.01 cw(c4198.68,5232.01) R94.2@4182.77,5247.92 ; R94.2@4172.42,5250.75 cw(c4163.34,5241.67) 4176.18,5241.67 cw(c4189.02,5241.67) R94.2@4179.94,5250.75 ; R94.2@4176.18,5255 4176.18,5213.82 4181.63,5208.37 v1(4223.52,5208.37) ; v1@4216.81,5201.66 ccw(c4200.59,5185.44) 4200.59,5208.37 ccw(c4200.59,5231.31) v1@4216.81,5215.09 ; v1@4219.64,5204.49 ccw(c4210.25,5195.1) 4210.25,5208.37 ccw(c4210.25,5221.65) v1@4219.64,5212.26
  MidLayer2 w4: v1(3631.86,5216.71) 3648.52,5233.37 4198.52,5233.37 v1(4223.52,5208.37) ; v1@3631.86,5222.21 ccw(c3631.86,5235.49) 3641.25,5226.1 ccw(c3650.64,5216.71) v1@3637.36,5216.71 ; v1@3631.86,5226.21 ccw(c3631.86,5249.14) 3648.07,5232.93 ccw(c3664.29,5216.71) v1@3641.36,5216.71 ; v1@4214.02,5208.37 ccw(c4191.09,5208.37) 4207.31,5224.59 ccw(c4223.52,5240.81) v1@4223.52,5217.87 ; v1@4218.02,5208.37 ccw(c4204.75,5208.37) 4214.14,5217.76 ccw(c4223.52,5227.15) v1@4223.52,5213.87
BOOT_FLASH.DIN: U30.C1 U50.5 U51.5 | length 2853.3
  Top Layer w4: U50.5@5930.59,1770 5976.9,1770 ; U50.5@5971.2,1766 cw(c5976.9,1763.94) 5976.9,1770 ; U50.5@5971.2,1774 ccw(c5976.9,1776.06) 5976.9,1770 ; v2@5982.28,1910.15 ccw(c5965.53,1926.9) 5989.21,1926.9 ccw(c6012.9,1926.9) v2@5996.15,1910.15 ; v2@5985.1,1907.32 ccw(c5975.18,1917.24) 5989.21,1917.24 ccw(c6003.24,1917.24) v2@5993.32,1907.32 ; v1@5988.52,1758.37 5976.9,1770 ; v2(5989.21,1903.21) 5989.21,2000.79 6008.43,2020 6039,2020 6055,2020 6099,2020 v2(6148,2020) ; v2@6141.06,2013.06 ccw(c6124.31,1996.31) 6124.31,2020 ccw(c6124.31,2043.69) v2@6141.06,2026.94 ; v2@6143.89,2015.89 ccw(c6133.97,2005.97) 6133.97,2020 ccw(c6133.97,2034.03) v2@6143.89,2024.11 ; v2@6303.06,1520.94 ccw(c6286.31,1537.69) 6310,1537.69 ccw(c6333.69,1537.69) v2@6316.94,1520.94 ; v2@6305.89,1518.11 ccw(c6295.97,1528.03) 6310,1528.03 ccw(c6324.03,1528.03) v2@6314.11,1518.11 ; v2(6310,1514) 6310,1562.5 6341.48,1593.98 6341.48,1687.61 6334,1695.09 6334,1701 v2(6334,1710) ; U51.5@6405.59,1430 6429,1430 v1(6465,1466) ; U51.5@6435.12,1441.78 ccw(c6435.12,1455.45) 6444.78,1445.78 ; U51.5@6438.9,1430 cw(c6462.79,1430) 6445.9,1446.9 ; U51.5@6442.9,1430 cw(c6476.45,1430) 6452.72,1453.72 ; v1@6455.5,1466 cw(c6432.56,1466) 6448.78,1449.78 cw(c6465,1433.56) v1@6465,1456.5 ; v1@6459.5,1466 cw(c6446.22,1466) 6455.61,1456.61 cw(c6465,1447.22) v1@6465,1460.5 ; v2@6585.17,2138.96 cw(c6569.5,2122.81) 6592,2122.81 ; v2@6587.95,2141.83 cw(c6578.68,2132.27) 6592,2132.27 cw(c6605.32,2132.27) v2@6596.05,2141.83 ; v2(6592,2146) 6592,2122.81 ; v2@6598.83,2138.96 ccw(c6614.5,2122.81) 6592,2122.81 ; U30.C1@6709.53,2076.34 ccw(c6697,2063.81) 6697,2081.53 ccw(c6697,2099.26) U30.C1@6709.53,2086.73 ; U30.C1@6714.72,2081.54 6655.53,2081.53 6652.19,2078.19 6636.62,2078.19 6592,2122.81
  MidLayer1 w4: v2@5982.28,1896.27 cw(c5965.53,1879.53) 5989.21,1879.53 cw(c6012.9,1879.53) v2@5996.15,1896.27 ; v1@5983.47,1765.09 ccw(c5967.26,1781.31) 5990.19,1781.31 ccw(c6013.13,1781.31) v1@5996.91,1765.09 ; v2@5985.1,1899.1 cw(c5975.18,1889.18) 5989.21,1889.18 cw(c6003.24,1889.18) v2@5993.32,1899.1 ; v1@5986.3,1762.26 ccw(c5976.91,1771.65) 5990.19,1771.65 ccw(c6003.47,1771.65) v1@5994.08,1762.26 ; v2(5989.21,1903.21) 5989.21,1800.79 5990.19,1799.81 v1(5990.19,1758.37) ; v2@6267.5,1834.4 cw(c6267.5,1810.71) 6284.25,1827.46 cw(c6301,1844.21) v2@6277.31,1844.21 ; v2@6267.5,1838.4 cw(c6267.5,1824.37) 6277.42,1834.29 cw(c6287.34,1844.21) v2@6273.31,1844.21 ; v2(6267.5,1844.21) 6318,1793.71 6318,1726 v2(6334,1710) ; v2@6324.19,1710.32 ccw(c6303.02,1711.02) 6318,1726 ccw(c6332.98,1740.98) v2@6333.68,1719.81 ; v2@6328.19,1710.19 ccw(c6315.65,1710.6) 6324.52,1719.48 ccw(c6333.4,1728.35) v2@6333.81,1715.81
  MidLayer2 w4: v2(5989.21,1903.21) 6003.54,1917.54 6008.54,1917.54 6075,1917.54 6085,1917.54 6100,1902.54 6100,1850 6119,1831 6254.29,1831 v2(6267.5,1844.21)
  Bottom Layer w4: v2(6148,2020) 6284.81,2020 6295.31,2030.5 6313.02,2048.21 6410.81,2146 v2(6592,2146) ; v2@6152.11,2015.89 cw(c6162.03,2005.97) 6162.03,2020 cw(c6162.03,2034.03) v2@6152.11,2024.11 ; v2@6154.94,2013.06 cw(c6171.69,1996.31) 6171.69,2020 cw(c6171.69,2043.69) v2@6154.94,2026.94 ; v2(6310,1514) 6322.75,1514 6338.56,1498.19 6432.81,1498.19 v1(6465,1466) ; v2@6585.06,2139.06 ccw(c6568.31,2122.31) 6568.31,2146 ccw(c6568.31,2169.69) v2@6585.06,2152.94 ; v2@6587.89,2141.89 ccw(c6577.97,2131.97) 6577.97,2146 ccw(c6577.97,2160.03) v2@6587.89,2150.11
BOOT_FLASH.DOUT: R160.2 U50.2 U51.2 | length 1983.6
  Top Layer w4: v1@5591.81,1802.43 ccw(c5575.59,1818.64) 5598.52,1818.64 ccw(c5621.46,1818.64) v1@5605.24,1802.43 ; v1@5594.64,1799.6 ccw(c5585.25,1808.99) 5598.52,1808.99 ccw(c5611.8,1808.99) v1@5602.41,1799.6 ; v1(5598.52,1795.71) 5598.52,1862 5606.52,1870 ; U50.2@5614.91,1864.79 ccw(c5606.52,1860.65) 5606.52,1870 ; U50.2@5614.91,1875.21 cw(c5606.53,1879.35) 5606.53,1870 ; U50.2@5655,1870 5606.52,1870 ; U51.2@6130,1530 6200,1530 6206.86,1536.86 v1(6206.86,1574.37) ; U51.2@6165.03,1524.5 cw(c6178.31,1511.22) 6178.31,1530 cw(c6178.31,1548.78) U51.2@6165.03,1535.5 ; U51.2@6167.86,1521.67 cw(c6187.97,1501.56) 6187.97,1530 cw(c6187.97,1558.44) U51.2@6167.86,1538.33 ; v1@6200.14,1567.66 cw(c6183.92,1551.44) 6206.86,1551.44 cw(c6229.79,1551.44) v1@6213.57,1567.66 ; v1@6202.97,1570.49 cw(c6193.58,1561.1) 6206.86,1561.1 cw(c6220.14,1561.1) v1@6210.75,1570.49
  MidLayer1 w4: v2@6137.06,1685.06 cw(c6120.31,1668.31) 6144,1668.31 cw(c6167.69,1668.31) v2@6150.94,1685.06 ; v2@6139.89,1687.89 cw(c6129.97,1677.97) 6144,1677.97 cw(c6158.03,1677.97) v2@6148.11,1687.89 ; v2(6144,1692) 6144,1637.23 v1(6206.86,1574.37) v1@6206.86,1575.14 ; v1@6197.36,1574.37 ccw(c6174.42,1574.37) 6190.64,1590.59 ccw(c6206.86,1606.81) v1@6206.86,1583.87 ; v1@6201.36,1574.37 ccw(c6188.08,1574.37) 6197.47,1583.76 ccw(c6206.86,1593.15) v1@6206.86,1579.87
  MidLayer2 w4: v1(5790.19,1575.04) 5791.23,1574 6206.48,1574 v1(6206.86,1574.37) ; v1@5794.08,1578.93 ccw(c5805.98,1590.83) 5805.98,1574 ; v1@5796.91,1568.32 cw(c5810.61,1554.62) 5810.61,1574 ; v1@5796.91,1581.76 ccw(c5815.64,1600.49) 5815.64,1574 ; 6183.02,1574 ccw(c6183.02,1598.21) v1@6200.14,1581.09 ; 6184.83,1574 cw(c6184.83,1552.34) v1@6200.14,1567.66 ; 6192.67,1574 ccw(c6192.67,1588.56) v1@6202.97,1578.26 ; 6194.48,1574 cw(c6194.48,1562) v1@6202.97,1570.49
  Bottom Layer w4: v1(5598.52,1795.71) 5613.01,1810.19 5619.86,1817.04 5736.33,1817.04 5746.18,1807.19 5808.95,1807.19 5811.95,1810.19 5877.44,1810.19 5995.59,1692.04 6082.9,1692.04 v2(6144,1692) ; v1(5790.19,1575.04) 5805.15,1590 R160.2@5863.82,1590 ; v2@6137.06,1685.06 ccw(c6120.31,1668.31) 6120.31,1692 ccw(c6120.31,1715.69) v2@6137.06,1698.94 ; v2@6139.89,1687.89 ccw(c6129.97,1677.97) 6129.97,1692 ccw(c6129.97,1706.03) v2@6139.89,1696.11
BOOT_FLASH.FLASH_CS_N: R158.1 U51.1 U69.3 | length 7095.2
  Top Layer w4: v2@5998,1630.19 cw(c5998,1606.5) 6014.75,1623.25 cw(c6031.5,1640) v2@6007.81,1640 ; v2@5998,1634.19 cw(c5998,1620.16) 6007.92,1630.08 cw(c6017.84,1640) v2@6003.81,1640 ; v2(5998,1640) 6058,1580 U51.1@6130,1580 6154.52,1580 6154.52,1619.52 ; U51.1@6092.14,1571.67 ccw(c6072.03,1551.56) 6072.03,1580 ccw(c6072.03,1608.44) U51.1@6092.14,1588.33 ; U51.1@6094.97,1574.5 ccw(c6081.69,1561.22) 6081.69,1580 ccw(c6081.69,1598.78) U51.1@6094.97,1585.5 ; U51.1@6151.2,1588.33 ccw(c6143.17,1596.36) 6154.52,1596.36 ; 6154.52,1600.68 ccw(c6179.49,1600.68) U51.1@6162.15,1582.72 ; 6154.52,1610.1 ccw(c6188.58,1610.1) U51.1@6164.93,1585.6 ; U51.1@6167.71,1588.48 cw(c6197.67,1619.52) 6154.52,1619.52 ; v1@6200.14,1626.66 ccw(c6183.92,1610.44) 6183.92,1633.37 ccw(c6183.92,1656.31) v1@6200.14,1640.09 ; v1@6202.97,1629.49 ccw(c6193.58,1620.1) 6193.58,1633.37 ccw(c6193.58,1646.65) v1@6202.97,1637.26 ; v1(6206.86,1633.37) 6168.37,1633.37 6154.52,1619.52
  MidLayer1 w4: v1@5843.28,2073.28 cw(c5827.06,2057.06) 5850,2057.06 cw(c5872.93,2057.06) v1@5856.72,2073.28 ; v1@5846.11,2076.11 cw(c5836.72,2066.72) 5850,2066.72 cw(c5863.28,2066.72) v1@5853.89,2076.11 ; v1@5848.36,1775.04 ccw(c5825.42,1775.04) 5841.64,1791.26 ccw(c5857.86,1807.48) v1@5857.86,1784.54 ; v1(5850,2080) 5850,2055 5829,2034 5829,1933.75 5817.5,1922.25 5817.5,1888.65 5841,1865.15 5841,1791.9 v1(5857.86,1775.04) 5918.96,1775.04 5998,1696 v2(5998,1640) ; v1@5852.36,1775.04 ccw(c5839.08,1775.04) 5848.47,1784.43 ccw(c5857.86,1793.82) v1@5857.86,1780.54 ; v1@5861.75,1771.15 cw(c5871.14,1761.76) 5871.14,1775.04 cw(c5871.14,1788.32) v1@5861.75,1778.93 ; v1@5864.57,1768.32 cw(c5880.79,1752.11) 5880.79,1775.04 cw(c5880.79,1797.98) v1@5864.57,1781.76 ; v2@5991.06,1646.94 ccw(c5974.31,1663.69) 5998,1663.69 ccw(c6021.69,1663.69) v2@6004.94,1646.94 ; v2@5993.89,1644.11 ccw(c5983.97,1654.03) 5998,1654.03 ccw(c6012.03,1654.03) v2@6002.11,1644.11
  MidLayer2 w4: v2@6889,2537.19 cw(c6889,2513.5) 6905.75,2530.25 cw(c6922.5,2547) v2@6898.81,2547 ; v2@6889,2541.19 cw(c6889,2527.16) 6898.92,2537.08 cw(c6908.84,2547) v2@6894.81,2547 ; v2(6889,2547) 6907.53,2528.47 6907.53,2511.72 6922.75,2496.5 6937.25,2496.5 6947.5,2506.75 6947.5,2527.25 6962.75,2542.5 6993.06,2542.5 7099.69,2649.13 7099.69,2805.55 7095.19,2810.05 7095.19,2857.95 7099.69,2862.45 7099.69,2968.48 7106.52,2975.32 7106.52,3096.52 7340.69,3330.69 7340.69,3432.25 7464.43,3556 7707.46,3556 7882.46,3731 8011.75,3731 8076.19,3795.43 8076.19,3996.01 8124.81,4044.63 8124.81,4641.06 8123.19,4642.68 8123.19,4736.81 8090,4770 v1(8090,4795) ; v1@8083.28,4788.28 cw(c8067.06,4772.06) 8090,4772.06 cw(c8112.94,4772.06) v1@8096.72,4788.28 ; v1@8086.11,4791.11 cw(c8076.72,4781.72) 8090,4781.72 cw(c8103.28,4781.72) v1@8093.89,4791.11
  Bottom Layer w4: v1@5844,2072.64 cw(c5833.7,2060) 5850,2060 ; v1@5846.53,2075.74 cw(c5840.56,2068.42) 5850,2068.42 cw(c5859.44,2068.42) v1@5853.47,2075.74 ; v1(5850,2080) 5850,2060 ; v1@5851.14,1768.32 cw(c5834.92,1752.11) 5857.86,1752.11 cw(c5880.79,1752.11) v1@5864.57,1768.32 ; v1@5853.97,1771.15 cw(c5844.58,1761.76) 5857.86,1761.76 cw(c5871.14,1761.76) v1@5861.75,1771.15 ; v1@5856,2072.64 ccw(c5866.3,2060) 5850,2060 ; v1(5857.86,1775.04) 5857.86,1735.96 R158.1@5863.82,1730 ; v2@6882.06,2540.06 cw(c6865.31,2523.31) 6889,2523.31 cw(c6912.69,2523.31) v2@6895.94,2540.06 ; v2@6884.89,2542.89 cw(c6874.97,2532.97) 6889,2532.97 cw(c6903.03,2532.97) v2@6893.11,2542.89 ; v2@6889,2544 v2(6889,2547) 6889,2479 6863.81,2453.81 6722.5,2453.81 6660.73,2392.04 6542.9,2392.04 6484.9,2334.04 6455.22,2334.04 6376.81,2255.63 6376.81,2157.25 6350.06,2130.5 6310.75,2130.5 6306.19,2135.06 6247.51,2135.06 6238.44,2144.12 6193.36,2144.12 6186.02,2151.46 6186.02,2337.29 6139.86,2383.46 6093.09,2383.46 6066.54,2410 5965,2410 5915,2460 5820,2460 5806.36,2446.36 5806.36,2361.81 5821.29,2346.87 5832.29,2346.87 5846.5,2332.67 5846.5,2235.7 5852.69,2229.51 5852.69,2210.93 5795,2153.24 5795,2061.81 5805.62,2051.19 5841.19,2051.19 5850,2060 ; U69.3@8043.24,4768.71 ccw(c8033.22,4778.74) 8047.4,4778.74 ccw(c8061.58,4778.74) U69.3@8051.55,4768.71 ; U69.3@8047.4,4755.7 8047.4,4787.4 8060,4800 ; 8068.28,4800 cw(c8068.28,4777.78) v1@8085.69,4791.58 ; 8076.55,4800 cw(c8076.55,4784.34) v1@8088.82,4794.07 ; 8079.14,4800 ccw(c8079.14,4805.86) v1@8083.28,4801.72 ; v1@8082.56,4789.1 ccw(c8060,4771.22) 8060,4800 ; v1(8090,4795) 8085,4800 8060,4800
BOOT_FLASH.SCLK: U30.H1 U30.L6 U50.6 U51.6 | length 3007.1
  Top Layer w4: U50.6@5930.59,1820 5994.81,1820 6023.52,1791.29 6023.52,1656.48 6028.96,1651.04 6223.52,1651.04 6229.02,1645.54 6229.02,1613.77 6227.5,1612.25 6227.5,1554.4 6231.86,1550.04 v1(6248.52,1533.37) ; U50.6@5965.62,1814.5 cw(c5978.9,1801.22) 5978.9,1820 cw(c5978.9,1838.78) U50.6@5965.62,1825.5 ; U50.6@5968.45,1811.67 cw(c5988.56,1791.56) 5988.56,1820 cw(c5988.56,1848.44) U50.6@5968.45,1828.33 ; v1@6239.02,1533.37 ccw(c6216.09,1533.37) 6232.31,1549.59 ccw(c6248.52,1565.81) v1@6248.52,1542.87 ; v1@6243.02,1533.37 ccw(c6229.75,1533.37) 6239.13,1542.76 ccw(c6248.52,1552.15) v1@6248.52,1538.87 ; v2@6337.06,1534.06 cw(c6317.9,1514.9) 6345,1514.9 ; v2@6339.89,1536.89 cw(c6327.56,1524.56) 6345,1524.56 ; v2(6344,1541) 6345,1540 6345,1510.7 6353,1502.7 6353,1480 ; 6345,1519.73 cw(c6365.27,1519.73) v2@6350.94,1534.06 ; U51.6@6366.52,1473.09 ccw(c6353,1463.31) 6353,1480 ; U51.6@6366.52,1486.9 cw(c6353,1496.69) 6353,1480 ; U51.6@6369.76,1475.44 ccw(c6360.83,1468.98) 6360.83,1480 ccw(c6360.83,1491.02) U51.6@6369.76,1484.56 ; U51.6@6405.59,1480 6353,1480 ; v2@6473.06,1837.06 cw(c6456.31,1820.31) 6480,1820.31 cw(c6503.69,1820.31) v2@6486.94,1837.06 ; v2@6475.89,1839.89 cw(c6465.97,1829.97) 6480,1829.97 cw(c6494.03,1829.97) v2@6484.11,1839.89 ; v2(6480,1844) 6480,1812.1 6474.19,1806.29 6470.9,1802.99 6470.9,1751.14 6445.5,1725.75 6445.5,1699.75 6445.5,1688.77 6472.86,1661.42 6472.86,1611.14 v2(6493,1591) ; v2@6483.19,1591 ccw(c6459.5,1591) 6476.25,1607.75 ccw(c6493,1624.5) v2@6493,1600.81 ; v2@6487.19,1591 ccw(c6473.16,1591) 6483.08,1600.92 ccw(c6493,1610.84) v2@6493,1596.81 ; v2(6586,1862) 6605,1862 ; v2@6594,1856.32 cw(c6605,1848.51) 6605,1862 ; v2@6594,1867.68 ccw(c6605,1875.49) 6605,1862 ; U30.H1@6709.53,1879.49 ccw(c6697,1866.96) 6697,1884.68 ccw(c6697,1902.41) U30.H1@6709.53,1889.88 ; U30.H1@6714.72,1884.68 6695.04,1884.68 6627.68,1884.68 6605,1862 ; v3(6891.89,1746.89) U30.L6@6911.57,1766.57 ; U30.L6@6904.23,1766.57 cw(c6886.51,1766.57) 6899.04,1754.04 cw(c6911.57,1741.51) U30.L6@6911.57,1759.23 ; 6904.69,1759.69 cw(c6891.89,1772.5) 6891.89,1754.39 ccw(c6891.89,1772.5) 6904.69,1759.69 ; 6904.69,1759.69 ccw(c6917.5,1746.89) 6899.39,1746.89 cw(c6917.5,1746.89) 6904.69,1759.69
  MidLayer1 w4: v2(6480,1844) 6565.19,1844 v2@6583.19,1862 ; v2@6484.11,1839.89 cw(c6494.03,1829.97) 6494.03,1844 cw(c6494.03,1858.03) v2@6484.11,1848.11 ; v2@6486.94,1837.06 cw(c6503.69,1820.31) 6503.69,1844 cw(c6503.69,1867.69) v2@6486.94,1850.94
  MidLayer2 w4: v1(6248.52,1533.37) 6288.37,1533.37 6296,1541 v2(6344,1541) ; v1@6252.41,1529.49 cw(c6261.8,1520.1) 6261.8,1533.37 cw(c6261.8,1546.65) v1@6252.41,1537.26 ; v1@6255.24,1526.66 cw(c6271.46,1510.44) 6271.46,1533.37 cw(c6271.46,1556.31) v1@6255.24,1540.09 ; v2@6337.06,1534.06 ccw(c6320.31,1517.31) 6320.31,1541 ccw(c6320.31,1564.69) v2@6337.06,1547.94 ; v2@6339.89,1536.89 ccw(c6329.97,1526.97) 6329.97,1541 ccw(c6329.97,1555.03) v2@6339.89,1545.11 ; v2@6487,1583.24 cw(c6477.52,1571) 6493,1571 ; v2@6489.44,1586.4 cw(c6483.83,1579.15) 6493,1579.15 cw(c6502.17,1579.15) v2@6496.56,1586.4 ; v2(6493,1591) 6493,1571 ; v2@6499,1583.24 ccw(c6508.48,1571) 6493,1571 ; v3@6884.5,1745.59 cw(c6866.67,1742.44) 6881.5,1732.06 ; v3@6893.19,1739.5 ccw(c6896.34,1721.67) 6881.5,1732.06 ; 6493,1571 6534,1530 6590.81,1530 6594.62,1533.81 6706.19,1533.81 6734.19,1505.81 6845.81,1505.81 6868.03,1528.03 6868.03,1609.89 6868.03,1684.01 6868.03,1707.26 cw(c6891.8,1707.26) 6874.42,1723.48 6881.5,1732.06
  Bottom Layer w4: v2@6344,1539.81 6412.81,1539.81 6466,1593 ; v2@6348.11,1545.11 ccw(c6360.9,1557.9) 6360.9,1539.81 ; v2@6350.94,1534.06 cw(c6364.82,1520.18) 6364.82,1539.81 ; v2@6350.94,1547.94 ccw(c6370.56,1567.56) 6370.56,1539.81 ; 6474.14,1593 ccw(c6474.14,1609.86) v2@6486.06,1597.94 ; 6475.15,1593 cw(c6475.15,1574.5) v2@6488.73,1587.06 ; v2@6485.79,1584.34 ccw(c6466,1566.05) 6466,1593 ; v2(6493,1591) 6491,1593 6466,1593
BUS_SDRAM_FEEDBACK: NT46.1 U8.J1 | length 8744.7
  Top Layer w4: v1@4817.65,4413.75 4824.86,4406.54 U8.J1@4858.5,4406.54 ; U8.J1@4853.31,4401.34 ccw(c4840.78,4388.81) 4840.78,4406.54 ccw(c4840.78,4424.26) U8.J1@4853.31,4411.73 ; v2@5218.3,5219.14 5237.81,5199.63 5270.62,5199.63 5278.98,5208 ; v2@5286.68,5203.38 ccw(c5278.99,5199.28) 5278.99,5208 ; v2@5286.68,5212.61 cw(c5278.99,5216.72) 5278.99,5208 ; v2(5295.34,5208) 5278.98,5208 ; v1@7474.86,5040.54 cw(c7474.86,5017.61) 7491.07,5033.82 cw(c7507.29,5050.04) v1@7484.36,5050.04 ; v1@7474.86,5044.54 cw(c7474.86,5031.26) 7484.25,5040.65 cw(c7493.64,5050.04) v1@7480.36,5050.04 ; v1(7474.86,5050.04) 7523.52,5001.37 7523.52,4892.81 7507.19,4876.48 7507.19,4857.62 7523.52,4841.29 7523.52,4812.73 7606.86,4729.39 7606.86,4483.37 7502.19,4378.71 7502.19,4061.63 7502.19,3777.81 7540,3740 v1(7555.01,3740.01)
  MidLayer1 w4: v2(4665.16,5115.8) 4680.7,5115.8 4775.81,5020.69 4775.81,4929.7 4774.13,4928.02 4774.13,4915 4774.13,4714.13 v1(4740,4680) ; v1@4740,4685.5 ccw(c4740,4698.78) 4749.39,4689.39 ccw(c4758.78,4680) v1@4745.5,4680 ; v1@4740,4689.5 ccw(c4740,4712.43) 4756.22,4696.22 ccw(c4772.43,4680) v1@4749.5,4680 ; v1(5387.02,5019.62) 5429.71,5019.62 5452.59,5042.5 5490.35,5042.5 5518.18,5070.33 5518.18,5079.07 5505.05,5092.2 5494.45,5092.2 v2(5474.25,5112.4) ; v1@5390.91,5015.73 cw(c5400.3,5006.35) 5400.3,5019.62 cw(c5400.3,5032.9) v1@5390.91,5023.51 ; v1@5393.74,5012.91 cw(c5409.96,4996.69) 5409.96,5019.62 cw(c5409.96,5042.56) v1@5393.74,5026.34 ; v2@5440.98,5267.69 cw(c5424.23,5250.94) 5447.92,5250.94 cw(c5471.6,5250.94) v2@5454.85,5267.69 ; v2(5443.56,5136.93) 5462.5,5155.87 5462.5,5172.79 5462.5,5197.19 5447.92,5211.77 v2(5447.92,5274.62) ; v2@5443.56,5142.74 ccw(c5443.56,5156.77) 5453.48,5146.85 ccw(c5463.4,5136.93) v2@5449.37,5136.93 ; v2@5443.56,5146.74 ccw(c5443.56,5170.43) 5460.31,5153.68 ccw(c5477.06,5136.93) v2@5453.37,5136.93 ; v2@5443.81,5270.51 cw(c5433.89,5260.59) 5447.92,5260.59 cw(c5461.94,5260.59) v2@5452.02,5270.51 ; v2@5474.25,5102.59 cw(c5474.25,5078.9) 5491,5095.65 ; v2@5474.25,5106.59 cw(c5474.25,5092.56) 5484.17,5102.48 cw(c5494.09,5112.4) v2@5480.06,5112.4 ; v2@5484.06,5112.4 ccw(c5507.74,5112.4) 5491,5095.65
  MidLayer2 w4: v2(4435.7,4438.2) 4439.41,4438.2 4458.2,4438.2 ; v2@4439.96,4434.25 cw(c4449.03,4425.83) 4449.03,4438.2 cw(c4449.03,4450.57) v2@4439.96,4442.15 ; v2@4442.89,4431.52 cw(c4458.2,4417.31) 4458.2,4438.2 ; v2@4442.89,4444.88 ccw(c4458.2,4459.09) 4458.2,4438.2 ; v1@4443.28,4858.28 cw(c4427.06,4842.06) 4450,4842.06 cw(c4472.93,4842.06) v1@4456.72,4858.28 ; v1@4446.11,4861.11 cw(c4436.72,4851.72) 4450,4851.72 cw(c4463.28,4851.72) v1@4453.89,4861.11 ; v1(4450,4865) 4450,4551.29 4490.69,4510.6 4490.69,4489.48 4472.02,4470.81 4472.02,4452.02 4458.2,4438.2 ; v2(4665.16,5115.8) 4710.8,5115.8 4819.54,5224.54 5190,5224.54 v2@5216.77,5224.54 ; v2@4669.27,5111.69 cw(c4679.19,5101.77) 4679.19,5115.8 cw(c4679.19,5129.83) v2@4669.27,5119.91 ; v2@4672.1,5108.86 cw(c4688.85,5092.12) 4688.85,5115.8 cw(c4688.85,5139.49) v2@4672.1,5122.74 ; v2(5295.34,5208) 5358.19,5270.86 5361.96,5274.62 v2(5447.92,5274.62) ; v2@5295.34,5213.81 ccw(c5295.34,5227.84) 5305.26,5217.92 ccw(c5315.18,5208) v2@5301.15,5208 ; v2@5295.34,5217.81 ccw(c5295.34,5241.49) 5312.08,5224.75 ccw(c5328.83,5208) v2@5305.15,5208 ; v2@5440.98,5267.69 ccw(c5424.23,5250.94) 5424.23,5274.62 ccw(c5424.23,5298.31) v2@5440.98,5281.56 ; v2@5443.81,5270.51 ccw(c5433.89,5260.59) 5433.89,5274.62 ccw(c5433.89,5288.65) v2@5443.81,5278.73 ; v1(7355,3555) 7340,3570 7300,3610 7300,3730 7305,3735 7340,3735 7415,3735 7440,3760 7535.01,3760 v1(7555.01,3740.01) ; v1@7545.51,3740.01 ccw(c7522.57,3740.01) 7538.79,3756.22 ccw(c7555.01,3772.44) v1@7555.01,3749.51 ; v1@7549.51,3740.01 ccw(c7536.23,3740.01) 7545.62,3749.39 ccw(c7555.01,3758.78) v1@7555.01,3745.51
  Bottom Layer w4: v2@4435.7,4428.39 cw(c4435.7,4404.7) 4452.45,4421.45 cw(c4469.2,4438.2) v2@4445.51,4438.2 ; v2@4435.7,4432.39 cw(c4435.7,4418.36) 4445.62,4428.28 cw(c4455.54,4438.2) v2@4441.51,4438.2 ; v2(4435.7,4438.2) 4468.62,4405.28 4468.62,4380.92 4500.5,4349.04 4540,4349.04 4563.46,4349.04 4572.62,4339.88 4584.3,4328.2 4595.61,4328.2 4606.95,4328.2 4629.5,4350.75 4629.5,4371.2 4682.92,4424.62 4687.38,4429.08 4801.22,4429.08 v1(4817.1,4413.2) ; v1(4450,4865) 4572.15,4865 4609.61,4827.54 4672.44,4827.54 4714.98,4785 4738.31,4785 4762.5,4760.81 4762.5,4702.5 v1(4740,4680) ; v1@4453.89,4861.11 cw(c4463.28,4851.72) 4463.28,4865 cw(c4463.28,4878.28) v1@4453.89,4868.89 ; v1@4456.72,4858.28 cw(c4472.93,4842.06) 4472.93,4865 cw(c4472.93,4887.93) v1@4456.72,4871.72 ; v1@4740,4685.5 ccw(c4740,4698.78) 4749.39,4689.39 ccw(c4758.78,4680) v1@4745.5,4680 ; v1@4740,4689.5 ccw(c4740,4712.43) 4756.22,4696.22 ccw(c4772.43,4680) v1@4749.5,4680 ; v1(5387.02,5019.62) 5917.5,5019.62 6097.92,5200.04 6123.58,5225.71 6814.17,5225.71 6839.84,5200.04 6865.17,5174.71 6905.92,5174.71 ; v2(5443.56,5136.93) 5468.07,5136.93 5474.25,5130.75 ; v2@5447.67,5132.82 cw(c5457.59,5122.9) 5457.59,5136.93 cw(c5457.59,5150.96) v2@5447.67,5141.04 ; v2@5450.5,5130 cw(c5467.24,5113.25) 5467.24,5136.93 cw(c5467.24,5160.62) v2@5450.5,5143.87 ; v2@5468.8,5120.56 ccw(c5461.98,5130.75) 5474.25,5130.75 ; v2(5474.25,5112.4) 5474.25,5130.75 ; v2@5479.7,5120.56 cw(c5486.51,5130.75) 5474.25,5130.75 ; 6906.08,5174.87 6924.3,5174.87 7140.36,5174.87 7148.52,5166.71 7240.19,5075.04 7449.86,5075.04 v1(7474.86,5050.04) ; NT46.1@7239,3669 7235,3665 7235,3630 7235,3619.24 7271.04,3583.2 7325,3583.2 7326.8,3583.2 v1(7355,3555) ; v1@7345.5,3555 ccw(c7322.56,3555) 7338.78,3571.22 ccw(c7355,3587.43) v1@7355,3564.5 ; v1@7349.5,3555 ccw(c7336.22,3555) 7345.61,3564.39 ccw(c7355,3573.78) v1@7355,3560.5 ; v1@7465.36,5050.04 ccw(c7442.42,5050.04) 7458.64,5066.26 ccw(c7474.86,5082.48) v1@7474.86,5059.54 ; v1@7469.36,5050.04 ccw(c7456.08,5050.04) 7465.47,5059.43 ccw(c7474.86,5068.82) v1@7474.86,5055.54
  other v2: 5218.3,5223.02
BUZZER: R8.1 U8.AA7 | length 6510.2
  Top Layer w4: v3(5075.04,3914.41) U8.AA7@5094.72,3934.09 ; U8.AA7@5087.38,3934.09 cw(c5069.66,3934.09) 5082.19,3921.56 cw(c5094.72,3909.03) U8.AA7@5094.72,3926.75 ; 5087.84,3927.21 cw(c5075.04,3940.02) 5075.04,3921.91 ccw(c5075.04,3940.02) 5087.84,3927.21 ; 5087.84,3927.21 ccw(c5100.65,3914.41) 5082.54,3914.41 cw(c5100.65,3914.41) 5087.84,3927.21
  MidLayer2 w4: v1@4308.47,4152.43 ccw(c4292.26,4168.64) 4315.19,4168.64 ccw(c4338.13,4168.64) v1@4321.91,4152.43 ; v1@4311.3,4149.6 ccw(c4301.91,4158.99) 4315.19,4158.99 ccw(c4328.47,4158.99) v1@4319.08,4149.6 ; v1(4315.19,4145.71) 4315.19,4200.19 4323.37,4208.37 v1(4348.52,4208.37) ; v1@4341.81,4201.66 ccw(c4325.59,4185.44) 4325.59,4208.37 ccw(c4325.59,4231.31) v1@4341.81,4215.09 ; v1@4344.64,4204.49 ccw(c4335.25,4195.1) 4335.25,4208.37 ccw(c4335.25,4221.65) v1@4344.64,4212.26
  Bottom Layer w4: R8.1@-278.82,3952.46 cw(c-278.82,3928.78) -262.07,3945.52 ; R8.1@-278.82,3956.46 cw(c-278.82,3942.43) R8.1@-268.9,3952.35 ; R8.1@-278.82,3962.27 -261.01,3944.46 -136.08,3944.46 -42.65,4037.9 -42.65,4044.19 -43.48,4045.02 -43.48,4146.73 151.51,4341.71 1390.19,4341.71 1406.86,4358.37 2615,4358.37 2648.67,4392.04 4048.23,4392.04 4231.9,4208.37 v1(4348.52,4208.37) ; R8.1@-273.5,3961.78 ccw(c-261.85,3961.78) R8.1@-270.09,3953.54 ; R8.1@-269.5,3961.78 ccw(c-248.19,3961.78) -263.26,3946.71 ; v1(4315.19,4145.71) 4421.92,4145.71 4475.81,4091.81 4683,4091.81 4722.5,4052.31 4722.5,3994.81 4722.5,3973.81 4748.19,3948.12 4748.19,3925 4750.19,3923 4757.25,3923 4759.44,3920.81 4762.75,3917.5 4764,3917.5 4768.5,3917.5 4771.81,3914.19 4784.94,3914.19 4787.16,3914.19 4818,3883.35 4818,3811.9 4830.82,3811.9 4838.82,3811.9 4840.41,3811.9 4898.67,3811.9 4956.93,3811.9 ccw(c4956.93,3835.67) 4980.7,3835.67 cw(c4996.3,3835.67) 4996.3,3851.27 ccw(c4996.3,3875.04) 5020.07,3875.04 cw(c5035.67,3875.04) 5035.67,3890.64 ccw(c5035.67,3914.41) 5052.48,3897.6 5060.21,3904.02 ; v1@4319.08,4141.82 cw(c4328.47,4132.43) 4328.47,4145.71 cw(c4328.47,4158.99) v1@4319.08,4149.6 ; v1@4321.91,4138.99 cw(c4338.13,4122.77) 4338.13,4145.71 cw(c4338.13,4168.64) v1@4321.91,4152.43 ; v1@4341.81,4201.66 ccw(c4325.59,4185.44) 4325.59,4208.37 ccw(c4325.59,4231.31) v1@4341.81,4215.09 ; v1@4344.64,4204.49 ccw(c4335.25,4195.1) 4335.25,4208.37 ccw(c4335.25,4221.65) v1@4344.64,4212.26 ; v3@5067.65,3915.71 cw(c5049.82,3918.86) 5060.21,3904.02 ; v3@5073.74,3907.02 ccw(c5070.59,3889.19) 5060.21,3904.02
CLK_ADJ_X1: C33.1 U2.1 Y1.1 | length 268.3
  Top Layer w12: U2.1@7868.67,3936.84 ccw(c7855.39,3950.12) 7874.17,3950.12 ccw(c7892.95,3950.12) U2.1@7879.67,3936.84 ; U2.1@7874.17,3931.34 7874.17,3959.84 C33.1@7909.33,3995 7909.33,4020 7904.88,4024.45 ; Y1.1@7893.79,4044.08 cw(c7881.97,4024.45) 7904.88,4024.45 ; C33.1@7903.52,3995 cw(c7889.49,3995) 7899.41,3985.08 cw(c7909.33,3975.16) C33.1@7909.33,3989.19 ; Y1.1@7904.88,4062.5 7904.88,4024.45 ; C33.1@7905.22,3999.11 ccw(c7895.3,4009.03) 7909.33,4009.03 ccw(c7923.36,4009.03) C33.1@7913.44,3999.11 ; Y1.1@7915.97,4044.08 ccw(c7927.79,4024.45) 7904.88,4024.45
CLK_ADJ_X2: C34.1 U2.16 Y1.3 | length 643.1
  Top Layer w12: 8012.77,4138.75 cw(c8044.15,4107.37) Y1.3@8060.4,4148.66 ; 8015.35,4141.32 cw(c8032.51,4124.16) Y1.3@8049.15,4141.84 ; 8024.1,4150.07 cw(c8040.99,4133.17) Y1.3@8057.37,4150.58 ; 8025.72,4151.69 cw(c8051.46,4125.95) Y1.3@8064.79,4159.83 ; 8032.85,4158.82 cw(c8049.48,4142.19) Y1.3@8065.59,4159.32 ; Y1.3@8044.06,4149.17 ccw(c8031.53,4143.91) 8031.53,4157.5 ; Y1.3@8044.06,4165.83 cw(c8031.53,4171.09) 8031.53,4157.5 ; C34.1@8061.56,3990.89 cw(c8051.64,3980.97) 8065.67,3980.97 cw(c8079.7,3980.97) C34.1@8069.78,3990.89 ; C34.1@8061.56,3999.11 ccw(c8051.64,4009.03) 8065.67,4009.03 ccw(c8079.7,4009.03) C34.1@8069.78,3999.11 ; Y1.3@8067.88,4157.5 8031.52,4157.5 ; U2.16@8093.08,3936.84 ccw(c8079.8,3950.12) 8098.58,3950.12 ccw(c8117.36,3950.12) U2.16@8104.08,3936.84 ; U2.16@8098.58,3931.34 8098.58,3961.42 8095,3965 8077.29,3965 8065.67,3976.62 C34.1@8065.67,3995 8065.67,4018.33 8064,4020 8030,4020 8016,4034 8016,4141.98 8031.52,4157.5
CLK_FIXED#: R29.2 U2.6 | length 681.7
  Top Layer w4: R29.2@7787.23,3532.08 ccw(c7771.32,3547.99) 7793.82,3547.99 ccw(c7816.32,3547.99) R29.2@7800.41,3532.08 ; R29.2@7790.06,3529.25 ccw(c7780.98,3538.33) 7793.82,3538.33 ccw(c7806.66,3538.33) R29.2@7797.58,3529.25 ; v1@7790.81,3568.32 cw(c7783.53,3561.05) 7793.82,3561.05 ; R29.2@7793.82,3525 7793.82,3571.34 v1(7797.52,3575.04) ; 7793.82,3543.16 cw(c7829.4,3543.16) v1@7804.24,3568.32 ; 7793.82,3552.82 cw(c7819.75,3552.82) v1@7801.41,3571.15 ; 7793.82,3562.47 cw(c7810.09,3562.47) v1@7798.58,3573.98 ; U2.6@7874.17,3681.34 7923.82,3681.34 7924.19,3681.71 7927.52,3681.71 v1(7931.86,3677.37) ; U2.6@7899.35,3681.34 cw(c7899.35,3644.87) v1@7925.14,3670.66 ; U2.6@7901.39,3675.9 cw(c7914.31,3663.26) 7914.31,3681.34 cw(c7914.31,3699.42) U2.6@7901.39,3686.78 ; U2.6@7909.01,3681.34 cw(c7909.01,3654.53) v1@7927.97,3673.49 ; 7918.49,3681.34 ccw(c7918.49,3690.74) v1@7925.14,3684.09 ; 7918.67,3681.34 cw(c7918.67,3664.18) v1@7930.8,3676.31
  Bottom Layer w4: v1(7797.52,3575.04) 7925.04,3575.04 7931.86,3581.86 v1(7931.86,3677.37) ; v1@7801.41,3571.15 cw(c7810.8,3561.76) 7810.8,3575.04 cw(c7810.8,3588.32) v1@7801.41,3578.93 ; v1@7804.24,3568.32 cw(c7820.46,3552.11) 7820.46,3575.04 cw(c7820.46,3597.98) v1@7804.24,3581.76 ; v1@7925.14,3670.66 cw(c7908.92,3654.44) 7931.86,3654.44 cw(c7954.79,3654.44) v1@7938.57,3670.66 ; v1@7927.97,3673.49 cw(c7918.58,3664.1) 7931.86,3664.1 cw(c7945.14,3664.1) v1@7935.75,3673.49
CLK_PROG#: R28.2 U2.11 | length 346.5
  Top Layer w4: U2.11@8098.58,3681.34 8150.56,3681.34 8171.18,3660.72 R28.2@8171.18,3525 ; U2.11@8125.74,3675.84 cw(c8139.02,3662.56) 8139.02,3681.34 cw(c8139.02,3700.12) U2.11@8125.74,3686.84 ; U2.11@8128.57,3673.01 cw(c8148.67,3652.9) 8148.67,3681.34 cw(c8148.67,3709.78) U2.11@8128.57,3689.67 ; R28.2@8164.59,3532.08 ccw(c8148.68,3547.99) 8171.18,3547.99 ccw(c8193.68,3547.99) R28.2@8177.77,3532.08 ; R28.2@8167.42,3529.25 ccw(c8158.34,3538.33) 8171.18,3538.33 ccw(c8184.02,3538.33) R28.2@8174.94,3529.25
CODEC.I2S_BCLK: R16.2 U8.K13 | length 9343.8
  Top Layer w4: v1@-385.9,2788.28 ccw(c-402.11,2772.06) -402.11,2795 ccw(c-402.11,2817.93) v1@-385.9,2801.72 ; v1@-383.07,2791.11 ccw(c-392.46,2781.72) -392.46,2795 ccw(c-392.46,2808.28) v1@-383.07,2798.89 ; v1(-379.18,2795) -445,2795 -450,2800 -450,3076.52 -426.48,3100.04 v1(-301.48,3100.04) ; v1@-308.19,3093.32 ccw(c-324.41,3077.11) -324.41,3100.04 ccw(c-324.41,3122.98) v1@-308.19,3106.76 ; v1@-305.36,3096.15 ccw(c-314.75,3086.76) -314.75,3100.04 ccw(c-314.75,3113.32) v1@-305.36,3103.93 ; v3(5311.26,4386.85) U8.K13@5330.94,4367.17 ; U8.K13@5323.6,4367.16 ccw(c5305.88,4367.16) 5318.41,4379.7 ccw(c5330.94,4392.23) U8.K13@5330.95,4374.51 ; 5324.06,4374.05 cw(c5336.87,4386.85) 5318.76,4386.85 ccw(c5336.87,4386.85) 5324.06,4374.05 ; 5324.06,4374.05 ccw(c5311.26,4361.24) 5311.26,4379.35 cw(c5311.26,4361.24) 5324.06,4374.05
  MidLayer1 w4: v1@-308.19,3106.76 ccw(c-324.41,3122.98) -301.48,3122.98 ccw(c-278.54,3122.98) v1@-294.76,3106.76 ; v1@-305.36,3103.93 ccw(c-314.75,3113.32) -301.48,3113.32 ccw(c-288.2,3113.32) v1@-297.59,3103.93 ; v1(-301.48,3100.04) -301.48,3197.06 -210,3288.54 -210,3552.37 -80.21,3682.16 -75.3,3687.07 -75.3,3790 ; -75,3790 -75,3800 -58.29,3816.71 1.71,3816.71 7.19,3822.19 7.19,3893.67 63.56,3950.04 156.86,3950.04 181.86,3975.04 181.86,4294.69 481.86,4594.69 v1(481.86,4700.04) ; v1@475.14,4693.32 cw(c458.92,4677.11) 481.86,4677.11 cw(c504.79,4677.11) v1@488.57,4693.32 ; v1@477.97,4696.15 cw(c468.58,4686.76) 481.86,4686.76 cw(c495.14,4686.76) v1@485.75,4696.15 ; v1(1331.86,4916.71) 1465.19,5050.04 1781.86,5050.04 1806.86,5025.04 3713.65,5025.04 3846.98,4891.71 3974.51,4891.71 3982.84,4883.37 v1(4031.86,4883.37) ; v1@1331.86,4922.21 ccw(c1331.86,4935.49) 1341.25,4926.1 ccw(c1350.64,4916.71) v1@1337.36,4916.71 ; v1@1331.86,4926.21 ccw(c1331.86,4949.14) 1348.07,4932.93 ccw(c1364.29,4916.71) v1@1341.36,4916.71 ; v1@4025.14,4876.66 ccw(c4008.92,4860.44) 4008.92,4883.37 ccw(c4008.92,4906.31) v1@4025.14,4890.09 ; v1@4027.97,4879.49 ccw(c4018.58,4870.1) 4018.58,4883.37 ccw(c4018.58,4896.65) v1@4027.97,4887.26
  MidLayer2 w4: v1@475.14,4706.76 ccw(c458.92,4722.98) 481.86,4722.98 ccw(c504.79,4722.98) v1@488.57,4706.76 ; v1@477.97,4703.93 ccw(c468.58,4713.32) 481.86,4713.32 ccw(c495.14,4713.32) v1@485.75,4703.93 ; v1(481.86,4700.04) 481.86,4883.37 531.86,4933.37 1315.19,4933.37 v1(1331.86,4916.71) ; v1@1322.36,4916.71 ccw(c1299.42,4916.71) 1315.64,4932.93 ccw(c1331.86,4949.14) v1@1331.86,4926.21 ; v1@1326.36,4916.71 ccw(c1313.08,4916.71) 1322.47,4926.1 ccw(c1331.86,4935.49) v1@1331.86,4922.21 ; v1(4031.86,4883.37) 4250.31,4883.37 4271.69,4862 4311.56,4862 4324.69,4848.87 4359.09,4848.87 4374.02,4863.81 4374.02,4887.35 v1(4316.85,4944.52) ; v1@4035.75,4879.49 cw(c4045.14,4870.1) 4045.14,4883.37 cw(c4045.14,4896.65) v1@4035.75,4887.26 ; v1@4038.57,4876.66 cw(c4054.79,4860.44) 4054.79,4883.37 cw(c4054.79,4906.31) v1@4038.57,4890.09
  Bottom Layer w4: v1(-379.18,2795) R16.2@-341.18,2795 ; v1@-375.29,2791.11 cw(c-365.9,2781.72) -365.9,2795 cw(c-365.9,2808.28) v1@-375.29,2798.89 ; v1@-372.46,2788.28 cw(c-356.24,2772.06) -356.24,2795 cw(c-356.24,2817.93) v1@-372.46,2801.72 ; R16.2@-347.77,2788.41 ccw(c-363.68,2772.5) -363.68,2795 ccw(c-363.68,2817.5) R16.2@-347.77,2801.59 ; R16.2@-344.94,2791.24 ccw(c-354.02,2782.16) -354.02,2795 ccw(c-354.02,2807.84) R16.2@-344.94,2798.76 ; v1(4316.85,4944.52) 4747.56,4944.52 4792.56,4899.52 4835.06,4899.52 4848.04,4912.5 4991.65,4912.5 5003.27,4900.87 5107.01,4900.87 5142.5,4936.37 5142.5,4942.25 5156.13,4955.87 5171.07,4970.82 5277.23,4970.82 5299.62,4948.43 5299.62,4872.43 5287.19,4860 5287.19,4797.62 5287.4,4797.41 5287.4,4543.27 5287.4,4523.85 5287.4,4449.73 5287.4,4430.23 ccw(c5329.13,4430.23) 5299.62,4400.72 ; v1@4320.74,4940.63 cw(c4330.13,4931.25) 4330.13,4944.52 cw(c4330.13,4957.8) v1@4320.74,4948.41 ; v1@4323.57,4937.81 cw(c4339.79,4921.59) 4339.79,4944.52 cw(c4339.79,4967.46) v1@4323.57,4951.24 ; v3@5303.79,4387.5 ccw(c5285.75,4389.08) 5299.62,4400.72 ; v3@5311.91,4394.32 cw(c5313.49,4412.36) 5299.62,4400.72
CODEC.I2S_DIN: R17.2 U8.AB8 | length 8888.7
  Top Layer w4: v3(5114.41,3875.04) U8.AB8@5134.09,3894.72 ; U8.AB8@5126.75,3894.72 cw(c5109.03,3894.72) 5121.56,3882.19 cw(c5134.09,3869.66) U8.AB8@5134.09,3887.38 ; 5127.21,3887.84 cw(c5114.41,3900.65) 5114.41,3882.54 ccw(c5114.41,3900.65) 5127.21,3887.84 ; 5127.21,3887.84 ccw(c5140.02,3875.04) 5121.91,3875.04 cw(c5140.02,3875.04) 5127.21,3887.84
  MidLayer1 w4: v1(2231.86,2350.04) 2363.54,2350.04 2380,2366.5 3021.5,2366.5 3055.37,2400.37 3120.88,2400.37 3315.19,2594.69 3315.19,2675.04 3371,2730.85 3371,3218.37 3497.52,3344.9 3497.52,3765.1 3507.47,3775.04 3832.19,3775.04 v1(3857.19,3800.04) ; v1@2235.75,2346.15 cw(c2245.14,2336.76) 2245.14,2350.04 cw(c2245.14,2363.32) v1@2235.75,2353.93 ; v1@2238.57,2343.32 cw(c2254.79,2327.11) 2254.79,2350.04 cw(c2254.79,2372.98) v1@2238.57,2356.76 ; v1@3847.69,3800.04 cw(c3824.76,3800.04) 3840.97,3783.82 cw(c3857.19,3767.61) v1@3857.19,3790.54 ; v1@3851.69,3800.04 cw(c3838.41,3800.04) 3847.8,3790.65 cw(c3857.19,3781.26) v1@3857.19,3794.54
  MidLayer2 w4: v2@-471.94,2393.06 cw(c-488.69,2376.31) -465,2376.31 cw(c-441.31,2376.31) v2@-458.06,2393.06 ; v2@-469.11,2395.89 cw(c-479.03,2385.97) -465,2385.97 cw(c-450.97,2385.97) v2@-460.89,2395.89 ; v2(-465,2400) -465,2370.25 -444.46,2349.71 -264.71,2349.71 v2(-245,2330) ; v2@-254.81,2330 ccw(c-278.5,2330) -261.75,2346.75 ccw(c-245,2363.5) v2@-245,2339.81 ; v2@-250.81,2330 ccw(c-264.84,2330) -254.92,2339.92 ccw(c-245,2349.84) v2@-245,2335.81
  Bottom Layer w4: v2@-471.94,2406.94 ccw(c-488.69,2423.69) -465,2423.69 ccw(c-441.31,2423.69) v2@-458.06,2406.94 ; v2@-469.11,2404.11 ccw(c-479.03,2414.03) -465,2414.03 ccw(c-450.97,2414.03) v2@-460.89,2404.11 ; v2(-465,2400) -465,2445 -480,2460 -480,2677.66 -470,2687.66 -462.34,2687.66 -440,2710 -440,2835 -430,2845 R17.2@-341.18,2845 ; R17.2@-347.77,2838.41 ccw(c-363.68,2822.5) -363.68,2845 ccw(c-363.68,2867.5) R17.2@-347.77,2851.59 ; R17.2@-344.94,2841.24 ccw(c-354.02,2832.16) -354.02,2845 ccw(c-354.02,2857.84) R17.2@-344.94,2848.76 ; v2(-245,2330) -180,2330 -170.02,2320.02 2104.61,2320.02 2134.63,2350.04 v1(2231.86,2350.04) ; v2@-240.89,2325.89 cw(c-230.97,2315.97) -230.97,2330 cw(c-230.97,2344.03) v2@-240.89,2334.11 ; v2@-238.06,2323.06 cw(c-221.31,2306.31) -221.31,2330 cw(c-221.31,2353.69) v2@-238.06,2336.94 ; v1@2225.14,2343.32 ccw(c2208.92,2327.11) 2208.92,2350.04 ccw(c2208.92,2372.98) v1@2225.14,2356.76 ; v1@2227.97,2346.15 ccw(c2218.58,2336.76) 2218.58,2350.04 ccw(c2218.58,2363.32) v1@2227.97,2353.93 ; v1(3857.19,3800.04) 3898.33,3800.04 3915,3783.37 3970,3783.37 4003.33,3816.71 4148.52,3816.71 4182.19,3850.37 4360.17,3850.37 4392.8,3883 4440.48,3883 4448.52,3891.04 4456.86,3899.37 4456.86,3950.04 4478.32,3971.5 4679.34,3971.5 4716.19,3934.65 4716.19,3909 4711.19,3904 4711.19,3860.13 4696.88,3845.82 4696.88,3757.06 4729.5,3724.44 4729.5,3668.45 4741.68,3656.27 4741.68,3645.69 4789.19,3598.19 4789.19,3562.71 4863.03,3488.88 4898.73,3488.88 4913.11,3474.5 4969.25,3474.5 5001.65,3506.9 5005.04,3506.9 5020.5,3522.37 5020.5,3542.44 5011.81,3551.13 5011.81,3561.08 4996.57,3576.33 4996.57,3606.57 5011.9,3621.9 5011.9,3630.82 5011.9,3638.82 5011.9,3640.41 5011.9,3698.67 5011.9,3756.93 cw(c5035.67,3756.93) 5035.67,3780.7 ccw(c5035.67,3796.3) 5051.27,3796.3 cw(c5075.04,3796.3) 5075.04,3820.07 ccw(c5075.04,3835.67) 5090.64,3835.67 cw(c5114.41,3835.67) 5097.6,3852.48 5104.02,3860.21 ; v1@3861.08,3796.15 cw(c3870.47,3786.76) 3870.47,3800.04 cw(c3870.47,3813.32) v1@3861.08,3803.93 ; v1@3863.91,3793.32 cw(c3880.13,3777.11) 3880.13,3800.04 cw(c3880.13,3822.98) v1@3863.91,3806.76 ; v3@5107.02,3873.74 cw(c5089.19,3870.59) 5104.02,3860.21 ; v3@5115.71,3867.65 ccw(c5118.86,3849.82) 5104.02,3860.21
CODEC.I2S_DOUT: R19.2 U8.AE6 | length 7509.2
  Top Layer w4: v3(5035.67,3756.93) U8.AE6@5055.35,3776.61 ; U8.AE6@5048.01,3776.61 cw(c5030.29,3776.61) 5042.82,3764.08 cw(c5055.35,3751.55) U8.AE6@5055.35,3769.27 ; 5048.47,3769.73 cw(c5035.67,3782.54) 5035.67,3764.43 ccw(c5035.67,3782.54) 5048.47,3769.73 ; 5048.47,3769.73 ccw(c5061.28,3756.93) 5043.17,3756.93 cw(c5061.28,3756.93) 5048.47,3769.73
  MidLayer1 w4: v1(4904,2476) 4890.86,2489.14 4890.86,2690.43 4923.52,2723.1 4923.52,3194.69 4956.86,3228.02 4956.86,3384.61 5004.5,3432.25 5004.5,3517.68 5012.5,3525.68 5012.5,3539.13 5003.81,3547.81 5003.81,3584.07 5035.67,3615.92 5035.67,3630.82 5035.67,3638.82 5035.67,3679.25 v3(5035.67,3756.93) ; v3@5030.48,3751.74 cw(c5017.94,3739.2) 5035.67,3739.2 cw(c5053.4,3739.2) v3@5040.86,3751.74 ; 5035.67,3738.82 cw(c5053.78,3738.82) 5040.97,3751.63 ccw(c5053.78,3738.82) 5035.67,3738.82 ; 5035.67,3738.82 ccw(c5017.56,3738.82) 5030.37,3751.63 cw(c5017.56,3738.82) 5035.67,3738.82
  MidLayer2 w4: v1(2180.86,2325.04) 2217.66,2325.04 2225.16,2332.54 2356.48,2332.54 2378.9,2354.96 2394.44,2370.5 2415.56,2370.5 2444.35,2341.71 2740.65,2341.71 2749.44,2350.5 2770.56,2350.5 2779.35,2341.71 3203.19,2341.71 3206.86,2338.04 3270.98,2338.04 3307.98,2375.04 4891.19,2375.04 4907.86,2391.71 4907.86,2474.66 4906.52,2476 v1(4904,2476) ; v1@2184.75,2321.15 cw(c2194.14,2311.76) 2194.14,2325.04 cw(c2194.14,2338.32) v1@2184.75,2328.93 ; v1@2187.57,2318.32 cw(c2203.79,2302.11) 2203.79,2325.04 cw(c2203.79,2347.98) v1@2187.57,2331.76 ; v1@4897.28,2469.28 cw(c4871.75,2443.75) 4907.86,2443.75 ; v1@4900.11,2472.11 cw(c4881.41,2453.41) 4907.86,2453.41 ; v1@4902.94,2474.94 cw(c4891.07,2463.07) 4907.86,2463.07 ; 4907.86,2462.38 cw(c4917.62,2462.38) v1@4910.72,2469.28
  Bottom Layer w4: R19.2@-350.5,2544.37 cw(c-370.74,2544.07) -356.43,2529.75 cw(c-343.14,2516.47) R19.2@-341.83,2535.21 ; R19.2@-350.22,2535.96 cw(c-342.33,2528.07) R19.2@-341.55,2539.2 ; R19.2@-349.74,2536.44 ccw(c-357.56,2544.27) R19.2@-346.5,2544.43 ; R19.2@-341.18,2545 -356.18,2530 -389,2530 -422,2497 -422,2390.81 -343.21,2312.02 2112.02,2312.02 2125.04,2325.04 v1(2180.86,2325.04) ; v1@2174.14,2318.32 ccw(c2157.92,2302.11) 2157.92,2325.04 ccw(c2157.92,2347.98) v1@2174.14,2331.76 ; v1@2176.97,2321.15 ccw(c2167.58,2311.76) 2167.58,2325.04 ccw(c2167.58,2338.32) v1@2176.97,2328.93
CODEC.I2S_MCLK: R20.1 U8.G14 | length 13755.6
  Top Layer w4: v3(5350.63,4504.96) U8.G14@5370.31,4485.28 ; U8.G14@5362.97,4485.28 ccw(c5345.25,4485.28) 5357.78,4497.81 ccw(c5370.31,4510.34) U8.G14@5370.31,4492.62 ; 5363.43,4492.16 cw(c5376.24,4504.96) 5358.13,4504.96 ccw(c5376.24,4504.96) 5363.43,4492.16 ; 5363.43,4492.16 ccw(c5350.63,4479.35) 5350.63,4497.46 cw(c5350.63,4479.35) 5363.43,4492.16
  MidLayer1 w4: v2(475,2945) 497.19,2945 ; v2@479.3,2941.09 cw(c488.14,2933.04) 488.14,2945 cw(c488.14,2956.96) v2@479.3,2948.91 ; v2@482.26,2938.4 cw(c497.19,2924.81) 497.19,2945 ; v2@482.26,2951.6 ccw(c497.19,2965.19) 497.19,2945 ; v1@5408.78,4951.03 ccw(c5392.56,4967.25) 5415.5,4967.25 ccw(c5438.43,4967.25) v1@5422.22,4951.03 ; v1@5411.61,4948.2 ccw(c5402.22,4957.59) 5415.5,4957.59 ccw(c5428.78,4957.59) v1@5419.39,4948.2 ; v1(5415.5,4944.31) 5415.5,4994.1 5455.9,5034.5 5493.66,5034.5 5526.18,5067.01 5526.18,5082.38 5495.86,5112.7 5495.86,5115.98 5478.5,5133.33 5478.5,5203.81 5470.5,5211.81 5470.5,5247.02 5491.76,5268.28 5505.19,5281.71 5573.52,5350.04 5674.19,5450.71 5674.19,5548.13 5694,5567.94 5694,6154.37 5615,6233.37 4825,6233.37 4802,6256.37 4802,6650.37 4713.37,6739 1836.63,6739 1821,6723.37 1821,6589 1890,6520 1890,6433.18 1840.19,6383.37 1370,6383.37 1265.19,6278.56 1265.19,5010.19 1245,4990 601.31,4990 590.19,4978.88 590.19,4680.39 198.19,4288.39 198.19,3866.37 181.86,3850.04 181.86,3497.02 127.18,3442.35 127.18,3408.07 137.75,3397.5 177.5,3397.5 240,3460 610,3460 619,3451 619,3370 584,3335 535,3335 495,3295 495,3230 513.61,3211.39 513.61,2961.42 497.19,2945
  MidLayer2 w4: 5339.24,4518.54 cw(c5349.17,4528.47) 5335.12,4528.47 5335.12,4542.4 5335.12,4602.59 5335.12,4622.01 5335.12,4680.27 5335.12,4738.53 5335.12,4741.18 5335.12,4751.18 5335.12,4793.81 5365.19,4823.88 5365.19,4871.37 ; v3@5343.16,4505.61 ccw(c5325.12,4507.19) 5338.99,4518.83 ccw(c5352.86,4530.47) v3@5351.28,4512.43 ; v1@5408.78,4937.59 ccw(c5392.56,4921.38) 5392.56,4944.31 ccw(c5392.56,4967.25) v1@5408.78,4951.03 ; v1@5411.61,4940.42 ccw(c5402.22,4931.03) 5402.22,4944.31 ccw(c5402.22,4957.59) v1@5411.61,4948.2 ; v1(5415.5,4944.31) 5376.13,4944.31 ; 5365.19,4871.37 5365.19,4885 ; 5365.19,4871.37 5365.19,4885 ; 5365.19,4885 5365.19,4933.37 ; 5365.19,4933.37 5376.13,4944.31 ; 5365.19,4933.37 5376.13,4944.31
  Bottom Layer w4: R20.1@-347.77,2888.41 ccw(c-363.68,2872.5) -363.68,2895 ccw(c-363.68,2917.5) R20.1@-347.77,2901.59 ; R20.1@-344.94,2891.24 ccw(c-354.02,2882.16) -354.02,2895 ccw(c-354.02,2907.84) R20.1@-344.94,2898.76 ; R20.1@-341.18,2895 -440,2895 -443.48,2898.48 -443.48,3030.06 -431.5,3042.04 377.96,3042.04 v2(475,2945) ; v2@465.19,2945 ccw(c441.5,2945) 458.25,2961.75 ccw(c475,2978.5) v2@475,2954.81 ; v2@469.19,2945 ccw(c455.16,2945) 465.08,2954.92 ccw(c475,2964.84) v2@475,2950.81