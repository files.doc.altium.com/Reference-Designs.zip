# Altium PCB NB3000AL.PcbDoc (part 19 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.UIO.IO35: J33.B37 PROTOTYPE1.B32 U8.AA8 UH2.19 | length 10443.7
  Top Layer w4: UH2.19@3273.76,4713.23 3320,4666.99 3320,4064.36 PROTOTYPE1.B32@3376.12,4008.23 ; UH2.19@3273.94,4697.71 cw(c3274.35,4661.66) 3299.84,4687.15 cw(c3325.33,4712.64) UH2.19@3289.29,4713.06 ; UH2.19@3273.98,4693.71 cw(c3274.5,4648.38) 3306.56,4680.43 cw(c3338.61,4712.49) UH2.19@3293.28,4713.01 ; UH2.19@3274.03,4689.71 cw(c3274.66,4635.09) 3313.28,4673.71 cw(c3351.9,4712.34) UH2.19@3297.28,4712.96 ; UH2.19@3274.08,4685.71 cw(c3274.81,4621.81) 3320,4667 cw(c3365.18,4712.18) UH2.19@3301.28,4712.92 ; PROTOTYPE1.B32@3347.12,4008.23 ccw(c3277.11,4008.23) 3326.62,4057.74 ccw(c3376.12,4107.25) PROTOTYPE1.B32@3376.12,4037.23 ; PROTOTYPE1.B32@3351.12,4008.23 ccw(c3290.77,4008.23) 3333.44,4050.91 ccw(c3376.12,4093.59) PROTOTYPE1.B32@3376.12,4033.23 ; PROTOTYPE1.B32@3355.12,4008.23 ccw(c3304.42,4008.23) 3340.27,4044.08 ccw(c3376.12,4079.93) PROTOTYPE1.B32@3376.12,4029.23 ; PROTOTYPE1.B32@3359.12,4008.23 ccw(c3318.08,4008.23) 3347.1,4037.26 ccw(c3376.12,4066.28) PROTOTYPE1.B32@3376.12,4025.23 ; PROTOTYPE1.B32@3363.12,4008.23 ccw(c3331.74,4008.23) 3353.93,4030.43 ccw(c3376.12,4052.62) PROTOTYPE1.B32@3376.12,4021.23 ; v3(5114.41,3914.41) U8.AA8@5134.09,3934.09 ; U8.AA8@5126.75,3934.09 cw(c5109.03,3934.09) 5121.56,3921.56 cw(c5134.09,3909.03) U8.AA8@5134.09,3926.75 ; 5127.21,3927.21 cw(c5114.41,3940.02) 5114.41,3921.91 ccw(c5114.41,3940.02) 5127.21,3927.21 ; 5127.21,3927.21 ccw(c5140.02,3914.41) 5121.91,3914.41 cw(c5140.02,3914.41) 5127.21,3927.21
  MidLayer1 w4: v1(2695,2725) 2809.19,2725 3331.86,3247.67 3331.86,3963.97 ; v1@2698.89,2721.11 cw(c2708.28,2711.72) 2708.28,2725 cw(c2708.28,2738.28) v1@2698.89,2728.89 ; v1@2701.72,2718.28 cw(c2717.93,2702.06) 2717.93,2725 cw(c2717.93,2747.93) v1@2701.72,2731.72 ; PROTOTYPE1.B32@3347.22,4005.85 cw(c3294.34,4001.49) 3331.86,3963.97 ; PROTOTYPE1.B32@3351.21,4006.18 cw(c3305.62,4002.42) 3337.96,3970.08 cw(c3370.31,3937.74) PROTOTYPE1.B32@3374.07,3983.32 ; PROTOTYPE1.B32@3355.19,4006.51 cw(c3316.9,4003.35) 3344.07,3976.18 cw(c3371.24,3949.02) PROTOTYPE1.B32@3374.39,3987.31 ; PROTOTYPE1.B32@3359.18,4006.84 cw(c3328.18,4004.28) 3350.17,3982.29 cw(c3372.17,3960.3) PROTOTYPE1.B32@3374.72,3991.29 ; PROTOTYPE1.B32@3373.74,3979.33 ccw(c3369.37,3926.46) 3331.86,3963.97 ; PROTOTYPE1.B32@3376.12,4008.23 3331.86,3963.97
  MidLayer2 w4: v1(490.19,3000.04) 631.86,3000.04 v1(699.19,2932.71) ; v1@494.08,2996.15 cw(c503.47,2986.76) 503.47,3000.04 cw(c503.47,3013.32) v1@494.08,3003.93 ; v1@496.91,2993.32 cw(c513.13,2977.11) 513.13,3000.04 cw(c513.13,3022.98) v1@496.91,3006.76 ; v1@689.69,2932.71 ccw(c666.76,2932.71) 682.97,2948.93 ccw(c699.19,2965.14) v1@699.19,2942.21 ; v1@693.69,2932.71 ccw(c680.41,2932.71) 689.8,2942.1 ccw(c699.19,2951.49) v1@699.19,2938.21 ; PROTOTYPE1.B32@3347.54,4013.15 ccw(c3308.55,4019.86) 3336.53,4047.83 ; PROTOTYPE1.B32@3351.48,4012.47 ccw(c3317.87,4018.25) 3341.99,4042.37 ccw(c3366.1,4066.48) PROTOTYPE1.B32@3371.88,4032.87 ; PROTOTYPE1.B32@3355.43,4011.79 ccw(c3327.19,4016.65) 3347.45,4036.91 ccw(c3367.71,4057.16) PROTOTYPE1.B32@3372.56,4028.93 ; PROTOTYPE1.B32@3359.37,4011.12 ccw(c3336.51,4015.05) 3352.91,4031.45 ccw(c3369.31,4047.84) PROTOTYPE1.B32@3373.24,4024.99 ; PROTOTYPE1.B32@3371.21,4036.82 cw(c3364.5,4075.8) 3336.53,4047.83 ; PROTOTYPE1.B32@3376.12,4008.23 3336.52,4047.83 ; v1@3689.02,4175.04 cw(c3666.09,4175.04) 3682.31,4158.82 cw(c3698.52,4142.61) v1@3698.52,4165.54 ; v1@3693.02,4175.04 cw(c3679.75,4175.04) 3689.13,4165.65 cw(c3698.52,4156.26) v1@3698.52,4169.54 ; v1(3698.52,4175.04) 3681.86,4158.37 3372.19,4158.37 3336.52,4122.71 3336.52,4047.83
  Bottom Layer w4: J33.B37@-785.98,2770.97 -480.55,2770.97 -451.48,2800.04 -451.48,3033.37 -434.81,3050.04 440.19,3050.04 v1(490.19,3000.04) ; J33.B37@-711.58,2765.47 cw(c-698.3,2752.19) -698.3,2770.97 cw(c-698.3,2789.75) J33.B37@-711.58,2776.47 ; J33.B37@-708.76,2762.64 cw(c-688.65,2742.53) -688.65,2770.97 cw(c-688.65,2799.41) J33.B37@-708.76,2779.3 ; v1@480.69,3000.04 ccw(c457.76,3000.04) 473.97,3016.26 ccw(c490.19,3032.48) v1@490.19,3009.54 ; v1@484.69,3000.04 ccw(c471.41,3000.04) 480.8,3009.43 ccw(c490.19,3018.82) v1@490.19,3005.54 ; v1@699.19,2923.21 cw(c699.19,2900.27) 715.41,2916.49 cw(c731.63,2932.71) v1@708.69,2932.71 ; v1@699.19,2927.21 cw(c699.19,2913.93) 708.58,2923.32 cw(c717.97,2932.71) v1@704.69,2932.71 ; v1(699.19,2932.71) 748.52,2883.37 1484.96,2883.37 1498.46,2869.87 1528.69,2869.87 1690.52,2708.04 2678.04,2708.04 v1(2695,2725) ; v1@2685.5,2725 cw(c2662.56,2725) 2678.78,2708.78 cw(c2695,2692.56) v1@2695,2715.5 ; v1@2689.5,2725 cw(c2676.22,2725) 2685.61,2715.61 cw(c2695,2706.22) v1@2695,2719.5 ; v1@3698.52,4165.54 cw(c3698.52,4142.61) 3714.74,4158.82 cw(c3730.96,4175.04) v1@3708.02,4175.04 ; v1@3698.52,4169.54 cw(c3698.52,4156.26) 3707.91,4165.65 cw(c3717.3,4175.04) v1@3704.02,4175.04 ; v1(3698.52,4175.04) 3760.64,4112.93 4176.78,4112.93 4206.67,4083.04 4679.34,4083.04 4714.5,4047.88 4714.5,3970.5 4740.19,3944.81 4740.19,3920 4745.19,3915 4753.94,3915 4759.44,3909.5 4765.19,3909.5 4768.5,3906.19 4783.84,3906.19 4810,3880.03 4810,3785 4814.3,3780.7 4830.82,3780.7 4838.82,3780.7 4840.41,3780.7 4898.67,3780.7 4956.93,3780.7 ccw(c4956.93,3796.3) 4972.53,3796.3 cw(c4996.3,3796.3) 4996.3,3820.07 ccw(c4996.3,3835.67) 5011.9,3835.67 cw(c5035.67,3835.67) 5035.67,3859.44 ccw(c5035.67,3875.04) 5051.27,3875.04 cw(c5075.04,3875.04) 5075.04,3898.81 5083.16,3898.81 ; 5083.21,3898.86 ccw(c5084.82,3922.58) 5099.61,3903.98 ; v3@5107.02,3915.71 cw(c5089.19,3918.86) 5099.58,3904.02 cw(c5109.96,3889.19) v3@5113.11,3907.02
ATE.VGA#.BLUE: J18.3 J33.B27 R117.1 R118.2 U20.3 U21.45 | length 12131.9
  Top Layer w4: J18.3@5761.68,6342.44 cw(c5761.68,6280.74) 5805.32,6324.37 cw(c5848.95,6368) J18.3@5787.24,6368 ; J18.3@5761.68,6346.44 cw(c5761.68,6294.39) 5798.49,6331.2 cw(c5835.29,6368) J18.3@5783.24,6368 ; J18.3@5761.68,6350.44 cw(c5761.68,6308.05) 5791.66,6338.02 cw(c5821.64,6368) J18.3@5779.24,6368 ; J18.3@5761.68,6354.44 cw(c5761.68,6321.71) 5784.83,6344.85 cw(c5807.98,6368) J18.3@5775.24,6368 ; J18.3@5761.68,6368 5840,6289.68 5840,6132.18 v1(5824.52,6116.71)
  MidLayer1 w4: v1@-694.31,3166.71 ccw(c-717.24,3166.71) -701.03,3182.93 ccw(c-684.81,3199.14) v1@-684.81,3176.21 ; v1@-690.31,3166.71 ccw(c-703.59,3166.71) -694.2,3176.1 ccw(c-684.81,3185.49) v1@-684.81,3172.21 ; v1(-684.81,3166.71) -718.14,3200.04 -718.14,3516.86 -650,3585 -583.94,3585 -551.48,3617.47 -551.48,3977.46 -534.5,3994.44 -534.5,4015.56 -555,4036.06 -555,4158.5 -549.19,4164.31 -549.19,4551.38 -612.81,4615 -612.81,4775 -580.14,4807.67 -580.14,5281.43 -571.52,5290.05 -571.52,5896.3 -545,5922.82 v2(-545,5975) ; v2@-551.94,5968.06 cw(c-568.69,5951.31) -545,5951.31 cw(c-521.31,5951.31) v2@-538.06,5968.06 ; v2@-549.11,5970.89 cw(c-559.03,5960.97) -545,5960.97 cw(c-530.97,5960.97) v2@-540.89,5970.89
  MidLayer2 w4: v2(-545,5975) -527.46,5992.54 -377.54,5992.54 -344.34,5959.34 53.28,5959.34 79.44,5985.5 280.5,5985.5 497.54,6202.54 5597.54,6202.54 5612.19,6217.19 5761.68,6366.68 J18.3@5761.68,6368 ; v2@-545,5980.81 ccw(c-545,5994.84) -535.08,5984.92 ccw(c-525.16,5975) v2@-539.19,5975 ; v2@-545,5984.81 ccw(c-545,6008.5) -528.25,5991.75 ccw(c-511.5,5975) v2@-535.19,5975 ; 5717.12,6322.12 ccw(c5671.25,6368) J18.3@5736.13,6368 ; 5720.3,6325.3 cw(c5761.68,6283.91) J18.3@5761.68,6342.44 ; 5723.95,6328.95 ccw(c5684.9,6368) J18.3@5740.13,6368 ; 5727.13,6332.13 cw(c5761.68,6297.57) J18.3@5761.68,6346.44 ; 5730.78,6335.78 ccw(c5698.56,6368) J18.3@5744.13,6368 ; 5733.95,6338.95 cw(c5761.68,6311.22) J18.3@5761.68,6350.44 ; 5737.61,6342.61 ccw(c5712.22,6368) J18.3@5748.13,6368 ; 5740.78,6345.78 cw(c5761.68,6324.88) J18.3@5761.68,6354.44
  Bottom Layer w4: J33.B27@-785.98,3164.67 -702.85,3164.67 -700.81,3166.71 ; v1@-693.15,3162.16 ccw(c-700.81,3157.98) -700.81,3166.71 ; v1@-693.15,3171.26 cw(c-700.81,3175.43) -700.81,3166.71 ; v1(-684.81,3166.71) -700.81,3166.71 ; U21.45@5191.38,5763.68 ccw(c5184.56,5770.51) 5194.21,5770.51 ccw(c5203.87,5770.51) U21.45@5197.04,5763.68 ; U21.45@5194.21,5737.32 5194.21,5795.79 5135,5855 5135,5962.37 5146.63,5974 5740.18,5974 R118.2@5781.18,6015 ; 5764.43,5998.25 cw(c5781.18,5981.5) R118.2@5781.18,6005.19 ; 5765.62,5999.44 ccw(c5750.55,6014.51) R118.2@5771.86,6014.51 ; R118.2@5771.26,6005.08 cw(c5781.18,5995.16) R118.2@5781.18,6009.19 ; R118.2@5772.45,6006.27 ccw(c5764.21,6014.51) R118.2@5775.86,6014.51 ; R118.2@5774.59,6022.08 ccw(c5758.68,6037.99) 5781.18,6037.99 ccw(c5803.68,6037.99) R118.2@5787.77,6022.08 ; R118.2@5777.42,6019.25 ccw(c5768.34,6028.33) 5781.18,6028.33 ccw(c5794.02,6028.33) R118.2@5784.94,6019.25 ; R118.2@5784.94,6011.24 cw(c5794.02,6002.16) 5794.02,6015 cw(c5794.02,6027.84) R118.2@5784.94,6018.76 ; R118.2@5787.77,6008.41 cw(c5803.68,5992.5) 5803.68,6015 cw(c5803.68,6037.5) R118.2@5787.77,6021.59 ; U20.3@5792.17,6118.82 v1@5815.19,6118.82 ; U20.3@5796.49,6118.82 cw(c5796.49,6088.68) v1@5817.81,6109.99 ; U20.3@5806.15,6118.82 cw(c5806.15,6098.33) v1@5820.64,6112.82 ; U20.3@5806.69,6118.82 ccw(c5806.69,6134.55) v1@5817.81,6123.43 ; v1@5815.19,6118.71 5817.19,6116.71 v1(5824.52,6116.71) 5824.52,6101.71 5781.18,6058.36 R118.2@5781.18,6015 ; R117.1@5867.23,6008.41 ccw(c5851.32,5992.5) 5851.32,6015 ccw(c5851.32,6037.5) R117.1@5867.23,6021.59 ; R117.1@5870.06,6011.24 ccw(c5860.98,6002.16) 5860.98,6015 ccw(c5860.98,6027.84) R117.1@5870.06,6018.76 ; R117.1@5873.82,6015 R118.2@5781.18,6015
ATE.VGA#.GREEN: J18.2 J33.B29 R119.1 R120.2 U20.4 U21.41 | length 12496.2
  Top Layer w4: v1(5672.52,6108.37) 5801.63,6108.37 5815,6095 5840,6095 5851.84,6106.84 J18.2@5851.84,6368 ; v1@5676.41,6104.49 cw(c5685.8,6095.1) 5685.8,6108.37 cw(c5685.8,6121.65) v1@5676.41,6112.26 ; v1@5679.24,6101.66 cw(c5695.46,6085.44) 5695.46,6108.37 cw(c5695.46,6131.31) v1@5679.24,6115.09 ; J18.2@5833.77,6349.93 cw(c5790.14,6306.3) 5851.84,6306.3 cw(c5913.55,6306.3) J18.2@5869.92,6349.93 ; J18.2@5836.6,6352.76 cw(c5799.79,6315.95) 5851.84,6315.95 cw(c5903.89,6315.95) J18.2@5867.09,6352.76 ; J18.2@5839.43,6355.58 cw(c5809.45,6325.61) 5851.84,6325.61 cw(c5894.23,6325.61) J18.2@5864.26,6355.58 ; J18.2@5842.25,6358.41 cw(c5819.11,6335.27) 5851.84,6335.27 cw(c5884.58,6335.27) J18.2@5861.43,6358.41
  MidLayer1 w4: v1(-584.81,3183.37) -569,3199.18 -569,3217.77 -568.98,3429.56 -487.44,3511.1 -468.81,3529.73 -468.81,4109.94 -444,4134.75 -444,4170 -444,4215.25 -468.81,4240.06 -468.81,4566.44 -437.5,4597.75 -437.5,4612.25 -548.14,4722.89 -548.14,5268.17 -464.75,5351.56 -339.03,5351.56 -335.52,5355.08 -335.52,5815.05 -391.48,5871.01 v1(-391.48,5975.04) ; v1@-398.19,5968.32 cw(c-414.41,5952.11) -391.48,5952.11 cw(c-368.54,5952.11) v1@-384.76,5968.32 ; v1@-395.36,5971.15 cw(c-404.75,5961.76) -391.48,5961.76 cw(c-378.2,5961.76) v1@-387.59,5971.15
  MidLayer2 w4: v1@-391.48,5965.54 cw(c-391.48,5942.61) -375.26,5958.82 cw(c-359.04,5975.04) v1@-381.98,5975.04 ; v1@-391.48,5969.54 cw(c-391.48,5956.26) -382.09,5965.65 cw(c-372.7,5975.04) v1@-385.98,5975.04 ; v1(-391.48,5975.04) -367.77,5951.34 56.59,5951.34 82.75,5977.5 283.81,5977.5 472.5,6166.19 500.85,6194.54 5600.85,6194.54 5606.35,6200.04 5683.88,6200.04 J18.2@5851.84,6368 ; J18.2@5826.28,6368 cw(c5764.58,6368) 5808.21,6324.37 cw(c5851.84,6280.74) J18.2@5851.84,6342.44 ; J18.2@5830.28,6368 cw(c5778.23,6368) 5815.04,6331.19 cw(c5851.84,6294.4) J18.2@5851.84,6346.44 ; J18.2@5834.28,6368 cw(c5791.89,6368) 5821.87,6338.02 cw(c5851.84,6308.05) J18.2@5851.84,6350.44 ; J18.2@5838.28,6368 cw(c5805.55,6368) 5828.7,6344.85 cw(c5851.84,6321.71) J18.2@5851.84,6354.44
  Bottom Layer w4: J33.B29@-785.98,3085.93 -663.92,3085.93 -654.72,3095.13 -589.54,3095.13 -570.41,3114.27 -570.41,3168.97 v1(-584.81,3183.37) ; J33.B29@-711.58,3080.43 cw(c-698.3,3067.15) -698.3,3085.93 cw(c-698.3,3104.71) J33.B29@-711.58,3091.43 ; J33.B29@-708.76,3077.6 cw(c-688.65,3057.49) -688.65,3085.93 cw(c-688.65,3114.37) J33.B29@-708.76,3094.26 ; U21.41@5112.64,5763.68 ccw(c5105.82,5770.51) 5115.47,5770.51 ccw(c5125.13,5770.51) U21.41@5118.3,5763.68 ; U21.41@5115.47,5737.32 5115.47,5965.47 5140,5990 5695,5990 5705,6000 5705,6104.49 U20.4@5719.33,6118.82 5718.15,6120 5695,6120 ; R119.1@5634.59,6122.08 ccw(c5618.68,6137.99) 5641.18,6137.99 ccw(c5663.68,6137.99) R119.1@5647.77,6122.08 ; R120.2@5634.59,6167.92 cw(c5618.68,6152.01) 5641.18,6152.01 cw(c5663.68,6152.01) R120.2@5647.77,6167.92 ; R119.1@5637.42,6119.25 ccw(c5628.34,6128.33) 5641.18,6128.33 ccw(c5654.02,6128.33) R119.1@5644.94,6119.25 ; R120.2@5637.42,6170.75 cw(c5628.34,6161.67) 5641.18,6161.67 cw(c5654.02,6161.67) R120.2@5644.94,6170.75 ; R120.2@5641.18,6175 R119.1@5641.18,6115 5647.81,6108.37 v1(5672.52,6108.37) 5683.37,6108.37 5695,6120 ; R119.1@5642.23,6115.31 ccw(c5656.3,6126.11) 5656.3,6108.37 ; v1@5665.81,6101.66 ccw(c5649.59,6085.44) 5649.59,6108.37 ccw(c5649.59,6131.31) v1@5665.81,6115.09 ; v1@5668.64,6104.49 ccw(c5659.25,6095.1) 5659.25,6108.37 ccw(c5659.25,6121.65) v1@5668.64,6112.26 ; v1@5673.18,6109.72 ccw(c5678.48,6120.63) 5687.06,6112.06 ; v1@5674.93,6113.32 ccw(c5681.08,6125.98) 5691.03,6116.03 ; v1@5676.68,6116.92 ccw(c5683.68,6131.32) 5695,6120 ; 5699.14,6120 ccw(c5699.14,6130.15) U20.4@5706.32,6122.97 ; U20.4@5706.04,6114.97 ccw(c5695,6105.38) 5695,6120
ATE.VGA#.HSYNC: J18.13 J33.A4 U8.C12 U20.6 | length 13141.3
  Top Layer w4: J33.A4@-785.98,4148.92 -702.59,4148.92 ; J33.A4@-717.72,4144.75 ccw(c-714.86,4163.57) -701.41,4150.11 ; J33.A4@-717.12,4148.71 ccw(c-713.39,4173.29) -695.81,4155.71 ; J33.A4@-716.52,4152.66 ccw(c-711.92,4183.01) -690.21,4161.3 ; J33.A4@-715.92,4156.62 ccw(c-710.44,4192.73) -684.62,4166.9 ; J33.A4@-715.32,4160.57 ccw(c-708.97,4202.45) -679.02,4172.5 ; J33.A4@-705.55,4146.52 cw(c-702.59,4145.9) -702.59,4148.92 ; J33.A4@-705.55,4151.33 ccw(c-702.59,4151.95) -702.59,4148.92 ; -635.21,4172.5 cw(c-635.21,4135.48) v1@-609.03,4161.66 ; -625.55,4172.5 cw(c-625.55,4145.14) v1@-606.2,4164.49 ; -615.89,4172.5 cw(c-615.89,4154.79) v1@-603.37,4167.31 ; -615.29,4172.5 ccw(c-615.29,4181.35) v1@-609.03,4175.09 ; v1(-602.31,4168.37) -601.48,4168.37 -605.6,4172.5 -679.02,4172.5 -702.59,4148.92 ; v1(-555,6135) -523.29,6166.71 -245.92,6166.71 -197.15,6215.48 -149.52,6215.48 73.52,6438.52 v1(73.52,6482.71) ; v1@-555,6140.5 ccw(c-555,6153.78) -545.61,6144.39 ccw(c-536.22,6135) v1@-549.5,6135 ; v1@-555,6144.5 ccw(c-555,6167.43) -538.78,6151.22 ccw(c-522.57,6135) v1@-545.5,6135 ; v1@66.81,6475.99 cw(c50.59,6459.77) 73.52,6459.77 cw(c96.46,6459.77) v1@80.24,6475.99 ; v1@69.64,6478.82 cw(c60.25,6469.43) 73.52,6469.43 cw(c86.8,6469.43) v1@77.41,6478.82 ; 5274.19,4855.56 cw(c5315.34,4855.56) v1@5286.24,4884.66 ; 5274.19,4865.22 cw(c5305.68,4865.22) v1@5283.41,4887.49 ; 5274.19,4874.87 cw(c5296.03,4874.87) v1@5280.58,4890.31 ; v1(5279.52,4891.37) 5274.19,4886.04 5274.19,4833.32 5263.19,4822.32 5263.19,4777.34 5267.71,4772.82 ; U8.C12@5284.23,4642.76 ccw(c5266.51,4642.76) 5279.04,4655.29 ; U8.C12@5291.58,4650.1 cw(c5291.58,4667.82) 5279.04,4655.29 ; v1(5565.52,6126.37) 5678.52,6126.37 5719.19,6167.04 v1(5719.19,6195.04) ; v1@5569.41,6122.49 cw(c5578.8,6113.1) 5578.8,6126.37 cw(c5578.8,6139.65) v1@5569.41,6130.26 ; v1@5572.24,6119.66 cw(c5588.46,6103.44) 5588.46,6126.37 cw(c5588.46,6149.31) v1@5572.24,6133.09 ; v1@5712.47,6188.32 cw(c5696.26,6172.11) 5719.19,6172.11 cw(c5742.13,6172.11) v1@5725.91,6188.32 ; v1@5712.47,6201.76 ccw(c5696.26,6217.98) 5719.19,6217.98 ccw(c5742.13,6217.98) v1@5725.91,6201.76 ; v1@5715.3,6191.15 cw(c5705.91,6181.76) 5719.19,6181.76 cw(c5732.47,6181.76) v1@5723.08,6191.15 ; v1@5715.3,6198.93 ccw(c5705.91,6208.32) 5719.19,6208.32 ccw(c5732.47,6208.32) v1@5723.08,6198.93 ; v1@5723.52,6199.37 v1(5719.19,6195.04) ; J18.13@5743.61,6549.93 cw(c5699.98,6506.29) 5761.69,6506.29 cw(c5823.39,6506.3) J18.13@5779.76,6549.93 ; J18.13@5746.44,6552.76 cw(c5709.64,6515.95) 5761.69,6515.95 cw(c5813.73,6515.95) J18.13@5776.93,6552.76 ; J18.13@5749.27,6555.58 cw(c5719.29,6525.61) 5761.69,6525.61 cw(c5804.08,6525.61) J18.13@5774.1,6555.58 ; J18.13@5752.1,6558.41 cw(c5728.95,6535.27) 5761.69,6535.27 cw(c5794.42,6535.27) J18.13@5771.27,6558.41 ; J18.13@5761.68,6568 5761.69,6435 5719.19,6392.5 v1(5719.19,6195.04) ; 5267.71,4751.18 5267.71,4772.81 ; 5267.71,4751.18 5267.71,4772.82 ; 5267.71,4751.18 5267.71,4741.18 5267.71,4682.64 ccw(c5306.39,4682.64) 5279.04,4655.29
  MidLayer1 w4: v1@-675,4240.5 cw(c-675,4217.56) -658.78,4233.78 cw(c-642.57,4250) v1@-665.5,4250 ; v1@-675,4244.5 cw(c-675,4231.22) -665.61,4240.61 cw(c-656.22,4250) v1@-669.5,4250 ; v1(-675,4250) -650.69,4225.69 -650.69,4217.59 v1@-602.31,4169.21 ; -619.12,4186.02 cw(c-636.76,4168.37) v1@-611.81,4168.37 ; -617.1,4184 ccw(c-602.31,4198.79) v1@-602.31,4177.87 ; -612.29,4179.19 cw(c-623.11,4168.37) v1@-607.81,4168.37 ; -610.27,4177.17 ccw(c-602.31,4185.14) v1@-602.31,4173.87 ; v1@5273.93,4899.05 ccw(c5265.9,4910.06) 5279.52,4910.06 ; v1(5279.52,4891.37) 5279.52,4910.06 ; v1@5285.12,4899.05 cw(c5293.15,4910.06) 5279.52,4910.06 ; v1@5556.02,6126.37 cw(c5533.09,6126.37) 5549.31,6110.16 cw(c5565.52,6093.94) v1@5565.52,6116.87 ; v1@5560.02,6126.37 cw(c5546.75,6126.37) 5556.14,6116.99 cw(c5565.52,6107.6) v1@5565.52,6120.87 ; v1(5565.52,6126.37) 5448.52,6009.37 5448.52,5797.37 5415.19,5764.04 5415.19,5740 5440.19,5715 5440.19,5303.4 5340.19,5203.4 5340.19,5077.67 5289.52,5027 5289.52,4920.06 5279.52,4910.06 ; v1@-602.31,4169.21 v1(-602.31,4168.37) -601.48,4168.37 v1@-602.31,4169.21
  Bottom Layer w4: v1@-675,4240.5 cw(c-675,4193.67) -641.88,4226.78 ; v1@-675,4244.5 cw(c-675,4207.32) -648.71,4233.61 ; v1@-675,4248.5 cw(c-675,4220.98) -655.54,4240.44 ; v1(-675,4250) -665.1,4250 -640.1,4225 -585,4225 -576.48,4233.52 -576.48,4567.02 -623,4613.54 -623,5291.69 -670,5338.69 -670,5746.12 -648.12,5768 -618.31,5768 -576.48,5809.84 -576.48,6113.52 v1(-555,6135) ; v1@-675,4252.5 cw(c-675,4234.64) -662.37,4247.27 ; v1@-564.5,6135 cw(c-587.44,6135) -571.22,6118.78 cw(c-555,6102.56) v1@-555,6125.5 ; v1@-560.5,6135 cw(c-573.78,6135) -564.39,6125.61 cw(c-555,6116.22) v1@-555,6129.5 ; v1(73.52,6482.71) 392.82,6802 2776.69,6802 2853.65,6725.04 5709.96,6725.04 5761.68,6673.31 J18.13@5761.68,6568 ; v1@73.52,6488.21 ccw(c73.52,6501.49) 82.91,6492.1 ccw(c92.3,6482.71) v1@79.02,6482.71 ; v1@73.52,6492.21 ccw(c73.52,6515.14) 89.74,6498.93 ccw(c105.96,6482.71) v1@83.02,6482.71 ; v1@5712.47,6188.32 cw(c5695.91,6171.76) U20.6@5719.33,6171.76 ; v1@5715.3,6191.15 cw(c5705.57,6181.42) 5719.33,6181.42 ; v1(5719.19,6195.04) 5719.33,6194.9 U20.6@5719.33,6170 ; U20.6@5719.33,6172.45 cw(c5741.78,6172.45) v1@5725.91,6188.32 ; 5719.33,6182.11 cw(c5732.12,6182.11) v1@5723.08,6191.15 ; J18.13@5743.61,6586.07 ccw(c5699.98,6629.7) 5761.69,6629.7 ccw(c5823.39,6629.7) J18.13@5779.76,6586.07 ; J18.13@5746.44,6583.24 ccw(c5709.64,6620.05) 5761.68,6620.05 ccw(c5813.73,6620.05) J18.13@5776.93,6583.24 ; J18.13@5749.27,6580.42 ccw(c5719.29,6610.39) 5761.68,6610.39 ccw(c5804.08,6610.39) J18.13@5774.1,6580.42 ; J18.13@5752.1,6577.59 ccw(c5728.95,6600.73) 5761.68,6600.73 ccw(c5794.42,6600.73) J18.13@5771.27,6577.59
ATE.VGA#.ID0: J18.11
ATE.VGA#.ID1/SDA/DDC: J18.12
ATE.VGA#.ID2: J18.4
ATE.VGA#.ID3/SCL/DDC: J18.15
ATE.VGA#.KEY: J18.9
ATE.VGA#.RED: J18.1 J33.B30 R121.2 R122.2 U20.1 U21.43 | length 12031.3
  Top Layer w4: v1@5867.14,6223.76 ccw(c5850.92,6239.98) 5873.86,6239.98 ccw(c5896.79,6239.98) v1@5880.57,6223.76 ; v1@5869.97,6220.93 ccw(c5860.58,6230.32) 5873.86,6230.32 ccw(c5887.14,6230.32) v1@5877.75,6220.93 ; v1(5873.86,6217.04) 5873.86,6299.86 J18.1@5942,6368 ; J18.1@5916.44,6368 cw(c5854.74,6368) 5898.37,6324.37 cw(c5942,6280.74) J18.1@5942,6342.44 ; J18.1@5920.44,6368 cw(c5868.39,6368) 5905.2,6331.2 cw(c5942,6294.39) J18.1@5942,6346.44 ; J18.1@5924.44,6368 cw(c5882.05,6368) 5912.02,6338.02 cw(c5942,6308.05) J18.1@5942,6350.44 ; J18.1@5928.44,6368 cw(c5895.71,6368) 5918.85,6344.85 cw(c5942,6321.71) J18.1@5942,6354.44
  MidLayer1 w4: v1(-659.81,3025.04) -586.02,3025.04 -521,3090.06 -521,3090.31 -515.5,3095.81 -515.5,3216.82 -332,3400.32 -332,3823.31 -285.23,3870.09 -285.23,4006.77 -287,4008.55 -287,4144.87 -153.87,4278 -93.16,4278 15.19,4386.35 15.19,4460.19 192,4637 192,4840.65 -1.48,5034.13 -1.48,5230.39 65.19,5297.06 65.19,5930 v1@92.6,5957.4 ; v1@-655.92,3021.15 cw(c-646.53,3011.76) -646.53,3025.04 cw(c-646.53,3038.32) v1@-655.92,3028.93 ; v1@-653.09,3018.32 cw(c-636.87,3002.11) -636.87,3025.04 cw(c-636.87,3047.98) v1@-653.09,3031.76 ; 70.11,5934.92 ccw(c45.03,5960) v1@80.5,5960 ; 76.94,5941.75 ccw(c58.69,5960) v1@84.5,5960 ; 82.64,5947.45 cw(c90,5940.1) v1@90,5950.5 ; 83.77,5948.58 ccw(c72.35,5960) v1@88.5,5960
  MidLayer2 w4: v1(90,5960) 277.63,5960 504.17,6186.54 5604.17,6186.54 5609.34,6191.71 5697.77,6191.71 5711.94,6177.54 5726.44,6177.54 5765.94,6217.04 v1(5873.86,6217.04) ; v1@93.89,5956.11 cw(c103.28,5946.72) 103.28,5960 cw(c103.28,5973.28) v1@93.89,5963.89 ; v1@96.72,5953.28 cw(c112.93,5937.06) 112.93,5960 cw(c112.93,5982.93) v1@96.72,5966.72 ; v1@5867.14,6210.32 ccw(c5850.92,6194.11) 5850.92,6217.04 ccw(c5850.92,6239.98) v1@5867.14,6223.76 ; v1@5869.97,6213.15 ccw(c5860.58,6203.76) 5860.58,6217.04 ccw(c5860.58,6230.32) v1@5869.97,6220.93
  Bottom Layer w4: J33.B30@-785.98,3046.56 -681.33,3046.56 v1(-659.81,3025.04) ; J33.B30@-711.58,3041.06 cw(c-698.3,3027.78) -698.3,3046.56 cw(c-698.3,3065.34) J33.B30@-711.58,3052.06 ; J33.B30@-708.76,3038.23 cw(c-688.65,3018.12) -688.65,3046.56 cw(c-688.65,3075) J33.B30@-708.76,3054.89 ; v1@-669.31,3025.04 ccw(c-692.24,3025.04) -676.03,3041.26 ccw(c-659.81,3057.48) v1@-659.81,3034.54 ; v1@-665.31,3025.04 ccw(c-678.59,3025.04) -669.2,3034.43 ccw(c-659.81,3043.82) v1@-659.81,3030.54 ; 5152.89,5775.23 ccw(c5169.22,5775.23) U21.43@5157.67,5763.68 ; U21.43@5154.84,5737.32 5152.89,5739.28 5152.89,5825 5125,5852.89 5125,5963.69 5143.31,5982 5702,5982 5715,5995 5715,6065 5750,6100 5750,6160 5760,6170 U20.1@5792.17,6170 5868.82,6170 R121.2@5873.82,6175 ; U20.1@5779.16,6165.85 ccw(c5769.13,6155.82) 5769.13,6170 ccw(c5769.13,6184.18) U20.1@5779.16,6174.15 ; U20.1@5805.18,6165.85 cw(c5815.21,6155.82) 5815.21,6170 cw(c5815.21,6184.18) U20.1@5805.18,6174.15 ; 5840.44,6170 ccw(c5840.44,6207.89) R121.2@5867.23,6181.1 ; 5850.09,6170 ccw(c5850.09,6198.23) R121.2@5870.06,6178.27 ; 5859.75,6170 ccw(c5859.75,6188.57) R121.2@5872.89,6175.44 ; 5862.2,6170 cw(c5862.2,6162.89) 5867.23,6167.92 cw(c5851.32,6152.01) 5873.82,6152.01 cw(c5896.32,6152.01) R121.2@5880.41,6167.92 ; v1@5867.14,6210.32 cw(c5850.92,6194.11) 5873.86,6194.11 cw(c5896.79,6194.11) v1@5880.57,6210.32 ; R122.2@5867.23,6122.08 ccw(c5851.32,6137.99) 5873.82,6137.99 ccw(c5896.32,6137.99) R122.2@5880.41,6122.08 ; R121.2@5867.23,6182.08 ccw(c5851.23,6198.08) 5873.86,6198.08 ; v1@5869.97,6213.15 cw(c5860.58,6203.76) 5873.86,6203.76 cw(c5887.14,6203.76) v1@5877.75,6213.15 ; R122.2@5870.06,6119.25 ccw(c5860.98,6128.33) 5873.82,6128.33 ccw(c5886.66,6128.33) R122.2@5877.58,6119.25 ; R121.2@5870.06,6170.75 cw(c5860.98,6161.67) 5873.82,6161.67 cw(c5886.66,6161.67) R121.2@5877.58,6170.75 ; R121.2@5870.06,6179.25 ccw(c5860.89,6188.43) 5873.86,6188.43 ; R122.2@5873.82,6115 R121.2@5873.82,6175 ; 5873.86,6188.24 ccw(c5886.57,6188.24) R121.2@5877.58,6179.25 ; 5873.86,6197.9 ccw(c5896.22,6197.9) R121.2@5880.41,6182.08 ; v1(5873.86,6217.04) 5873.86,6175.04 R121.2@5873.82,6175
ATE.VGA#.VSYNC: J18.14 J33.B28 U8.H13 U20.5 | length 12644.1
  Top Layer w4: v3(5311.26,4465.59) U8.H13@5330.94,4445.91 ; U8.H13@5323.6,4445.91 ccw(c5305.88,4445.91) 5318.41,4458.44 ccw(c5330.94,4470.97) U8.H13@5330.95,4453.25 ; J18.14@5653.45,6549.93 cw(c5609.82,6506.29) 5671.53,6506.29 cw(c5733.23,6506.3) J18.14@5689.6,6549.93 ; v1@5656.14,6151.43 ccw(c5639.92,6167.64) 5662.86,6167.64 ccw(c5685.79,6167.64) v1@5669.57,6151.43 ; J18.14@5656.28,6552.76 cw(c5619.48,6515.95) 5671.53,6515.95 cw(c5723.57,6515.95) J18.14@5686.77,6552.76 ; v1@5658.97,6148.6 ccw(c5649.58,6157.99) 5662.86,6157.99 ccw(c5676.14,6157.99) v1@5666.75,6148.6 ; J18.14@5659.11,6555.58 cw(c5629.13,6525.61) 5671.53,6525.61 cw(c5713.92,6525.61) J18.14@5683.94,6555.58 ; J18.14@5661.94,6558.41 cw(c5638.79,6535.26) 5671.53,6535.26 cw(c5704.26,6535.27) J18.14@5681.12,6558.41 ; v1(5662.86,6144.71) 5662.86,6175 5706.86,6219 5706.86,6429.71 5671.53,6465.04 J18.14@5671.53,6568 ; 5324.06,4452.79 cw(c5336.87,4465.59) 5318.76,4465.59 ccw(c5336.87,4465.59) 5324.06,4452.79 ; 5324.06,4452.79 ccw(c5311.26,4439.98) 5311.26,4458.09 cw(c5311.26,4439.98) 5324.06,4452.79
  MidLayer1 w4: v1@-689.65,3116.55 ccw(c-694.68,3125.04) -684.81,3125.04 ; v1(-684.81,3108.37) -684.81,3125.04 ; v1@-679.97,3116.55 cw(c-674.94,3125.04) -684.81,3125.04 ; v1@-541.53,5876.66 cw(c-557.74,5860.44) -534.81,5860.44 cw(c-511.87,5860.44) v1@-528.09,5876.66 ; v1@-538.7,5879.49 cw(c-548.09,5870.1) -534.81,5870.1 cw(c-521.53,5870.1) v1@-530.92,5879.49 ; v1(-534.81,5883.37) -534.81,5827.75 -544,5818.56 -547.52,5815.05 -547.52,5280.11 -556.14,5271.48 -556.14,4719.58 -475,4638.43 -475,4596.31 -484.81,4586.5 -484.81,4233.43 -460,4208.62 -460,4141.38 -484.81,4116.57 -484.81,3600.04 -585,3499.85 -585,3272.79 -659.81,3197.98 -659.81,3150.04 -684.81,3125.04 ; v1@5318.4,4890.09 ccw(c5302.18,4906.31) 5325.12,4906.31 ccw(c5348.05,4906.31) v1@5331.83,4890.09 ; v1@5321.23,4887.26 ccw(c5311.84,4896.65) 5325.12,4896.65 ccw(c5338.4,4896.65) v1@5329.01,4887.26 ; v1@5323.52,4883.38 v1(5325.12,4883.38) 5325.12,4910.07 5315.19,4920 5315.19,5016.71 5390.19,5091.71 5395.25,5096.77 5428.58,5096.77 5470.5,5138.69 5470.5,5200.5 5462.5,5208.5 5462.5,5250.33 5666.19,5454.02 5666.19,5551.45 5686,5571.26 5686,6069 5650,6105 5650,6131.85 v1(5662.86,6144.71)
  MidLayer2 w4: v1@-541.53,5890.09 ccw(c-557.74,5906.31) -534.81,5906.31 ccw(c-511.87,5906.31) v1@-528.09,5890.09 ; v1@-538.7,5887.26 ccw(c-548.09,5896.65) -534.81,5896.65 ccw(c-521.53,5896.65) v1@-530.92,5887.26 ; v1(-534.81,5883.37) -534.81,5925.19 -524.66,5935.34 78.6,5935.34 79.44,5934.5 274.76,5934.5 415.3,6075.04 5550,6075.04 5619.67,6144.71 v1(5662.86,6144.71) ; v3@5303.79,4466.24 ccw(c5285.75,4467.82) 5299.62,4479.46 ; v3@5311.91,4473.06 cw(c5313.49,4491.1) 5299.62,4479.46 ; v1(5325.12,4883.38) 5323.52,4881.78 5323.52,4860.98 5279.19,4816.65 5279.19,4794.31 5287.4,4786.1 5287.4,4751.18 5287.4,4741.18 5287.4,4622.01 5287.4,4602.59 5287.4,4528.47 5287.4,4508.97 ccw(c5329.13,4508.97) 5299.62,4479.46 ; v1@5656.14,6137.99 ccw(c5639.92,6121.77) 5639.92,6144.71 ccw(c5639.92,6167.64) v1@5656.14,6151.43 ; v1@5658.97,6140.82 ccw(c5649.58,6131.43) 5649.58,6144.71 ccw(c5649.58,6157.99) v1@5658.97,6148.6
  Bottom Layer w4: J33.B28@-785.98,3125.3 -701.74,3125.3 ; J33.B28@-717.65,3129.48 cw(c-714.82,3108.65) -699.95,3123.52 ; J33.B28@-705.71,3122.26 cw(c-701.74,3121.19) -701.74,3125.3 ; J33.B28@-705.71,3128.35 ccw(c-701.74,3129.41) -701.74,3125.3 ; v1@-694.31,3108.37 ccw(c-717.24,3108.37) -701.03,3124.59 ccw(c-684.81,3140.81) v1@-684.81,3117.87 ; v1@-690.31,3108.37 ccw(c-703.59,3108.37) -694.2,3117.76 ccw(c-684.81,3127.15) v1@-684.81,3113.87 ; v1(-684.81,3108.37) -701.74,3125.3 ; v1(5662.86,6144.71) 5678.86,6144.71 ; v1@5671.2,6140.16 cw(c5678.86,6135.98) 5678.86,6144.71 ; v1@5671.2,6149.26 ccw(c5678.86,6153.43) 5678.86,6144.71 ; U20.5@5706.32,6140.26 ccw(c5696.29,6130.23) 5696.29,6144.41 ccw(c5696.29,6158.59) U20.5@5706.32,6148.56 ; U20.5@5719.33,6144.41 5679.16,6144.41 5678.86,6144.71
AUDIO_CODEC.MUTEA: U1.21
AUDIO_CODEC.MUTEB: U1.24