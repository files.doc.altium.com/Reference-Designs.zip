# Altium PCB NB3000AL.PcbDoc (part 55 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
HOST_USB.FIFOADR2: U30.D9 U56.36 | length 5743.4
  Top Layer w4: v4@6592.16,6012 cw(c6572.84,6012) 6586.5,5998.34 cw(c6600.16,5984.69) v4@6600.16,6004 ; v4(6600.16,6012) 6574.71,5986.55 6501.55,5986.55 6475,5960 6475,5693.21 6485.17,5683.04 6738.82,5683.04 6806.86,5615 6806.86,5169.69 6818.5,5158.04 6870,5158.04 6969.67,5158.04 7260,5158.04 7265.52,5158.04 7280.81,5142.75 7491.52,4932.04 7491.52,4900.65 7483.19,4892.32 7483.19,4847.68 7491.52,4839.35 7491.52,4810.37 7478.19,4797.04 7478.19,3997.37 v1(7454.86,3974.04) ; U30.D9@7029.69,2042.17 v3(7049.37,2061.85) ; U30.D9@7029.69,2049.51 ccw(c7029.69,2067.23) 7042.22,2054.7 ccw(c7054.75,2042.16) U30.D9@7037.03,2042.17 ; v1@7454.86,3979.54 ccw(c7454.86,3992.82) 7464.25,3983.43 ccw(c7473.64,3974.04) v1@7460.36,3974.04 ; v1@7454.86,3983.54 ccw(c7454.86,4006.48) 7471.07,3990.26 ccw(c7487.29,3974.04) v1@7464.36,3974.04 ; 7036.57,2049.05 cw(c7049.37,2036.24) 7049.37,2054.35 ccw(c7049.37,2036.24) 7036.57,2049.05 ; 7036.57,2049.05 ccw(c7023.76,2061.85) 7041.87,2061.85 cw(c7023.76,2061.85) 7036.57,2049.05
  MidLayer1 w4: v3@7048.07,2069.24 ccw(c7044.92,2087.07) 7059.76,2076.68 ; v3@7056.76,2063.15 cw(c7074.59,2066.3) 7059.76,2076.68 ; 7073.23,2138.66 7073.23,2124.73 ; 7220.94,2466.13 ccw(c7203.89,2483.18) v2@7228.01,2483.18 ; 7221.37,2466.56 cw(c7237.82,2450.12) v2@7237.82,2473.37 ; 7227.77,2472.96 ccw(c7217.54,2483.18) v2@7232.01,2483.18 ; 7228.2,2473.39 cw(c7237.82,2463.78) v2@7237.82,2477.37 ; v2(7237.82,2483.18) 7237.82,2483 7214,2459.19 7214,2376.14 7187.4,2349.54 7156.24,2349.54 7073.23,2266.54 7073.23,2218.27 7073.23,2198.85 7073.23,2124.73 ; v2@7333.25,2709.29 ccw(c7296.38,2746.16) 7348.52,2746.16 ; v2@7336.08,2706.46 ccw(c7306.04,2736.5) 7348.52,2736.5 ; v2@7338.91,2703.63 ccw(c7315.69,2726.85) 7348.52,2726.85 ; v2(7340.19,2702.35) 7343.35,2702.35 7348.52,2707.52 7348.52,3216.71 7440.19,3308.37 7440.19,3791.71 7406.86,3825.04 7406.86,3926.04 v1(7454.86,3974.04) ; v2@7341.74,2700.8 ccw(c7325.35,2717.19) 7348.52,2717.19 ; v1@7445.36,3974.04 cw(c7422.42,3974.04) 7438.64,3957.82 cw(c7454.86,3941.61) v1@7454.86,3964.54 ; v1@7449.36,3974.04 cw(c7436.08,3974.04) 7445.47,3964.65 cw(c7454.86,3955.26) v1@7454.86,3968.54 ; 7059.76,2076.68 7066.84,2085.26 ccw(c7049.46,2101.48) 7073.23,2101.48 7073.23,2124.73
  MidLayer2 w4: v2(7237.82,2483.18) 7240.18,2483.18 7331.02,2574.02 7331.02,2645 7331.02,2682.29 7331.02,2693.19 v2(7340.19,2702.35) ; v2@7237.82,2488.99 ccw(c7237.82,2508.74) 7251.78,2494.78 ; v2@7237.82,2492.99 ccw(c7237.82,2522.4) 7258.61,2501.61 ; v2@7247.63,2483.18 cw(c7265.6,2483.18) 7252.89,2495.89 ; 7331.02,2680.3 cw(c7343.52,2680.3) v2@7341.65,2692.65 ; 7331.02,2684.95 cw(c7342.82,2684.95) v2@7341.06,2696.61 ; 7331.02,2689.59 cw(c7342.12,2689.59) v2@7340.46,2700.56 ; 7331.02,2694.24 cw(c7341.41,2694.24) v2@7339.86,2704.52
  Bottom Layer w8: v4@6595.91,6007.76 cw(c6585.67,5997.51) 6600.16,5997.51 cw(c6614.64,5997.51) v4@6604.4,6007.76 ; U56.36@6600.16,5980.67 v4(6600.16,6012)
HOST_USB.FLAGA: U30.B12 U56.29 | length 6087.5
  Top Layer w4: v2@7182.2,2238.05 ccw(c7170.19,2228.9) 7170.19,2244 ; v2@7182.2,2249.95 cw(c7170.19,2259.1) 7170.19,2244 ; v2(7190,2244) 7170.19,2244 ; 7160.33,2133.44 cw(c7147.8,2145.97) 7147.8,2128.25 ccw(c7147.8,2145.97) 7160.33,2133.44 ; 7160.33,2133.44 ccw(c7172.86,2120.91) 7155.14,2120.91 cw(c7172.86,2120.91) 7160.33,2133.44 ; 7160.33,2133.44 ccw(c7153.15,2140.62) 7163.3,2140.62 ; 7160.33,2133.44 ccw(c7153.15,2140.62) 7163.3,2140.62 ; 7163.3,2140.62 7163.3,2237.11 7170.19,2244
  MidLayer1 w4: v1@6777.52,5957.21 cw(c6777.52,5934.27) 6793.74,5950.49 cw(c6809.96,5966.71) v1@6787.02,5966.71 ; v1@6777.52,5961.21 cw(c6777.52,5947.93) 6786.91,5957.32 cw(c6796.3,5966.71) v1@6783.02,5966.71 ; v1(6777.52,5966.71) 6825,5919.23 6825,5737.86 7118.51,5444.35 7187.55,5444.35 7240.19,5391.71 7240.35,5391.87 7817.69,5391.87 7920,5289.56 7920,5123.91 7887.5,5091.41 7887.5,4894.5 8098.52,4683.48 8112,4670 8112,3985.19 ; v1@7615,2583.18 v1(7615,2580) 7631.19,2596.19 ; v1@7615.01,2585.5 ccw(c7615.02,2598.72) 7624.37,2589.37 ccw(c7633.72,2580.02) v1@7620.5,2580.01 ; v1@7615.01,2589.5 ccw(c7615.04,2612.33) 7631.19,2596.19 ; v1@7624.5,2580.01 cw(c7647.33,2580.04) 7631.19,2596.19 ; 7631.19,2596.19 7631.19,2599.37 7631.19,2606 ; 7631.19,2606 7631.19,2615 ; 7631.19,2606 7631.19,2615 ; 7631.19,2615 7631.19,2634 ; 7631.19,2615 7631.19,2634 ; 7631.19,2615 7631.19,2634 ; 7631.19,2634 7751.81,2754.63 7751.81,2864.68 ; 7751.81,2864.68 7751.81,2885 ; 7751.81,2864.68 7751.81,2885 ; 7751.81,2885 7751.81,2899.32 7749.69,2901.44 7748.67,2902.46 7748.67,2987.15 7748.67,3196.52 7806.19,3254.04 7806.19,3284.58 7794.02,3296.75 7794.02,3375.17 7798.69,3379.83 7798.69,3395 ; 7798.69,3395 7798.69,3407.58 ; 7798.69,3395 7798.69,3407.58 ; 7798.69,3407.58 7798.69,3526.32 ; 7798.69,3526.32 7830.51,3558.13 ; 7798.69,3526.32 7830.51,3558.13 ; 7830.51,3558.13 7887.75,3615.37 7932.15,3659.78 7944.35,3659.78 7982.69,3698.13 7982.69,3714 8011.69,3743 ; 8011.69,3743 8028.19,3743 ; 8011.69,3743 8028.19,3743 ; 8028.19,3743 8040.04,3743 8183.81,3886.77 8183.81,3898.62 8183.81,3913.38 ; 8112,3985.19 8183.81,3913.38 ; 8112,3985.19 8183.81,3913.38
  Bottom Layer w4: U56.29@6737.95,5980.67 6763.86,5980.67 6777.52,5967 v1(6777.52,5966.71) ; U56.29@6740.78,5977.84 cw(c6747.61,5971.01) 6747.61,5980.67 cw(c6747.61,5990.33) U56.29@6740.78,5983.5 ; v2@7183.06,2250.94 ccw(c7165.86,2268.14) 7190.19,2268.14 ; v2@7185.89,2248.11 ccw(c7175.51,2258.49) 7190.19,2258.49 ; v2(7190,2244) 7190.19,2244.19 7190.19,2320 7202.54,2332.35 7202.54,2360.04 7425.31,2582.81 7453,2582.81 ; 7190.19,2257.57 ccw(c7203.57,2257.57) v2@7194.11,2248.11 ; 7190.19,2267.23 ccw(c7213.23,2267.23) v2@7196.94,2250.94 ; v1@7608.28,2573.28 ccw(c7592.06,2557.06) 7592.06,2580 ccw(c7592.06,2602.93) v1@7608.28,2586.72 ; v1@7611.11,2576.11 ccw(c7601.72,2566.72) 7601.72,2580 ccw(c7601.72,2593.28) v1@7611.11,2583.89 ; v1@7612.56,2586 7615.19,2583.37 7615,2583.18 v1(7615,2580) 7584.17,2580 7581.67,2577.5 7564.01,2577.5 7547.75,2577.5 7542.44,2582.81 7495,2582.81 ; 7453,2582.81 7495,2582.81 ; 7453,2582.81 7495,2582.81
HOST_USB.FLAGB: U30.E11 U56.30 | length 5418.5
  Top Layer w4: U30.E11@7108.43,2002.8 v3(7128.11,2022.48) ; U30.E11@7108.43,2010.14 ccw(c7108.43,2027.86) 7120.96,2015.33 ccw(c7133.49,2002.79) U30.E11@7115.77,2002.79 ; v1@7341.81,5615.66 cw(c7325.59,5599.44) 7348.52,5599.44 cw(c7371.46,5599.44) v1@7355.24,5615.66 ; v1@7344.64,5618.49 cw(c7335.25,5609.1) 7348.52,5609.1 cw(c7361.8,5609.1) v1@7352.41,5618.49 ; v1(7348.52,5622.37) 7348.52,5366.96 7623.19,5092.3 7623.19,4831.69 7654.52,4800.35 7654.52,4389.37 7615.19,4350.04 7615.19,4307.98 7648.17,4275 7730,4275 7736.48,4268.52 7799.19,4205.81 7799.19,3662.02 7681.86,3544.69 7681.86,3258.04 7682,3258.18 v1(7682,3260) ; v1@7675.28,3266.72 ccw(c7659.41,3282.59) 7681.86,3282.59 ; v1@7678.11,3263.89 ccw(c7669.07,3272.93) 7681.86,3272.93 ; 7681.86,3273.62 ccw(c7695.62,3273.62) v1@7685.89,3263.89 ; 7681.86,3283.28 ccw(c7705.28,3283.28) v1@7688.72,3266.72 ; 7115.31,2009.68 cw(c7128.11,1996.87) 7128.11,2014.98 ccw(c7128.11,1996.87) 7115.31,2009.68 ; 7115.31,2009.68 ccw(c7102.5,2022.48) 7120.61,2022.48 cw(c7102.5,2022.48) 7115.31,2009.68
  MidLayer2 w4: v4(6718.27,6012) 6761.57,6012 6815.19,5958.37 7012.52,5958.37 v1(7348.52,5622.37) ; v4@6723.92,6006.34 cw(c6737.58,5992.69) 6737.58,6012 cw(c6737.58,6031.31) v4@6723.92,6017.66 ; v3@7127.46,2029.95 ccw(c7125.88,2047.99) 7139.75,2036.35 ccw(c7153.62,2024.71) v3@7135.58,2023.13 ; 7139.5,2036.06 ccw(c7129.57,2045.99) 7143.62,2045.99 7143.62,2139.53 7143.62,2226.88 7128.19,2242.31 7128.19,2322.61 7147.5,2341.92 7147.5,2421.25 7130.19,2438.56 7130.19,2453.38 7140.62,2463.81 7162.59,2463.81 7265,2566.22 7265,2678.52 7417.29,2830.81 7423.65,2830.81 7581,2988.16 7581,3135 7682,3236 v1(7682,3260) ; v1@7339.02,5622.37 ccw(c7316.09,5622.37) 7332.31,5638.59 ccw(c7348.52,5654.81) v1@7348.52,5631.87 ; v1@7343.02,5622.37 ccw(c7329.75,5622.37) 7339.14,5631.76 ccw(c7348.52,5641.15) v1@7348.52,5627.87 ; v1@7675.28,3253.28 cw(c7659.06,3237.06) 7682,3237.06 cw(c7704.94,3237.06) v1@7688.72,3253.28 ; v1@7678.11,3256.11 cw(c7668.72,3246.72) 7682,3246.72 cw(c7695.28,3246.72) v1@7685.89,3256.11
  Bottom Layer w8: v4@6714.03,6007.76 cw(c6703.78,5997.51) 6718.27,5997.51 cw(c6732.75,5997.51) v4@6722.51,6007.76 ; U56.30@6718.27,5980.67 v4(6718.27,6012)
HOST_USB.FLAGC: U30.E9 U56.31 | length 6273.3
  Top Layer w4: v1@6650.14,5781.76 ccw(c6633.92,5797.98) 6656.86,5797.98 ccw(c6679.79,5797.98) v1@6663.57,5781.76 ; v1@6652.97,5778.93 ccw(c6643.58,5788.32) 6656.86,5788.32 ccw(c6670.14,5788.32) v1@6660.75,5778.93 ; v1(6656.86,5775.04) 6656.86,5878.71 6698.58,5920.43 v4(6698.58,5949.34) ; v4@6692.93,5943.68 cw(c6679.27,5930.02) 6698.58,5930.02 cw(c6717.9,5930.03) v4@6704.24,5943.68 ; U30.E9@7029.69,2002.8 v3(7049.37,2022.48) ; U30.E9@7029.68,2010.14 ccw(c7029.68,2027.86) 7042.22,2015.33 ccw(c7054.75,2002.79) U30.E9@7037.03,2002.79 ; 7036.57,2009.68 cw(c7049.37,1996.87) 7049.37,2014.98 ccw(c7049.37,1996.87) 7036.57,2009.68 ; 7036.57,2009.68 ccw(c7023.76,2022.48) 7041.87,2022.48 cw(c7023.76,2022.48) 7036.57,2009.68
  MidLayer2 w4: v1@6650.14,5768.32 cw(c6633.92,5752.11) 6656.86,5752.11 cw(c6679.79,5752.11) v1@6663.57,5768.32 ; v1@6652.97,5771.15 cw(c6643.58,5761.76) 6656.86,5761.76 cw(c6670.14,5761.76) v1@6660.75,5771.15 ; v1(6656.86,5775.04) 6656.86,5731 6821.48,5566.37 7266,5566.37 7578.37,5254 7614.21,5254 7636.21,5232 8181.69,5232 8240.52,5173.16 8240.52,4081.15 8132.19,3972.82 8132.19,3534.82 8071.58,3474.21 7882.37,3474.21 7871.58,3485 7683.48,3485 7565.19,3366.71 7557,3358.52 7557,2998.1 7413.71,2854.81 7405.81,2854.81 7150,2599 7150,2546 7157,2539 7157,2502.82 7110.19,2456 7110.19,2436.69 7058.19,2384.69 7058.19,2221.81 7064.88,2215.12 7064.88,2045.99 cw(c7050.83,2045.99) 7060.76,2036.06 ; v3@7048.72,2029.95 ccw(c7047.14,2047.99) 7061.01,2036.35 ccw(c7074.88,2024.71) v3@7056.84,2023.13
  Bottom Layer w8: v4@6694.34,5953.58 ccw(c6684.1,5963.82) 6698.58,5963.82 ccw(c6713.07,5963.82) v4@6702.83,5953.58 ; v4(6698.58,5949.34) U56.31@6698.58,5980.67
HOST_USB.FLAGD_CS_N: U30.B7 U56.40 | length 6678.1
  Top Layer w4: v2@6927.06,2244.06 cw(c6907.65,2224.65) 6935.1,2224.65 ; v2@6929.89,2246.89 cw(c6917.31,2234.31) 6935.1,2234.31 ; 6935.1,2229.98 cw(c6955.02,2229.98) v2@6940.94,2244.06 ; v2@6935.1,2251 6935.1,2140.95 6935.44,2140.62 ; 6935.44,2140.62 ccw(c6945.59,2140.62) 6938.41,2133.44 ; 6935.44,2140.62 ccw(c6945.59,2140.62) 6938.41,2133.44 ; 6938.41,2133.44 ccw(c6950.94,2145.97) 6950.94,2128.25 cw(c6950.94,2145.97) 6938.41,2133.44 ; 6938.41,2133.44 cw(c6925.88,2120.91) 6943.6,2120.91 ccw(c6925.88,2120.91) 6938.41,2133.44
  MidLayer1 w4: v4@6515.76,6006.34 cw(c6502.1,5992.69) 6521.42,5992.69 cw(c6540.73,5992.69) v4@6527.07,6006.34 ; v4@6523.52,6012 6523.52,6014.71 6521.52,6016.71 6521.42,6016.71 v4(6521.42,6012) 6521.42,5793.81 6956.86,5358.37 7281.86,5358.37 7306.86,5333.37 v1(7329.86,5333.37) ; v1@7323.14,5326.66 ccw(c7306.92,5310.44) 7306.92,5333.37 ccw(c7306.92,5356.31) v1@7323.14,5340.09 ; v1@7325.97,5329.49 ccw(c7316.58,5320.1) 7316.58,5333.37 ccw(c7316.58,5346.65) v1@7325.97,5337.26
  MidLayer2 w4: v1(7048,2546) 7061.52,2559.52 7061.52,2586.33 7115.69,2640.5 7115.69,2812.18 7111.19,2816.68 7111.19,2851.32 7115.69,2855.82 7115.69,2961.85 7429.69,3275.86 ; v1@7323.14,5326.66 cw(c7306.92,5310.44) 7329.86,5310.44 cw(c7352.79,5310.44) v1@7336.57,5326.66 ; v1@7325.97,5329.49 cw(c7316.58,5320.1) 7329.86,5320.1 cw(c7343.14,5320.1) v1@7333.75,5329.49 ; v1(7329.86,5333.37) 7329.86,5310.35 7471.21,5169 7494.23,5169 ; 7429.69,3275.86 7440,3286.16 ; 7429.69,3275.86 7440,3286.16 ; 7440,3286.16 7443,3289.16 7443,3352.81 ; 7443,3352.81 7443,3370 ; 7443,3352.81 7443,3370 ; 7443,3370 7443,3511.94 7471.06,3540 7714.09,3540 7827.86,3540 7946.39,3658.54 7957.99,3658.54 7958.15,3658.37 8034.23,3658.37 8092.19,3716.33 8092.19,3989.38 8140.81,4038.01 8140.81,4647.69 8139.19,4649.31 8139.19,4867.69 8215.86,4944.36 8215.86,5163.89 8171.75,5208 7694.38,5208 7655.38,5169 7565,5169 ; 7494.23,5169 7560.06,5169 7565,5169 ; 7494.23,5169 7565,5169
  Bottom Layer w4: v2@6927.06,2257.94 ccw(c6910.31,2274.69) 6934,2274.69 ccw(c6957.69,2274.69) v2@6940.94,2257.94 ; v2@6929.89,2255.11 ccw(c6919.97,2265.03) 6934,2265.03 ccw(c6948.03,2265.03) v2@6938.11,2255.11 ; v2(6934,2251) 6934,2303.5 6934,2408 ; v1@7041.28,2539.28 ccw(c7025.06,2523.06) 7025.06,2546 ccw(c7025.06,2568.93) v1@7041.28,2552.72 ; v1@7044.11,2542.11 ccw(c7034.72,2532.72) 7034.72,2546 ccw(c7034.72,2559.28) v1@7044.11,2549.89 ; v1(7048,2546) 7019.19,2546 7015.69,2542.5 6977.5,2542.5 ; 6934,2408 6957.81,2431.81 6957.81,2432 ; 6934,2408 6934,2408.18 6957.81,2432 ; 6957.81,2432 6957.81,2452 6957.81,2460 6952.5,2465.32 6952.5,2532.25 6962.75,2542.5 6975,2542.5 ; 6975,2542.5 6977.5,2542.5 ; 6975,2542.5 6977.5,2542.5
  Bottom Layer w8: v4@6517.17,6007.76 cw(c6506.93,5997.51) 6521.42,5997.51 cw(c6535.9,5997.51) v4@6525.66,6007.76 ; U56.40@6521.42,5980.67 v4(6521.42,6012)
HOST_USB.IFCLK: R249.1 U30.C11 | length 5397.5
  Top Layer w4: v1(6827.86,6337.37) 6918,6337.37 7015.37,6240 7238.92,6240 7315.52,6163.39 7315.52,5606.69 7332.52,5589.69 7332.52,5359.66 7535.68,5156.5 7535.68,5094.32 7607.19,5022.81 7607.19,4825.06 7638.52,4793.73 7638.52,4396 7598.52,4356 7598.52,4311.37 v1(7580.52,4293.37) ; v1@6831.75,6333.49 cw(c6841.14,6324.1) 6841.14,6337.37 cw(c6841.14,6350.65) v1@6831.75,6341.26 ; v1@6834.57,6330.66 cw(c6850.79,6314.44) 6850.79,6337.37 cw(c6850.79,6360.31) v1@6834.57,6344.09 ; U30.C11@7108.43,2081.54 v3(7128.11,2101.22) ; U30.C11@7108.43,2088.88 ccw(c7108.43,2106.6) 7120.96,2094.07 ccw(c7133.49,2081.54) U30.C11@7115.77,2081.54 ; v1@7580.52,4298.87 ccw(c7580.52,4312.15) 7589.91,4302.76 ccw(c7599.3,4293.37) v1@7586.02,4293.37 ; v1@7580.52,4302.87 ccw(c7580.52,4325.81) 7596.74,4309.59 ccw(c7612.96,4293.37) v1@7590.02,4293.37 ; 7115.31,2088.42 cw(c7128.11,2075.61) 7128.11,2093.72 ccw(c7128.11,2075.61) 7115.31,2088.42 ; 7115.31,2088.42 ccw(c7102.5,2101.22) 7120.61,2101.22 cw(c7102.5,2101.22) 7115.31,2088.42
  MidLayer1 w4: v3@7126.81,2108.61 ccw(c7123.66,2126.44) 7138.5,2116.05 ccw(c7153.33,2105.67) v3@7135.5,2102.52 ; 7138.53,2116.08 ccw(c7110.49,2133.73) 7143.62,2133.9 7143.62,2218.27 7143.62,2226.88 7128.19,2242.31 7128.19,2271.12 7137.07,2280 7161.2,2304.13 7169.26,2312.19 7182.38,2312.19 7226.81,2356.63 7226.81,2402.07 7427.19,2602.44 7427.19,2734.95 7432.5,2740.26 7432.5,2782.31 7447.81,2797.62 7447.81,2812.38 7440,2820.19 7440,2844.5 7506.86,2911.36 7506.86,3313.73 7481.86,3338.73 7481.86,3496.31 7572.51,3586.96 7572.51,3747.25 7572.29,3747.47 7572.29,4177.81 7594.52,4200.04 7594.52,4279.37 v1(7580.52,4293.37)
  Bottom Layer w4: R249.1@6796.18,6360 6825,6360 6827.86,6357.14 ; R249.1@6799.94,6356.24 cw(c6809.02,6347.16) 6809.02,6360 cw(c6809.02,6372.84) R249.1@6799.94,6363.76 ; R249.1@6802.77,6353.41 cw(c6818.68,6337.5) 6818.68,6360 cw(c6818.68,6382.5) R249.1@6802.77,6366.59 ; v1@6821.92,6344.79 ccw(c6812.04,6357.14) 6827.86,6357.14 ; v1(6827.86,6337.37) 6827.86,6357.14 ; v1@6833.79,6344.79 cw(c6843.67,6357.14) 6827.86,6357.14
HOST_USB.INT_N: R252.1 U30.C9 U56.34 | length 5771.4
  Top Layer w4: v4@6639.53,6004 cw(c6639.53,5984.69) 6653.18,5998.34 cw(c6666.84,6012) v4@6647.53,6012 ; v4(6639.53,6012) 6659.82,5991.71 v1(6948.52,5991.71) ; v1@6941.81,5984.99 ccw(c6925.59,5968.77) 6925.59,5991.71 ccw(c6925.59,6014.64) v1@6941.81,5998.43 ; v1@6944.64,5987.82 ccw(c6935.25,5978.43) 6935.25,5991.71 ccw(c6935.25,6004.99) v1@6944.64,5995.6 ; U30.C9@7029.69,2081.54 v3(7049.37,2101.22) ; U30.C9@7029.69,2088.88 ccw(c7029.69,2106.6) 7042.22,2094.07 ccw(c7054.75,2081.54) U30.C9@7037.03,2081.54 ; 7036.57,2088.42 cw(c7049.37,2075.61) 7049.37,2093.72 ccw(c7049.37,2075.61) 7036.57,2088.42 ; 7036.57,2088.42 ccw(c7023.76,2101.22) 7041.87,2101.22 cw(c7023.76,2101.22) 7036.57,2088.42
  MidLayer1 w4: v4@6631.53,6012 cw(c6612.21,6012) 6625.87,5998.34 cw(c6639.53,5984.69) v4@6639.53,6004 ; v4@6640.19,6012 6640.19,6016.71 6639.53,6016.71 v4(6639.53,6012) 6600,5972.47 6600,5940.23 6609.83,5930.4 7165.19,5375.04 7165.35,5374.88 7450,5374.88 7481.7,5374.88 ; v3@7048.07,2108.61 ccw(c7044.92,2126.44) 7059.76,2116.05 ; v3@7056.76,2102.52 cw(c7074.59,2105.67) 7059.76,2116.05 ; 7064.88,2219.33 7064.88,2218.27 7064.88,2133.9 cw(c7031.75,2133.73) 7059.79,2116.08 ; 7065,2219.33 7065,2367 7094.5,2396.5 7173.25,2396.5 7183.5,2406.75 7183.5,2465.37 7314.44,2596.31 7320.17,2596.31 7366.19,2642.33 7366.19,2701.54 7356.52,2711.21 7356.52,3213.39 7449.02,3305.89 7449.02,3310.86 7448.52,3311.35 7448.52,3805.39 7448.52,3811.35 7490.19,3853.02 7490.19,4463.33 7615.86,4589 7615.86,4753.08 7625,4762.22 7625,4866.27 7630,4871.27 7630,5226.9 7482.02,5374.88
  Bottom Layer w4: v1@6941.81,5998.43 ccw(c6925.59,6014.64) 6948.52,6014.64 ccw(c6971.46,6014.64) v1@6955.24,5998.43 ; v1@6944.64,5995.6 ccw(c6935.25,6004.99) 6948.52,6004.99 ccw(c6961.8,6004.99) v1@6952.41,5995.6 ; v1(6948.52,5991.71) 6948.52,6033.37 7006.86,6091.71 7006.86,6182 6998.86,6190 ; R252.1@6983.82,6190 6998.86,6190 ; R252.1@6992.16,6185.85 cw(c6998.86,6182.53) 6998.86,6190 ; R252.1@6992.16,6194.15 ccw(c6998.86,6197.47) 6998.86,6190
  Bottom Layer w8: v4@6635.28,6007.76 cw(c6625.04,5997.51) 6639.53,5997.51 cw(c6654.01,5997.51) v4@6643.77,6007.76 ; U56.34@6639.53,5980.67 v4(6639.53,6012)
HOST_USB.PKTEND: U30.B9 U56.39 | length 6652
  Top Layer w4: v2@7034.68,2473.42 ccw(c7017.94,2456.67) 7017.94,2480.36 ccw(c7017.94,2504.04) v2@7034.68,2487.29 ; v2@7037.51,2476.25 ccw(c7027.59,2466.33) 7027.59,2480.36 ccw(c7027.59,2494.39) v2@7037.51,2484.47 ; v2(7041.62,2480.36) 7014.36,2480.36 7013.2,2479.2 6972.69,2438.69 ; 7045.19,2219.3 7045.19,2218 ; 7045.19,2231.19 7045.19,2228 ; 6972.69,2416.5 6972.69,2438.69 ; 6972.69,2416.5 6972.69,2438.69 ; 6972.69,2416.5 6985.19,2404 ; 6985.19,2404 7028,2404 ; 6985.19,2404 7010,2404 ; 6985.19,2404 7010,2404 ; 7010,2404 7028,2404 ; 7028,2404 7045.19,2386.81 7045.19,2228.01 ; 7042.22,2133.44 cw(c7029.68,2145.97) 7029.68,2128.25 ccw(c7029.68,2145.97) 7042.22,2133.44 ; 7042.22,2133.44 ccw(c7054.75,2120.91) 7037.03,2120.91 cw(c7054.75,2120.91) 7042.22,2133.44 ; 7042.22,2133.44 ccw(c7035.04,2140.62) 7045.19,2140.62 ; 7042.22,2133.44 ccw(c7035.04,2140.62) 7045.19,2140.62 ; 7045.19,2140.62 7045.19,2218 ; 7045.19,2218 7045.19,2228
  MidLayer1 w4: v2(7041.62,2480.36) 7104.03,2480.36 v2(7135.67,2512) ; v2@7045.73,2476.25 cw(c7055.65,2466.33) 7055.65,2480.36 cw(c7055.65,2494.39) v2@7045.73,2484.47 ; v2@7048.56,2473.42 cw(c7065.31,2456.67) 7065.31,2480.36 cw(c7065.31,2504.04) v2@7048.56,2487.29 ; v2@7125.86,2512 cw(c7102.17,2512) 7118.92,2495.25 cw(c7135.67,2478.5) v2@7135.67,2502.19 ; v2@7129.86,2512 cw(c7115.83,2512) 7125.75,2502.08 cw(c7135.67,2492.16) v2@7135.67,2506.19
  MidLayer2 w4: v4(6541.1,5949.34) 6557.66,5965.9 6632.66,5965.9 6640.19,5958.37 6640.19,5792.37 6631.86,5784.04 6631.86,5744.69 6818.17,5558.37 7262.68,5558.37 7575.06,5246 7610.9,5246 7632.9,5224 8178.37,5224 8232.52,5169.85 8232.52,4084.47 8124.19,3976.13 8124.19,3609.04 8048.52,3533.37 7865.19,3533.37 7848.52,3516.71 7848.03,3516.21 7838.01,3516.21 7837.8,3516 7724.03,3516 7481,3516 7467,3502 7467,3279.22 7139.86,2952.08 7139.86,2846.05 7135.19,2841.38 7135.19,2826.62 7139.86,2821.95 7139.86,2516.19 v2(7135.67,2512) ; v4@6541.1,5957.34 ccw(c6541.1,5976.65) 6554.76,5963 ccw(c6568.42,5949.34) v4@6549.1,5949.34 ; v2@7128.73,2518.94 ccw(c7101.88,2545.79) 7139.86,2545.79 ; v2@7131.56,2516.11 ccw(c7111.54,2536.13) 7139.86,2536.13 ; v2@7134.39,2513.28 ccw(c7121.19,2526.48) 7139.86,2526.48 ; 7139.86,2525.58 ccw(c7149.25,2525.58) v2@7142.61,2518.94
  Bottom Layer w8: v4@6536.86,5953.58 ccw(c6526.62,5963.82) 6541.1,5963.82 ccw(c6555.59,5963.82) v4@6545.34,5953.58 ; v4(6541.1,5949.34) U56.39@6541.1,5980.67
HOST_USB.RD_N: U30.A7 U56.1 | length 7381.6
  Top Layer w4: U30.A7@6945.75,2165.47 ccw(c6933.22,2178) 6950.94,2178 ccw(c6968.67,2178) U30.A7@6956.14,2165.47 ; U30.A7@6950.94,2160.28 6950.94,2240.94 6950.94,2242.94 v2(6970,2262) ; v2@6960.19,2262 cw(c6936.5,2262) 6953.25,2245.25 cw(c6970,2228.5) v2@6970,2252.19 ; v2@6964.19,2262 cw(c6950.16,2262) 6960.08,2252.08 cw(c6970,2242.16) v2@6970,2256.19
  MidLayer1 w4: v1@7023.52,2458 7069.94,2458 7083.75,2471.81 7135,2471.81 7145.29,2471.81 7159.17,2471.81 7285,2597.64 7285,2611.52 7288.39,2614.9 v1(7348.52,2675.04) ; v1@7027.41,2454.49 cw(c7035.9,2446) 7035.9,2458 ; v1@7027.41,2462.26 ccw(c7037.71,2472.56) 7037.71,2458 ; v1@7030.24,2451.66 cw(c7045.55,2436.34) 7045.55,2458 ; v1@7030.24,2465.09 ccw(c7047.36,2482.21) 7047.36,2458 ; v1@7339.02,2675.04 cw(c7316.09,2675.04) 7332.31,2658.82 cw(c7348.52,2642.61) v1@7348.52,2665.54 ; v1@7343.02,2675.04 cw(c7329.75,2675.04) 7339.14,2665.65 cw(c7348.52,2656.26) v1@7348.52,2669.54 ; v1@7581.86,6240.54 cw(c7581.86,6217.61) 7598.07,6233.82 cw(c7614.29,6250.04) v1@7591.36,6250.04 ; v1@7581.86,6244.54 cw(c7581.86,6231.26) 7591.25,6240.65 cw(c7600.64,6250.04) v1@7587.36,6250.04 ; v1(7581.86,6250.04) 7773.52,6058.37 7981.63,6058.37 8266.02,5773.98 8266.02,5334.46 8256.52,5324.96 8256.52,5078.96 8257.35,5078.13 8257.35,5053.28 8256.52,5052.45 8256.52,4581.52 8245,4570 8245,4260 8265,4240 8265,3866.14 8232.02,3833.16 8232.02,3795.49 8231.52,3795 8231.52,3424.04 v1(8248.52,3407.04) ; v1@8239.02,3407.04 ccw(c8216.09,3407.04) 8232.31,3423.26 ccw(c8248.52,3439.48) v1@8248.52,3416.54 ; v1@8243.02,3407.04 ccw(c8229.75,3407.04) 8239.14,3416.43 ccw(c8248.52,3425.82) v1@8248.52,3412.54
  MidLayer2 w4: v1@6490.19,6313.87 cw(c6490.19,6290.94) 6506.41,6307.16 cw(c6522.63,6323.37) v1@6499.69,6323.37 ; v1@6490.19,6317.87 cw(c6490.19,6304.6) 6499.58,6313.99 cw(c6508.97,6323.37) v1@6495.69,6323.37 ; v1(6490.19,6323.37) 6521.86,6291.71 6862.11,6291.71 6901.68,6252.13 7555,6252.13 7579.76,6252.13 v1(7581.86,6250.04)
  Bottom Layer w4: U56.1@6479.22,6303.09 ccw(c6472.39,6309.92) 6482.05,6309.92 ccw(c6491.7,6309.92) U56.1@6484.88,6303.09 ; U56.1@6482.05,6288.37 cw(c6516.09,6288.37) v1@6495.84,6315.74 ; U56.1@6482.05,6289.33 6482.05,6315.23 v1(6490.19,6323.37) ; U56.1@6482.05,6296.31 cw(c6510.22,6296.31) v1@6493.46,6318.95 ; U56.1@6482.05,6304.24 cw(c6504.35,6304.24) v1@6491.08,6322.17 ; 6482.05,6312.18 cw(c6498.47,6312.18) v1@6488.7,6325.38 ; v2@6963.06,2268.94 ccw(c6946.31,2285.69) 6970,2285.69 ccw(c6993.69,2285.69) v2@6976.94,2268.94 ; v2@6965.89,2266.11 ccw(c6955.97,2276.03) 6970,2276.03 ccw(c6984.03,2276.03) v2@6974.11,2266.11 ; v2(6970,2262) 6970,2305.1 6974.36,2309.46 6974.36,2323.96 6974,2324.31 6974,2338.64 6966.42,2346.22 6966.42,2376.52 7023.52,2433.63 v1@7023.52,2458 ; v1@7016.81,2451.66 cw(c7000.59,2435.44) 7023.52,2435.44 cw(c7046.46,2435.44) v1@7030.24,2451.66 ; v1@7019.64,2454.49 cw(c7010.25,2445.1) 7023.52,2445.1 cw(c7036.8,2445.1) v1@7027.41,2454.49 ; v1(7348.52,2675.04) 7404.89,2731.41 7532.72,2731.41 ; v1@7348.52,2680.54 ccw(c7348.52,2693.82) 7357.91,2684.43 ccw(c7367.3,2675.04) v1@7354.02,2675.04 ; v1@7348.52,2684.54 ccw(c7348.52,2707.48) 7364.74,2691.26 ccw(c7380.96,2675.04) v1@7358.02,2675.04 ; v1@8241.81,3400.32 cw(c8225.59,3384.11) 8248.52,3384.11 cw(c8271.46,3384.11) v1@8255.24,3400.32 ; v1@8244.64,3403.15 cw(c8235.25,3393.76) 8248.52,3393.76 cw(c8261.8,3393.76) v1@8252.41,3403.15 ; v1(8248.52,3407.04) 8248.52,3193.52 8220,3165 8090.19,3165 8065.19,3140 8056.52,3131.33 8056.52,2919.36 8030.53,2893.36 7895.88,2758.71 7720,2758.71 7635.17,2758.71 7560.02,2758.71 7543.02,2741.71 ; 7532.72,2731.41 7543.02,2741.71 ; 7532.72,2731.41 7543.02,2741.71
  other v1: 7023.52,2458.37
HOST_USB.READY: U30.J13 U56.33 | length 7067.6
  Top Layer w4: U30.J13@7187.17,1837.97 cw(c7187.17,1820.25) 7199.7,1832.78 cw(c7212.23,1845.31) U30.J13@7194.51,1845.31 ; U30.J13@7187.17,1845.31 v3(7206.85,1825.63) ; 7194.05,1838.43 cw(c7181.24,1825.63) 7199.35,1825.63 ccw(c7181.24,1825.63) 7194.05,1838.43 ; 7194.05,1838.43 ccw(c7206.85,1851.24) 7206.85,1833.13 cw(c7206.85,1851.24) 7194.05,1838.43
  MidLayer1 w4: v4(6659.21,5949.34) 6676.58,5966.71 6715.86,5966.71 6765.19,6016.04 6765.19,6070 6780.19,6085 6815,6085 6880,6020 6880,5877.69 6841,5838.69 6841,5744.49 7104.94,5480.55 7124.31,5461.18 7181.75,5461.18 7193.35,5461.18 7246.15,5408.37 7632.06,5408.37 7638.57,5414.88 7638.57,5573.57 7642,5577 7923,5577 7942.81,5557.19 7942.81,5517.62 7934.28,5509.1 7934.28,5379.32 7939.19,5374.42 7939.19,5304.31 8018,5225.5 8018,4875.69 8073.19,4820.5 8100.56,4820.5 8128,4793.06 8128,4627.19 8188,4567.19 8188,4176.6 8174,4162.6 8174,3945.82 8199.81,3920 8199.81,3880.14 8067.36,3747.69 8067.36,3694.98 8023.83,3651.46 8008.15,3635.78 7945.58,3635.78 7942.1,3635.78 7822.69,3516.38 7822.69,3512.89 7822.69,3510 7822.69,3410 7822.69,3395 7822.69,3369.89 7818.02,3365.22 7818.02,3352.29 7818.02,3320 7818.02,3306.69 7830.19,3294.52 ; v4@6659.21,5957.34 ccw(c6659.21,5976.66) 6672.87,5963 ccw(c6686.52,5949.34) v4@6667.21,5949.34 ; v3@7208.15,1818.24 cw(c7211.3,1800.41) 7221.68,1815.24 ; v3@7214.24,1826.93 ccw(c7232.07,1830.08) 7221.68,1815.24 ; 7283.66,1801.77 7269.73,1801.77 ; 7221.68,1815.24 7230.26,1808.16 ccw(c7246.48,1825.54) 7246.48,1801.77 7269.73,1801.77 ; 7269.73,1801.77 7343.85,1801.77 7372.96,1801.77 7399.72,1775 7425,1775 7445,1755 7603.02,1755 7678,1829.98 7678,1970.47 7669.99,1978.48 7669.99,2022.12 7709.58,2061.71 7745.81,2097.94 7745.81,2104.5 7745.81,2126.59 7774.61,2155.39 7774.61,2185 7774.61,2198.77 7774.61,2407.12 7758.19,2423.53 7758.19,2513.96 7754.81,2517.34 7754.81,2563 7738.63,2579.19 7709.31,2579.19 7694.19,2594.31 7694.19,2615.69 7709.31,2630.81 7753.63,2630.81 7798.5,2675.68 7798.5,2718.63 7798.5,2725 7798.5,2749.13 7783.81,2763.82 7783.81,2766.19 7783.81,2805 7783.81,2912.57 7781.69,2914.69 7781.69,3125.38 7830.19,3173.88 7830.19,3280 ; 7830.19,3280 7830.19,3294.52 ; 7830.19,3280 7830.19,3294.52
  Bottom Layer w8: v4@6654.97,5953.58 ccw(c6644.73,5963.82) 6659.21,5963.82 ccw(c6673.7,5963.82) v4@6663.45,5953.58 ; v4(6659.21,5949.34) U56.33@6659.21,5980.67
HOST_USB.RESET_N: U30.C6 U60.3 | length 5437.7
  Top Layer w4: v3(6891.89,2101.22) U30.C6@6911.57,2081.54 ; U30.C6@6904.23,2081.54 ccw(c6886.51,2081.54) 6899.04,2094.07 ccw(c6911.57,2106.6) U30.C6@6911.57,2088.88 ; 6904.69,2088.42 cw(c6917.5,2101.22) 6899.39,2101.22 ccw(c6917.5,2101.22) 6904.69,2088.42 ; 6904.69,2088.42 ccw(c6891.89,2075.61) 6891.89,2093.72 cw(c6891.89,2075.61) 6904.69,2088.42
  MidLayer1 w4: v1(6106,5611) 6135,5640 6441.29,5640 6858.92,5222.37 v1(6886.86,5222.37) ; v1@6106,5616.5 ccw(c6106,5629.78) 6115.39,5620.39 ccw(c6124.78,5611) v1@6111.5,5611 ; v1@6106,5620.5 ccw(c6106,5643.43) 6122.22,5627.22 ccw(c6138.43,5611) v1@6115.5,5611 ; 6876.38,2210 6876.38,2270.81 6872.19,2275 6872.19,2464.37 ; 6876.38,2218.27 6876.38,2133.9 ccw(c6909.51,2133.73) 6881.47,2116.08 ; v1@6880.14,5215.66 ccw(c6863.92,5199.44) 6863.92,5222.37 ccw(c6863.92,5245.31) v1@6880.14,5229.09 ; v1@6882.97,5218.49 ccw(c6873.58,5209.1) 6873.58,5222.37 ccw(c6873.58,5235.65) v1@6882.97,5226.26 ; v3@6884.5,2102.52 ccw(c6866.67,2105.67) 6881.5,2116.05 ccw(c6896.34,2126.44) v3@6893.19,2108.61 ; v1@6990.19,4940.54 cw(c6990.19,4917.61) 7006.41,4933.82 cw(c7022.63,4950.04) v1@6999.69,4950.04 ; v1@6990.19,4944.54 cw(c6990.19,4931.26) 6999.58,4940.65 cw(c7008.97,4950.04) v1@6995.69,4950.04 ; v1(6990.19,4950.04) 7077.48,4862.75 7090.19,4850.04 7156.86,4850.04 7165.19,4858.37 7306.86,4858.37 7375.02,4790.21 7375.02,4741.97 7364.52,4731.48 7364.52,4625.71 7365.19,4625.04 7365.69,4624.54 7365.69,4534.54 7364.5,4533.35 7364.5,4489.19 7369.21,4484.48 7391.86,4461.83 7391.86,4384.48 7340.86,4333.48 7340.86,4255 7290.19,4204.33 7290.19,4149.69 7290.19,4145 7290.19,3094.69 7273.38,3077.88 7261.69,3066.19 7261.69,3050.56 7261.69,3035 7261.69,3020 7261.69,2998.16 7261.69,2905.48 7256.86,2900.65 7244.25,2888.04 7164.4,2808.19 ; 6872.19,2464.37 6886.69,2478.87 ; 6872.19,2464.37 6886.69,2478.87 ; 6886.69,2478.87 6886.69,2506.75 6965.19,2585.25 6965.19,2708.37 7066.69,2809.87 7140.13,2809.87 7141.81,2808.19 7142.31,2808.19 ; 7142.31,2808.19 7164.4,2808.19 ; 7142.31,2808.19 7164.4,2808.19
  MidLayer2 w4: v1@6880.14,5215.66 cw(c6863.92,5199.44) 6886.86,5199.44 cw(c6909.79,5199.44) v1@6893.57,5215.66 ; v1@6882.97,5218.49 cw(c6873.58,5209.1) 6886.86,5209.1 cw(c6900.14,5209.1) v1@6890.75,5218.49 ; v1(6886.86,5222.37) 6886.86,5191.71 6940.19,5138.37 6940.19,5000.04 v1(6990.19,4950.04) ; v1@6980.69,4950.04 ccw(c6957.76,4950.04) 6973.97,4966.26 ccw(c6990.19,4982.48) v1@6990.19,4959.54 ; v1@6984.69,4950.04 ccw(c6971.41,4950.04) 6980.8,4959.43 ccw(c6990.19,4968.82) v1@6990.19,4955.54
  Bottom Layer w4: U60.3@6049.65,5653.31 6086.69,5653.31 ; U60.3@6055.19,5647.94 cw(c6067.83,5635.73) 6067.83,5653.31 cw(c6067.83,5670.89) U60.3@6055.19,5658.67 ; U60.3@6058.07,5645.17 cw(c6077.26,5626.62) 6077.26,5653.31 cw(c6077.26,5680) U60.3@6058.07,5661.45 ; U60.3@6060.95,5642.39 cw(c6086.69,5617.51) 6086.69,5653.31 ; U60.3@6060.95,5664.23 ccw(c6086.69,5689.11) 6086.69,5653.31 ; 6091,5624 ccw(c6100.84,5633.84) v1@6103.91,5620.27 ; 6091.2,5623.8 cw(c6078.39,5611) v1@6096.5,5611 ; 6096.13,5618.87 ccw(c6102.73,5625.47) v1@6104.79,5616.36 ; v1@6105,5610 6090,5625 6090,5650 6086.69,5653.31
HOST_USB.SLOE: U30.B8 U56.35 | length 6308.7
  Top Layer w4: v2@6968.06,2219.06 cw(c6952.59,2203.59) 6974.47,2203.59 ; v2@6970.89,2221.89 cw(c6962.24,2213.24) 6974.47,2213.24 ; 6974.47,2201.04 cw(c6999.96,2201.04) v2@6981.94,2219.06 ; 6974.47,2210.7 cw(c6990.3,2210.7) v2@6979.11,2221.89 ; v2@6974.47,2226 6974.47,2140.95 6974.81,2140.62 ; 6974.81,2140.62 ccw(c6984.96,2140.62) 6977.78,2133.44 ; 6974.81,2140.62 ccw(c6984.96,2140.62) 6977.78,2133.44 ; 6977.78,2133.44 ccw(c6990.31,2145.97) 6990.31,2128.25 cw(c6990.31,2145.97) 6977.78,2133.44 ; 6977.78,2133.44 cw(c6965.25,2120.91) 6982.97,2120.91 ccw(c6965.25,2120.91) 6977.78,2133.44
  MidLayer1 w4: v4@6614.57,5943.32 cw(c6604.41,5931.7) 6619.84,5931.7 ; v4(6619.84,5949.34) 6619.84,5931.7 ; v4@6625.11,5943.32 ccw(c6635.28,5931.7) 6619.84,5931.7 ; 7462.7,5382.88 7435,5382.88 ; v1@7599,2642.36 ccw(c7588.7,2655) 7605,2655 ccw(c7621.3,2655) v1@7611,2642.36 ; v1@7601.53,2639.26 ccw(c7595.56,2646.58) 7605,2646.58 ccw(c7614.44,2646.58) v1@7608.47,2639.26 ; v1(7605,2635) 7605,2635.23 7605,2655 7615,2665 7639.56,2665 7735.81,2761.25 7735.81,2871.31 ; 7780.02,3617.87 7789.53,3627.38 ; 6619.84,5931.7 7168.67,5382.88 7225,5382.88 ; 7225,5382.88 7242.68,5382.88 ; 7225,5382.88 7242.68,5382.88 ; 7242.68,5382.88 7435,5382.88 ; 7435,5382.88 7815.36,5382.88 ; 7735.81,2871.31 7735.81,2885 ; 7735.81,2871.31 7735.81,2885 ; 7735.81,2885 7735.81,2892.69 7733.69,2894.81 7732.67,2895.83 7732.67,2980.52 7732.67,3203.15 7790.19,3260.67 7790.19,3277.95 7778.02,3290.12 7778.02,3381.79 7782.69,3386.46 7782.69,3400 ; 7778.02,3555 7782.69,3550.33 7782.69,3400.96 ; 7778.02,3555 7778.02,3615.87 ; 7778.02,3555 7778.02,3615.87 ; 7778.02,3615.87 7789.53,3627.38 ; 7782.69,3400 7782.69,3400.96 ; 7782.69,3400 7782.69,3400.96 ; 7789.53,3627.38 7815.19,3653.04 7815.19,4180.71 7842.89,4208.41 7856.52,4222.04 7856.52,4449.71 7865.19,4458.37 7873.52,4466.71 8077.23,4466.71 8090.52,4480 8090.52,4679.08 7879.5,4890.1 7879.5,5094.72 7912,5127.23 7912,5286.24 ; 7815.36,5382.88 7912,5286.24 ; 7815.36,5382.88 7912,5286.24
  Bottom Layer w4: v1(7605,2635) v1@7605.23,2635 ; 6989,2240 v2(6975,2226) 6989,2240 ; 6989,2240 6989,2271.47 6986,2274.47 6986,2292 6990,2296 7027,2296 7036.86,2305.86 ; 7036.86,2305.86 7037,2306 7037,2329.86 7036.86,2330 ; 7036.86,2305.86 7036.86,2330 ; 7036.86,2330 7036.86,2330.05 7089.69,2382.88 7151.01,2382.88 7163.94,2395.81 7172.56,2395.81 ; 7172.56,2395.81 7190,2413.25 ; 7172.56,2395.81 7190,2413.25 ; 7190,2413.25 7190,2460.56 7219.19,2489.75 ; 7219.19,2489.75 7230.44,2500.99 ; 7219.19,2489.75 7230.44,2500.99 ; 7230.44,2500.99 7309.75,2580.31 7368.87,2580.31 ; 7368.87,2580.31 7394.69,2606.12 ; 7368.87,2580.31 7394.69,2606.12 ; 7394.69,2606.12 7437.75,2649.19 7545.25,2649.19 7546.1,2650.04 7590.19,2650.04 7605.12,2635.12 v1@7605.23,2635 ; v1@7605.23,2635 7606.86,2633.37 v1@7605.23,2635
  Bottom Layer w8: v4@6615.6,5953.58 ccw(c6605.36,5963.82) 6619.84,5963.82 ccw(c6634.33,5963.82) v4@6624.09,5953.58 ; v4(6619.84,5949.34) U56.35@6619.84,5980.67
HOST_USB.VBUS: R245.1 R246.1 U30.B13 | length 4830.1
  Top Layer w4: v1@7091.81,5768.66 cw(c7075.59,5752.44) 7098.52,5752.44 cw(c7121.46,5752.44) v1@7105.24,5768.66 ; v1@7094.64,5771.49 cw(c7085.25,5762.1) 7098.52,5762.1 cw(c7111.8,5762.1) v1@7102.41,5771.49 ; v1(7098.52,5775.37) 7098.52,5281.48 7204.96,5175.04 7259.84,5175.04 7500.19,4934.69 7500.19,4898.01 7491.19,4889 7491.19,4851 7500.19,4841.99 7500.19,4807.73 7486.19,4793.73 7486.19,3756.04 7456.86,3726.71 7456.86,3408.37 7473.52,3391.71 7618.52,3391.71 7623.52,3386.71 7623.52,3273.36 7623.03,3272.86 7623.03,3267.89 7681.86,3209.06 7681.86,3009.71 v1(7656.86,2984.71) ; v2(7231.31,2254) 7231.31,2248.81 7202.67,2220.17 7202.67,2140.62 ; v1@7656.86,2990.21 ccw(c7656.86,3003.49) 7666.25,2994.1 ccw(c7675.64,2984.71) v1@7662.36,2984.71 ; v1@7656.86,2994.21 ccw(c7656.86,3017.14) 7673.07,3000.93 ccw(c7689.29,2984.71) v1@7666.36,2984.71 ; 7199.7,2133.44 cw(c7187.17,2145.97) 7187.17,2128.25 ccw(c7187.17,2145.97) 7199.7,2133.44 ; 7199.7,2133.44 ccw(c7212.23,2120.91) 7194.51,2120.91 cw(c7212.23,2120.91) 7199.7,2133.44 ; 7199.7,2133.44 ccw(c7192.52,2140.62) 7202.67,2140.62 ; 7199.7,2133.44 ccw(c7192.52,2140.62) 7202.67,2140.62
  MidLayer2 w4: v2@7224.38,2260.94 ccw(c7207.63,2277.69) 7231.31,2277.69 ccw(c7255,2277.69) v2@7238.25,2260.94 ; v2@7227.2,2258.11 ccw(c7217.28,2268.03) 7231.31,2268.03 ccw(c7245.34,2268.03) v2@7235.42,2258.11 ; v2(7231.31,2254) 7231.31,2279.87 7228.19,2283 ; v1@7647.36,2984.71 cw(c7624.42,2984.71) 7640.64,2968.49 cw(c7656.86,2952.27) v1@7656.86,2975.21 ; v1@7651.36,2984.71 cw(c7638.08,2984.71) 7647.47,2975.32 cw(c7656.86,2965.93) v1@7656.86,2979.21 ; v1(7656.86,2984.71) 7605.52,2933.37 7597.19,2933.37 7374.19,2710.37 7374.19,2537.69 7218.19,2381.68 7218.19,2293 ; 7218.19,2293 7228.19,2283 ; 7218.19,2293 7228.19,2283
  Bottom Layer w4: v1@7091.81,5782.09 ccw(c7069.17,5804.72) R245.1@7101.18,5804.72 ; R245.1@7094.59,5812.08 ccw(c7078.68,5827.99) 7101.18,5827.99 ccw(c7123.68,5827.99) R245.1@7107.77,5812.08 ; R246.1@7094.59,5845.42 cw(c7078.68,5829.51) 7101.18,5829.51 cw(c7123.68,5829.51) R246.1@7107.77,5845.42 ; v1@7094.64,5779.26 ccw(c7078.83,5795.07) R245.1@7101.18,5795.07 ; R245.1@7097.42,5800.75 cw(c7088.34,5791.67) 7101.18,5791.67 cw(c7114.02,5791.67) R245.1@7104.94,5800.75 ; R245.1@7097.42,5809.25 ccw(c7088.34,5818.33) 7101.18,5818.33 ccw(c7114.02,5818.33) R245.1@7104.94,5809.25 ; R246.1@7097.42,5848.25 cw(c7088.34,5839.17) 7101.18,5839.17 cw(c7114.02,5839.17) R246.1@7104.94,5848.25 ; v1(7098.52,5775.37) 7101.18,5778.03 R245.1@7101.18,5805 R246.1@7101.18,5852.5 ; 7101.18,5791.9 ccw(c7115.04,5791.9) v1@7105.24,5782.09
HOST_USB.WR_N: U30.L16 U56.2 | length 7560
  Top Layer w4: U30.L16@7305.28,1766.57 7331,1766.57 7385.43,1766.57 7392,1760 v2(7392,1734) ; U30.L16@7310.47,1761.38 cw(c7323,1748.85) 7323,1766.57 cw(c7323,1784.3) U30.L16@7310.47,1771.77 ; v2@7385.06,1740.94 ccw(c7368.31,1757.69) 7392,1757.69 ccw(c7415.69,1757.69) v2@7398.94,1740.94 ; v2@7387.89,1738.11 ccw(c7377.97,1748.03) 7392,1748.03 ccw(c7406.03,1748.03) v2@7396.11,1738.11
  MidLayer1 w4: v4@6493.73,6258 ccw(c6474.42,6258) 6488.08,6271.66 ccw(c6501.73,6285.31) v4@6501.73,6266 ; v4(6501.73,6258) 6472.69,6287.04 6472.69,6330.62 6509.42,6367.35 6509.42,6515.39 6533.03,6539 6612.97,6539 6648.5,6503.47 6648.5,6482.81 6681.1,6450.21 6935.02,6450.21 6982.62,6497.81 7056.82,6497.81 7285,6269.63 7285,5810 7510,5585 7926.31,5585 7950.81,5560.5 7950.81,5514.31 7942.81,5506.31 7942.81,5382.11 7947.19,5377.73 7947.19,5307.62 8026,5228.81 8026,4879 8076.5,4828.5 8103.88,4828.5 8136,4796.38 8136,4630.5 8197,4569.5 8197,4240.12 8216.02,4221.09 8216.02,3885.04 8126.23,3795.25 8075.36,3744.38 8075.36,3691.67 8011.47,3627.78 7945.41,3627.78 7914.69,3597.06 7914.69,3433.62 7931.86,3416.46 7931.86,3264.23 7789.69,3122.06 7789.69,2918.01 7791.81,2915.89 7791.81,2767.13 7806.5,2752.44 7806.5,2672.37 7756.94,2622.81 7712.62,2622.81 7702.19,2612.38 7702.19,2597.62 7712.62,2587.19 7742.56,2587.19 7792.5,2537.25 7792.5,2522.75 7774.19,2504.44 7774.19,2430.16 7790.61,2413.74 7790.61,2205.4 7832.5,2163.51 7832.5,2063.75 7822.25,2053.5 7759.13,2053.5 7752.82,2059.81 7719,2059.81 7677.99,2018.8 7677.99,1981.8 7686,1973.78 7686,1826.66 7588.45,1729.11 7396.89,1729.11 v2(7392,1734) ; v2@7392,1736 v2@7393,1735 ; v2@7393.28,1735.28 ccw(c7408.18,1750.18) 7408.18,1729.11 ; v2@7396.11,1738.11 ccw(c7417.83,1759.83) 7417.83,1729.11 ; v2@7398.94,1727.06 cw(c7403.88,1722.12) 7403.88,1729.11 ; v2@7398.94,1740.94 ccw(c7427.49,1769.49) 7427.49,1729.11
  Bottom Layer w8: v4@6497.49,6262.24 ccw(c6487.25,6272.49) 6501.73,6272.49 ccw(c6516.22,6272.49) v4@6505.97,6262.24 ; v4(6501.73,6258) U56.2@6501.73,6289.33
HOST_USB.XTALIN: C167.1 U56.5 Y4.3 | length 811.7
  MidLayer2 w12: v1@6294.64,6059.93 ccw(c6285.25,6069.32) 6298.52,6069.32 ccw(c6311.8,6069.32) v1@6302.41,6059.93 ; v1(6298.52,6056.04) 6298.52,6188.52 6404.39,6294.39 6404.39,6329.39 6420,6345 6536.45,6345 v4(6560.79,6320.66)
  Bottom Layer w8: v4@6556.54,6316.42 cw(c6546.3,6306.18) 6560.79,6306.18 cw(c6575.27,6306.18) v4@6565.03,6316.42 ; U56.5@6560.79,6289.33 v4(6560.79,6320.66)
  Bottom Layer w12: Y4.3@6277.5,5993.5 6298.52,6014.52 v1(6298.52,6056.04) ; Y4.3@6278.27,5995.12 ccw(c6269.21,6023) Y4.3@6298.52,6023 ; v1@6294.64,6052.15 cw(c6285.25,6042.76) 6298.52,6042.76 cw(c6311.8,6042.76) v1@6302.41,6052.15 ; C167.1@6490,6354.33 6545.67,6354.33 6560.79,6339.21 v4(6560.79,6320.66) ; C167.1@6494.11,6350.22 cw(c6504.03,6340.3) 6504.03,6354.33 cw(c6504.03,6368.36) C167.1@6494.11,6358.44
HOST_USB.XTALOUT: C166.1 U54.2 U56.4 Y4.1 | length 1026.5
  MidLayer1 w12: v1(6224.15,6137.69) 6287.84,6137.69 v1(6381.86,6231.71) ; v1@6228.04,6133.8 cw(c6237.43,6124.41) 6237.43,6137.69 cw(c6237.43,6150.97) v1@6228.04,6141.58 ; v1@6376.36,6231.71 cw(c6363.08,6231.71) 6372.47,6222.32 cw(c6381.86,6212.93) v1@6381.86,6226.21
  MidLayer2 w12: v1(6381.86,6231.71) 6381.86,6236.86 6423,6278 6430,6278 ; v1@6387.36,6231.71 cw(c6413.07,6231.71) 6394.89,6249.89 ; v1@6426.3,6317.15 cw(c6416.91,6307.76) 6430.19,6307.76 cw(c6443.47,6307.76) v1@6434.08,6317.15 ; v1(6430.19,6321.04) 6430.19,6278.19 6430,6278 ; v4(6541.1,6258) 6521.1,6278 6430,6278
  Bottom Layer w8: v4@6536.86,6262.24 ccw(c6526.62,6272.49) 6541.1,6272.49 ccw(c6555.59,6272.49) v4@6545.35,6262.24 ; v4(6541.1,6258) U56.4@6541.1,6289.33
  Bottom Layer w12: U54.2@6159.66,6110.77 cw(c6171,6117.41) 6161.71,6126.71 ; U54.2@6160.89,6118.01 ccw(c6150.97,6127.93) 6165,6127.93 ccw(c6179.03,6127.93) U54.2@6169.11,6118.01 ; U54.2@6165,6100.12 6165,6130 6172.69,6137.69 ; U54.2@6170.01,6116.84 cw(c6184.85,6125.53) 6172.69,6137.69 ; v1@6220.26,6133.8 ccw(c6210.87,6124.41) 6210.87,6137.69 ccw(c6210.87,6150.97) v1@6220.26,6141.58 ; v1(6224.15,6137.69) 6172.69,6137.69 ; Y4.1@6357.3,6175.7 ccw(c6320.59,6212.41) 6372.5,6212.41 ccw(c6424.41,6212.41) Y4.1@6387.7,6175.7 ; Y4.1@6372.5,6156.5 6372.5,6222.35 v1(6381.86,6231.71) ; 6372.5,6195.84 cw(c6417.73,6195.84) v1@6385.75,6227.82 ; 6372.5,6224.81 cw(c6388.76,6224.81) v1@6377.26,6236.3 ; C166.1@6425.89,6350.22 cw(c6415.97,6340.3) 6430,6340.3 cw(c6444.03,6340.3) C166.1@6434.11,6350.22 ; v1@6426.3,6324.93 ccw(c6417.37,6333.86) 6430,6333.86 ; 6430,6334.78 ccw(c6443.93,6334.78) v1@6434.08,6324.93 ; C166.1@6430,6354.33 6430,6321.23 v1(6430.19,6321.04)
HOSTUSB#.DMINUS: J10.2 U55.6 U56.9 | length 714.6
  MidLayer1 w4: v1@6571.02,6500.04 ccw(c6588.84,6500.04) 6576.24,6487.44 ; v1(6573.52,6500.04) 6573.52,6490.16 6639.53,6424.16 v4(6639.53,6320.66) ; v1@6575.02,6500.04 ccw(c6602.49,6500.04) 6583.07,6480.62 ; v1@6579.02,6500.04 ccw(c6616.15,6500.04) 6589.9,6473.79 ; v1@6583.02,6500.04 ccw(c6629.81,6500.04) 6596.73,6466.96 ; v4@6633.87,6326.32 ccw(c6620.21,6339.98) 6639.53,6339.98 ccw(c6658.84,6339.97) v4@6645.18,6326.32
  Bottom Layer w4: U55.6@6562.76,6462.4 U55.6@6575,6474.65 ; U55.6@6566.31,6465.36 ccw(c6551.94,6483.4) 6575,6483.4 ; v1@6567.01,6493.13 cw(c6549.54,6474.6) U55.6@6575,6474.6 ; U55.6@6568.8,6462.23 ccw(c6558.55,6475.1) U55.6@6575,6475.1 ; v1@6569.75,6496.04 cw(c6558.28,6483.87) 6575,6483.87 ; v1(6573.52,6500.04) 6596.5,6523.01 J10.2@6596.5,6594 ; v1@6573.52,6505.54 ccw(c6573.52,6518.82) 6582.91,6509.43 ccw(c6592.3,6500.04) v1@6579.02,6500.04 ; v1@6573.52,6509.54 ccw(c6573.52,6532.48) 6589.74,6516.26 ccw(c6605.96,6500.04) v1@6583.02,6500.04 ; U55.6@6575,6475.54 ccw(c6581.8,6475.54) U55.6@6576.99,6470.73 ; 6575,6480.67 cw(c6592.9,6480.67) v1@6580.24,6493.32 ; v1@6575,6500 U55.6@6575,6474.65 ; J10.2@6590.95,6543.18 cw(c6577.56,6529.79) 6596.5,6529.79 cw(c6615.43,6529.79) J10.2@6602.04,6543.18
  Bottom Layer w8: v4@6635.28,6316.42 cw(c6625.04,6306.18) 6639.53,6306.18 cw(c6654.01,6306.18) v4@6643.77,6316.42 ; U56.9@6639.53,6289.33 v4(6639.53,6320.66)
HOSTUSB#.DPLUS: J10.3 U55.1 U56.8 | length 829.8
  MidLayer1 w4: v1@6599.47,6490.32 cw(c6583.26,6474.11) 6606.19,6474.11 cw(c6629.13,6474.11) v1@6612.91,6490.32 ; v1@6602.3,6493.15 cw(c6592.91,6483.76) 6606.19,6483.76 cw(c6619.47,6483.76) v1@6610.08,6493.15 ; v1(6606.19,6497.04) 6606.19,6468.81 6626.16,6448.84 6647.53,6427.47 6647.53,6343 6655.53,6335 6655.53,6314.03 6619.84,6278.35 v4(6619.84,6258) ; v4@6614.19,6263.66 ccw(c6600.53,6277.31) 6619.84,6277.31 ccw(c6639.16,6277.31) v4@6625.5,6263.66
  Bottom Layer w4: v1@6599.47,6490.32 cw(c6582.93,6473.78) 6606.33,6473.78 ; v1@6599.47,6503.76 ccw(c6583.26,6519.98) 6606.19,6519.98 ccw(c6629.13,6519.98) v1@6612.91,6503.76 ; v1@6602.3,6493.15 cw(c6592.58,6483.43) 6606.33,6483.43 ; v1@6602.3,6500.93 ccw(c6592.91,6510.32) 6606.19,6510.32 ccw(c6619.47,6510.32) v1@6610.08,6500.93 ; v1(6606.19,6497.04) 6606.33,6497.04 6606.33,6468.67 6612.6,6462.4 U55.1@6657.24,6462.4 ; v1@6606.19,6497.18 6606.19,6526.19 6627.99,6547.99 J10.3@6627.99,6594 ; 6606.33,6474.43 cw(c6628.8,6474.43) v1@6612.91,6490.32 ; 6606.33,6484.09 cw(c6619.14,6484.09) v1@6610.08,6493.15 ; 6614.09,6534.09 ccw(c6599.45,6548.73) J10.3@6620.15,6548.73 ; 6615.86,6535.86 cw(c6627.99,6523.72) J10.3@6627.99,6540.88 ; J10.3@6620.92,6540.92 ccw(c6613.11,6548.73) J10.3@6624.15,6548.73 ; U55.1@6643.01,6454.07 ccw(c6622.9,6433.96) 6622.9,6462.4 ccw(c6622.9,6490.84) U55.1@6643.01,6470.73 ; U55.1@6645.84,6456.9 ccw(c6632.56,6443.62) 6632.56,6462.4 ccw(c6632.56,6481.18) U55.1@6645.84,6467.9
  Bottom Layer w8: v4@6615.6,6262.24 ccw(c6605.36,6272.49) 6619.84,6272.49 ccw(c6634.33,6272.49) v4@6624.09,6262.24 ; v4(6619.84,6258) U56.8@6619.84,6289.33
HOSTUSB#.VBUS: J10.1 R245.2 R247.1 | length 1874.4
  Top Layer w4: v1@6513.28,6563.28 cw(c6497.06,6547.06) 6520,6547.06 cw(c6542.93,6547.06) v1@6526.72,6563.28 ; v1@6516.11,6566.11 cw(c6506.72,6556.72) 6520,6556.72 cw(c6533.28,6556.72) v1@6523.89,6566.11 ; v1(6520,6570) 6520,6430 6533.29,6416.71 v1(6863.86,6416.71) ; v1@6857.14,6409.99 ccw(c6840.92,6393.77) 6840.92,6416.71 ccw(c6840.92,6439.64) v1@6857.14,6423.43 ; v1@6859.97,6412.82 ccw(c6850.58,6403.43) 6850.58,6416.71 ccw(c6850.58,6429.99) v1@6859.97,6420.6
  MidLayer1 w4: v1@6863.86,6407.21 cw(c6863.86,6384.27) 6880.07,6400.49 cw(c6896.29,6416.71) v1@6873.36,6416.71 ; v1@6863.86,6411.21 cw(c6863.86,6397.93) 6873.25,6407.32 cw(c6882.64,6416.71) v1@6869.36,6416.71 ; v1(6863.86,6416.71) 6923,6357.56 6923,6334.62 7056.86,6200.77 v1(7056.86,5775.04) ; v1@7050.14,5781.76 ccw(c7033.92,5797.98) 7056.86,5797.98 ccw(c7079.79,5797.98) v1@7063.57,5781.76 ; v1@7052.97,5778.93 ccw(c7043.58,5788.32) 7056.86,5788.32 ccw(c7070.14,5788.32) v1@7060.75,5778.93
  Bottom Layer w4: v1(6520,6570) 6560,6570 6565,6575 J10.1@6565,6600 ; v1@6523.89,6566.11 cw(c6533.28,6556.72) 6533.28,6570 cw(c6533.28,6583.28) v1@6523.89,6573.89 ; v1@6526.72,6563.28 cw(c6542.93,6547.06) 6542.93,6570 cw(c6542.93,6592.93) v1@6526.72,6576.72 ; 6538.55,6570 cw(c6538.55,6536.84) J10.1@6568.79,6550.43 ; 6544.73,6570 cw(c6544.73,6539.62) J10.1@6572.44,6552.07 ; R247.1@6795,6440 6818.29,6416.71 v1(6863.86,6416.71) ; R247.1@6796.18,6430.19 cw(c6796.18,6409.35) 6810.91,6424.09 ; R247.1@6796.18,6434.19 cw(c6796.18,6423.01) R247.1@6804.08,6430.92 ; R247.1@6801.5,6439.51 ccw(c6816,6439.51) R247.1@6805.75,6429.25 ; R247.1@6805.5,6439.51 ccw(c6829.66,6439.51) 6812.58,6422.42 ; v1@6857.14,6409.99 ccw(c6840.92,6393.77) 6840.92,6416.71 ccw(c6840.92,6439.64) v1@6857.14,6423.43 ; v1@6859.97,6412.82 ccw(c6850.58,6403.43) 6850.58,6416.71 ccw(c6850.58,6429.99) v1@6859.97,6420.6 ; R245.2@7055.54,5795.79 cw(c7053.75,5791.04) 7058.82,5791.04 ; v1(7056.86,5775.04) 7056.86,5789.08 7058.82,5791.04 ; R245.2@7058.82,5805 7058.82,5791.04 ; R245.2@7062.1,5795.79 ccw(c7063.89,5791.04) 7058.82,5791.04
I2C.SCL: EXTHDR1.25 R277.2 U8.AD2 | length 4673.3
  Top Layer w4: EXTHDR1.25@1747.71,3122.62 ccw(c1725.64,3144.7) 1756.86,3144.7 ; v1@1750.14,3211.66 cw(c1733.92,3195.44) 1756.86,3195.44 cw(c1779.79,3195.44) v1@1763.57,3211.66 ; EXTHDR1.25@1750.54,3119.8 ccw(c1735.29,3135.04) 1756.86,3135.04 ; v1@1752.97,3214.49 cw(c1743.58,3205.1) 1756.86,3205.1 cw(c1770.14,3205.1) v1@1760.75,3214.49 ; EXTHDR1.25@1756.86,3075.04 1756.86,3160.02 v1(1756.86,3218.37) ; EXTHDR1.25@1756.86,3119.85 cw(c1803.66,3119.85) R277.2@1770.56,3152.94 ; 1756.86,3127.86 ccw(c1764.26,3127.86) EXTHDR1.25@1759.03,3122.62 ; 1756.86,3129.5 cw(c1794,3129.5) R277.2@1767.74,3155.77 ; 1756.86,3139.16 cw(c1784.34,3139.16) R277.2@1764.91,3158.6 ; R277.2@1756.86,3148.82 cw(c1774.69,3148.82) R277.2@1762.08,3161.42 ; R277.2@1756.86,3171.22 ccw(c1774.69,3171.22) R277.2@1762.08,3158.62 ; 1756.86,3180.88 ccw(c1784.34,3180.88) R277.2@1764.91,3161.44 ; 1756.86,3190.54 ccw(c1794,3190.54) R277.2@1767.74,3164.27 ; 1756.86,3200.19 ccw(c1803.66,3200.19) R277.2@1770.56,3167.1 ; v1(4701.79,3689.71) 4712.5,3700.41 4712.5,3777.25 4714.44,3779.19 4730,3779.19 ; 4730,3779.19 4735.69,3779.19 ; 4730,3779.19 4735.69,3779.19 ; 4735.69,3779.19 4743.43,3779.19 ; 4743.43,3779.19 4746.12,3776.5 ; 4743.43,3779.19 4746.12,3776.5 ; 4746.12,3776.5 4773.88,3776.5 4778.88,3776.5 4798.5,3796.12 4802.85,3800.48 ; 4802.85,3800.48 4810,3800.48 ; 4802.85,3800.48 4810,3800.48 ; 4810,3800.48 4830.82,3800.48 4838.82,3800.48 ; 4838.82,3800.48 4878.16,3800.48 ; 4838.82,3800.48 4878.16,3800.48 ; 4878.16,3800.48 ccw(c4878.16,3810.63) 4885.34,3803.45 ; 4878.16,3800.48 ccw(c4878.16,3810.63) 4885.34,3803.45 ; 4885.34,3803.45 ccw(c4872.81,3815.98) 4890.53,3815.98 cw(c4872.81,3815.98) 4885.34,3803.45 ; 4885.34,3803.45 cw(c4897.87,3790.92) 4897.87,3808.64 ccw(c4897.87,3790.92) 4885.34,3803.45
  MidLayer2 w4: v1(1756.86,3218.37) 1797.06,3218.37 1820.39,3241.71 2720.54,3241.71 2795.54,3316.71 3753.88,3316.71 ; v1@1760.75,3214.49 cw(c1770.14,3205.1) 1770.14,3218.37 cw(c1770.14,3231.65) v1@1760.75,3222.26 ; v1@1763.57,3211.66 cw(c1779.79,3195.44) 1779.79,3218.37 cw(c1779.79,3241.31) v1@1763.57,3225.09 ; v1@4705.68,3685.82 cw(c4715.07,3676.43) 4715.07,3689.71 cw(c4715.07,3702.99) v1@4705.68,3693.6 ; v1@4708.51,3682.99 cw(c4724.73,3666.77) 4724.73,3689.71 cw(c4724.73,3712.64) v1@4708.51,3696.43 ; v1@4709.01,3689.71 v1(4701.79,3689.71) 4732.21,3689.71 4740,3697.5 ; 4762.25,3662.5 4772.5,3672.75 ; 3753.88,3316.71 3766.71,3329.54 ; 3753.88,3316.71 3766.71,3329.54 ; 3766.71,3329.54 3785,3329.54 ; 3785,3329.54 3994.54,3329.54 ; 3785,3329.54 3994.54,3329.54 ; 3994.54,3329.54 4000.04,3329.54 4045.54,3375.04 ; 4045.54,3375.04 4096.52,3375.04 ; 4045.54,3375.04 4096.52,3375.04 ; 4096.52,3375.04 4115.19,3393.71 4115.19,3405.19 4251.71,3541.71 4355,3541.71 ; 4355,3541.71 4390.19,3541.71 ; 4355,3541.71 4390.19,3541.71 ; 4390.19,3541.71 4411.67,3541.71 4445,3575.04 ; 4445,3575.04 4470,3575.04 ; 4445,3575.04 4470,3575.04 ; 4470,3575.04 4624.52,3575.04 4680.03,3630.55 4706.59,3630.55 4708.94,3628.21 ; 4708.94,3628.21 4725.58,3628.21 ; 4708.94,3628.21 4725.58,3628.21 ; 4725.58,3628.21 4727.96,3628.21 4762.25,3662.5 4772.5,3672.75 ; 4740,3697.5 4762.25,3697.5 ; 4740,3697.5 4762.25,3697.5 ; 4762.25,3697.5 4772.5,3687.25 4772.5,3680 ; 4772.5,3672.75 4772.5,3680 ; 4772.5,3672.75 4772.5,3680