# Altium PCB NB3000AL.PcbDoc (part 17 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.UIO.IO16: J33.A25 PROTOTYPE1.H15 U8.L5 UH1.18 | length 9732.3
  Top Layer w4: J33.A25@-785.98,3243.41 -699.41,3243.41 ; J33.A25@-706.21,3238.88 cw(c-699.41,3236.05) -699.41,3243.41 ; J33.A25@-706.21,3247.94 ccw(c-699.41,3250.78) -699.41,3243.41 ; v1@-689.5,3224 ccw(c-712.44,3224) -696.22,3240.22 ccw(c-680,3256.43) v1@-680,3233.5 ; v1@-685.5,3224 ccw(c-698.78,3224) -689.39,3233.39 ccw(c-680,3242.78) v1@-680,3229.5 ; v1(-680,3224) -699.41,3243.41 ; PROTOTYPE1.H15@1676.12,4208.23 1740.19,4272.3 1740.19,4470 1820,4549.81 1820,4769.36 UH1.18@1776.12,4813.23 1840.19,4877.3 1840.19,5051.71 v1(1855.19,5066.71) ; PROTOTYPE1.H15@1676.12,4221.23 ccw(c1676.12,4252.62) 1698.31,4230.43 ccw(c1720.51,4208.23) PROTOTYPE1.H15@1689.12,4208.23 ; PROTOTYPE1.H15@1676.12,4225.23 ccw(c1676.12,4266.28) 1705.14,4237.26 ccw(c1734.16,4208.23) PROTOTYPE1.H15@1693.12,4208.23 ; PROTOTYPE1.H15@1676.12,4229.23 ccw(c1676.12,4279.93) 1711.97,4244.08 ccw(c1747.82,4208.23) PROTOTYPE1.H15@1697.12,4208.23 ; PROTOTYPE1.H15@1676.12,4233.23 ccw(c1676.12,4293.59) 1718.8,4250.91 ccw(c1761.48,4208.23) PROTOTYPE1.H15@1701.12,4208.23 ; PROTOTYPE1.H15@1676.12,4237.23 ccw(c1676.12,4307.25) 1725.63,4257.74 ccw(c1775.13,4208.23) PROTOTYPE1.H15@1705.12,4208.23 ; UH1.18@1776.12,4828.76 ccw(c1776.12,4866.25) 1802.63,4839.74 ccw(c1829.14,4813.23) UH1.18@1791.65,4813.23 ; UH1.18@1776.12,4832.76 ccw(c1776.12,4879.91) 1809.46,4846.57 ccw(c1842.79,4813.23) UH1.18@1795.65,4813.23 ; UH1.18@1776.12,4836.76 ccw(c1776.12,4893.56) 1816.29,4853.4 ccw(c1856.45,4813.23) UH1.18@1799.65,4813.23 ; UH1.18@1776.12,4840.76 ccw(c1776.12,4907.22) 1823.11,4860.23 ccw(c1870.11,4813.23) UH1.18@1803.65,4813.23 ; UH1.18@1776.89,4797.73 cw(c1778.47,4766.08) 1800.87,4788.49 cw(c1823.28,4810.89) UH1.18@1791.63,4812.46 ; UH1.18@1777.09,4793.73 cw(c1779.07,4753.93) 1807.25,4782.11 cw(c1835.42,4810.29) UH1.18@1795.62,4812.26 ; UH1.18@1777.29,4789.74 cw(c1779.67,4741.79) 1813.62,4775.73 cw(c1847.57,4809.68) UH1.18@1799.62,4812.07 ; UH1.18@1777.49,4785.74 cw(c1780.28,4729.64) 1820,4769.36 cw(c1859.72,4809.08) UH1.18@1803.61,4811.87 ; v3(4996.3,4347.48) U8.L5@5015.98,4327.8 ; U8.L5@5008.64,4327.8 ccw(c4990.92,4327.8) 5003.45,4340.33 ccw(c5015.98,4352.86) U8.L5@5015.98,4335.14 ; 5009.1,4334.68 cw(c5021.91,4347.48) 5003.8,4347.48 ccw(c5021.91,4347.48) 5009.1,4334.68 ; 5009.1,4334.68 ccw(c4996.3,4321.87) 4996.3,4339.98 cw(c4996.3,4321.87) 5009.1,4334.68
  MidLayer1 w4: v1(1855.19,5066.71) 1855.36,5066.54 3456.5,5066.54 3490,5100.04 3548.52,5100.04 3573.52,5075.04 3674.96,5075.04 3850.29,4899.71 4015.29,4899.71 4020.58,4905 4093.56,4905 4281.86,4716.71 4281.86,4620 ; v1@1859.08,5062.82 cw(c1868.07,5053.83) 1868.07,5066.54 ; v1@1859.08,5070.6 ccw(c1868.87,5080.39) 1868.87,5066.54 ; v1@1861.91,5059.99 cw(c1877.72,5044.18) 1877.72,5066.54 ; v1@1861.91,5073.43 ccw(c1878.53,5090.05) 1878.53,5066.54 ; 4982.72,4358.87 ccw(c4972.79,4348.94) 4972.79,4362.99 4958.86,4362.99 4898.67,4362.99 4879.25,4362.99 4838.82,4362.99 4830.82,4362.99 4804.35,4362.99 4796,4371.34 4759.13,4408.21 4720.92,4408.21 4714.54,4414.59 4665,4414.59 4646.9,4414.59 4554.34,4414.59 4534.31,4434.63 4524.5,4444.44 4524.5,4486.79 4402.58,4608.71 4293.15,4608.71 ; v3@4988.83,4346.83 ccw(c4970.79,4345.25) 4982.43,4359.12 ccw(c4994.07,4372.99) v3@4995.65,4354.95 ; 4281.86,4620 4293.15,4608.71 ; 4281.86,4620 4293.15,4608.71
  MidLayer2 w4: v1(-680,3224) -652.52,3224 -634.81,3241.71 -634.81,3308.71 -668.14,3342.04 -668.14,3365 -689.5,3386.36 -689.5,3482.5 -652,3520 -652,3604.83 -588.12,3668.71 -532.28,3724.55 -489,3767.83 -489,4070.34 -234.29,4325.04 620.52,4325.04 678.86,4383.37 1348.52,4383.37 1439.72,4292.18 1592.18,4292.18 PROTOTYPE1.H15@1676.12,4208.23 ; v1@-676.11,3220.11 cw(c-666.72,3210.72) -666.72,3224 cw(c-666.72,3237.28) v1@-676.11,3227.89 ; v1@-673.28,3217.28 cw(c-657.07,3201.06) -657.07,3224 cw(c-657.07,3246.93) v1@-673.28,3230.72 ; PROTOTYPE1.H15@1647.12,4208.23 ccw(c1577.11,4208.23) 1626.62,4257.74 ccw(c1676.12,4307.25) PROTOTYPE1.H15@1676.12,4237.23 ; PROTOTYPE1.H15@1651.12,4208.23 ccw(c1590.77,4208.23) 1633.44,4250.91 ccw(c1676.12,4293.59) PROTOTYPE1.H15@1676.12,4233.23 ; PROTOTYPE1.H15@1655.12,4208.23 ccw(c1604.42,4208.23) 1640.27,4244.08 ccw(c1676.12,4279.93) PROTOTYPE1.H15@1676.12,4229.23 ; PROTOTYPE1.H15@1659.12,4208.23 ccw(c1618.08,4208.23) 1647.1,4237.26 ccw(c1676.12,4266.28) PROTOTYPE1.H15@1676.12,4225.23 ; PROTOTYPE1.H15@1663.12,4208.23 ccw(c1631.74,4208.23) 1653.93,4230.43 ccw(c1676.12,4252.62) PROTOTYPE1.H15@1676.12,4221.23
ATE.UIO.IO17: J33.A26 PROTOTYPE1.H16 U8.M2 UH1.19 | length 9662.3
  Top Layer w4: J33.A26@-785.98,3204.04 -607.48,3204.04 v1(-586.48,3225.04) ; J33.A26@-711.58,3198.54 cw(c-698.3,3185.26) -698.3,3204.04 cw(c-698.3,3222.82) J33.A26@-711.58,3209.54 ; J33.A26@-708.76,3195.71 cw(c-688.65,3175.6) -688.65,3204.04 cw(c-688.65,3232.48) J33.A26@-708.76,3212.37 ; v1@-595.98,3225.04 cw(c-618.91,3225.04) -602.69,3208.82 cw(c-586.48,3192.61) v1@-586.48,3215.54 ; v1@-591.98,3225.04 cw(c-605.25,3225.04) -595.87,3215.65 cw(c-586.48,3206.26) v1@-586.48,3219.54 ; v1(-40,3295) 23.52,3358.52 23.52,4225.04 ; v1@-40,3300.5 ccw(c-40,3313.78) -30.61,3304.39 ccw(c-21.22,3295) v1@-34.5,3295 ; v1@-40,3304.5 ccw(c-40,3327.43) -23.78,3311.22 ccw(c-7.57,3295) v1@-30.5,3295 ; 43.96,4245.48 23.52,4225.04 ; v1@97.36,4375.04 cw(c74.42,4375.04) 90.64,4358.82 cw(c106.86,4342.61) v1@106.86,4365.54 ; v1@101.36,4375.04 cw(c88.08,4375.04) 97.47,4365.65 cw(c106.86,4356.26) v1@106.86,4369.54 ; v1(106.86,4375.04) 56.86,4325.04 56.86,4258.37 23.52,4225.04 ; PROTOTYPE1.H16@1755.62,4228.74 ccw(c1706.11,4278.25) 1776.12,4278.25 ccw(c1846.13,4278.25) PROTOTYPE1.H16@1796.63,4228.74 ; PROTOTYPE1.H16@1758.44,4225.91 ccw(c1715.77,4268.59) 1776.12,4268.59 ccw(c1836.48,4268.59) PROTOTYPE1.H16@1793.8,4225.91 ; PROTOTYPE1.H16@1761.27,4223.08 ccw(c1725.42,4258.93) 1776.12,4258.93 ccw(c1826.82,4258.93) PROTOTYPE1.H16@1790.97,4223.08 ; PROTOTYPE1.H16@1764.1,4220.26 ccw(c1735.08,4249.28) 1776.12,4249.28 ccw(c1817.16,4249.28) PROTOTYPE1.H16@1788.14,4220.26 ; PROTOTYPE1.H16@1766.93,4217.43 ccw(c1744.74,4239.62) 1776.12,4239.62 ccw(c1807.51,4239.62) PROTOTYPE1.H16@1785.31,4217.43 ; PROTOTYPE1.H16@1776.12,4208.23 1776.12,4408.37 1876.12,4508.37 UH1.19@1876.12,4713.23 ; UH1.19@1856.66,4693.77 cw(c1809.66,4646.78) 1876.12,4646.78 cw(c1942.58,4646.78) UH1.19@1895.59,4693.77 ; UH1.19@1859.48,4696.6 cw(c1819.32,4656.43) 1876.12,4656.43 cw(c1932.92,4656.43) UH1.19@1892.76,4696.6 ; UH1.19@1862.31,4699.43 cw(c1828.98,4666.09) 1876.12,4666.09 cw(c1923.26,4666.09) UH1.19@1889.93,4699.43 ; UH1.19@1865.14,4702.26 cw(c1838.63,4675.75) 1876.12,4675.75 cw(c1913.61,4675.75) UH1.19@1887.1,4702.26 ; v1@4765,4320.5 cw(c4765,4297.57) 4781.22,4313.78 cw(c4797.44,4330) v1@4774.5,4330 ; v1@4765,4324.5 cw(c4765,4311.22) 4774.39,4320.61 cw(c4783.78,4330) v1@4770.5,4330 ; v1(4765,4330) 4791.07,4303.93 4830.82,4303.93 4838.82,4303.93 4878.16,4303.93 cw(c4878.16,4293.78) 4885.34,4300.96 ; U8.M2@4890.53,4288.42 ccw(c4872.81,4288.42) 4885.34,4300.96 ; U8.M2@4897.87,4295.77 cw(c4897.87,4313.49) 4885.34,4300.96
  MidLayer2 w4: v1(756.86,4458.37) 798.52,4500.04 1431.86,4500.04 v1(1473.52,4541.71) 1533.34,4481.89 4272.04,4481.89 4290.19,4500.04 4310,4500.04 4322.19,4500.04 4325.25,4500.04 4366.91,4458.37 4406.7,4418.59 4406.7,4408.14 4479.84,4335 4481.84,4333 4568.19,4333 ; v1@756.86,4463.87 ccw(c756.86,4477.15) 766.25,4467.76 ccw(c775.64,4458.37) v1@762.36,4458.37 ; v1@756.86,4467.87 ccw(c756.86,4490.81) 773.07,4474.59 ccw(c789.29,4458.37) v1@766.36,4458.37 ; v1@1464.02,4541.71 cw(c1441.09,4541.71) 1457.31,4525.49 cw(c1473.52,4509.27) 1473.52,4532.21 cw(c1473.52,4509.27) 1489.74,4525.49 cw(c1505.96,4541.71) v1@1483.02,4541.71 ; v1@1468.02,4541.71 cw(c1454.75,4541.71) 1464.14,4532.32 cw(c1473.52,4522.93) 1473.52,4536.21 cw(c1473.52,4522.93) 1482.91,4532.32 cw(c1492.3,4541.71) v1@1479.02,4541.71 ; v1(4765,4330) 4761.72,4326.72 4752.66,4326.72 4744.66,4334.72 4726.66,4334.72 4709.13,4317.19 4629.37,4317.19 4622.75,4323.81 4577.38,4323.81 ; 4568.19,4333 4577.38,4323.81 ; 4568.19,4333 4577.38,4323.81
  Bottom Layer w4: v1(-586.48,3225.04) -109.96,3225.04 v1(-40,3295) ; v1@-582.59,3221.15 cw(c-573.2,3211.76) -573.2,3225.04 cw(c-573.2,3238.32) v1@-582.59,3228.93 ; v1@-579.76,3218.32 cw(c-563.54,3202.11) -563.54,3225.04 cw(c-563.54,3247.98) v1@-579.76,3231.76 ; v1@-49.5,3295 cw(c-72.44,3295) -56.22,3278.78 cw(c-40,3262.56) v1@-40,3285.5 ; v1@-45.5,3295 cw(c-58.78,3295) -49.39,3285.61 cw(c-40,3276.22) v1@-40,3289.5 ; v1(106.86,4375.04) 176.82,4445 743.48,4445 v1(756.86,4458.37) ; v1@106.86,4380.54 ccw(c106.86,4393.82) 116.25,4384.43 ccw(c125.64,4375.04) v1@112.36,4375.04 ; v1@106.86,4384.54 ccw(c106.86,4407.48) 123.07,4391.26 ccw(c139.29,4375.04) v1@116.36,4375.04 ; v1(1473.52,4541.71) 1590.19,4658.37 1715.19,4658.37 1723.52,4666.71 1723.52,4725.04 1748.52,4750.04 1839.32,4750.04 ; v1@1473.52,4547.21 ccw(c1473.52,4560.49) 1482.91,4551.1 ccw(c1492.3,4541.71) v1@1479.02,4541.71 ; v1@1473.52,4551.21 ccw(c1473.52,4574.14) 1489.74,4557.93 ccw(c1505.96,4541.71) v1@1483.02,4541.71 ; UH1.19@1849.08,4718.37 ccw(c1814.25,4724.98) 1839.32,4750.04 ; UH1.19@1853.01,4717.62 ccw(c1823.24,4723.27) 1844.66,4744.69 ccw(c1866.09,4766.11) UH1.19@1871.73,4736.35 ; UH1.19@1856.94,4716.88 ccw(c1832.23,4721.56) 1850.01,4739.34 ccw(c1867.79,4757.12) UH1.19@1872.48,4732.42 ; UH1.19@1870.99,4740.28 cw(c1864.38,4775.1) 1839.32,4750.04 ; UH1.19@1873.73,4715.62 1839.32,4750.04
ATE.UIO.IO18: J33.A27 PROTOTYPE1.H17 U8.J4 UH2.2 | length 9384.6
  Top Layer w4: J33.A27@-785.98,3164.67 -717.09,3164.67 -690.05,3191.71 -668.14,3191.71 -626.48,3150.04 v1(-591.81,3150.04) ; J33.A27@-717.08,3172.45 ccw(c-717.08,3191.23) -703.81,3177.95 ccw(c-690.52,3164.67) J33.A27@-709.3,3164.67 ; J33.A27@-717.08,3176.45 ccw(c-717.08,3204.89) -696.98,3184.78 ccw(c-676.86,3164.67) J33.A27@-705.3,3164.67 ; v1@-598.53,3143.32 ccw(c-614.74,3127.11) -614.74,3150.04 ccw(c-614.74,3172.98) v1@-598.53,3156.76 ; v1@-595.7,3146.15 ccw(c-605.09,3136.76) -605.09,3150.04 ccw(c-605.09,3163.32) v1@-595.7,3153.93 ; PROTOTYPE1.H17@1876.12,4208.23 1948.52,4280.64 1948.52,4841.71 1965.19,4858.37 2249.9,4858.37 2295.04,4813.23 UH2.2@2373.76,4813.23 ; PROTOTYPE1.H17@1876.12,4221.23 ccw(c1876.12,4252.62) 1898.31,4230.43 ccw(c1920.51,4208.23) PROTOTYPE1.H17@1889.12,4208.23 ; PROTOTYPE1.H17@1876.12,4225.23 ccw(c1876.12,4266.28) 1905.14,4237.26 ccw(c1934.16,4208.23) PROTOTYPE1.H17@1893.12,4208.23 ; PROTOTYPE1.H17@1876.12,4229.23 ccw(c1876.12,4279.93) 1911.97,4244.08 ccw(c1947.82,4208.23) PROTOTYPE1.H17@1897.12,4208.23 ; PROTOTYPE1.H17@1876.12,4233.23 ccw(c1876.12,4293.59) 1918.8,4250.91 ccw(c1961.48,4208.23) PROTOTYPE1.H17@1901.12,4208.23 ; PROTOTYPE1.H17@1876.12,4237.23 ccw(c1876.12,4307.25) 1925.63,4257.74 ccw(c1975.13,4208.23) PROTOTYPE1.H17@1905.12,4208.23 ; UH2.2@2354.29,4793.77 ccw(c2307.3,4746.78) 2307.3,4813.23 ccw(c2307.3,4879.69) UH2.2@2354.29,4832.7 ; UH2.2@2357.12,4796.6 ccw(c2316.96,4756.43) 2316.96,4813.23 ccw(c2316.96,4870.04) UH2.2@2357.12,4829.87 ; UH2.2@2359.95,4799.43 ccw(c2326.62,4766.09) 2326.62,4813.23 ccw(c2326.61,4860.38) UH2.2@2359.95,4827.04 ; UH2.2@2362.78,4802.25 ccw(c2336.27,4775.75) 2336.27,4813.23 ccw(c2336.27,4850.72) UH2.2@2362.78,4824.21 ; v3(4956.93,4426.22) U8.J4@4976.61,4406.54 ; U8.J4@4969.27,4406.54 ccw(c4951.55,4406.54) 4964.08,4419.07 ccw(c4976.61,4431.6) U8.J4@4976.61,4413.88 ; 4969.73,4413.42 cw(c4982.54,4426.22) 4964.43,4426.22 ccw(c4982.54,4426.22) 4969.73,4413.42 ; 4969.73,4413.42 ccw(c4956.93,4400.61) 4956.93,4418.72 cw(c4956.93,4400.61) 4969.73,4413.42
  MidLayer1 w4: v1(3948.52,4950.04) 3990.19,4991.71 3996.29,4997.81 4087.38,4997.81 4165.69,4919.5 4165.69,4905.15 4254.29,4816.54 4256.42,4816.54 4331.86,4741.1 4331.86,4713.37 4589.5,4455.73 4591.36,4453.87 4605.23,4440 4635.15,4440 4723.07,4440 4730.86,4432.21 4824.83,4432.21 4830.82,4426.22 4838.82,4426.22 4879.25,4426.22 v3(4956.93,4426.22) ; v1@3948.52,4955.54 ccw(c3948.52,4968.82) 3957.91,4959.43 ccw(c3967.3,4950.04) v1@3954.02,4950.04 ; v1@3948.52,4959.54 ccw(c3948.52,4982.48) 3964.74,4966.26 ccw(c3980.96,4950.04) v1@3958.02,4950.04 ; v3@4951.63,4420.92 ccw(c4938.82,4408.11) 4938.82,4426.22 ccw(c4938.82,4444.33) v3@4951.63,4431.52 ; v3@4951.74,4421.03 ccw(c4939.2,4408.49) 4939.2,4426.22 ccw(c4939.2,4443.95) v3@4951.74,4431.41
  MidLayer2 w4: v1(-591.81,3150.04) -559.81,3182.04 -559.81,3542.96 -568.31,3551.46 -568.31,3623.95 -465,3727.26 -465,3986.52 -376.48,4075.04 -183.81,4075.04 -167.14,4058.37 -166.27,4057.5 -117.35,4057.5 -104.35,4070.5 -57.02,4070.5 -22.52,4105 26.9,4105 65.19,4066.71 1398.52,4066.71 1423.52,4091.71 1423.52,4125.04 1448.52,4150.04 1817.93,4150.04 PROTOTYPE1.H17@1876.12,4208.23 ; v1@-591.81,3155.54 ccw(c-591.81,3168.82) -582.42,3159.43 ccw(c-573.03,3150.04) v1@-586.31,3150.04 ; v1@-591.81,3159.54 ccw(c-591.81,3182.48) -575.59,3166.26 ccw(c-559.37,3150.04) v1@-582.31,3150.04 ; PROTOTYPE1.H17@1847.12,4208.23 cw(c1777.11,4208.23) 1826.62,4158.73 cw(c1876.12,4109.22) PROTOTYPE1.H17@1876.12,4179.23 ; PROTOTYPE1.H17@1851.12,4208.23 cw(c1790.77,4208.23) 1833.44,4165.56 cw(c1876.12,4122.88) PROTOTYPE1.H17@1876.12,4183.23 ; PROTOTYPE1.H17@1855.12,4208.23 cw(c1804.42,4208.23) 1840.27,4172.39 cw(c1876.12,4136.54) PROTOTYPE1.H17@1876.12,4187.23 ; PROTOTYPE1.H17@1859.12,4208.23 cw(c1818.08,4208.23) 1847.1,4179.21 cw(c1876.12,4150.19) PROTOTYPE1.H17@1876.12,4191.23 ; PROTOTYPE1.H17@1863.12,4208.23 cw(c1831.74,4208.23) 1853.93,4186.04 cw(c1876.12,4163.85) PROTOTYPE1.H17@1876.12,4195.23
  Bottom Layer w4: UH2.2@2373.76,4813.23 2420.05,4813.23 2481.86,4875.04 3873.52,4875.04 v1(3948.52,4950.04) ; UH2.2@2390.92,4803.91 cw(c2406.6,4795.39) 2406.6,4813.23 cw(c2406.6,4831.08) UH2.2@2390.92,4822.56 ; UH2.2@2394.43,4802 cw(c2413.32,4791.73) 2413.32,4813.23 cw(c2413.32,4834.73) UH2.2@2394.43,4824.47 ; UH2.2@2397.95,4800.09 cw(c2420.05,4788.08) 2420.05,4813.23 cw(c2420.05,4838.39) UH2.2@2397.95,4826.38 ; v1@3939.02,4950.04 cw(c3916.09,4950.04) 3932.31,4933.82 cw(c3948.52,4917.61) v1@3948.52,4940.54 ; v1@3943.02,4950.04 cw(c3929.75,4950.04) 3939.14,4940.65 cw(c3948.52,4931.26) v1@3948.52,4944.54
ATE.UIO.IO19: J33.A28 PROTOTYPE1.H18 U8.L2 UH2.3 | length 10394.6
  Top Layer w4: J33.A28@-785.98,3125.3 -696.48,3125.3 ; J33.A28@-706.93,3119.32 cw(c-696.48,3113.16) -696.48,3125.3 ; J33.A28@-706.93,3131.28 ccw(c-696.48,3137.44) -696.48,3125.3 ; v1@-658.19,3121.66 ccw(c-674.41,3105.44) -674.41,3128.37 ccw(c-674.41,3151.31) v1@-658.19,3135.09 ; v1@-655.36,3124.49 ccw(c-664.75,3115.1) -664.75,3128.37 ccw(c-664.75,3141.65) v1@-655.36,3132.26 ; v1(-651.48,3128.37) -693.4,3128.37 -696.48,3125.3 ; PROTOTYPE1.H18@1955.62,4228.74 ccw(c1906.11,4278.25) 1976.12,4278.25 ccw(c2046.13,4278.25) PROTOTYPE1.H18@1996.63,4228.74 ; PROTOTYPE1.H18@1958.44,4225.91 ccw(c1915.77,4268.59) 1976.12,4268.59 ccw(c2036.48,4268.59) PROTOTYPE1.H18@1993.8,4225.91 ; PROTOTYPE1.H18@1961.27,4223.08 ccw(c1925.42,4258.93) 1976.12,4258.93 ccw(c2026.82,4258.93) PROTOTYPE1.H18@1990.97,4223.08 ; PROTOTYPE1.H18@1964.1,4220.26 ccw(c1935.08,4249.28) 1976.12,4249.28 ccw(c2017.16,4249.28) PROTOTYPE1.H18@1988.14,4220.26 ; PROTOTYPE1.H18@1966.93,4217.43 ccw(c1944.74,4239.62) 1976.12,4239.62 ccw(c2007.51,4239.62) PROTOTYPE1.H18@1985.31,4217.43 ; PROTOTYPE1.H18@1976.12,4208.23 1976.12,4611.12 2040.04,4675.04 2435.57,4675.04 ; UH2.3@2446.57,4708.92 cw(c2407.83,4702.78) 2435.57,4675.04 ; UH2.3@2450.52,4709.55 cw(c2417.41,4704.3) 2441.12,4680.59 cw(c2464.82,4656.89) UH2.3@2470.07,4690 ; UH2.3@2454.47,4710.17 cw(c2426.99,4705.82) 2446.67,4686.14 cw(c2466.34,4666.47) UH2.3@2470.7,4693.95 ; UH2.3@2458.42,4710.8 cw(c2436.57,4707.33) 2452.22,4691.69 cw(c2467.86,4676.05) UH2.3@2471.33,4697.9 ; UH2.3@2469.45,4686.05 ccw(c2463.3,4647.31) 2435.57,4675.04 ; UH2.3@2473.76,4713.23 2435.57,4675.04 ; v1@4517,4394.5 ccw(c4517,4407.78) 4526.39,4398.39 ccw(c4535.78,4389) v1@4522.5,4389 ; v1@4517,4398.5 ccw(c4517,4421.43) 4533.22,4405.22 ccw(c4549.43,4389) v1@4526.5,4389 ; v1@4526.63,4389 v1(4517,4389) 4535.5,4407.5 4545.13,4407.5 ; U8.L2@4890.53,4327.79 ccw(c4872.81,4327.79) 4885.34,4340.33 ; U8.L2@4897.87,4335.14 cw(c4897.87,4352.86) 4885.34,4340.33 ; 4545.13,4407.5 4555,4407.5 ; 4545.13,4407.5 4555,4407.5 ; 4555,4407.5 4628.5,4407.5 4635.59,4414.59 4716.91,4414.59 4733.73,4397.77 4745.61,4397.77 4782.74,4360.64 4800.07,4343.3 4805,4343.3 4830.82,4343.3 4838.82,4343.3 4878.16,4343.3 cw(c4878.16,4333.15) 4885.34,4340.33
  MidLayer1 w4: v1@-658.19,3135.09 ccw(c-674.41,3151.31) -651.48,3151.31 ccw(c-628.54,3151.31) v1@-644.76,3135.09 ; v1@-655.36,3132.26 ccw(c-664.75,3141.65) -651.48,3141.65 ccw(c-638.2,3141.65) v1@-647.59,3132.26 ; v1(-651.48,3128.37) -651.48,3195 -577,3269.48 -577,3432.85 -476.81,3533.04 -476.81,4113.26 -452,4138.06 -452,4211.93 -476.81,4236.74 -476.81,4583.19 v1(-455,4605)
  MidLayer2 w4: v1(-455,4605) -322.72,4605 -288.6,4570.87 -219.43,4570.87 -188.93,4601.37 86.63,4601.37 162.03,4676.78 197.25,4712 411.56,4712 479.75,4643.81 977.38,4643.81 1013.48,4607.71 1631.39,4607.71 1648.39,4624.71 2454.71,4624.71 2473.76,4643.76 UH2.3@2473.76,4713.23 ; v1@-451.11,4601.11 cw(c-441.72,4591.72) -441.72,4605 cw(c-441.72,4618.28) v1@-451.11,4608.89 ; v1@-448.28,4598.28 cw(c-432.07,4582.06) -432.07,4605 cw(c-432.07,4627.93) v1@-448.28,4611.72 ; UH2.3@2454.29,4693.77 cw(c2407.3,4646.78) 2473.76,4646.78 cw(c2540.22,4646.78) UH2.3@2493.22,4693.77 ; UH2.3@2457.12,4696.6 cw(c2416.96,4656.43) 2473.76,4656.43 cw(c2530.56,4656.43) UH2.3@2490.4,4696.6 ; UH2.3@2459.95,4699.43 cw(c2426.62,4666.09) 2473.76,4666.09 cw(c2520.9,4666.09) UH2.3@2487.57,4699.43 ; UH2.3@2462.78,4702.25 cw(c2436.27,4675.75) 2473.76,4675.75 cw(c2511.25,4675.75) UH2.3@2484.74,4702.25
  Bottom Layer w4: UH2.3@2474.21,4728.76 ccw(c2475.19,4762.73) 2499.22,4738.7 ccw(c2523.25,4714.66) UH2.3@2489.28,4713.68 ; UH2.3@2474.32,4732.75 ccw(c2475.56,4775.48) 2505.78,4745.25 ccw(c2536,4715.03) UH2.3@2493.28,4713.8 ; UH2.3@2474.44,4736.75 ccw(c2475.92,4788.23) 2512.34,4751.81 ccw(c2548.75,4715.4) UH2.3@2497.28,4713.91 ; UH2.3@2474.55,4740.75 ccw(c2476.29,4800.98) 2518.9,4758.37 ccw(c2561.5,4715.77) UH2.3@2501.27,4714.03 ; v1@4510.28,4395.72 ccw(c4485.66,4420.34) 4520.48,4420.34 ; v1@4513.11,4392.89 ccw(c4495.32,4410.68) 4520.48,4410.68 ; v1@4515.94,4390.06 ccw(c4504.98,4401.02) 4520.48,4401.02 ; v1(4517,4389) 4520.48,4392.48 4520.48,4479.58 4517,4483.06 4517,4537 4581.86,4601.86 4581.86,4755.85 4570,4767.71 4380.79,4767.71 4377.03,4763.95 4329.14,4763.95 4325.39,4767.71 3329.02,4767.71 3319.69,4758.37 2518.9,4758.37 UH2.3@2490.19,4729.67 ; 4520.48,4403.53 ccw(c4531.53,4403.53) v1@4523.72,4395.72 ; UH2.3@2490.19,4729.67 UH2.3@2473.76,4713.23 2490.19,4713.23 UH2.3@2490.19,4729.67
ATE.UIO.IO20: J33.A29 PROTOTYPE1.H19 U8.J7 UH2.4 | length 12891.3
  Top Layer w4: J33.A29@-785.98,3085.93 -657.25,3085.93 -626.48,3116.71 v1(-600.48,3116.71) ; J33.A29@-711.58,3080.43 cw(c-698.3,3067.15) -698.3,3085.93 cw(c-698.3,3104.71) J33.A29@-711.58,3091.43 ; J33.A29@-708.76,3077.6 cw(c-688.65,3057.49) -688.65,3085.93 cw(c-688.65,3114.37) J33.A29@-708.76,3094.26 ; v1@-607.19,3109.99 ccw(c-623.41,3093.77) -623.41,3116.71 ccw(c-623.41,3139.64) v1@-607.19,3123.43 ; v1@-604.36,3112.82 ccw(c-613.75,3103.43) -613.75,3116.71 ccw(c-613.75,3129.99) v1@-604.36,3120.6 ; PROTOTYPE1.H19@2055.62,4228.74 ccw(c2006.11,4278.25) 2076.12,4278.25 ccw(c2146.13,4278.25) PROTOTYPE1.H19@2096.63,4228.74 ; PROTOTYPE1.H19@2058.44,4225.91 ccw(c2015.77,4268.59) 2076.12,4268.59 ccw(c2136.48,4268.59) PROTOTYPE1.H19@2093.8,4225.91 ; PROTOTYPE1.H19@2061.27,4223.08 ccw(c2025.42,4258.93) 2076.12,4258.93 ccw(c2126.82,4258.93) PROTOTYPE1.H19@2090.97,4223.08 ; PROTOTYPE1.H19@2064.1,4220.26 ccw(c2035.08,4249.28) 2076.12,4249.28 ccw(c2117.16,4249.28) PROTOTYPE1.H19@2088.14,4220.26 ; PROTOTYPE1.H19@2066.93,4217.43 ccw(c2044.74,4239.62) 2076.12,4239.62 ccw(c2107.51,4239.62) PROTOTYPE1.H19@2085.31,4217.43 ; PROTOTYPE1.H19@2076.12,4208.23 2076.12,4656.12 2086.71,4666.71 2487.86,4666.71 2515.19,4694.04 2515.19,4771.8 ; UH2.4@2446.23,4813.23 ccw(c2379.77,4813.23) 2426.77,4860.23 ccw(c2473.76,4907.22) UH2.4@2473.76,4840.76 ; UH2.4@2450.23,4813.23 ccw(c2393.43,4813.23) 2433.59,4853.4 ccw(c2473.76,4893.56) UH2.4@2473.76,4836.76 ; UH2.4@2454.23,4813.23 ccw(c2407.09,4813.23) 2440.42,4846.57 ccw(c2473.76,4879.91) UH2.4@2473.76,4832.76 ; UH2.4@2458.23,4813.23 ccw(c2420.74,4813.23) 2447.25,4839.74 ccw(c2473.76,4866.25) UH2.4@2473.76,4828.76 ; UH2.4@2475.2,4797.77 cw(c2477.75,4770.48) 2497.13,4789.86 cw(c2516.51,4809.25) UH2.4@2489.22,4811.79 ; UH2.4@2475.57,4793.79 cw(c2478.78,4759.47) 2503.15,4783.84 cw(c2527.52,4808.22) UH2.4@2493.2,4811.42 ; UH2.4@2475.94,4789.81 cw(c2479.8,4748.46) 2509.17,4777.82 cw(c2538.53,4807.19) UH2.4@2497.18,4811.05 ; UH2.4@2476.32,4785.83 cw(c2480.83,4737.45) 2515.19,4771.8 ; UH2.4@2501.17,4810.68 ccw(c2549.55,4806.16) 2515.19,4771.8 ; v1@4864.02,5125.04 ccw(c4841.09,5125.04) 4857.31,5141.26 ccw(c4873.52,5157.48) v1@4873.52,5134.54 ; v1@4868.02,5125.04 ccw(c4854.75,5125.04) 4864.14,5134.43 ccw(c4873.52,5143.82) v1@4873.52,5130.54 ; v1(4873.52,5125.04) 4815.19,5183.37 4731.86,5183.37 4648.19,5267.04 4648.19,5495.02 4556.86,5586.36 4556.86,6058.37 4481.86,6133.37 3751.67,6133.37 3735,6150.04 3106.86,6150.04 3090.19,6133.37 3090.19,5091.71 3073.48,5075 2115,5075 2095,5055 2095,4875 2103.29,4866.71 2420.29,4866.71 UH2.4@2473.41,4813.58 ; v3(5075.04,4426.22) U8.J7@5094.72,4406.54 ; U8.J7@5087.38,4406.54 ccw(c5069.66,4406.54) 5082.19,4419.07 ccw(c5094.72,4431.6) U8.J7@5094.72,4413.88 ; UH2.4@2473.41,4813.58 UH2.4@2473.76,4813.23 ; UH2.4@2473.41,4813.58 UH2.4@2473.76,4813.23 ; UH2.4@2473.76,4813.23 2515.19,4771.8 ; 5087.84,4413.42 cw(c5100.65,4426.22) 5082.54,4426.22 ccw(c5100.65,4426.22) 5087.84,4413.42 ; 5087.84,4413.42 ccw(c5075.04,4400.61) 5075.04,4418.72 cw(c5075.04,4400.61) 5087.84,4413.42
  MidLayer2 w4: v1@-600.48,3122.21 ccw(c-600.48,3137.09) -589.95,3126.57 ; v1@-600.48,3126.21 ccw(c-600.48,3150.75) -583.12,3133.4 ; v1@-599.81,3116.71 -551.48,3165.04 -551.48,3545.94 -560.31,3554.78 -560.31,3620.64 -457,3723.95 -457,3983.2 -373.5,4066.71 -186.79,4066.71 -169.58,4049.5 -114.04,4049.5 -101.04,4062.5 -96.35,4062.5 -95,4062.5 -53.7,4062.5 -19.2,4097 23.58,4097 62.21,4058.37 2015.19,4058.37 2031.86,4075.04 2031.86,4163.97 ; v1@-594.98,3116.71 cw(c-583.31,3116.71) -591.56,3124.96 ; v1@-590.98,3116.71 cw(c-569.65,3116.71) -584.73,3131.79 ; PROTOTYPE1.H19@2047.22,4205.85 cw(c1994.34,4201.49) 2031.86,4163.97 ; PROTOTYPE1.H19@2051.21,4206.18 cw(c2005.62,4202.42) 2037.96,4170.08 cw(c2070.31,4137.74) PROTOTYPE1.H19@2074.07,4183.32 ; PROTOTYPE1.H19@2055.19,4206.51 cw(c2016.9,4203.35) 2044.07,4176.18 cw(c2071.24,4149.02) PROTOTYPE1.H19@2074.39,4187.31 ; PROTOTYPE1.H19@2059.18,4206.84 cw(c2028.18,4204.28) 2050.17,4182.29 cw(c2072.17,4160.3) PROTOTYPE1.H19@2074.72,4191.29 ; PROTOTYPE1.H19@2073.74,4179.33 ccw(c2069.37,4126.46) 2031.86,4163.97 ; PROTOTYPE1.H19@2076.12,4208.23 2031.86,4163.97 ; v1@4864.02,5125.04 cw(c4841.09,5125.04) 4857.31,5108.82 cw(c4873.52,5092.61) v1@4873.52,5115.54 ; v1@4868.02,5125.04 cw(c4854.75,5125.04) 4864.14,5115.65 cw(c4873.52,5106.26) v1@4873.52,5119.54 ; v1(4873.52,5125.04) 4799.36,5050.87 4799.36,4941.93 4782.13,4924.7 4782.13,4813.39 4773.52,4804.79 4773.52,4451.48 4783.27,4441.73 4957.99,4441.73 4977.41,4441.73 5037.6,4441.73 5051.53,4441.73 cw(c5051.53,4427.68) 5061.46,4437.61 ; v3@5067.57,4425.57 ccw(c5049.53,4423.99) 5061.17,4437.86 ccw(c5072.81,4451.73) v3@5074.39,4433.69
ATE.UIO.IO21: J33.A30 PROTOTYPE1.H20 U8.K7 UH2.5 | length 9818.5
  Top Layer w4: J33.A30@-785.98,3046.56 -696.62,3046.56 ; J33.A30@-706.9,3040.65 cw(c-696.62,3034.68) -696.62,3046.56 ; J33.A30@-706.9,3052.48 ccw(c-696.62,3058.44) -696.62,3046.56 ; v1@-646.19,3068.32 ccw(c-662.41,3052.11) -662.41,3075.04 ccw(c-662.41,3097.98) v1@-646.19,3081.76 ; v1@-643.36,3071.15 ccw(c-652.75,3061.76) -652.75,3075.04 ccw(c-652.75,3088.32) v1@-643.36,3078.93 ; v1(-639.48,3075.04) -668.14,3075.04 -696.62,3046.56 ; v1(2175,4425.04) 2460.04,4425.04 2523.52,4488.52 2523.52,4841.71 2540.19,4858.37 2615.19,4858.37 ; v1@2178.89,4421.15 cw(c2188.28,4411.76) 2188.28,4425.04 cw(c2188.28,4438.32) v1@2178.89,4428.93 ; v1@2181.72,4418.32 cw(c2197.93,4402.11) 2197.93,4425.04 cw(c2197.93,4447.98) v1@2181.72,4431.76 ; UH2.5@2573.76,4713.23 2573.76,4716.71 2606.86,4716.71 ; UH2.5@2599.94,4721.73 ccw(c2606.86,4723.98) 2606.86,4716.71 ; UH2.5@2601.23,4711.44 cw(c2606.86,4711.07) 2606.86,4716.71 ; v1@3214.02,5133.37 cw(c3191.09,5133.37) 3207.31,5117.16 cw(c3223.52,5100.94) v1@3223.52,5123.87 ; v1@3218.02,5133.37 cw(c3204.75,5133.37) 3214.14,5123.99 cw(c3223.52,5114.6) v1@3223.52,5127.87 ; v1(3223.52,5133.37) 3098.52,5008.37 2631.86,5008.37 2615.19,4991.71 2615.19,4858.37 ; v3(5075.04,4386.85) U8.K7@5094.72,4367.17 ; U8.K7@5087.38,4367.17 ccw(c5069.66,4367.17) 5082.19,4379.7 ccw(c5094.72,4392.23) U8.K7@5094.72,4374.51 ; 2606.86,4716.71 2615.19,4725.04 2615.19,4858.37 ; 5087.84,4374.05 cw(c5100.65,4386.85) 5082.54,4386.85 ccw(c5100.65,4386.85) 5087.84,4374.05 ; 5087.84,4374.05 ccw(c5075.04,4361.24) 5075.04,4379.35 cw(c5075.04,4361.24) 5087.84,4374.05
  MidLayer1 w4: v1(-639.48,3075.04) -558.65,3075.04 -537,3096.69 -537,3204.51 -536.98,3416.31 -436.81,3516.47 -436.81,3741.13 -301.23,3876.71 -301.23,4000.15 -303,4001.92 -303,4151.5 -102.81,4351.69 v1(-102.81,4375.04) ; v1@-109.53,4368.32 cw(c-125.74,4352.11) -102.81,4352.11 cw(c-79.87,4352.11) v1@-96.09,4368.32 ; v1@-106.7,4371.15 cw(c-116.09,4361.76) -102.81,4361.76 cw(c-89.53,4361.76) v1@-98.92,4371.15 ; PROTOTYPE1.H20@2155.62,4228.74 ccw(c2106.11,4278.25) 2176.12,4278.25 ccw(c2246.13,4278.25) PROTOTYPE1.H20@2196.63,4228.74 ; PROTOTYPE1.H20@2158.44,4225.91 ccw(c2115.77,4268.59) 2176.12,4268.59 ccw(c2236.48,4268.59) PROTOTYPE1.H20@2193.8,4225.91 ; PROTOTYPE1.H20@2161.27,4223.08 ccw(c2125.42,4258.93) 2176.12,4258.93 ccw(c2226.82,4258.93) PROTOTYPE1.H20@2190.97,4223.08 ; PROTOTYPE1.H20@2164.1,4220.26 ccw(c2135.08,4249.28) 2176.12,4249.28 ccw(c2217.16,4249.28) PROTOTYPE1.H20@2188.14,4220.26 ; PROTOTYPE1.H20@2166.93,4217.43 ccw(c2144.74,4239.62) 2176.12,4239.62 ccw(c2207.51,4239.62) PROTOTYPE1.H20@2185.31,4217.43 ; v1@2168.28,4418.32 cw(c2152.06,4402.11) 2175,4402.11 cw(c2197.93,4402.11) v1@2181.72,4418.32 ; v1@2171.11,4421.15 cw(c2161.72,4411.76) 2175,4411.76 cw(c2188.28,4411.76) v1@2178.89,4421.15 ; v1(2175,4425.04) 2175,4281.12 2176.12,4280 PROTOTYPE1.H20@2176.12,4208.23
  MidLayer2 w4: v1@4775.14,5036.32 cw(c4758.92,5020.11) 4781.86,5020.11 cw(c4804.79,5020.11) v1@4788.57,5036.32 ; v1@4777.97,5039.15 cw(c4768.58,5029.76) 4781.86,5029.76 cw(c4795.14,5029.76) v1@4785.75,5039.15 ; v1(4781.86,5043.04) 4781.86,4935.74 4774.13,4928.02 4774.13,4816.71 4764.81,4807.38 4764.81,4415.54 4790.35,4390 4820.6,4390 4832.9,4402.3 4838.82,4402.36 4957.99,4402.36 5051.53,4402.36 cw(c5051.53,4388.31) 5061.46,4398.24 ; v3@5067.57,4386.2 ccw(c5049.53,4384.62) 5061.17,4398.49 ccw(c5072.81,4412.36) v3@5074.39,4394.32
  Bottom Layer w4: v1(-102.81,4375.04) -60,4375.04 -46.04,4389 56.63,4389 80.34,4412.72 120.63,4453 700.63,4453 724.19,4476.56 1063.67,4476.56 1089.76,4450.48 1115.19,4425.04 1132.19,4408.04 1518.31,4408.04 1543.98,4382.37 2132.33,4382.37 v1(2175,4425.04) ; v1@-98.92,4371.15 cw(c-89.53,4361.76) -89.53,4375.04 cw(c-89.53,4388.32) v1@-98.92,4378.93 ; v1@-96.09,4368.32 cw(c-79.87,4352.11) -79.87,4375.04 cw(c-79.87,4397.98) v1@-96.09,4381.76 ; v1@2165.5,4425.04 cw(c2142.56,4425.04) 2158.78,4408.82 cw(c2175,4392.61) v1@2175,4415.54 ; v1@2169.5,4425.04 cw(c2156.22,4425.04) 2165.61,4415.65 cw(c2175,4406.26) v1@2175,4419.54 ; v1(3223.52,5133.37) 3224.34,5134.19 4690.71,5134.19 4691.52,5133.37 v1(4781.86,5043.04) ; v1@3227.41,5129.49 cw(c3238.77,5118.13) 3238.77,5134.19 ; v1@3230.24,5126.66 cw(c3248.42,5108.47) 3248.42,5134.19 ; v1@3230.24,5140.09 ccw(c3244.49,5154.34) 3244.49,5134.19 ; v1@4772.36,5043.04 ccw(c4749.42,5043.04) 4765.64,5059.26 ccw(c4781.86,5075.48) v1@4781.86,5052.54 ; v1@4776.36,5043.04 ccw(c4763.08,5043.04) 4772.47,5052.43 ccw(c4781.86,5061.82) v1@4781.86,5048.54
ATE.UIO.IO22: J33.A31 PROTOTYPE1.H21 U8.J6 UH2.6 | length 10023.3
  Top Layer w4: J33.A31@-785.98,3007.19 -770,3007.19 -767.19,3010 -712.77,3010 v1(-677.14,2974.37) ; J33.A31@-717.08,2999.41 cw(c-717.08,2963.43) -691.64,2988.87 ; J33.A31@-717.08,3003.41 cw(c-717.08,2977.09) -698.47,2995.7 ; J33.A31@-705.3,3007.19 ccw(c-694.07,3007.19) -702.01,2999.25 ; v1@-686.64,2974.37 ccw(c-709.58,2974.37) -693.36,2990.59 ccw(c-677.14,3006.81) v1@-677.14,2983.87 ; v1@-682.64,2974.37 ccw(c-695.92,2974.37) -686.53,2983.76 ccw(c-677.14,2993.15) v1@-677.14,2979.87 ; PROTOTYPE1.H21@2276.12,4208.23 2531.86,4463.97 2531.86,4771.33 ; PROTOTYPE1.H21@2276.12,4221.23 ccw(c2276.12,4252.62) 2298.31,4230.43 ccw(c2320.51,4208.23) PROTOTYPE1.H21@2289.12,4208.23 ; PROTOTYPE1.H21@2276.12,4225.23 ccw(c2276.12,4266.28) 2305.14,4237.26 ccw(c2334.16,4208.23) PROTOTYPE1.H21@2293.12,4208.23 ; PROTOTYPE1.H21@2276.12,4229.23 ccw(c2276.12,4279.93) 2311.97,4244.08 ccw(c2347.82,4208.23) PROTOTYPE1.H21@2297.12,4208.23 ; PROTOTYPE1.H21@2276.12,4233.23 ccw(c2276.12,4293.59) 2318.8,4250.91 ccw(c2361.48,4208.23) PROTOTYPE1.H21@2301.12,4208.23 ; PROTOTYPE1.H21@2276.12,4237.23 ccw(c2276.12,4307.25) 2325.63,4257.74 ccw(c2375.13,4208.23) PROTOTYPE1.H21@2305.12,4208.23 ; UH2.6@2546.33,4810.91 cw(c2496.5,4806.7) 2531.86,4771.33 ; UH2.6@2550.31,4811.25 cw(c2507.72,4807.65) 2537.95,4777.42 cw(c2568.17,4747.2) UH2.6@2571.78,4789.79 ; UH2.6@2554.3,4811.59 cw(c2518.95,4808.6) 2544.04,4783.51 cw(c2569.12,4758.42) UH2.6@2572.11,4793.78 ; UH2.6@2558.29,4811.93 cw(c2530.18,4809.55) 2550.12,4789.6 cw(c2570.07,4769.65) UH2.6@2572.45,4797.76 ; UH2.6@2571.44,4785.8 ccw(c2567.22,4735.97) 2531.86,4771.33 ; UH2.6@2573.76,4813.23 2531.86,4771.33 ; v3(5035.67,4426.22) U8.J6@5055.35,4406.54 ; U8.J6@5048.01,4406.54 ccw(c5030.29,4406.54) 5042.82,4419.07 ccw(c5055.35,4431.6) U8.J6@5055.35,4413.88 ; 5048.47,4413.42 cw(c5061.28,4426.22) 5043.17,4426.22 ccw(c5061.28,4426.22) 5048.47,4413.42 ; 5048.47,4413.42 ccw(c5035.67,4400.61) 5035.67,4418.72 cw(c5035.67,4400.61) 5048.47,4413.42
  MidLayer1 w4: v1(2100.52,3277.04) 2231.86,3408.37 2231.86,4163.97 ; v1@2100.52,3282.54 ccw(c2100.52,3295.82) 2109.91,3286.43 ccw(c2119.3,3277.04) v1@2106.02,3277.04 ; v1@2100.52,3286.54 ccw(c2100.52,3309.48) 2116.74,3293.26 ccw(c2132.96,3277.04) v1@2110.02,3277.04 ; PROTOTYPE1.H21@2247.22,4205.85 cw(c2194.34,4201.49) 2231.86,4163.97 ; PROTOTYPE1.H21@2251.21,4206.18 cw(c2205.62,4202.42) 2237.96,4170.08 cw(c2270.31,4137.74) PROTOTYPE1.H21@2274.07,4183.32 ; PROTOTYPE1.H21@2255.19,4206.51 cw(c2216.9,4203.35) 2244.07,4176.18 cw(c2271.24,4149.02) PROTOTYPE1.H21@2274.39,4187.31 ; PROTOTYPE1.H21@2259.18,4206.84 cw(c2228.18,4204.28) 2250.17,4182.29 cw(c2272.17,4160.3) PROTOTYPE1.H21@2274.72,4191.29 ; PROTOTYPE1.H21@2273.74,4179.33 ccw(c2269.37,4126.46) 2231.86,4163.97 ; PROTOTYPE1.H21@2276.12,4208.23 2231.86,4163.97 ; v1@4550,4590.5 cw(c4550,4567.56) 4566.22,4583.78 cw(c4582.43,4600) v1@4559.5,4600 ; v1@4550,4594.5 cw(c4550,4581.22) 4559.39,4590.61 cw(c4568.78,4600) v1@4555.5,4600 ; v1(4550,4600) 4574.5,4575.5 4580.81,4575.5 4696.31,4460 4700.31,4456 4729.7,4456 4735.62,4450.08 4747.48,4450.08 4755,4450.08 4828.82,4450.08 4838.82,4450.08 4879.25,4450.08 4898.67,4450.08 4972.79,4450.08 ; 4958.86,4450.08 4972.79,4450.08 ; v3@5028.2,4425.57 ccw(c5010.16,4423.99) 5021.8,4437.86 ; v3@5035.02,4433.69 cw(c5033.44,4451.73) 5021.8,4437.86 ; 4972.79,4450.08 4992.29,4450.08 cw(c4992.29,4408.35) 5021.8,4437.86
  MidLayer2 w4: v1(-677.14,2974.37) -656.36,2995.16 -617.67,2995.16 -529.79,3083.04 -351.96,3083.04 -316.67,3118.33 -293.33,3118.33 -260,3085 193.94,3085 368.94,2910 765,2910 782.36,2927.36 782.36,2941.46 829.82,2988.93 829.82,3009.82 855,3035 1130.5,3035 1311.54,3216.04 1646.04,3216.04 1688.37,3258.37 2081.86,3258.37 v1(2100.52,3277.04) ; v1@-677.14,2979.87 ccw(c-677.14,2993.15) -667.75,2983.76 ccw(c-658.36,2974.37) v1@-671.64,2974.37 ; v1@-677.14,2983.87 ccw(c-677.14,3006.81) -660.93,2990.59 ccw(c-644.71,2974.37) v1@-667.64,2974.37 ; v1@2091.02,3277.04 cw(c2068.09,3277.04) 2084.31,3260.82 cw(c2100.52,3244.61) v1@2100.52,3267.54 ; v1@2095.02,3277.04 cw(c2081.75,3277.04) 2091.13,3267.65 cw(c2100.52,3258.26) v1@2100.52,3271.54
  Bottom Layer w4: 2431.37,4765 2430,4765 2423.19,4758.19 2423.19,4683.12 2497.44,4608.87 4355,4608.87 4406.36,4608.87 4470.05,4608.87 4486.98,4591.94 4486.98,4491.98 4475,4480 4475,4456.52 4480,4451.52 4502.23,4451.52 4512.48,4461.77 4512.48,4476.27 4507.5,4481.25 4507.5,4557.5 v1(4550,4600) ; 2431.37,4766.37 2526.9,4766.37 ; UH2.6@2546.23,4813.18 cw(c2480.24,4813.04) 2526.9,4766.38 ; UH2.6@2550.23,4813.19 cw(c2493.83,4813.07) 2533.71,4773.19 cw(c2573.6,4733.3) UH2.6@2573.71,4789.71 ; UH2.6@2554.23,4813.19 cw(c2507.42,4813.1) 2540.52,4779.99 cw(c2573.62,4746.89) UH2.6@2573.72,4793.71 ; UH2.6@2558.23,4813.2 cw(c2521.01,4813.13) 2547.33,4786.8 cw(c2573.65,4760.48) UH2.6@2573.73,4797.71 ; UH2.6@2573.7,4785.71 ccw(c2573.57,4719.71) 2526.9,4766.38 ; UH2.6@2573.76,4813.23 2526.9,4766.37 ; v1@4540.5,4600 cw(c4517.56,4600) 4533.78,4583.78 cw(c4550,4567.56) v1@4550,4590.5 ; v1@4544.5,4600 cw(c4531.22,4600) 4540.61,4590.61 cw(c4550,4581.22) v1@4550,4594.5
ATE.UIO.IO23: J33.B31 PROTOTYPE1.H22 U8.L6 UH2.7 | length 10476
  Top Layer w4: UH2.7@2673.76,4713.23 2673.76,4716.71 2673.52,4716.71 2673.52,4725.04 2715.19,4766.71 v1(2715.19,4950.04) ; UH2.7@2673.76,4736.76 ccw(c2673.76,4764.49) 2693.37,4744.88 ; UH2.7@2673.76,4740.76 ccw(c2673.76,4778.15) 2700.2,4751.71 ; UH2.7@2681.14,4714.73 cw(c2708.87,4720.36) 2688.86,4740.37 ; UH2.7@2685.06,4715.53 cw(c2717.62,4722.14) 2694.12,4745.64 ; UH2.7@2688.98,4716.32 cw(c2726.38,4723.92) 2699.39,4750.91 ; UH2.7@2692.9,4717.12 cw(c2735.13,4725.7) 2704.66,4756.17 ; UH2.7@2696.82,4717.92 cw(c2743.89,4727.48) 2709.92,4761.44 ; v1@2708.47,4943.32 cw(c2692.26,4927.11) 2715.19,4927.11 cw(c2738.13,4927.11) v1@2721.91,4943.32 ; v1@2711.3,4946.15 cw(c2701.91,4936.76) 2715.19,4936.76 cw(c2728.47,4936.76) v1@2719.08,4946.15 ; v3(5035.67,4347.48) U8.L6@5055.35,4327.8 ; U8.L6@5048.01,4327.8 ccw(c5030.29,4327.8) 5042.82,4340.33 ccw(c5055.35,4352.86) U8.L6@5055.35,4335.14 ; 5048.47,4334.68 cw(c5061.28,4347.48) 5043.17,4347.48 ccw(c5061.28,4347.48) 5048.47,4334.68 ; 5048.47,4334.68 ccw(c5035.67,4321.87) 5035.67,4339.98 cw(c5035.67,4321.87) 5048.47,4334.68
  MidLayer1 w4: v1@-687.48,3009.54 cw(c-687.48,2986.61) -671.26,3002.82 cw(c-655.04,3019.04) v1@-677.98,3019.04 ; v1@-687.48,3013.54 cw(c-687.48,3000.26) -678.09,3009.65 cw(c-668.7,3019.04) v1@-681.98,3019.04 ; v1(-687.48,3019.04) -668.48,3000.04 -599.7,3000.04 -513,3086.75 -513,3087 -507.5,3092.5 -507.5,3213.51 -352.74,3368.26 -324,3397.01 -324,3820 -277.23,3866.77 -277.23,4010.09 -279,4011.86 -279,4141.56 -150.56,4270 -89.85,4270 -60.92,4298.93 23.52,4383.37 23.52,4441.71 v1(194.86,4613.04) ; v1@185.36,4613.04 cw(c162.42,4613.04) 178.64,4596.82 cw(c194.86,4580.61) v1@194.86,4603.54 ; v1@189.36,4613.04 cw(c176.08,4613.04) 185.47,4603.65 cw(c194.86,4594.26) v1@194.86,4607.54 ; v1@1706.86,4582.21 cw(c1706.86,4559.27) 1723.07,4575.49 cw(c1739.29,4591.71) v1@1716.36,4591.71 ; v1@1706.86,4586.21 cw(c1706.86,4572.93) 1716.25,4582.32 cw(c1725.64,4591.71) v1@1712.36,4591.71 ; v1(1706.86,4591.71) 1756.86,4541.71 2353.29,4541.71 2376.12,4518.88 PROTOTYPE1.H22@2376.12,4208.23 ; PROTOTYPE1.H22@2355.62,4228.74 ccw(c2306.11,4278.25) 2376.12,4278.25 ccw(c2446.13,4278.25) PROTOTYPE1.H22@2396.63,4228.74 ; PROTOTYPE1.H22@2358.44,4225.91 ccw(c2315.77,4268.59) 2376.12,4268.59 ccw(c2436.48,4268.59) PROTOTYPE1.H22@2393.8,4225.91 ; PROTOTYPE1.H22@2361.27,4223.08 ccw(c2325.42,4258.93) 2376.12,4258.93 ccw(c2426.82,4258.93) PROTOTYPE1.H22@2390.97,4223.08 ; PROTOTYPE1.H22@2364.1,4220.26 ccw(c2335.08,4249.28) 2376.12,4249.28 ccw(c2417.16,4249.28) PROTOTYPE1.H22@2388.14,4220.26 ; PROTOTYPE1.H22@2366.93,4217.43 ccw(c2344.74,4239.62) 2376.12,4239.62 ccw(c2407.51,4239.62) PROTOTYPE1.H22@2385.31,4217.43 ; v1@4048.52,4957.21 cw(c4048.52,4934.27) 4064.74,4950.49 cw(c4080.96,4966.71) v1@4058.02,4966.71 ; v1@4048.52,4961.21 cw(c4048.52,4947.93) 4057.91,4957.32 cw(c4067.3,4966.71) v1@4054.02,4966.71 ; v1(4048.52,4966.71) 4069.53,4945.7 4128.17,4945.7 4157.69,4916.18 4157.69,4901.83 4250.98,4808.54 4253.11,4808.54 4315.19,4746.46 4315.19,4731.71 4290.19,4706.71 4290.19,4625.04 4298.52,4616.71 4405.9,4616.71 4532.5,4490.1 4532.5,4447.75 4541.21,4439.04 4557.66,4422.59 4643.59,4422.59 4655,4422.59 4717.85,4422.59 4724.24,4416.21 4762.44,4416.21 4804,4374.65 4807.31,4371.34 4830.82,4371.34 4838.82,4371.34 4879.25,4371.34 4898.67,4371.34 4972.79,4371.34 ; 4958.86,4371.34 4972.79,4371.34 ; v3@5028.2,4346.83 ccw(c5010.16,4345.25) 5021.8,4359.12 ; v3@5035.02,4354.95 cw(c5033.44,4372.99) 5021.8,4359.12 ; 4972.79,4371.34 4992.29,4371.34 cw(c4992.29,4329.61) 5021.8,4359.12
  MidLayer2 w4: v1@194.86,4603.54 cw(c194.86,4580.61) 211.07,4596.82 cw(c227.29,4613.04) v1@204.36,4613.04 ; v1@194.86,4607.54 cw(c194.86,4594.26) 204.25,4603.65 cw(c213.64,4613.04) v1@200.36,4613.04 ; v1(194.86,4613.04) 233.86,4574.04 451.69,4574.04 505.46,4627.81 970.75,4627.81 1006.86,4591.71 v1(1706.86,4591.71) 1734.56,4564 2654,4564 2673.76,4583.76 UH2.7@2673.76,4713.23 ; v1@1700.14,4584.99 ccw(c1683.92,4568.77) 1683.92,4591.71 ccw(c1683.92,4614.64) v1@1700.14,4598.43 ; v1@1702.97,4587.82 ccw(c1693.58,4578.43) 1693.58,4591.71 ccw(c1693.58,4604.99) v1@1702.97,4595.6 ; v1@1706.86,4582.21 cw(c1706.86,4559.27) 1723.07,4575.49 cw(c1739.29,4591.71) v1@1716.36,4591.71 ; v1@1706.86,4586.21 cw(c1706.86,4572.93) 1716.25,4582.32 cw(c1725.64,4591.71) v1@1712.36,4591.71 ; UH2.7@2654.29,4693.77 cw(c2607.3,4646.78) 2673.76,4646.78 cw(c2740.22,4646.78) UH2.7@2693.22,4693.77 ; UH2.7@2657.12,4696.6 cw(c2616.96,4656.43) 2673.76,4656.43 cw(c2730.56,4656.43) UH2.7@2690.4,4696.6 ; UH2.7@2659.95,4699.43 cw(c2626.62,4666.09) 2673.76,4666.09 cw(c2720.9,4666.09) UH2.7@2687.57,4699.43 ; UH2.7@2662.78,4702.25 cw(c2636.27,4675.75) 2673.76,4675.75 cw(c2711.25,4675.75) UH2.7@2684.74,4702.25
  Bottom Layer w4: J33.B31@-766.3,3007.19 -699.33,3007.19 ; J33.B31@-706.23,3002.61 cw(c-699.33,2999.7) -699.33,3007.19 ; J33.B31@-706.23,3011.77 ccw(c-699.33,3014.69) -699.33,3007.19 ; v1(-687.48,3019.04) -699.33,3007.19 ; v1(2715.19,4950.04) 2732.69,4967.54 3805.67,4967.54 3814.67,4958.54 3874.85,4958.54 3898.31,4982 4033.23,4982 v1(4048.52,4966.71) ; v1@2715.19,4955.54 ccw(c2715.19,4968.82) 2724.58,4959.43 ccw(c2733.97,4950.04) v1@2720.69,4950.04 ; v1@2715.19,4959.54 ccw(c2715.19,4982.48) 2731.41,4966.26 ccw(c2747.63,4950.04) v1@2724.69,4950.04
ATE.UIO.IO24: J33.A32 PROTOTYPE1.H23 U8.H4 UH2.8 | length 9595.1
  Top Layer w4: J33.A32@-785.98,2967.82 -696.48,2967.82 ; J33.A32@-706.93,2961.84 cw(c-696.48,2955.69) -696.48,2967.82 ; J33.A32@-706.93,2973.8 ccw(c-696.48,2979.96) -696.48,2967.82 ; v1@-612.19,2947.66 ccw(c-628.41,2931.44) -628.41,2954.37 ccw(c-628.41,2977.31) v1@-612.19,2961.09 ; v1@-609.36,2950.49 ccw(c-618.75,2941.1) -618.75,2954.37 ccw(c-618.75,2967.65) v1@-609.36,2958.26 ; v1(-605.48,2954.37) -683.03,2954.37 -696.48,2967.82 ; PROTOTYPE1.H23@2476.12,4208.23 2631.86,4363.97 2631.86,4771.33 ; PROTOTYPE1.H23@2476.12,4221.23 ccw(c2476.12,4252.62) 2498.31,4230.43 ccw(c2520.51,4208.23) PROTOTYPE1.H23@2489.12,4208.23 ; PROTOTYPE1.H23@2476.12,4225.23 ccw(c2476.12,4266.28) 2505.14,4237.26 ccw(c2534.16,4208.23) PROTOTYPE1.H23@2493.12,4208.23 ; PROTOTYPE1.H23@2476.12,4229.23 ccw(c2476.12,4279.93) 2511.97,4244.08 ccw(c2547.82,4208.23) PROTOTYPE1.H23@2497.12,4208.23 ; PROTOTYPE1.H23@2476.12,4233.23 ccw(c2476.12,4293.59) 2518.8,4250.91 ccw(c2561.48,4208.23) PROTOTYPE1.H23@2501.12,4208.23 ; PROTOTYPE1.H23@2476.12,4237.23 ccw(c2476.12,4307.25) 2525.63,4257.74 ccw(c2575.13,4208.23) PROTOTYPE1.H23@2505.12,4208.23 ; UH2.8@2646.33,4810.91 cw(c2596.5,4806.7) 2631.86,4771.33 ; UH2.8@2650.31,4811.25 cw(c2607.72,4807.65) 2637.95,4777.42 cw(c2668.17,4747.2) UH2.8@2671.78,4789.79 ; UH2.8@2654.3,4811.59 cw(c2618.95,4808.6) 2644.04,4783.51 cw(c2669.12,4758.42) UH2.8@2672.11,4793.78 ; UH2.8@2658.29,4811.93 cw(c2630.18,4809.55) 2650.12,4789.6 cw(c2670.07,4769.65) UH2.8@2672.45,4797.76 ; UH2.8@2671.44,4785.8 ccw(c2667.22,4735.97) 2631.86,4771.33 ; UH2.8@2673.76,4813.23 2631.86,4771.33 ; v3(4956.93,4465.59) U8.H4@4976.61,4445.91 ; U8.H4@4969.27,4445.91 ccw(c4951.55,4445.91) 4964.08,4458.44 ccw(c4976.61,4470.97) U8.H4@4976.61,4453.25 ; 4969.73,4452.79 cw(c4982.54,4465.59) 4964.43,4465.59 ccw(c4982.54,4465.59) 4969.73,4452.79 ; 4969.73,4452.79 ccw(c4956.93,4439.98) 4956.93,4458.09 cw(c4956.93,4439.98) 4969.73,4452.79
  MidLayer1 w4: v1(2406.86,2883.37) 2438.52,2915.04 2438.52,4170.64 ; v1@2406.86,2888.87 ccw(c2406.86,2902.15) 2416.25,2892.76 ccw(c2425.64,2883.37) v1@2412.36,2883.37 ; v1@2406.86,2892.87 ccw(c2406.86,2915.81) 2423.07,2899.59 ccw(c2439.29,2883.37) v1@2416.36,2883.37 ; PROTOTYPE1.H23@2447.78,4202.1 cw(c2414.32,4194.85) 2438.53,4170.64 ; PROTOTYPE1.H23@2451.69,4202.94 cw(c2422.84,4196.7) 2443.71,4175.83 cw(c2464.58,4154.95) PROTOTYPE1.H23@2470.83,4183.8 ; PROTOTYPE1.H23@2455.6,4203.79 cw(c2431.37,4198.54) 2448.9,4181.01 cw(c2466.43,4163.48) PROTOTYPE1.H23@2471.68,4187.71 ; PROTOTYPE1.H23@2459.51,4204.64 cw(c2439.89,4200.39) 2454.08,4186.2 cw(c2468.27,4172) PROTOTYPE1.H23@2472.52,4191.62 ; PROTOTYPE1.H23@2469.98,4179.89 ccw(c2462.74,4146.43) 2438.53,4170.64 ; PROTOTYPE1.H23@2476.12,4208.23 2438.52,4170.64 ; v1(4615.19,4598.37) 4651.76,4598.37 4655.03,4595.1 4683.09,4567.04 4707.88,4567.04 4748.52,4526.39 4750.5,4524.42 4750.5,4490.66 4750.5,4485 4750.5,4473.02 4757.93,4465.59 4829.41,4465.59 4838.82,4465.59 4879.25,4465.59 4898.67,4465.59 v3(4956.93,4465.59) ; v1@4619.08,4594.49 cw(c4628.47,4585.1) 4628.47,4598.37 cw(c4628.47,4611.65) v1@4619.08,4602.26 ; v1@4621.91,4591.66 cw(c4638.13,4575.44) 4638.13,4598.37 cw(c4638.13,4621.31) v1@4621.91,4605.09 ; v3@4951.63,4460.29 ccw(c4938.82,4447.48) 4938.82,4465.59 ccw(c4938.82,4483.7) v3@4951.63,4470.89 ; v3@4951.74,4460.4 ccw(c4939.2,4447.86) 4939.2,4465.59 ccw(c4939.2,4483.32) v3@4951.74,4470.78
  MidLayer2 w4: v1(-605.48,2954.37) -501.48,3058.37 186.63,3058.37 359,2886 2206.5,2886 2212.21,2891.71 2293.17,2891.71 2301.5,2883.37 v1(2406.86,2883.37) ; v1@-605.48,2959.87 ccw(c-605.48,2973.15) -596.09,2963.76 ccw(c-586.7,2954.37) v1@-599.98,2954.37 ; v1@-605.48,2963.87 ccw(c-605.48,2986.81) -589.26,2970.59 ccw(c-573.04,2954.37) v1@-595.98,2954.37 ; v1@2400.14,2876.66 ccw(c2383.92,2860.44) 2383.92,2883.37 ccw(c2383.92,2906.31) v1@2400.14,2890.09 ; v1@2402.97,2879.49 ccw(c2393.58,2870.1) 2393.58,2883.37 ccw(c2393.58,2896.65) v1@2402.97,2887.26
  Bottom Layer w4: UH2.8@2673.76,4813.23 2720.28,4766.71 ; UH2.8@2673.9,4793.71 cw(c2674.22,4747.7) 2706.76,4780.23 cw(c2739.3,4812.77) UH2.8@2693.29,4813.09 ; UH2.8@2673.87,4797.71 cw(c2674.13,4761.12) 2700,4786.99 cw(c2725.87,4812.86) UH2.8@2689.29,4813.12 ; UH2.8@2673.93,4789.71 cw(c2674.32,4734.27) 2713.52,4773.47 cw(c2752.72,4812.67) UH2.8@2697.29,4813.07 ; UH2.8@2673.95,4785.71 cw(c2674.42,4720.85) 2720.28,4766.71 ; UH2.8@2701.29,4813.04 ccw(c2766.15,4812.58) 2720.28,4766.71 ; 3316.37,4766.37 3316.71,4766.71 ; v1(4615.19,4598.37) 4589.86,4623.71 4589.86,4760.85 4575,4775.71 4377.47,4775.71 4373.72,4771.95 4332.45,4771.95 4328.7,4775.71 3325.71,4775.71 3316.71,4766.71 ; 2720.28,4766.71 3316.71,4766.71
ATE.UIO.IO25: J33.B32 PROTOTYPE1.H24 U8.K4 UH2.9 | length 9949.1
  Top Layer w4: v1(2598.52,4382.04) 2623.52,4407.04 2623.52,4988.73 2635.17,5000.37 2804.63,5000.37 2823.52,4981.48 2823.52,4763 UH2.9@2773.76,4713.23 ; v1@2598.52,4387.54 ccw(c2598.52,4400.82) 2607.91,4391.43 ccw(c2617.3,4382.04) v1@2604.02,4382.04 ; v1@2598.52,4391.54 ccw(c2598.52,4414.48) 2614.74,4398.26 ccw(c2630.96,4382.04) v1@2608.02,4382.04 ; UH2.9@2773.76,4728.76 ccw(c2773.76,4766.25) 2800.27,4739.74 ccw(c2826.77,4713.23) UH2.9@2789.29,4713.23 ; UH2.9@2773.76,4732.76 ccw(c2773.76,4779.91) 2807.1,4746.57 ccw(c2840.43,4713.23) UH2.9@2793.29,4713.23 ; UH2.9@2773.76,4736.76 ccw(c2773.76,4793.56) 2813.92,4753.4 ccw(c2854.08,4713.23) UH2.9@2797.29,4713.23 ; UH2.9@2773.76,4740.76 ccw(c2773.76,4807.22) 2820.75,4760.23 ccw(c2867.74,4713.23) UH2.9@2801.29,4713.23 ; v3(4956.93,4386.85) U8.K4@4976.61,4367.17 ; U8.K4@4969.27,4367.17 ccw(c4951.55,4367.17) 4964.08,4379.7 ccw(c4976.61,4392.23) U8.K4@4976.61,4374.51 ; 4969.73,4374.05 cw(c4982.54,4386.85) 4964.43,4386.85 ccw(c4982.54,4386.85) 4969.73,4374.05 ; 4969.73,4374.05 ccw(c4956.93,4361.24) 4956.93,4379.35 cw(c4956.93,4361.24) 4969.73,4374.05
  MidLayer1 w4: v1(990.19,3208.37) 1123.52,3341.71 1123.52,4058.37 1131.86,4066.71 1501.71,4066.71 1520,4085 1520,4359.56 v1(1497.52,4382.04) ; v1@990.19,3213.87 ccw(c990.19,3227.15) 999.58,3217.76 ccw(c1008.97,3208.37) v1@995.69,3208.37 ; v1@990.19,3217.87 ccw(c990.19,3240.81) 1006.41,3224.59 ccw(c1022.63,3208.37) v1@999.69,3208.37 ; v1@1497.52,4372.54 cw(c1497.52,4349.61) 1513.74,4365.82 cw(c1529.96,4382.04) v1@1507.02,4382.04 ; v1@1497.52,4376.54 cw(c1497.52,4363.26) 1506.91,4372.65 cw(c1516.3,4382.04) v1@1503.02,4382.04 ; PROTOTYPE1.H24@2555.62,4228.74 ccw(c2506.11,4278.25) 2576.12,4278.25 ccw(c2646.13,4278.25) PROTOTYPE1.H24@2596.63,4228.74 ; PROTOTYPE1.H24@2558.44,4225.91 ccw(c2515.77,4268.59) 2576.12,4268.59 ccw(c2636.48,4268.59) PROTOTYPE1.H24@2593.8,4225.91 ; PROTOTYPE1.H24@2561.27,4223.08 ccw(c2525.42,4258.93) 2576.12,4258.93 ccw(c2626.82,4258.93) PROTOTYPE1.H24@2590.97,4223.08 ; PROTOTYPE1.H24@2564.1,4220.26 ccw(c2535.08,4249.28) 2576.12,4249.28 ccw(c2617.16,4249.28) PROTOTYPE1.H24@2588.14,4220.26 ; PROTOTYPE1.H24@2566.93,4217.43 ccw(c2544.74,4239.62) 2576.12,4239.62 ccw(c2607.51,4239.62) PROTOTYPE1.H24@2585.31,4217.43 ; PROTOTYPE1.H24@2576.12,4208.23 2576.12,4359.64 v1(2598.52,4382.04) ; v1@2589.02,4382.04 cw(c2566.09,4382.04) 2582.31,4365.82 cw(c2598.52,4349.61) v1@2598.52,4372.54 ; v1@2593.02,4382.04 cw(c2579.75,4382.04) 2589.14,4372.65 cw(c2598.52,4363.26) v1@2598.52,4376.54 ; v1(4310,4640) 4393.92,4640 4540.5,4493.42 4575,4458.92 4603.32,4430.59 4604.41,4430.59 4650,4430.59 4655,4430.59 4721.16,4430.59 4727.55,4424.21 4765.76,4424.21 4803.11,4386.85 4809.7,4386.85 4830.82,4386.85 4838.82,4386.85 4879.25,4386.85 4898.67,4386.85 v3(4956.93,4386.85) ; v1@4313.89,4636.11 cw(c4323.28,4626.72) 4323.28,4640 cw(c4323.28,4653.28) v1@4313.89,4643.89 ; v1@4316.72,4633.28 cw(c4332.93,4617.06) 4332.93,4640 cw(c4332.93,4662.93) v1@4316.72,4646.72 ; v3@4951.74,4381.66 ccw(c4939.2,4369.12) 4939.2,4386.85 ccw(c4939.2,4404.58) v3@4951.74,4392.04 ; 4938.82,4386.85 cw(c4938.82,4368.74) 4951.63,4381.55 ccw(c4938.82,4368.74) 4938.82,4386.85 ; 4938.82,4386.85 ccw(c4938.82,4404.96) 4951.63,4392.15 cw(c4938.82,4404.96) 4938.82,4386.85
  Bottom Layer w4: J33.B32@-785.98,2967.82 -697.82,2967.82 ; J33.B32@-706.6,2962.45 cw(c-697.82,2957.96) -697.82,2967.82 ; J33.B32@-706.6,2973.19 ccw(c-697.82,2977.68) -697.82,2967.82 ; v1@980.69,3208.37 ccw(c957.76,3208.37) 973.97,3224.59 ccw(c990.19,3240.81) v1@990.19,3217.87 ; v1@984.69,3208.37 ccw(c971.41,3208.37) 980.8,3217.76 ccw(c990.19,3227.15) v1@990.19,3213.87 ; v1(990.19,3208.37) 964.86,3233.71 786.29,3233.71 736.78,3184.19 -15.69,3184.19 -26.5,3195 -550,3195 -562.41,3182.59 -562.41,2947.59 -575,2935 -620,2935 -640,2955 -685,2955 -697.82,2967.82 ; v1(1497.52,4382.04) 1513.19,4366.37 2568,4366.37 2583.67,4382.04 v1(2598.52,4382.04) ; UH2.9@2773.76,4713.23 2810.52,4750 2885,4750 2898.52,4750.04 2931.86,4716.71 2931.86,4680.9 2987.89,4624.87 4294.87,4624.87 v1(4310,4640) ; UH2.9@2777.42,4732.42 ccw(c2782.11,4757.04) 2799.84,4739.31 ccw(c2817.56,4721.59) UH2.9@2792.94,4716.89 ; UH2.9@2778.17,4736.35 ccw(c2783.82,4766.01) 2805.18,4744.66 ccw(c2826.54,4723.3) UH2.9@2796.87,4717.64 ; UH2.9@2778.92,4740.27 ccw(c2785.54,4774.99) 2810.52,4750 ccw(c2835.51,4725.01) UH2.9@2800.8,4718.39