# Altium PCB NB3000AL.PcbDoc (part 6 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
1V2: C140.1 C141.1 C184.1 C189.1 C190.1 C191.1 C192.1 C193.1 C194.1 C195.1 C196.1 C197.1 C198.1 C199.1 C219.1 C220.1 C221.1 C222.1 C223.1 C224.1 C225.1 C226.1 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C260.1 C265.1 C266.1 C267.1 C268.1 C269.1 C270.1 C271.1 C272.1 C273.1 C274.1 C275.1 C295.1 C296.1 C297.1 C298.1 C299.1 C300.1 C301.1 C302.1 C313.1 C314.1 C315.1 C316.1 C317.1 C318.1 EXTHDR1.73 EXTHDR1.75 PROTOTYPE1.2 R207.2 TP7.1 U8.J9 U8.J20 U8.K9 U8.K11 U8.K17 U8.K19 U8.L10 U8.L12 U8.L14 U8.L16 U8.L18 U8.M11 U8.M13 U8.M15 U8.M17 U8.M19 U8.N10 U8.N12 U8.N14 U8.N16 U8.N18 U8.N20 U8.P9 U8.P11 U8.P13 U8.P15 U8.P17 U8.P19 U8.R10 U8.R12 U8.R14 U8.R16 U8.R18 U8.R20 U8.T11 U8.T13 U8.T15 U8.T17 U8.T19 U8.U10 U8.U12 U8.U14 U8.U16 U8.U18 U8.V11 U8.V13 U8.V15 U8.V17 U8.V19 U8.W12 U8.W14 U8.W18 U8.Y9 U8.Y20 U30.D13 U30.G6 U30.G7 U30.G8 U30.G9 U30.G10 U30.H6 U30.H11 U30.K7 U30.N4 U42.4 | length 35258.7
  Top Layer w4: v3(5153.78,3953.78) U8.Y9@5173.46,3973.46 ; v3(5153.78,4229.37) U8.P9@5173.46,4209.68 ; v3(5153.78,4386.85) U8.K9@5173.46,4367.17 ; v3(5153.78,4426.22) U8.J9@5173.46,4406.54 ; U8.Y9@5166.12,3973.46 cw(c5148.4,3973.46) 5160.93,3960.93 cw(c5173.46,3948.4) U8.Y9@5173.46,3966.12 ; U8.P9@5166.12,4209.68 ccw(c5148.4,4209.68) 5160.93,4222.22 ccw(c5173.46,4234.75) U8.P9@5173.46,4217.03 ; U8.K9@5166.12,4367.17 ccw(c5148.4,4367.17) 5160.93,4379.7 ccw(c5173.46,4392.23) U8.K9@5173.46,4374.51 ; U8.J9@5166.12,4406.54 ccw(c5148.4,4406.53) 5160.93,4419.07 ccw(c5173.46,4431.6) U8.J9@5173.46,4413.88 ; v3(5193.15,4071.89) U8.U10@5212.83,4091.57 ; v3(5193.15,4150.63) U8.R10@5212.83,4170.31 ; v3(5193.15,4268.74) U8.N10@5212.83,4249.05 ; v3(5193.15,4347.48) U8.L10@5212.83,4327.8 ; U8.U10@5205.49,4091.57 cw(c5187.77,4091.57) 5200.3,4079.04 cw(c5212.83,4066.51) U8.U10@5212.83,4084.23 ; U8.R10@5205.49,4170.31 cw(c5187.77,4170.31) 5200.3,4157.78 cw(c5212.83,4145.25) U8.R10@5212.83,4162.97 ; U8.N10@5205.49,4249.05 ccw(c5187.77,4249.05) 5200.3,4261.59 ccw(c5212.83,4274.12) U8.N10@5212.83,4256.4 ; U8.L10@5205.49,4327.8 ccw(c5187.77,4327.8) 5200.3,4340.33 ccw(c5212.83,4352.86) U8.L10@5212.83,4335.14 ; v3(5232.52,4032.52) U8.V11@5252.2,4052.2 ; v3(5232.52,4111.26) U8.T11@5252.2,4130.94 ; v3(5232.52,4229.37) U8.P11@5252.2,4209.68 ; v3(5232.52,4308.11) U8.M11@5252.2,4288.42 ; v3(5232.52,4386.85) U8.K11@5252.2,4367.17 ; U8.V11@5244.86,4052.2 cw(c5227.14,4052.2) 5239.67,4039.67 cw(c5252.2,4027.14) U8.V11@5252.2,4044.86 ; U8.T11@5244.86,4130.95 cw(c5227.14,4130.95) 5239.67,4118.41 cw(c5252.2,4105.88) U8.T11@5252.2,4123.6 ; U8.P11@5244.86,4209.68 ccw(c5227.14,4209.68) 5239.67,4222.22 ccw(c5252.2,4234.75) U8.P11@5252.2,4217.03 ; U8.M11@5244.86,4288.42 ccw(c5227.14,4288.42) 5239.67,4300.96 ccw(c5252.2,4313.49) U8.M11@5252.2,4295.77 ; U8.K11@5244.86,4367.16 ccw(c5227.14,4367.16) 5239.67,4379.7 ccw(c5252.2,4392.23) U8.K11@5252.2,4374.51 ; v3(5271.89,3993.15) U8.W12@5291.57,4012.83 ; v3(5271.89,4150.63) U8.R12@5291.57,4170.31 ; v3(5271.89,4268.74) U8.N12@5291.57,4249.05 ; v3(5271.89,4347.48) U8.L12@5291.57,4327.8 ; U8.W12@5284.23,4012.83 cw(c5266.51,4012.83) 5279.04,4000.3 cw(c5291.57,3987.77) U8.W12@5291.57,4005.49 ; U8.R12@5284.23,4170.31 cw(c5266.51,4170.31) 5279.04,4157.78 cw(c5291.57,4145.25) U8.R12@5291.57,4162.97 ; U8.N12@5284.23,4249.05 ccw(c5266.51,4249.05) 5279.04,4261.59 ccw(c5291.57,4274.12) U8.N12@5291.57,4256.4 ; U8.L12@5284.23,4327.79 ccw(c5266.51,4327.79) 5279.04,4340.33 ccw(c5291.57,4352.86) U8.L12@5291.57,4335.14 ; U8.U12@5291.57,4091.57 v3(5311.26,4111.26) U8.T13@5330.94,4130.94 ; U8.U12@5291.57,4098.92 ccw(c5291.57,4116.64) 5304.11,4104.11 ccw(c5316.64,4091.57) U8.U12@5298.92,4091.57 ; v3(5311.26,4032.52) U8.V13@5330.94,4052.2 ; v3(5311.26,4229.37) U8.P13@5330.94,4209.68 ; v3(5311.26,4308.11) U8.M13@5330.94,4288.42 ; U8.V13@5323.6,4052.2 cw(c5305.88,4052.2) 5318.41,4039.67 cw(c5330.94,4027.14) U8.V13@5330.95,4044.86 ; U8.T13@5323.6,4130.95 cw(c5305.88,4130.95) 5318.41,4118.41 cw(c5330.94,4105.88) U8.T13@5330.95,4123.6 ; U8.P13@5323.6,4209.68 ccw(c5305.88,4209.68) 5318.41,4222.22 ccw(c5330.94,4234.75) U8.P13@5330.94,4217.03 ; U8.M13@5323.6,4288.42 ccw(c5305.88,4288.42) 5318.41,4300.96 ccw(c5330.94,4313.49) U8.M13@5330.95,4295.77 ; v3(5350.63,3993.15) U8.W14@5370.31,4012.83 ; v3(5350.63,4071.89) U8.U14@5370.31,4091.57 ; v3(5350.63,4150.63) U8.R14@5370.31,4170.31 ; v3(5350.63,4268.74) U8.N14@5370.31,4249.05 ; v3(5350.63,4347.48) U8.L14@5370.31,4327.8 ; U8.W14@5362.97,4012.83 cw(c5345.25,4012.83) 5357.78,4000.3 cw(c5370.31,3987.77) U8.W14@5370.31,4005.49 ; U8.U14@5362.97,4091.57 cw(c5345.25,4091.57) 5357.78,4079.04 cw(c5370.31,4066.51) U8.U14@5370.31,4084.23 ; U8.R14@5362.97,4170.31 cw(c5345.25,4170.31) 5357.78,4157.78 cw(c5370.31,4145.25) U8.R14@5370.31,4162.97 ; U8.N14@5362.97,4249.05 ccw(c5345.25,4249.05) 5357.78,4261.59 ccw(c5370.31,4274.12) U8.N14@5370.31,4256.4 ; U8.L14@5362.97,4327.8 ccw(c5345.25,4327.8) 5357.78,4340.33 ccw(c5370.31,4352.86) U8.L14@5370.31,4335.14 ; U8.V15@5409.69,4044.86 cw(c5409.69,4027.14) 5422.22,4039.67 cw(c5434.75,4052.2) U8.V15@5417.03,4052.2 ; U8.V15@5409.68,4052.2 v3(5429.37,4032.52) ; U8.T15@5409.69,4123.6 cw(c5409.69,4105.88) 5422.22,4118.41 cw(c5434.75,4130.94) U8.T15@5417.03,4130.94 ; U8.T15@5409.68,4130.94 v3(5429.37,4111.26) ; U8.P15@5409.68,4209.68 v3(5429.37,4229.37) ; U8.P15@5409.68,4217.03 ccw(c5409.68,4234.75) 5422.22,4222.22 ccw(c5434.75,4209.68) U8.P15@5417.03,4209.68 ; U8.M15@5409.68,4288.42 v3(5429.37,4308.11) ; U8.M15@5409.69,4295.77 ccw(c5409.69,4313.49) 5422.22,4300.96 ccw(c5434.75,4288.42) U8.M15@5417.03,4288.42 ; U8.U16@5449.05,4084.23 cw(c5449.05,4066.51) 5461.59,4079.04 cw(c5474.12,4091.57) U8.U16@5456.4,4091.57 ; U8.U16@5449.06,4091.57 v3(5468.74,4071.89) ; U8.R16@5449.06,4162.97 cw(c5449.06,4145.25) 5461.59,4157.78 cw(c5474.12,4170.31) U8.R16@5456.4,4170.31 ; U8.R16@5449.06,4170.31 v3(5468.74,4150.63) ; U8.N16@5449.06,4249.05 v3(5468.74,4268.74) U8.M17@5488.43,4288.42 ; U8.N16@5449.05,4256.4 ccw(c5449.05,4274.12) 5461.59,4261.59 ccw(c5474.12,4249.05) U8.N16@5456.4,4249.05 ; U8.L16@5449.06,4327.8 v3(5468.74,4347.48) ; U8.L16@5449.05,4335.14 ccw(c5449.05,4352.86) 5461.59,4340.33 ccw(c5474.12,4327.79) U8.L16@5456.4,4327.79 ; U8.M17@5481.08,4288.43 cw(c5463.36,4288.43) 5475.89,4275.89 cw(c5488.43,4263.36) U8.M17@5488.43,4281.08 ; U8.V17@5488.42,4044.86 cw(c5488.42,4027.14) 5500.96,4039.67 cw(c5513.49,4052.2) U8.V17@5495.77,4052.2 ; U8.V17@5488.43,4052.2 v3(5508.11,4032.52) ; U8.T17@5488.42,4123.6 cw(c5488.42,4105.88) 5500.96,4118.41 cw(c5513.49,4130.95) U8.T17@5495.77,4130.95 ; U8.T17@5488.43,4130.94 v3(5508.11,4111.26) ; U8.P17@5488.43,4209.68 v3(5508.11,4229.37) ; U8.P17@5488.43,4217.03 ccw(c5488.42,4234.75) 5500.96,4222.22 ccw(c5513.49,4209.68) U8.P17@5495.77,4209.68 ; U8.K17@5488.43,4367.17 v3(5508.11,4386.85) ; U8.K17@5488.42,4374.51 ccw(c5488.42,4392.23) 5500.96,4379.7 ccw(c5513.49,4367.16) U8.K17@5495.77,4367.16 ; U8.W18@5527.8,4005.49 cw(c5527.8,3987.77) 5540.33,4000.3 cw(c5552.86,4012.83) U8.W18@5535.14,4012.83 ; U8.W18@5527.8,4012.83 v3(5547.48,3993.15) ; U8.U18@5527.8,4084.23 cw(c5527.8,4066.51) 5540.33,4079.04 cw(c5552.86,4091.57) U8.U18@5535.14,4091.57 ; U8.U18@5527.8,4091.57 v3(5547.48,4071.89) ; U8.R18@5527.8,4162.97 cw(c5527.8,4145.25) 5540.33,4157.78 cw(c5552.86,4170.31) U8.R18@5535.14,4170.31 ; U8.R18@5527.8,4170.31 v3(5547.48,4150.63) ; U8.N18@5527.8,4249.05 v3(5547.48,4268.74) ; U8.N18@5527.8,4256.4 ccw(c5527.8,4274.12) 5540.33,4261.59 ccw(c5552.86,4249.05) U8.N18@5535.14,4249.05 ; U8.L18@5527.8,4327.8 v3(5547.48,4347.48) ; U8.L18@5527.8,4335.14 ccw(c5527.8,4352.86) 5540.33,4340.33 ccw(c5552.86,4327.79) U8.L18@5535.14,4327.79 ; U8.V19@5567.17,4044.86 cw(c5567.17,4027.14) 5579.7,4039.67 cw(c5592.23,4052.2) U8.V19@5574.51,4052.2 ; U8.V19@5567.17,4052.2 v3(5586.85,4032.52) ; U8.T19@5567.17,4123.6 cw(c5567.17,4105.88) 5579.7,4118.41 cw(c5592.23,4130.94) U8.T19@5574.51,4130.94 ; U8.T19@5567.17,4130.94 v3(5586.85,4111.26) ; U8.P19@5567.17,4209.68 v3(5586.85,4229.37) ; U8.P19@5567.17,4217.03 ccw(c5567.17,4234.75) 5579.7,4222.22 ccw(c5592.23,4209.68) U8.P19@5574.51,4209.68 ; U8.M19@5567.17,4288.42 v3(5586.85,4308.11) ; U8.M19@5567.17,4295.77 ccw(c5567.17,4313.49) 5579.7,4300.96 ccw(c5592.23,4288.42) U8.M19@5574.51,4288.42 ; U8.K19@5567.17,4367.17 v3(5586.85,4386.85) ; U8.K19@5567.17,4374.51 ccw(c5567.17,4392.23) 5579.7,4379.7 ccw(c5592.23,4367.16) U8.K19@5574.51,4367.16 ; U8.Y20@5606.54,3966.12 cw(c5606.54,3948.4) 5619.07,3960.93 cw(c5631.6,3973.46) U8.Y20@5613.88,3973.46 ; U8.Y20@5606.54,3973.46 v3(5626.22,3953.78) ; U8.R20@5606.54,4162.97 cw(c5606.54,4145.25) 5619.07,4157.78 cw(c5631.6,4170.31) U8.R20@5613.88,4170.31 ; U8.R20@5606.54,4170.31 v3(5626.22,4150.63) ; U8.N20@5606.54,4249.05 v3(5626.22,4268.74) ; U8.N20@5606.54,4256.4 ccw(c5606.54,4274.12) 5619.07,4261.59 ccw(c5631.6,4249.05) U8.N20@5613.88,4249.05 ; U8.J20@5606.54,4406.54 v3(5626.22,4426.22) ; U8.J20@5606.54,4413.88 ccw(c5606.54,4431.6) 5619.07,4419.07 ccw(c5631.6,4406.53) U8.J20@5613.88,4406.54 ; v2(6671,2454) 6686.03,2454 6721.84,2418.19 6745,2418.19 6764.33,2398.86 C242.1@6764.33,2375 ; C242.1@6757.39,2381.94 ccw(c6740.64,2398.69) 6764.33,2398.69 ccw(c6788.02,2398.69) C242.1@6771.27,2381.94 ; C237.1@6759.28,1346.59 cw(c6753.93,1337.67) 6764.33,1337.67 ; C242.1@6760.22,2379.11 ccw(c6750.3,2389.03) 6764.33,2389.03 ccw(c6778.36,2389.03) C242.1@6768.44,2379.11 ; C237.1@6764.33,1355 6764.33,1337.67 ; C237.1@6769.38,1346.59 ccw(c6774.74,1337.67) 6764.33,1337.67 ; v2(6778,1324) 6764.33,1337.67 ; v3(6813.15,1668.15) U30.N4@6832.83,1687.83 ; U30.N4@6825.49,1687.83 cw(c6807.77,1687.83) 6820.3,1675.3 cw(c6832.83,1662.77) U30.N4@6832.83,1680.49 ; v3(6891.89,1904.37) U30.H6@6911.57,1884.68 ; v3(6891.89,1943.74) U30.G6@6911.57,1924.05 ; v2(6898,1326) 6915.75,1326 ; U30.H6@6904.23,1884.68 ccw(c6886.51,1884.68) 6899.04,1897.22 ccw(c6911.57,1909.75) U30.H6@6911.57,1892.03 ; U30.G6@6904.23,1924.05 ccw(c6886.51,1924.05) 6899.04,1936.59 ccw(c6911.57,1949.12) U30.G6@6911.57,1931.4 ; v2@6906.31,1320.78 cw(c6915.75,1314.85) 6915.75,1326 ; v2@6906.31,1331.22 ccw(c6915.75,1337.15) 6915.75,1326 ; v3(6931.26,1786.26) U30.K7@6950.94,1805.94 ; v3(6931.26,1943.74) U30.G7@6950.94,1924.05 ; U30.K7@6943.6,1805.94 cw(c6925.88,1805.94) 6938.41,1793.41 cw(c6950.94,1780.88) U30.K7@6950.94,1798.6 ; U30.G7@6943.6,1924.05 ccw(c6925.88,1924.05) 6938.41,1936.59 ccw(c6950.94,1949.12) U30.G7@6950.94,1931.4 ; C198.1@6945.86,1355 cw(c6922.17,1355) 6938.92,1338.25 cw(c6955.67,1321.5) C198.1@6955.67,1345.19 ; C198.1@6949.86,1355 cw(c6935.83,1355) 6945.75,1345.08 cw(c6955.67,1335.16) C198.1@6955.67,1349.19 ; C198.1@6955.67,1355 6937.48,1336.81 6926.56,1336.81 6915.75,1326 ; C196.1@6956.86,2375 C196.1@6956.86,2376.19 ; v3(6970.63,1943.74) U30.G8@6990.32,1924.05 ; U30.G8@6982.97,1924.05 ccw(c6965.25,1924.05) 6977.78,1936.59 ccw(c6990.31,1949.12) U30.G8@6990.31,1931.4 ; U30.G9@7029.69,1924.05 v3(7049.37,1943.74) ; U30.G9@7029.68,1931.4 ccw(c7029.68,1949.12) 7042.22,1936.59 ccw(c7054.75,1924.05) U30.G9@7037.03,1924.05 ; U30.G10@7069.06,1924.05 v3(7088.74,1943.74) ; U30.G10@7069.06,1931.4 ccw(c7069.06,1949.12) 7081.59,1936.59 ccw(c7094.12,1924.05) U30.G10@7076.4,1924.05 ; 7089.33,2394 7090.52,2392.81 ; 7089.33,2414.53 7111.05,2392.81 7148.48,2392.81 7153.48,2387.81 7201.52,2387.81 ; U30.H11@7108.43,1884.68 v3(7128.11,1904.37) ; U30.H11@7108.43,1892.03 ccw(c7108.42,1909.75) 7120.96,1897.22 ccw(c7133.49,1884.68) U30.H11@7115.77,1884.68 ; 7179.03,2387.81 cw(c7179.03,2339.7) C219.1@7213.05,2373.72 ; U30.D13@7187.17,2042.17 v3(7206.85,2061.85) ; U30.D13@7187.17,2049.51 ccw(c7187.17,2067.23) 7199.7,2054.7 ccw(c7212.23,2042.16) U30.D13@7194.51,2042.17 ; 7188.69,2387.81 cw(c7188.69,2349.36) C219.1@7215.88,2376.55 ; 7198.34,2387.81 cw(c7198.34,2359.01) C219.1@7218.71,2379.38 ; C219.1@7204.73,2377.02 ccw(c7193.16,2379.45) 7201.52,2387.81 ; C219.1@7212.31,2384.6 cw(c7209.88,2396.17) 7201.52,2387.81 ; C219.1@7214.33,2375 7201.52,2387.81 ; v2(7490,1826) 7486,1822 7494,1822 v2@7498,1822 ; C195.1@7520,1810.67 C195.1@7520,1816.81 ; 5166.58,3966.58 cw(c5153.78,3979.39) 5153.78,3961.28 ccw(c5153.78,3979.39) 5166.58,3966.58 ; 5166.58,3966.58 ccw(c5179.39,3953.78) 5161.28,3953.78 cw(c5179.39,3953.78) 5166.58,3966.58 ; 5166.58,4216.57 cw(c5179.39,4229.37) 5161.28,4229.37 ccw(c5179.39,4229.37) 5166.58,4216.57 ; 5166.58,4216.57 ccw(c5153.78,4203.76) 5153.78,4221.87 cw(c5153.78,4203.76) 5166.58,4216.57 ; 5166.58,4374.05 cw(c5179.39,4386.85) 5161.28,4386.85 ccw(c5179.39,4386.85) 5166.58,4374.05 ; 5166.58,4374.05 ccw(c5153.78,4361.24) 5153.78,4379.35 cw(c5153.78,4361.24) 5166.58,4374.05 ; 5166.58,4413.42 cw(c5179.39,4426.22) 5161.28,4426.22 ccw(c5179.39,4426.22) 5166.58,4413.42 ; 5166.58,4413.42 ccw(c5153.78,4400.61) 5153.78,4418.72 cw(c5153.78,4400.61) 5166.58,4413.42 ; 5205.95,4084.69 cw(c5193.15,4097.5) 5193.15,4079.39 ccw(c5193.15,4097.5) 5205.95,4084.69 ; 5205.95,4084.69 ccw(c5218.76,4071.89) 5200.65,4071.89 cw(c5218.76,4071.89) 5205.95,4084.69 ; 5205.95,4163.43 cw(c5193.15,4176.24) 5193.15,4158.13 ccw(c5193.15,4176.24) 5205.95,4163.43 ; 5205.95,4163.43 ccw(c5218.76,4150.63) 5200.65,4150.63 cw(c5218.76,4150.63) 5205.95,4163.43 ; 5205.95,4255.94 cw(c5218.76,4268.74) 5200.65,4268.74 ccw(c5218.76,4268.74) 5205.95,4255.94 ; 5205.95,4255.94 ccw(c5193.15,4243.13) 5193.15,4261.24 cw(c5193.15,4243.13) 5205.95,4255.94 ; 5205.95,4334.68 cw(c5218.76,4347.48) 5200.65,4347.48 ccw(c5218.76,4347.48) 5205.95,4334.68 ; 5205.95,4334.68 ccw(c5193.15,4321.87) 5193.15,4339.98 cw(c5193.15,4321.87) 5205.95,4334.68 ; v1@5234.86,5050.04 5240,5050.04 v1@5234.9,5050 ; v1@5234.86,5050.04 v1@5234.9,5050 ; 5245.32,4045.32 cw(c5232.52,4058.13) 5232.52,4040.02 ccw(c5232.52,4058.13) 5245.32,4045.32 ; 5245.32,4045.32 ccw(c5258.13,4032.52) 5240.02,4032.52 cw(c5258.13,4032.52) 5245.32,4045.32 ; 5245.32,4124.06 cw(c5232.52,4136.87) 5232.52,4118.76 ccw(c5232.52,4136.87) 5245.32,4124.06 ; 5245.32,4124.06 ccw(c5258.13,4111.26) 5240.02,4111.26 cw(c5258.13,4111.26) 5245.32,4124.06 ; 5245.32,4216.57 cw(c5258.13,4229.37) 5240.02,4229.37 ccw(c5258.13,4229.37) 5245.32,4216.57 ; 5245.32,4216.57 ccw(c5232.52,4203.76) 5232.52,4221.87 cw(c5232.52,4203.76) 5245.32,4216.57 ; 5245.32,4295.31 cw(c5258.13,4308.11) 5240.02,4308.11 ccw(c5258.13,4308.11) 5245.32,4295.31 ; 5245.32,4295.31 ccw(c5232.52,4282.5) 5232.52,4300.61 cw(c5232.52,4282.5) 5245.32,4295.31 ; 5245.32,4374.05 cw(c5258.13,4386.85) 5240.02,4386.85 ccw(c5258.13,4386.85) 5245.32,4374.05 ; 5245.32,4374.05 ccw(c5232.52,4361.24) 5232.52,4379.35 cw(c5232.52,4361.24) 5245.32,4374.05 ; 5284.69,4005.95 cw(c5271.89,4018.76) 5271.89,4000.65 ccw(c5271.89,4018.76) 5284.69,4005.95 ; 5284.69,4005.95 ccw(c5297.5,3993.15) 5279.39,3993.15 cw(c5297.5,3993.15) 5284.69,4005.95 ; 5284.69,4163.43 cw(c5271.89,4176.24) 5271.89,4158.13 ccw(c5271.89,4176.24) 5284.69,4163.43 ; 5284.69,4163.43 ccw(c5297.5,4150.63) 5279.39,4150.63 cw(c5297.5,4150.63) 5284.69,4163.43 ; 5284.69,4255.94 cw(c5297.5,4268.74) 5279.39,4268.74 ccw(c5297.5,4268.74) 5284.69,4255.94 ; 5284.69,4255.94 ccw(c5271.89,4243.13) 5271.89,4261.24 cw(c5271.89,4243.13) 5284.69,4255.94 ; 5284.69,4334.68 cw(c5297.5,4347.48) 5279.39,4347.48 ccw(c5297.5,4347.48) 5284.69,4334.68 ; 5284.69,4334.68 ccw(c5271.89,4321.87) 5271.89,4339.98 cw(c5271.89,4321.87) 5284.69,4334.68 ; 5298.46,4098.46 cw(c5311.26,4085.65) 5311.26,4103.76 ccw(c5311.26,4085.65) 5298.46,4098.46 ; 5298.46,4098.46 ccw(c5285.65,4111.26) 5303.76,4111.26 cw(c5285.65,4111.26) 5298.46,4098.46 ; 5324.06,4045.32 cw(c5311.26,4058.13) 5311.26,4040.02 ccw(c5311.26,4058.13) 5324.06,4045.32 ; 5324.06,4045.32 ccw(c5336.87,4032.52) 5318.76,4032.52 cw(c5336.87,4032.52) 5324.06,4045.32 ; 5324.06,4124.06 cw(c5311.26,4136.87) 5311.26,4118.76 ccw(c5311.26,4136.87) 5324.06,4124.06 ; 5324.06,4124.06 ccw(c5336.87,4111.26) 5318.76,4111.26 cw(c5336.87,4111.26) 5324.06,4124.06 ; 5324.06,4216.57 cw(c5336.87,4229.37) 5318.76,4229.37 ccw(c5336.87,4229.37) 5324.06,4216.57 ; 5324.06,4216.57 ccw(c5311.26,4203.76) 5311.26,4221.87 cw(c5311.26,4203.76) 5324.06,4216.57 ; 5324.06,4295.31 cw(c5336.87,4308.11) 5318.76,4308.11 ccw(c5336.87,4308.11) 5324.06,4295.31 ; 5324.06,4295.31 ccw(c5311.26,4282.5) 5311.26,4300.61 cw(c5311.26,4282.5) 5324.06,4295.31 ; 5363.43,4005.95 cw(c5350.63,4018.76) 5350.63,4000.65 ccw(c5350.63,4018.76) 5363.43,4005.95 ; 5363.43,4005.95 ccw(c5376.24,3993.15) 5358.13,3993.15 cw(c5376.24,3993.15) 5363.43,4005.95 ; 5363.43,4084.69 cw(c5350.63,4097.5) 5350.63,4079.39 ccw(c5350.63,4097.5) 5363.43,4084.69 ; 5363.43,4084.69 ccw(c5376.24,4071.89) 5358.13,4071.89 cw(c5376.24,4071.89) 5363.43,4084.69 ; 5363.43,4163.43 cw(c5350.63,4176.24) 5350.63,4158.13 ccw(c5350.63,4176.24) 5363.43,4163.43 ; 5363.43,4163.43 ccw(c5376.24,4150.63) 5358.13,4150.63 cw(c5376.24,4150.63) 5363.43,4163.43 ; 5363.43,4255.94 cw(c5376.24,4268.74) 5358.13,4268.74 ccw(c5376.24,4268.74) 5363.43,4255.94 ; 5363.43,4255.94 ccw(c5350.63,4243.13) 5350.63,4261.24 cw(c5350.63,4243.13) 5363.43,4255.94 ; 5363.43,4334.68 cw(c5376.24,4347.48) 5358.13,4347.48 ccw(c5376.24,4347.48) 5363.43,4334.68 ; 5363.43,4334.68 ccw(c5350.63,4321.87) 5350.63,4339.98 cw(c5350.63,4321.87) 5363.43,4334.68 ; 5416.57,4045.32 cw(c5403.76,4032.52) 5421.87,4032.52 ccw(c5403.76,4032.52) 5416.57,4045.32 ; 5416.57,4045.32 ccw(c5429.37,4058.13) 5429.37,4040.02 cw(c5429.37,4058.13) 5416.57,4045.32 ; 5416.57,4124.06 cw(c5403.76,4111.26) 5421.87,4111.26 ccw(c5403.76,4111.26) 5416.57,4124.06 ; 5416.57,4124.06 ccw(c5429.37,4136.87) 5429.37,4118.76 cw(c5429.37,4136.87) 5416.57,4124.06 ; 5416.57,4216.57 cw(c5429.37,4203.76) 5429.37,4221.87 ccw(c5429.37,4203.76) 5416.57,4216.57 ; 5416.57,4216.57 ccw(c5403.76,4229.37) 5421.87,4229.37 cw(c5403.76,4229.37) 5416.57,4216.57 ; 5416.57,4295.31 cw(c5429.37,4282.5) 5429.37,4300.61 ccw(c5429.37,4282.5) 5416.57,4295.31 ; 5416.57,4295.31 ccw(c5403.76,4308.11) 5421.87,4308.11 cw(c5403.76,4308.11) 5416.57,4295.31 ; 5455.94,4084.69 cw(c5443.13,4071.89) 5461.24,4071.89 ccw(c5443.13,4071.89) 5455.94,4084.69 ; 5455.94,4084.69 ccw(c5468.74,4097.5) 5468.74,4079.39 cw(c5468.74,4097.5) 5455.94,4084.69 ; 5455.94,4163.43 cw(c5443.13,4150.63) 5461.24,4150.63 ccw(c5443.13,4150.63) 5455.94,4163.43 ; 5455.94,4163.43 ccw(c5468.74,4176.24) 5468.74,4158.13 cw(c5468.74,4176.24) 5455.94,4163.43 ; 5455.94,4255.94 cw(c5468.74,4243.13) 5468.74,4261.24 ccw(c5468.74,4243.13) 5455.94,4255.94 ; 5455.94,4255.94 ccw(c5443.13,4268.74) 5461.24,4268.74 cw(c5443.13,4268.74) 5455.94,4255.94 ; 5455.94,4334.68 cw(c5468.74,4321.87) 5468.74,4339.98 ccw(c5468.74,4321.87) 5455.94,4334.68 ; 5455.94,4334.68 ccw(c5443.13,4347.48) 5461.24,4347.48 cw(c5443.13,4347.48) 5455.94,4334.68 ; 5481.54,4281.54 cw(c5468.74,4294.35) 5468.74,4276.24 ccw(c5468.74,4294.35) 5481.54,4281.54 ; 5481.54,4281.54 ccw(c5494.35,4268.74) 5476.24,4268.74 cw(c5494.35,4268.74) 5481.54,4281.54 ; 5495.31,4045.32 cw(c5482.5,4032.52) 5500.61,4032.52 ccw(c5482.5,4032.52) 5495.31,4045.32 ; 5495.31,4045.32 ccw(c5508.11,4058.13) 5508.11,4040.02 cw(c5508.11,4058.13) 5495.31,4045.32 ; 5495.31,4124.06 cw(c5482.5,4111.26) 5500.61,4111.26 ccw(c5482.5,4111.26) 5495.31,4124.06 ; 5495.31,4124.06 ccw(c5508.11,4136.87) 5508.11,4118.76 cw(c5508.11,4136.87) 5495.31,4124.06 ; 5495.31,4216.57 cw(c5508.11,4203.76) 5508.11,4221.87 ccw(c5508.11,4203.76) 5495.31,4216.57 ; 5495.31,4216.57 ccw(c5482.5,4229.37) 5500.61,4229.37 cw(c5482.5,4229.37) 5495.31,4216.57 ; 5495.31,4374.05 cw(c5508.11,4361.24) 5508.11,4379.35 ccw(c5508.11,4361.24) 5495.31,4374.05 ; 5495.31,4374.05 ccw(c5482.5,4386.85) 5500.61,4386.85 cw(c5482.5,4386.85) 5495.31,4374.05 ; 5534.68,4005.95 cw(c5521.87,3993.15) 5539.98,3993.15 ccw(c5521.87,3993.15) 5534.68,4005.95 ; 5534.68,4005.95 ccw(c5547.48,4018.76) 5547.48,4000.65 cw(c5547.48,4018.76) 5534.68,4005.95 ; 5534.68,4084.69 cw(c5521.87,4071.89) 5539.98,4071.89 ccw(c5521.87,4071.89) 5534.68,4084.69 ; 5534.68,4084.69 ccw(c5547.48,4097.5) 5547.48,4079.39 cw(c5547.48,4097.5) 5534.68,4084.69 ; 5534.68,4163.43 cw(c5521.87,4150.63) 5539.98,4150.63 ccw(c5521.87,4150.63) 5534.68,4163.43 ; 5534.68,4163.43 ccw(c5547.48,4176.24) 5547.48,4158.13 cw(c5547.48,4176.24) 5534.68,4163.43 ; 5534.68,4255.94 cw(c5547.48,4243.13) 5547.48,4261.24 ccw(c5547.48,4243.13) 5534.68,4255.94 ; 5534.68,4255.94 ccw(c5521.87,4268.74) 5539.98,4268.74 cw(c5521.87,4268.74) 5534.68,4255.94 ; 5534.68,4334.68 cw(c5547.48,4321.87) 5547.48,4339.98 ccw(c5547.48,4321.87) 5534.68,4334.68 ; 5534.68,4334.68 ccw(c5521.87,4347.48) 5539.98,4347.48 cw(c5521.87,4347.48) 5534.68,4334.68 ; 5574.05,4045.32 cw(c5561.24,4032.52) 5579.35,4032.52 ccw(c5561.24,4032.52) 5574.05,4045.32 ; 5574.05,4045.32 ccw(c5586.85,4058.13) 5586.85,4040.02 cw(c5586.85,4058.13) 5574.05,4045.32 ; 5574.05,4124.06 cw(c5561.24,4111.26) 5579.35,4111.26 ccw(c5561.24,4111.26) 5574.05,4124.06 ; 5574.05,4124.06 ccw(c5586.85,4136.87) 5586.85,4118.76 cw(c5586.85,4136.87) 5574.05,4124.06 ; 5574.05,4216.57 cw(c5586.85,4203.76) 5586.85,4221.87 ccw(c5586.85,4203.76) 5574.05,4216.57 ; 5574.05,4216.57 ccw(c5561.24,4229.37) 5579.35,4229.37 cw(c5561.24,4229.37) 5574.05,4216.57 ; 5574.05,4295.31 cw(c5586.85,4282.5) 5586.85,4300.61 ccw(c5586.85,4282.5) 5574.05,4295.31 ; 5574.05,4295.31 ccw(c5561.24,4308.11) 5579.35,4308.11 cw(c5561.24,4308.11) 5574.05,4295.31 ; 5574.05,4374.05 cw(c5586.85,4361.24) 5586.85,4379.35 ccw(c5586.85,4361.24) 5574.05,4374.05 ; 5574.05,4374.05 ccw(c5561.24,4386.85) 5579.35,4386.85 cw(c5561.24,4386.85) 5574.05,4374.05 ; 5613.42,3966.58 cw(c5600.61,3953.78) 5618.72,3953.78 ccw(c5600.61,3953.78) 5613.42,3966.58 ; 5613.42,3966.58 ccw(c5626.22,3979.39) 5626.22,3961.28 cw(c5626.22,3979.39) 5613.42,3966.58 ; 5613.42,4163.43 cw(c5600.61,4150.63) 5618.72,4150.63 ccw(c5600.61,4150.63) 5613.42,4163.43 ; 5613.42,4163.43 ccw(c5626.22,4176.24) 5626.22,4158.13 cw(c5626.22,4176.24) 5613.42,4163.43 ; 5613.42,4255.94 cw(c5626.22,4243.13) 5626.22,4261.24 ccw(c5626.22,4243.13) 5613.42,4255.94 ; 5613.42,4255.94 ccw(c5600.61,4268.74) 5618.72,4268.74 cw(c5600.61,4268.74) 5613.42,4255.94 ; 5613.42,4413.42 cw(c5626.22,4400.61) 5626.22,4418.72 ccw(c5626.22,4400.61) 5613.42,4413.42 ; 5613.42,4413.42 ccw(c5600.61,4426.22) 5618.72,4426.22 cw(c5600.61,4426.22) 5613.42,4413.42 ; 6825.95,1680.95 cw(c6813.15,1693.76) 6813.15,1675.65 ccw(c6813.15,1693.76) 6825.95,1680.95 ; 6825.95,1680.95 ccw(c6838.76,1668.15) 6820.65,1668.15 cw(c6838.76,1668.15) 6825.95,1680.95 ; 6904.69,1891.57 cw(c6917.5,1904.37) 6899.39,1904.37 ccw(c6917.5,1904.37) 6904.69,1891.57 ; 6904.69,1891.57 ccw(c6891.89,1878.76) 6891.89,1896.87 cw(c6891.89,1878.76) 6904.69,1891.57 ; 6904.69,1930.94 cw(c6917.5,1943.74) 6899.39,1943.74 ccw(c6917.5,1943.74) 6904.69,1930.94 ; 6904.69,1930.94 ccw(c6891.89,1918.13) 6891.89,1936.24 cw(c6891.89,1918.13) 6904.69,1930.94 ; 6944.06,1799.06 cw(c6931.26,1811.87) 6931.26,1793.76 ccw(c6931.26,1811.87) 6944.06,1799.06 ; 6944.06,1799.06 ccw(c6956.87,1786.26) 6938.76,1786.26 cw(c6956.87,1786.26) 6944.06,1799.06 ; 6944.06,1930.94 cw(c6956.87,1943.74) 6938.76,1943.74 ccw(c6956.87,1943.74) 6944.06,1930.94 ; 6944.06,1930.94 ccw(c6931.26,1918.13) 6931.26,1936.24 cw(c6931.26,1918.13) 6944.06,1930.94 ; 6983.43,1930.94 cw(c6996.24,1943.74) 6978.13,1943.74 ccw(c6996.24,1943.74) 6983.43,1930.94 ; 6983.43,1930.94 ccw(c6970.63,1918.13) 6970.63,1936.24 cw(c6970.63,1918.13) 6983.43,1930.94 ; 7036.57,1930.94 cw(c7049.37,1918.13) 7049.37,1936.24 ccw(c7049.37,1918.13) 7036.57,1930.94 ; 7036.57,1930.94 ccw(c7023.76,1943.74) 7041.87,1943.74 cw(c7023.76,1943.74) 7036.57,1930.94 ; 7075.94,1930.94 cw(c7088.74,1918.13) 7088.74,1936.24 ccw(c7088.74,1918.13) 7075.94,1930.94 ; 7075.94,1930.94 ccw(c7063.13,1943.74) 7081.24,1943.74 cw(c7063.13,1943.74) 7075.94,1930.94 ; 7115.31,1891.57 cw(c7128.11,1878.76) 7128.11,1896.87 ccw(c7128.11,1878.76) 7115.31,1891.57 ; 7115.31,1891.57 ccw(c7102.5,1904.37) 7120.61,1904.37 cw(c7102.5,1904.37) 7115.31,1891.57 ; 7194.05,2049.05 cw(c7206.85,2036.24) 7206.85,2054.35 ccw(c7206.85,2036.24) 7194.05,2049.05 ; 7194.05,2049.05 ccw(c7181.24,2061.85) 7199.35,2061.85 cw(c7181.24,2061.85) 7194.05,2049.05
  Top Layer w8: C241.1@6499.81,1769.35 ccw(c6517.81,1767.76) 6505.03,1754.98 ; C241.1@6500,1769.33 6500,1760.02 6521.81,1738.21 6521.81,1721.79 6518,1717.98 6518,1705 ; C241.1@6507.78,1768.64 ccw(c6540.08,1765.79) 6517.15,1742.86
  Top Layer w12: C191.1@-304.81,3842.2 C191.1@-292.01,3855 ; v1@961.92,3139.15 cw(c952.15,3129.38) 965.97,3129.38 ; EXTHDR1.75@965.97,3071.85 v1@965.97,3142.88 ; 965.97,3130.14 cw(c978.71,3130.14) v1@969.7,3139.15 ; v1@993.42,3139.15 cw(c983.65,3129.38) 997.46,3129.38 ; v1@993.73,3007.7 ccw(c984.72,3016.71) 997.46,3016.71 ; v1@997.46,3003.96 EXTHDR1.73@997.46,3071.85 ; EXTHDR1.73@997.46,3017.46 ccw(c1011.28,3017.46) v1@1001.51,3007.7 ; EXTHDR1.73@997.46,3075 EXTHDR1.73@997.46,3071.85 ; 997.46,3130.14 cw(c1010.21,3130.14) v1@1001.2,3139.15 ; v1@997.46,3142.88 EXTHDR1.73@997.46,3071.85 ; v1@5236.11,5046.11 cw(c5226.72,5036.72) 5240,5036.72 cw(c5253.28,5036.72) v1@5243.89,5046.11 ; v1(5240,5050) 5240,5015 5250,5005 ; C260.1@5257.53,4998.77 ccw(c5250,4997.33) 5250,5005 ; C260.1@5257.53,5011.23 cw(c5250,5012.67) 5250,5005 ; v1(5273.52,3253.37) 5294.52,3253.37 5303.4,3262.25 5303.4,3351.91 5290.31,3365 C265.1@5290.31,3375 ; v1@5277.41,3249.49 cw(c5286.8,3240.1) 5286.8,3253.37 cw(c5286.8,3266.65) v1@5277.41,3257.26 ; C265.1@5283.8,3364.33 cw(c5239.06,3318.09) 5303.4,3318.09 ; C260.1@5290.31,5005 5250,5005 ; 5303.4,3322.09 cw(c5339.29,3322.09) C265.1@5313.91,3347.47 ; v1(5450,5060) 5450.29,5059.71 5481.69,5059.71 5489.68,5051.71 ; v1@5453.89,5056.11 cw(c5462.57,5047.43) 5462.57,5059.71 ; v1@5453.89,5063.89 ccw(c5463.98,5073.98) 5463.98,5059.71 ; C266.1@5479.65,3339.24 cw(c5475.33,3325.55) 5489.69,3325.55 ; C267.1@5481.57,5041.31 ccw(c5478.96,5051.71) 5489.68,5051.71 ; 5481.58,5059.62 cw(c5454.23,5036.72) C267.1@5482.31,5014.72 ; C267.1@5484.43,4993.31 cw(c5462.98,4961.68) 5501.19,4961.68 ; 5489.03,5052.36 cw(c5464.97,5028.3) C267.1@5491.76,5007.32 ; C266.1@5489.68,3375 5489.69,3325.55 ; v1@5491.11,4878.89 ccw(c5466.78,4903.22) 5501.19,4903.22 ; C267.1@5493.07,4962.9 cw(c5483.32,4948.52) 5500.69,4948.52 ; C267.1@5497.8,5041.31 cw(c5500.41,5051.71) 5489.69,5051.71 ; C266.1@5499.72,3339.24 ccw(c5504.04,3325.55) 5489.69,3325.55 ; v1@5501.19,4875 5501.19,4917.19 ; 5501.19,4947.52 5501.19,4932 ; 5501.19,4948.28 cw(c5542.47,4948.28) C267.1@5513.28,4977.47 ; 5501.19,4952.81 ccw(c5536.81,4952.81) v2@5511.62,4927.62 ; C267.1@5501.19,4981.78 ccw(c5565.78,4981.78) v2@5520.11,4936.11 ; v1@5505.69,3304.04 ccw(c5492.41,3304.04) 5501.8,3313.43 ccw(c5511.19,3322.82) v1@5511.19,3309.54 ; v1(5511.19,3304.04) 5489.69,3325.55 ; v2(5516,4932) 5501.19,4917.19 ; C240.1@6495.89,2065.22 cw(c6485.97,2055.3) 6500,2055.3 cw(c6514.03,2055.3) C240.1@6504.11,2065.22 ; C238.1@6500,1960.67 6520,1980.67 v2(6520,1994) 6520,2014 6500,2034 C240.1@6500,2069.33 ; C238.1@6500,1966.48 ccw(c6500,1980.51) 6509.92,1970.59 ccw(c6519.84,1960.67) C238.1@6505.81,1960.67 ; C238.1@6506.67,1967.34 ccw(c6486.83,1987.17) v2@6514.31,1992.83 ; v2@6512.2,1672.28 cw(c6500,1672.88) C222.1@6500,1660.67 6506.67,1660.67 v2(6518,1672) 6518,1705 ; 6512.6,1660.67 ccw(c6512.6,1672.26) v2@6524.18,1671.7 ; v2@6513.89,1676.11 ccw(c6503.97,1686.03) 6518,1686.03 ccw(c6532.03,1686.03) v2@6522.11,1676.11 ; v2@6515.89,1998.11 ccw(c6505.97,2008.03) 6520,2008.03 ccw(c6534.03,2008.03) v2@6524.11,1998.11 ; C189.1@6642.99,2730 6671.37,2758.37 6699.86,2758.37 6700,2758.23 v1(6700,2758) ; 6685.82,2758.37 cw(c6685.82,2743.82) v1@6696.11,2754.11 ; 6687.63,2758.37 ccw(c6687.63,2770.37) v1@6696.11,2761.89 ; C196.1@6951.56,2370.89 cw(c6938.77,2358.1) 6956.86,2358.1 ; v1@6952.97,2320.6 ccw(c6943.58,2329.99) 6956.86,2329.99 ccw(c6970.14,2329.99) v1@6960.75,2320.6 ; C196.1@6955.67,2375 6956.86,2373.81 v1(6956.86,2316.71) ; C199.1@7064.33,1355 7064.33,1345.67 v1(7085,1325) ; v1@7079.5,1325 ccw(c7066.22,1325) 7075.61,1334.39 ccw(c7085,1343.78) v1@7085,1330.5 ; 7081.86,2421.47 cw(c7095.34,2421.47) v1@7088.71,2433.21 ; C197.1@7085.22,2379.11 ccw(c7075.3,2389.03) 7089.33,2389.03 ccw(c7103.36,2389.03) C197.1@7093.44,2379.11 ; v1(7086,2438) 7083.23,2438 7081.86,2439.37 7081.86,2422 7089.33,2414.53 7089.33,2394 C197.1@7089.33,2375 ; v1(7181.19,2758.37) 7248.63,2758.37 C184.1@7277.01,2730 7286.52,2720.48 v1(7286.52,2662.71) ; v1@7185.08,2754.49 cw(c7194.47,2745.1) 7194.47,2758.37 cw(c7194.47,2771.65) v1@7185.08,2762.26 ; 7201.08,2758.37 cw(c7201.08,2693.92) C184.1@7258.1,2723.97 ; 7220.97,2758.37 cw(c7220.97,2704.4) C184.1@7268.72,2729.57 ; C184.1@7240.86,2758.37 cw(c7240.86,2714.89) C184.1@7279.33,2735.16 ; C223.1@7255.67,1355 7303,1355 v2(7352,1306) ; v1@7282.64,2666.6 ccw(c7273.25,2675.99) 7286.52,2675.99 ccw(c7299.8,2675.99) v1@7290.41,2666.6 ; v2@7346.19,1306 ccw(c7332.16,1306) 7342.08,1315.92 ccw(c7352,1325.84) v2@7352,1311.81 ; v2(7480,2110) 7479.33,2110.67 7480,2110.67 C193.1@7520,2110.67 ; v2@7484.11,2105.89 cw(c7495.64,2094.36) 7495.64,2110.67 ; v2@7484.11,2114.11 ccw(c7492.41,2122.41) 7492.41,2110.67 ; v1(7487.52,1583.37) 7489.19,1583.37 7513.37,1583.37 7520,1590 C220.1@7520,1619.33 ; v1@7491.41,1579.49 cw(c7500.8,1570.1) 7500.8,1583.37 cw(c7500.8,1596.65) v1@7491.41,1587.26 ; C220.1@7515.89,1615.22 cw(c7505.97,1605.3) 7520,1605.3 cw(c7534.03,1605.3) C220.1@7524.11,1615.22 ; C193.1@7515.89,2106.56 ccw(c7505.97,2096.64) 7505.97,2110.67 ccw(c7505.97,2124.7) C193.1@7515.89,2114.78 ; C194.1@7520,1919.33 7540.67,1940 7549.6,1940 7571.86,1917.74 7571.86,1908.14 7620,1860 C190.1@7642,1838 ; v1@7636.11,1856.11 cw(c7621.89,1841.89) C190.1@7642,1841.89 ; v1@7643.5,1863.5 v1@7642,1862 ; C190.1@7667.01,1812.99 C190.1@7667.01,1810 7642,1835.01 C190.1@7642,1838 ; 5489.68,5051.71 C267.1@5489.68,5005 5501.19,4993.49 5501.19,4932 ; 5501.19,4917.19 5501.19,4932 ; 5501.19,4917.19 5501.19,4932 ; C190.1@7642,1838 v1@7642,1862 ; v1@7642,1862 v1(7640,1860) 7640,1863 7642,1865 v1@7642,1862
  Top Layer w20: v14(-350,3770) -350,3845 -340,3855 ; -348.83,3846.17 cw(c-322.55,3819.88) C191.1@-298.16,3847.93 ; -340.86,3854.14 cw(c-309.92,3823.19) C191.1@-286.26,3860.01 ; -333.67,3861.33 cw(c-308.44,3836.1) C191.1@-285.03,3863.02 ; C191.1@-318.16,3841.64 ccw(c-340,3830.48) -340,3855 ; C191.1@-318.16,3868.36 cw(c-340,3879.52) -340,3855 ; C191.1@-292.01,3855 -340,3855 ; v2(7490,1826) 7494,1822 7505.33,1810.67 C195.1@7520,1810.67 cw(c7520,1843.68) v2@7491.56,1826.92
  MidLayer1 w4: 4838.82,3772.53 4840.41,3772.53 4898.67,3772.53 4956.93,3772.53 ccw(c4956.93,3796.3) 4980.7,3796.3 cw(c4996.3,3796.3) 4996.3,3811.9 ccw(c4996.3,3835.67) 5020.07,3835.67 cw(c5035.67,3835.67) 5035.67,3851.27 ccw(c5035.67,3875.04) 5059.44,3875.04 cw(c5075.04,3875.04) 5075.04,3890.64 ccw(c5075.04,3914.41) 5098.81,3914.41 cw(c5114.41,3914.41) 5114.41,3930.01 ccw(c5114.41,3953.78) 5138.18,3953.78 cw(c5153.78,3953.78) 5153.78,3969.38 ccw(c5153.78,3993.15) 5177.55,3993.15 cw(c5193.15,3993.15) 5193.15,4008.75 ccw(c5193.15,4032.52) 5216.92,4032.52 cw(c5232.52,4032.52) 5232.52,4048.12 ccw(c5232.52,4071.89) 5256.29,4071.89 cw(c5280.06,4071.89) 5280.06,4095.66 ; 4838.82,4599.3 4840.41,4599.3 4898.67,4599.3 4956.93,4599.3 cw(c4956.93,4583.7) 4972.53,4583.7 ccw(c4996.3,4583.7) 4996.3,4559.93 cw(c4996.3,4544.33) 5011.9,4544.33 ccw(c5035.67,4544.33) 5035.67,4520.56 cw(c5035.67,4504.96) 5051.27,4504.96 ccw(c5075.04,4504.96) 5075.04,4481.19 cw(c5075.04,4465.59) 5090.64,4465.59 ccw(c5114.41,4465.59) 5114.41,4441.82 cw(c5114.41,4426.22) 5130.01,4426.22 ccw(c5153.78,4426.22) 5153.78,4402.45 cw(c5153.78,4386.85) 5169.38,4386.85 ccw(c5193.15,4386.85) 5193.15,4363.08 cw(c5193.15,4347.48) 5208.75,4347.48 ccw(c5232.52,4347.48) 5232.52,4323.71 cw(c5232.52,4308.11) 5248.12,4308.11 ; 4980.7,4741.18 4980.7,4739.59 4980.7,4681.33 4980.7,4623.07 ccw(c4996.3,4623.07) 4996.3,4607.47 cw(c4996.3,4583.7) 5020.07,4583.7 ccw(c5035.67,4583.7) 5035.67,4568.1 cw(c5035.67,4544.33) 5059.44,4544.33 ccw(c5075.04,4544.33) 5075.04,4528.73 cw(c5075.04,4504.96) 5098.81,4504.96 ccw(c5114.41,4504.96) 5114.41,4489.36 cw(c5114.41,4465.59) 5138.18,4465.59 ccw(c5153.78,4465.59) 5153.78,4449.99 cw(c5153.78,4426.22) 5177.55,4426.22 ccw(c5193.15,4426.22) 5193.15,4410.62 cw(c5193.15,4386.85) 5216.92,4386.85 ccw(c5232.52,4386.85) 5232.52,4371.25 cw(c5232.52,4347.48) 5256.29,4347.48 ccw(c5271.89,4347.48) 5271.89,4331.88 ; 5248.03,4308.62 ccw(c5286.7,4308.62) 5259.36,4281.27 ; v3@5264.55,4268.74 ccw(c5246.82,4268.74) 5259.36,4281.27 ; 5271.38,4331.97 cw(c5271.38,4293.3) 5298.73,4320.64 ; v3@5271.89,4276.08 cw(c5271.89,4293.81) 5259.36,4281.27 ; 5280.06,4095.71 ccw(c5281.67,4119.43) 5296.46,4100.83 ; v3@5303.87,4112.56 cw(c5286.04,4115.71) 5296.43,4100.87 cw(c5306.81,4086.04) v3@5309.96,4103.87 ; v3@5303.92,4308.11 ccw(c5286.19,4308.11) 5298.73,4320.64 ; v3@5311.26,4315.45 cw(c5311.26,4333.18) 5298.73,4320.64 ; v3@5468.74,4064.55 cw(c5468.74,4046.82) 5481.27,4059.36 ; v3@5470.04,4276.13 ccw(c5473.19,4293.96) 5483.57,4279.13 ccw(c5493.96,4264.29) v3@5476.13,4267.44 ; v3@5476.08,4071.89 ccw(c5493.81,4071.89) 5481.27,4059.36 ; 5483.54,4279.17 cw(c5498.33,4260.57) 5499.94,4284.29 ; 5499.94,4284.34 ccw(c5499.94,4308.11) 5523.71,4308.11 cw(c5547.48,4308.11) 5547.48,4331.88 ccw(c5547.48,4347.48) 5563.08,4347.48 cw(c5586.85,4347.48) 5586.85,4371.25 ccw(c5586.85,4386.85) 5602.45,4386.85 cw(c5626.22,4386.85) 5626.22,4410.62 ccw(c5626.22,4426.22) 5641.82,4426.22 cw(c5665.59,4426.22) 5665.59,4449.99 ccw(c5665.59,4465.59) 5681.19,4465.59 cw(c5704.96,4465.59) 5704.96,4489.36 ccw(c5704.96,4504.96) 5720.56,4504.96 cw(c5744.33,4504.96) 5744.33,4528.73 ccw(c5744.33,4544.33) 5759.93,4544.33 cw(c5783.7,4544.33) 5783.7,4568.1 ccw(c5783.7,4583.7) 5799.3,4583.7 cw(c5823.07,4583.7) 5823.07,4607.47 5881.33,4607.47 5939.59,4607.47 5941.18,4607.47 ; 5508.11,4048.12 cw(c5508.11,4032.52) 5523.71,4032.52 ccw(c5547.48,4032.52) 5547.48,4008.75 cw(c5547.48,3993.15) 5563.08,3993.15 ccw(c5586.85,3993.15) 5586.85,3969.38 cw(c5586.85,3953.78) 5602.45,3953.78 ccw(c5626.22,3953.78) 5626.22,3930.01 cw(c5626.22,3914.41) 5641.82,3914.41 ccw(c5665.59,3914.41) 5665.59,3890.64 cw(c5665.59,3875.04) 5681.19,3875.04 ccw(c5704.96,3875.04) 5704.96,3851.27 cw(c5704.96,3835.67) 5720.56,3835.67 ccw(c5744.33,3835.67) 5744.33,3811.9 cw(c5744.33,3796.3) 5759.93,3796.3 ccw(c5783.7,3796.3) 5783.7,3772.53 cw(c5783.7,3756.93) 5799.3,3756.93 5799.3,3698.67 5799.3,3640.41 5799.3,3638.82 ; v3@5508.11,4103.92 cw(c5508.11,4086.19) 5520.64,4098.73 ; 5508.62,4048.03 cw(c5508.62,4086.7) 5481.27,4059.36 ; v3@5515.45,4111.26 ccw(c5533.18,4111.26) 5520.64,4098.73 ; 5531.88,4071.89 ccw(c5547.48,4071.89) 5547.48,4056.29 cw(c5547.48,4032.52) 5571.25,4032.52 ccw(c5586.85,4032.52) 5586.85,4016.92 cw(c5586.85,3993.15) 5610.62,3993.15 ccw(c5626.22,3993.15) 5626.22,3977.55 cw(c5626.22,3953.78) 5649.99,3953.78 ccw(c5665.59,3953.78) 5665.59,3938.18 cw(c5665.59,3914.41) 5689.36,3914.41 ccw(c5704.96,3914.41) 5704.96,3898.81 cw(c5704.96,3875.04) 5728.73,3875.04 ccw(c5744.33,3875.04) 5744.33,3859.44 cw(c5744.33,3835.67) 5768.1,3835.67 ccw(c5783.7,3835.67) 5783.7,3820.07 cw(c5783.7,3796.3) 5807.47,3796.3 ccw(c5823.07,3796.3) 5823.07,3780.7 5881.33,3780.7 5939.59,3780.7 5941.18,3780.7 ; 5531.97,4071.38 ccw(c5493.3,4071.38) 5520.64,4098.73 ; v2(6778,1324) 6800,1324 ; v2@6782.32,1320.12 cw(c6791.03,1312.3) 6791.03,1324 cw(c6791.03,1335.7) v2@6782.32,1327.88 ; v2@6785.3,1317.44 cw(c6800,1304.24) 6800,1324 ; v2@6785.3,1330.56 ccw(c6800,1343.76) 6800,1324 ; 6789.29,1591.34 6789.29,1605.27 ; v3@6805.76,1666.85 cw(c6787.93,1663.7) 6802.76,1653.32 ; v3@6814.45,1660.76 ccw(c6817.6,1642.93) 6802.76,1653.32 ; v3@7205.55,2069.24 ccw(c7202.4,2087.07) 7217.24,2076.68 ; v3@7214.24,2063.15 cw(c7232.07,2066.3) 7217.24,2076.68 ; 7230.71,2138.66 7230.71,2124.73 ; 7230.71,2219.33 7230.71,2218.27 7230.71,2198.85 7230.71,2124.73 ; 6789.29,1605.27 6789.29,1531.15 6789.29,1483.9 6812.19,1461 6812.19,1336.19 6800,1324 ; 6789.29,1605.27 6789.29,1628.52 cw(c6813.06,1628.52) 6795.68,1644.74 6802.76,1653.32 ; 7217.24,2076.68 7224.32,2085.26 ccw(c7206.94,2101.48) 7230.71,2101.48 7230.71,2124.73
  MidLayer1 w12: v2@5511.89,4936.11 ccw(c5501.97,4946.03) 5516,4946.03 ccw(c5530.03,4946.03) v2@5520.11,4936.11 ; v2(5516,4932) 5516,4951.15 5570.2,5005.35 ; v1@5901.23,5475.23 cw(c5887.95,5475.23) 5897.34,5465.85 cw(c5906.73,5456.46) v1@5906.73,5469.73 ; v1(5906.73,5475.23) 5728.36,5296.87 5655,5223.51 5655,5164 5590.91,5099.91 5590.91,5096.91 5590.91,5026.06 5572,5007.15 ; 5570.2,5005.35 5572,5007.15 ; 5570.2,5005.35 5572,5007.15
  MidLayer1 w20: TP7.1@56.12,3608.23 cw(c7.84,3608.23) 41.98,3574.09 cw(c76.12,3539.95) TP7.1@76.12,3588.23 ; TP7.1@76.12,3608.23 24,3556.11 24,3339 53,3310 355,3310 376.12,3331.12 PROTOTYPE1.2@376.12,3408.23 ; PROTOTYPE1.2@361.27,3393.39 cw(c325.42,3357.54) 376.12,3357.54 cw(c426.82,3357.54) PROTOTYPE1.2@390.97,3393.39
  MidLayer2 w4: 4838.82,3780.7 4840.41,3780.7 4898.67,3780.7 4956.93,3780.7 ccw(c4956.93,3796.3) 4972.53,3796.3 cw(c4996.3,3796.3) 4996.3,3820.07 ccw(c4996.3,3835.67) 5011.9,3835.67 cw(c5035.67,3835.67) 5035.67,3859.44 ccw(c5035.67,3875.04) 5051.27,3875.04 cw(c5075.04,3875.04) 5075.04,3898.81 ccw(c5075.04,3914.41) 5090.64,3914.41 cw(c5114.41,3914.41) 5114.41,3938.18 ccw(c5114.41,3953.78) 5130.01,3953.78 cw(c5153.78,3953.78) 5153.78,3977.55 ccw(c5153.78,3993.15) 5169.38,3993.15 cw(c5193.15,3993.15) 5193.15,4016.92 ccw(c5193.15,4032.52) 5208.75,4032.52 ; 4838.82,4607.47 4840.41,4607.47 4898.67,4607.47 4956.93,4607.47 cw(c4956.93,4583.7) 4980.7,4583.7 ccw(c4996.3,4583.7) 4996.3,4568.1 cw(c4996.3,4544.33) 5020.07,4544.33 ccw(c5035.67,4544.33) 5035.67,4528.73 cw(c5035.67,4504.96) 5059.44,4504.96 ccw(c5075.04,4504.96) 5075.04,4489.36 cw(c5075.04,4465.59) 5098.81,4465.59 ccw(c5114.41,4465.59) 5114.41,4449.99 cw(c5114.41,4426.22) 5138.18,4426.22 ccw(c5153.78,4426.22) 5153.78,4410.62 cw(c5153.78,4386.85) 5177.55,4386.85 ccw(c5193.15,4386.85) 5193.15,4371.25 cw(c5193.15,4347.48) 5216.92,4347.48 5216.92,4327.91 ; 4972.53,4741.18 4972.53,4739.59 4972.53,4681.33 4972.53,4623.07 ccw(c4996.3,4623.07) 4996.3,4599.3 cw(c4996.3,4583.7) 5011.9,4583.7 ccw(c5035.67,4583.7) 5035.67,4559.93 cw(c5035.67,4544.33) 5051.27,4544.33 ccw(c5075.04,4544.33) 5075.04,4520.56 cw(c5075.04,4504.96) 5090.64,4504.96 ccw(c5114.41,4504.96) 5114.41,4481.19 cw(c5114.41,4465.59) 5130.01,4465.59 ccw(c5153.78,4465.59) 5153.78,4441.82 cw(c5153.78,4426.22) 5169.38,4426.22 ccw(c5193.15,4426.22) 5193.15,4402.45 cw(c5193.15,4386.85) 5208.75,4386.85 ; 4980.7,3638.82 4980.7,3640.41 4980.7,3698.67 4980.7,3756.93 cw(c4996.3,3756.93) 4996.3,3772.53 ccw(c4996.3,3796.3) 5020.07,3796.3 cw(c5035.67,3796.3) 5035.67,3811.9 ccw(c5035.67,3835.67) 5059.44,3835.67 cw(c5075.04,3835.67) 5075.04,3851.27 ccw(c5075.04,3875.04) 5098.81,3875.04 cw(c5114.41,3875.04) 5114.41,3890.64 ccw(c5114.41,3914.41) 5138.18,3914.41 cw(c5153.78,3914.41) 5153.78,3930.01 ccw(c5153.78,3953.78) 5177.55,3953.78 cw(c5193.15,3953.78) 5193.15,3969.38 ccw(c5193.15,3993.15) 5216.92,3993.15 ; 5208.66,4032.61 5208.66,4071.38 cw(c5247.33,4071.38) 5219.99,4098.73 ; 5215.71,4370.04 cw(c5232.52,4386.85) 5208.75,4386.85 ; 5217.01,4327.82 ccw(c5227.16,4327.82) 5219.99,4320.64 ; v3@5225.18,4111.26 cw(c5207.45,4111.26) 5219.99,4098.73 ; v3@5225.18,4308.11 ccw(c5207.45,4308.11) 5219.99,4320.64 ; v3@5232.52,4103.92 ccw(c5232.52,4086.19) 5219.99,4098.73 ; v3@5232.52,4315.45 cw(c5232.52,4333.18) 5219.99,4320.64 ; 5232.61,4008.66 5271.38,4008.66 ccw(c5271.38,4047.33) 5298.73,4019.99 ; 5252.08,4363.08 5232.52,4363.08 cw(c5232.52,4386.85) 5208.75,4386.85 ; 5252.18,4362.99 cw(c5252.18,4352.84) 5259.36,4360.01 ; v3@5303.92,4032.52 cw(c5286.19,4032.52) 5298.73,4019.99 ; v3@5311.26,4025.18 ccw(c5311.26,4007.45) 5298.73,4019.99 ; v3@5468.74,4354.82 ccw(c5468.74,4372.55) 5481.27,4360.01 ; v3@5476.08,4347.48 cw(c5493.81,4347.48) 5481.27,4360.01 ; 5527.82,4017.01 cw(c5527.82,4027.16) 5520.64,4019.99 ; 5527.92,4016.92 5547.48,4016.92 cw(c5547.48,3993.15) 5571.25,3993.15 ; 5547.39,4371.34 5508.62,4371.34 ccw(c5508.62,4332.67) 5481.27,4360.01 ; v3@5547.48,4064.55 cw(c5547.48,4046.82) 5560.01,4059.36 ; v3@5547.48,4276.08 ccw(c5547.48,4293.81) 5560.01,4281.27 ; v3@5554.82,4071.89 ccw(c5572.55,4071.89) 5560.01,4059.36 ; v3@5554.82,4268.74 cw(c5572.55,4268.74) 5560.01,4281.27 ; 5562.99,4052.18 ccw(c5552.84,4052.18) 5560.01,4059.36 ; 5563.08,4052.08 5563.08,4032.52 ccw(c5586.85,4032.52) 5586.85,4008.75 cw(c5586.85,3993.15) 5602.45,3993.15 ccw(c5626.22,3993.15) 5626.22,3969.38 cw(c5626.22,3953.78) 5641.82,3953.78 ccw(c5665.59,3953.78) 5665.59,3930.01 cw(c5665.59,3914.41) 5681.19,3914.41 ccw(c5704.96,3914.41) 5704.96,3890.64 cw(c5704.96,3875.04) 5720.56,3875.04 ccw(c5744.33,3875.04) 5744.33,3851.27 cw(c5744.33,3835.67) 5759.93,3835.67 ccw(c5783.7,3835.67) 5783.7,3811.9 cw(c5783.7,3796.3) 5799.3,3796.3 ccw(c5823.07,3796.3) 5823.07,3772.53 5881.33,3772.53 5939.59,3772.53 5941.18,3772.53 ; 5564.29,4009.96 cw(c5547.48,3993.15) 5571.25,3993.15 ; 5571.25,4347.48 cw(c5586.85,4347.48) 5586.85,4363.08 ccw(c5586.85,4386.85) 5610.62,4386.85 cw(c5626.22,4386.85) 5626.22,4402.45 ccw(c5626.22,4426.22) 5649.99,4426.22 cw(c5665.59,4426.22) 5665.59,4441.82 ccw(c5665.59,4465.59) 5689.36,4465.59 cw(c5704.96,4465.59) 5704.96,4481.19 ccw(c5704.96,4504.96) 5728.73,4504.96 cw(c5744.33,4504.96) 5744.33,4520.56 ccw(c5744.33,4544.33) 5768.1,4544.33 cw(c5783.7,4544.33) 5783.7,4559.93 ccw(c5783.7,4583.7) 5807.47,4583.7 cw(c5823.07,4583.7) 5823.07,4599.3 5881.33,4599.3 5939.59,4599.3 5941.18,4599.3 ; 5571.34,4347.39 5571.34,4308.62 cw(c5532.67,4308.62) 5560.01,4281.27 ; 5799.3,4741.18 5799.3,4739.59 5799.3,4681.33 5799.3,4623.07 cw(c5783.7,4623.07) 5783.7,4607.47 ccw(c5783.7,4583.7) 5759.93,4583.7 cw(c5744.33,4583.7) 5744.33,4568.1 ccw(c5744.33,4544.33) 5720.56,4544.33 cw(c5704.96,4544.33) 5704.96,4528.73 ccw(c5704.96,4504.96) 5681.19,4504.96 cw(c5665.59,4504.96) 5665.59,4489.36 ccw(c5665.59,4465.59) 5641.82,4465.59 cw(c5626.22,4465.59) 5626.22,4449.99 ccw(c5626.22,4426.22) 5602.45,4426.22 cw(c5586.85,4426.22) 5586.85,4410.62 ccw(c5586.85,4386.85) 5563.08,4386.85 ; 5807.47,3638.82 5807.47,3640.41 5807.47,3698.67 5807.47,3756.93 ccw(c5783.7,3756.93) 5783.7,3780.7 cw(c5783.7,3796.3) 5768.1,3796.3 ccw(c5744.33,3796.3) 5744.33,3820.07 cw(c5744.33,3835.67) 5728.73,3835.67 ccw(c5704.96,3835.67) 5704.96,3859.44 cw(c5704.96,3875.04) 5689.36,3875.04 ccw(c5665.59,3875.04) 5665.59,3898.81 cw(c5665.59,3914.41) 5649.99,3914.41 ccw(c5626.22,3914.41) 5626.22,3938.18 cw(c5626.22,3953.78) 5610.62,3953.78 ccw(c5586.85,3953.78) 5586.85,3977.55 cw(c5586.85,3993.15) 5571.25,3993.15 ; 6665.67,1928.23 6735.47,1928.23 6754.89,1928.23 6829.01,1928.23 6848.51,1928.23 cw(c6848.51,1886.5) 6878.02,1916.01 ; 6665.67,1967.6 6735.47,1967.6 6754.89,1967.6 6829.01,1967.6 6848.51,1967.6 cw(c6848.51,1925.87) 6878.02,1955.38 ; v3@6884.42,1903.72 ccw(c6866.38,1902.14) 6878.02,1916.01 ; v3@6884.42,1943.09 ccw(c6866.38,1941.51) 6878.02,1955.38 ; v3@6891.24,1911.84 cw(c6889.66,1929.88) 6878.02,1916.01 ; v3@6891.24,1951.21 cw(c6889.66,1969.25) 6878.02,1955.38 ; v3@7128.76,1911.84 ccw(c7130.34,1929.88) 7141.98,1916.01 ; v3@7135.58,1903.72 cw(c7153.62,1902.14) 7141.98,1916.01 ; 7354.33,1928.23 7284.53,1928.23 7265.11,1928.23 7190.99,1928.23 7171.49,1928.23 ccw(c7171.49,1886.5) 7141.98,1916.01 ; 5216.92,3993.15 cw(c5232.52,3993.15) 5232.52,4008.75 ccw(c5232.52,3993.15) 5216.92,3993.15 ; 5259.36,4360.01 cw(c5246.82,4347.48) 5264.55,4347.48 ccw(c5246.82,4347.48) 5259.36,4360.01 ; 5259.36,4360.01 ccw(c5271.89,4372.55) 5271.89,4354.82 cw(c5271.89,4372.55) 5259.36,4360.01 ; 5520.64,4019.99 cw(c5533.18,4032.52) 5515.45,4032.52 ccw(c5533.18,4032.52) 5520.64,4019.99 ; 5520.64,4019.99 ccw(c5508.11,4007.45) 5508.11,4025.18 cw(c5508.11,4007.45) 5520.64,4019.99 ; 5563.08,4386.85 cw(c5547.48,4386.85) 5547.48,4371.25 ccw(c5547.48,4386.85) 5563.08,4386.85
  MidLayer2 w12: v1@4884.82,4803 4946.41,4803 4982.36,4838.95 4982.36,4997.36 5020,5035 5150,5035 5165.04,5050.04 5239.96,5050.04 v1(5240,5050) ; v1@4887.89,4807.89 ccw(c4899.69,4819.69) 4899.69,4803 ; 5226.62,5050.04 cw(c5226.62,5036.62) v1@5236.11,5046.11 ; 5226.82,5050.04 ccw(c5226.82,5063.18) v1@5236.11,5053.89
  MidLayer2 w20: v14(-350,3770) -350,3800 -335,3815 -225,3815 -210,3800 -210,3735 -235.5,3709.5 -285.5,3709.5 -310,3685 -310,3640 -278.23,3608.23 TP7.1@76.12,3608.23 ; TP7.1@61.98,3594.09 ccw(c27.84,3559.95) 27.84,3608.23 ccw(c27.84,3656.52) TP7.1@61.98,3622.38 ; PROTOTYPE1.2@361.27,3393.39 cw(c325.42,3357.54) 376.12,3357.54 cw(c426.82,3357.54) PROTOTYPE1.2@390.97,3393.39 ; PROTOTYPE1.2@376.12,3408.23 376.12,3343.88 410,3310 720,3310 730,3300 730,3235 705,3210 580,3210 545,3175 545,3100 565,3080 955,3080 965.81,3090.81 v1(965.81,3143.04)