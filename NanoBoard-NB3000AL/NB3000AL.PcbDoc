# Altium PCB NB3000AL.PcbDoc (part 78 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Other copper (continued)
GND+SHIELD (plane layer: these items are gaps in the copper):
  lines w10: -530.1,1895 -530.1,1565 ccw(c-470.1,1565) -470.1,1505 515,1505 cw(c515,1445) 575,1445 575,1210 cw(c515,1210) 515,1150 210,1150 ccw(c210,1090) 150,1090 150,375 ccw(c210,375) 210,315 2775,315 ; -526.2,2235.6 -526.2,5396.2 ; -525.94,3175.26 79.74,3175.26 ccw(c79.74,3205.26) 109.74,3205.26 109.75,4033.54 ccw(c76.12,4033.54) 76.12,4067.16 cw(c76.12,4108.23) 76.12,4149.31 ccw(c76.12,4182.93) 109.75,4182.93 109.74,5475 109.74,5739.74 ccw(c79.74,5739.74) 79.74,5769.74 -325.77,5769.74 ; -430,2270 -430,2975 cw(c-400,2975) -400,3005 195,3005 cw(c195,2975) 225,2975 225,2260 cw(c195,2260) 195,2230 -340,2230 ; -352.91,5741.94 181.84,6276.69 cw(c224.27,6234.27) 224.27,6294.27 365.43,6294.27 ccw(c365.43,6354.27) 425.43,6354.27 425.43,6565.73 cw(c485.43,6565.73) 485.43,6625.73 1035.73,6625.73 cw(c1035.73,6565.73) 1095.73,6565.73 1095.73,6354.27 ccw(c1155.73,6354.27) 1155.73,6294.27 1391.56,6294.27 ccw(c1391.56,6354.27) 1433.99,6311.84 1534.57,6412.43 cw(c1577,6370) 1577,6430 1791,6430 cw(c1791,6370) 1833.43,6412.43 1934.01,6311.84 ccw(c1976.44,6354.27) 1976.44,6294.27 ; 822.49,2662.37 822.49,3217.66 ccw(c762.49,3217.66) 804.91,3260.09 752.66,3312.34 cw(c795.09,3354.77) 735.09,3354.77 735.05,3408.23 cw(c776.12,3408.23) 817.19,3408.23 817.23,3354.77 ccw(c877.23,3354.77) 834.81,3312.34 ; 822.85,2662.01 ccw(c882.85,2662.01) 840.42,2619.58 1247.57,2212.43 cw(c1205.15,2170) 1265.15,2170 ; 834.94,3312.34 869.85,3277.43 cw(c827.43,3235) 887.43,3235 ; 887.43,2887.57 1632.57,2887.57 cw(c1632.57,2827.57) 1675,2870 2332.57,2212.43 cw(c2290.15,2170) 2350.15,2170 ; 887.43,3167.57 1000,3167.57 ; 887.43,3234.99 887.43,2702.42 ccw(c947.43,2702.42) 905.01,2660 ; 905.15,2660 1332.57,2232.57 ccw(c1375,2275) 1375,2215 1695.69,2215 cw(c1695.69,2155) 1755.69,2155 1755.69,1915 ccw(c1815.69,1915) 1815.69,1855 cw(c1815.69,1795) 1875.69,1795 1875.69,1674.02 cw(c1815.69,1674.02) 1815.69,1614.02 1605,1614.02 ccw(c1605,1554.02) 1545,1554.02 1545,1480 ; 950,3165 950,3035 ccw(c1010,3035) 1010,2975 1730,2975 cw(c1730,2915) 1772.43,2957.43 2978.26,1751.59 ccw(c3020.69,1794.02) 3020.69,1734.02 ; 952.57,3167.57 982.57,3167.57 1737.09,3167.57 cw(c1737.09,3107.57) 1779.52,3150 3027.57,1901.94 ccw(c3070,1944.37) 3070,1884.37 3359.37,1884.37 4834.69,1884.37 ccw(c4834.69,1963.11) 4913.43,1963.11 4913.43,2046.57 4913.43,2752.52 cw(c4992.17,2752.52) 4992.17,2831.26 5081.26,2831.26 ccw(c5081.26,2910) 5160,2910 5160,3490 cw(c5238.74,3490) 5238.74,3568.74 ccw(c5238.74,3647.48) 5317.48,3647.48 5317.48,3750 cw(c5338.88,3750) 5327.05,3767.83 5341.06,3778.47 ccw(c5329.23,3796.3) 5350.63,3796.3 5350.63,3939.16 ccw(c5311.26,3939.16) 5311.26,3978.53 5229.7,3978.53 ccw(c5229.7,3939.16) 5190.33,3939.16 cw(c5153.78,3953.78) 5153.78,3914.41 cw(c5153.78,3953.78) 5114.41,3953.78 ; 1214,5562.61 1214,5789.88 ccw(c1184,5789.88) 1184,5819.88 cw(c1184,5849.88) 1154,5849.88 1154,5905.73 cw(c1184,5905.73) 1184,5935.73 1264.78,5935.73 cw(c1264.78,5905.73) 1294.78,5905.73 1294.78,5502.61 1294.78,5227.39 cw(c1264.78,5227.39) 1264.78,5197.39 139.74,5197.39 cw(c139.74,5227.39) 109.74,5227.39 109.74,5502.61 cw(c139.74,5502.61) 139.74,5532.61 1184,5532.61 ccw(c1184,5562.61) 1214,5562.61 ; 1265,2169.85 1265,2005 cw(c1215,2005) 1215,1955 1095,1955 ccw(c1095,1905) 1045,1905 ccw(c1095,1905) 1095,1855 1385,1855 cw(c1385,1795) 1445,1795 1445,1480 ; 1445,1515 1445,1300 ccw(c1495,1300) 1495,1250 4075,1250 ; 1545,1515 1545,1390 ccw(c1595,1390) 1595,1340 3975,1340 ; 1978.67,6294.27 2053.67,6294.27 2602.33,6294.27 2677.33,6294.27 ; 2350,2169.85 2350,2005 cw(c2300,2005) 2300,1955 2180,1955 ccw(c2180,1905) 2130,1905 ccw(c2180,1905) 2180,1855 2470,1855 cw(c2470,1795) 2530,1795 2530,1480 ccw(c2580,1480) 2580,1430 ccw(c2580,1480) 2630,1480 2630,1554.02 cw(c2690,1554.02) 2690,1614.02 2900.69,1614.02 ccw(c2900.69,1674.02) 2960.69,1674.02 cw(c3020.69,1674.02) 3020.69,1734.02 ; 2630.08,5532.61 ccw(c2630.08,5562.61) 2660.08,5562.61 2660.08,5789.88 ccw(c2630.08,5789.88) 2630.08,5819.88 cw(c2630.08,5849.88) 2600.08,5849.88 2600.08,5905.73 cw(c2630.08,5905.73) 2630.08,5935.73 2710.87,5935.73 cw(c2710.87,5905.73) 2740.87,5905.73 2740.87,5502.61 2740.87,5227.39 cw(c2710.87,5227.39) 2710.87,5197.39 1585.83,5197.39 cw(c1585.83,5227.39) 1555.83,5227.39 1555.83,5502.61 cw(c1585.83,5502.61) 1585.83,5532.61 2635,5532.61 ; 2679.56,6294.27 ccw(c2679.56,6354.27) 2721.99,6311.84 2976.84,6566.69 cw(c3019.27,6524.27) 3019.27,6584.27 4952.17,6584.27 cw(c4952.17,6524.27) 4994.6,6566.69 5188.72,6372.57 ccw(c5231.14,6415) 5231.14,6355 5306.14,6355 ; 2775.11,315.04 cw(c2775.11,255.04) 2817.54,297.46 2837.45,277.55 ccw(c2879.87,319.98) 2879.87,259.98 3172.33,259.98 ccw(c3172.33,319.98) 3214.76,277.55 3234.67,297.46 cw(c3277.09,255.04) 3277.09,315.04 3365.11,315.04 cw(c3365.11,255.04) 3407.54,297.46 3427.45,277.55 ccw(c3469.87,319.98) 3469.87,259.98 3762.33,259.98 ccw(c3762.33,319.98) 3804.76,277.55 3824.67,297.46 cw(c3867.09,255.04) 3867.09,315.04 3896.61,315.04 cw(c3896.61,255.04) 3939.03,297.46 3958.94,277.55 ccw(c4001.37,319.98) 4001.37,259.98 4990,259.98 ccw(c4990,319.98) 5050,319.98 5050,750 cw(c5080,750) 5080,780 5104.44,780 cw(c5104.44,750) 5134.44,750 5134.44,405 ccw(c5164.44,405) 5164.44,375 5235.35,375 ; 3975,1339.96 ccw(c3975,1389.96) 4025,1389.96 4025,1524.96 cw(c4075,1524.96) 4075,1574.96 cw(c4075,1524.96) 4125,1524.96 4125,1299.96 cw(c4075,1299.96) 4075,1249.96 ; 5114.39,3953.8 5114.41,3953.78 ; 5160,4920 5160,5000 cw(c5238.74,5000) 5238.74,5078.74 5541.26,5078.74 cw(c5541.26,5000) 5620,5000 5620,4925 cw(c5541.26,4925) 5541.26,4846.26 5512.41,4846.26 ccw(c5512.41,4767.52) 5433.67,4767.52 5433.67,4500.99 cw(c5394.3,4500.99) 5419.71,4470.92 ccw(c5445.12,4440.84) 5405.75,4440.84 ccw(c5445.12,4440.84) 5445.12,4401.47 5550.3,4401.47 ccw(c5550.3,4440.84) 5589.67,4440.84 cw(c5626.22,4426.22) 5626.22,4465.59 cw(c5626.22,4426.22) 5665.59,4426.22 cw(c5649.84,4422.28) 5653.78,4406.54 ccw(c5655.75,4392.76) 5641.97,4390.79 5641.97,4382.91 5641.97,4343.54 ccw(c5655.75,4341.58) 5653.78,4327.8 cw(c5649.84,4312.05) 5665.59,4308.11 5665.59,4111.26 cw(c5649.84,4107.32) 5653.78,4091.57 ccw(c5655.75,4077.8) 5641.97,4075.83 5641.97,3997.09 5641.97,3989.21 ccw(c5655.75,3987.24) 5653.78,3973.46 cw(c5649.84,3957.72) 5665.59,3953.78 cw(c5626.22,3953.78) 5626.22,3914.41 cw(c5626.22,3953.78) 5589.67,3939.16 ccw(c5550.3,3939.16) 5550.3,3978.53 5468.74,3978.53 ccw(c5468.74,3939.16) 5429.37,3939.16 5429.37,3796.3 ccw(c5450.77,3796.3) 5438.94,3778.47 5452.95,3767.83 cw(c5441.12,3750) 5462.52,3750 5462.52,3647.48 ccw(c5541.26,3647.48) 5541.26,3568.74 cw(c5541.26,3490) 5615.63,3515.87 ; 5160,4925 ccw(c5238.74,4925) 5238.74,4846.26 5256.14,4846.26 cw(c5256.14,4767.52) 5334.88,4767.52 5334.88,4440.84 cw(c5295.51,4440.84) 5295.51,4401.47 5229.7,4401.47 cw(c5229.7,4440.84) 5190.33,4440.84 ccw(c5153.78,4426.22) 5153.78,4465.59 ccw(c5153.78,4426.22) 5114.41,4426.22 ccw(c5130.16,4422.28) 5126.22,4406.54 cw(c5124.25,4392.76) 5138.03,4390.79 5138.03,4382.91 cw(c5124.25,4380.95) 5126.22,4367.17 ccw(c5130.16,4351.42) 5114.41,4347.48 5114.41,4032.52 ccw(c5130.16,4028.58) 5126.22,4012.83 cw(c5124.25,3999.05) 5138.03,3997.09 5138.03,3989.21 cw(c5124.25,3987.24) 5126.22,3973.46 ccw(c5130.16,3957.72) 5114.41,3953.78 ; 5164.59,375.15 5283.99,375.15 5283.99,447.59 cw(c5317.57,447.59) 5351.15,447.59 5351.15,375.94 5351.54,375.54 5388.64,375.54 5388.64,447.98 cw(c5422.22,447.98) 5455.8,447.98 5455.8,375.54 5456.58,374.76 5603.99,374.76 5603.99,447.2 cw(c5637.57,447.2) 5671.15,447.2 5671.15,375.54 5671.54,375.15 5708.64,375.15 5708.64,447.59 cw(c5742.22,447.59) 5775.8,447.59 5775.8,375.15 ; 5233.37,6355 5308.37,6355 ccw(c5308.37,6415) 5350.8,6372.57 5605.65,6627.43 ; 5598,3487.46 ccw(c5598,3468) 5598,3448.54 5600.46,3448.54 ; 5598,3487.91 ccw(c5598,3507.37) 5615.56,3515.75 ; 5600.54,3448.46 cw(c5600.54,3429) 5620,3429 5620,3260 cw(c5541.26,3260) 5541.26,3181.26 ccw(c5541.26,3102.52) 5462.52,3102.52 5462.52,2742.48 cw(c5383.78,2742.48) 5383.78,2663.74 5294.68,2663.74 ccw(c5294.68,2585) 5215.94,2585 5215.94,2460.94 5215.94,1963.43 ccw(c5294.68,1963.43) 5294.68,1884.68 6480.6,1884.7 ccw(c6480.6,1904.7) 6500.6,1904.7 ; 5605.94,6627.43 cw(c5648.37,6585) 5648.37,6645 5875,6645 cw(c5875,6585) 5917.43,6627.43 ; 5776,375 5895.35,375 ccw(c5895.35,405) 5925.35,405 5925.35,750 cw(c5955.35,750) 5955.35,780 5979.79,780 cw(c5979.79,750) 6009.79,750 6009.79,319.98 cw(c5979.79,319.98) 5979.79,289.98 5359.98,289.98 ccw(c5359.98,259.98) 5329.98,259.98 5329.98,164.98 ccw(c5359.98,164.98) 5359.98,134.98 6590.02,134.98 cw(c6590.02,74.98) 6632.45,117.41 6652.35,97.5 ccw(c6694.78,139.93) 6694.78,79.93 7089.93,79.93 ccw(c7089.93,109.93) 7119.93,109.93 7119.93,354.93 cw(c7149.93,354.93) 7149.93,384.93 7225,384.93 cw(c7225,354.93) 7255,354.93 7255,295 ccw(c7285,295) 7285,265 7429.01,265 ccw(c7429.01,295) 7459.01,295 7459.01,354.93 cw(c7489.01,354.93) 7489.01,384.93 7564.09,384.93 cw(c7564.09,354.93) 7594.09,354.93 7594.09,64.12 ; 5917.72,6627.43 6172.57,6372.57 ccw(c6215,6415) 6215,6355 6290,6355 ccw(c6290,6415) 6332.43,6372.57 6449.85,6490 cw(c6492.28,6447.57) 6492.28,6507.57 6495.99,6507.57 ccw(c6495.99,6537.57) 6525.99,6537.57 6525.99,6619 cw(c6555.99,6619) 6555.99,6649 6700,6649 cw(c6700,6619) 6730,6619 6730,6559.07 ccw(c6760,6559.07) 6760,6529.07 6860,6529.07 ccw(c6860,6589.07) 6920,6589.07 6920,6615 cw(c6980,6615) 6980,6675 7145,6675 cw(c7145,6615) 7187.43,6657.43 7336.57,6508.41 ccw(c7379,6550.84) 7379,6490.84 7697.85,6490.84 ; 6478.7,1766.5 cw(c6478.7,1746.5) 6498.7,1746.5 ; 6478.7,1766.57 3825.94,1766.57 ccw(c3825.94,1687.83) 3747.2,1687.83 3747.2,1497.8 cw(c3668.46,1497.8) 3668.46,1419.06 3470,1419.06 cw(c3470,1497.8) 3391.26,1497.8 cw(c3470,1497.8) 3470,1576.54 ccw(c3470,1655.28) 3548.74,1655.28 ccw(c3470,1655.28) 3470,1734.02 3020.69,1734.02 ; 6498.64,1746.5 6498.64,1658.2 ccw(c6518.1,1658.2) 6537.56,1658.2 ; 6500.54,1904.7 6500.54,1993 cw(c6520,1993) 6539.46,1993 ; 6537.4,1746.5 cw(c6557.4,1746.5) 6557.4,1766.5 ; 6537.46,1658.2 6537.46,1746.5 ; 6539.3,1904.7 ccw(c6559.3,1904.7) 6559.3,1884.7 6793.46,1884.7 ; 6539.36,1904.7 6539.36,1993 ; 6559.2,1766.73 6852.36,1766.73 cw(c6852.36,1746.73) 6872.36,1746.73 6872.36,1715.68 cw(c6852.36,1715.68) 6852.36,1695.68 6813.15,1695.68 ; 6778,1342 ccw(c6778,1321) 6778,1300 7308,1300 ; 6780.1,1341.83 6819.31,1341.83 ; 6793.31,1660.15 6793.31,1676.15 ; 6793.46,1660.15 ccw(c6813.15,1660.15) 6813.15,1640.46 ; 6793.46,1676.15 cw(c6813.15,1676.15) 6813.15,1695.83 ; 6813.15,1640.62 6852.36,1640.62 cw(c6852.36,1620.62) 6872.36,1620.62 ; 6813.62,1341.82 6852.58,1341.82 ; 6852.6,1341.8 ccw(c6852.6,1361.48) 6872.28,1361.48 ; 6872.2,2416 6872.2,1963.43 ; 6872.2,2419 ccw(c6856.66,2419) 6856.66,2434.54 6829,2434.54 ; 6872.31,1361.49 6872.31,1620.62 ; 7108.27,1622.85 7108.27,1707.36 cw(c7128.27,1707.36) 7128.27,1727.36 ; 7108.27,1943.9 ccw(c7128.27,1943.9) 7128.27,1923.9 ; 7108.3,1943.9 7108.3,2070.54 cw(c7128.3,2070.54) 7128.3,2090.54 7170,2090.54 cw(c7170,2072.54) 7188,2072.54 7188,2064 ccw(c7208,2064) 7208,2044 ccw(c7208,2060) 7224,2060 7224,2064.54 cw(c7250,2064.54) 7250,2090.54 7480,2090.54 ccw(c7480,2110) 7480,2129.46 7431,2129.46 7431,2146 ccw(c7398,2146) 7365,2146 7365,2129.46 7129,2129.46 ; 7108.3,2149.46 ccw(c7128.3,2149.46) 7128.3,2129.46 ; 7108.36,1498.99 cw(c7128.36,1498.99) 7128.36,1518.99 7487.52,1518.97 ; 7108.36,1622.76 ccw(c7128.36,1622.76) 7128.36,1602.76 7269.38,1602.77 7269.4,1589.87 ccw(c7285.59,1589.41) 7301.79,1589.9 7301.79,1602.79 7487.52,1602.77 cw(c7487.52,1583.32) 7506.98,1583.32 7506.98,1538.37 cw(c7487.52,1538.37) 7487.52,1518.92 ; 7108.42,1404 ccw(c7146.42,1404) 7146.42,1366 7326,1366 cw(c7326,1316) 7376,1316 7376,1306 cw(c7352,1306) 7352,1282 cw(c7352,1310.97) 7331.51,1290.49 ccw(c7308.54,1267.51) 7308.54,1300 ; 7108.42,1408 7108.42,1500 ; 7108.43,2149.46 7108.43,2561.57 cw(c7187.17,2561.57) 7187.17,2640.32 7370,2640.32 ccw(c7370,2719.06) 7448.74,2719.06 ccw(c7370,2719.06) 7370,2797.8 6650,2797.8 ccw(c6650,2719.06) 6571.26,2719.06 ccw(c6650,2719.06) 6650,2640.32 6793.46,2640.32 cw(c6793.46,2561.57) 6872.2,2561.57 6872.2,2488 cw(c6857.66,2488) 6857.66,2473.46 6829,2473.46 ; 7127.95,1727.05 ccw(c7127.95,1747.05) 7147.95,1747.05 ; 7127.95,1924.21 cw(c7127.95,1904.21) 7147.95,1904.21 ; 7147.64,1746.73 cw(c7167.64,1746.73) 7167.64,1766.73 7680.16,1766.73 ; 7147.64,1904.53 ccw(c7167.64,1904.53) 7167.64,1884.53 ; 7167.64,1884.68 7475,1884.68 7680.32,1884.68 cw(c7680.32,1825.63) 7680.32,1766.57 ; 6671,2434.54 cw(c6671,2454) 6671,2473.46 ; 6671,2434.54 cw(c6671,2454) 6671,2473.46 ; 6671,2434.54 6829,2434.54 ; 6671,2434.54 6829,2434.54 ; 6671,2473.46 6829,2473.46 ; 6671,2473.46 6829,2473.46 ; 6872.2,1963.43 cw(c6793.46,1963.43) 6793.46,1884.68 ccw(c6793.46,1963.43) 6872.2,1963.43 ; 7108.42,1500 7108.42,1400 7108.42,1500
  text "AUGND" at -310,5725 h30
  text "AGND" at 155,5470 h30
  text "AGND" at 1601.08,5470 h30
  text "AUGND" at -410,2965 h30
  text "GND" at 1795,2365 h30
  text "2V5" at 1515,1950 h30
  text "1V8" at 2620,1900 h30
  text "1V2" at 3600,1775 h30
  text "SHIELD" at 75,1335 h30