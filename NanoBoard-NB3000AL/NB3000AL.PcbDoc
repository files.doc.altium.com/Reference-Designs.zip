# Altium PCB NB3000AL.PcbDoc (part 39 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_SRAM2.NCS: U8.J10 U15.6 | length 4409
  Top Layer w4: v3(5193.15,4426.22) U8.J10@5212.83,4406.54 ; U8.J10@5205.49,4406.54 ccw(c5187.77,4406.53) 5200.3,4419.07 ccw(c5212.83,4431.6) U8.J10@5212.83,4413.88 ; 5205.95,4413.42 cw(c5218.76,4426.22) 5200.65,4426.22 ccw(c5218.76,4426.22) 5205.95,4413.42 ; 5205.95,4413.42 ccw(c5193.15,4400.61) 5193.15,4418.72 cw(c5193.15,4400.61) 5205.95,4413.42
  MidLayer2 w4: v1@4930.5,4895 ccw(c4907.56,4895) 4923.78,4911.22 ccw(c4940,4927.43) v1@4940,4904.5 ; v1@4934.5,4895 ccw(c4921.22,4895) 4930.61,4904.39 ccw(c4940,4913.78) v1@4940,4900.5 ; v1(4940,4895) 4923.52,4911.48 4923.52,5091.71 4948.52,5116.71 5098.29,5116.71 5117,5098 5128.31,5098 5138.31,5088 5328,5088 5394.74,5154.74 5464.84,5154.74 5478.37,5141.21 5483.34,5141.21 ; 5483.84,5141.71 v1(5598.52,5141.71) ; v1@7091.81,5243.32 cw(c7075.59,5227.11) 7098.52,5227.11 cw(c7121.46,5227.11) v1@7105.24,5243.32 ; v1@7094.64,5246.15 cw(c7085.25,5236.76) 7098.52,5236.76 cw(c7111.8,5236.76) v1@7102.41,5246.15 ; v1(7098.52,5250.04) 7098.52,4983.37 v1(7165.19,4916.71) ; v1@7155.69,4916.71 ccw(c7132.76,4916.71) 7148.97,4932.93 ccw(c7165.19,4949.14) v1@7165.19,4926.21 ; v1@7159.69,4916.71 ccw(c7146.41,4916.71) 7155.8,4926.1 ccw(c7165.19,4935.49) v1@7165.19,4922.21
  Bottom Layer w4: v1(4940,4895) 4972.87,4895 4975,4892.87 4985,4892.87 4998.83,4892.87 5026.04,4892.87 5055,4892.87 5110.32,4892.87 5130.95,4913.5 5168.56,4913.5 5195.5,4886.56 5195.5,4775.5 5190.64,4770.64 5177.64,4757.64 5177.64,4749.18 5177.64,4741.18 5177.64,4718.05 5177.64,4659.79 5177.64,4601.53 5177.64,4543.27 5177.64,4523.85 5177.64,4463.66 5177.64,4458.9 ccw(c5210.77,4458.73) 5182.73,4441.08 ; v1@4943.89,4891.11 cw(c4953.28,4881.72) 4953.28,4895 cw(c4953.28,4908.28) v1@4943.89,4898.89 ; v1@4946.72,4888.28 cw(c4962.93,4872.06) 4962.93,4895 cw(c4962.93,4917.93) v1@4946.72,4901.72 ; v3@5185.76,4427.52 ccw(c5167.93,4430.67) 5182.76,4441.05 ccw(c5197.6,4451.44) v3@5194.45,4433.61 ; v1@5591.81,5148.43 ccw(c5575.59,5164.64) 5598.52,5164.64 ccw(c5621.46,5164.64) v1@5605.24,5148.43 ; v1@5594.64,5145.6 ccw(c5585.25,5154.99) 5598.52,5154.99 ccw(c5611.8,5154.99) v1@5602.41,5145.6 ; v1(5598.52,5141.71) 5598.52,5213.73 5643.17,5258.37 7050,5258.37 7062.94,5258.37 7071.27,5250.04 v1(7098.52,5250.04) ; v1@7091.81,5243.32 ccw(c7075.59,5227.11) 7075.59,5250.04 ccw(c7075.59,5272.98) v1@7091.81,5256.76 ; v1@7094.64,5246.15 ccw(c7085.25,5236.76) 7085.25,5250.04 ccw(c7085.25,5263.32) v1@7094.64,5253.93 ; v1@7165.19,4907.21 cw(c7165.19,4884.27) 7181.41,4900.49 cw(c7197.63,4916.71) v1@7174.69,4916.71 ; v1@7165.19,4911.21 cw(c7165.19,4897.93) 7174.58,4907.32 cw(c7183.97,4916.71) v1@7170.69,4916.71 ; v1(7165.19,4916.71) 7265.19,4816.71 ; 7249.23,4832.67 ccw(c7276.85,4860.29) U15.6@7276.85,4821.23 ; 7256.06,4825.84 ccw(c7276.85,4846.63) U15.6@7276.85,4817.23 ; 7262.89,4819.01 ccw(c7276.85,4832.97) U15.6@7276.85,4813.23 ; 7265.94,4816.71 ccw(c7265.94,4824.14) U15.6@7271.19,4818.88 ; U15.6@7268.85,4813.1 ccw(c7265.19,4813.05) 7265.19,4816.71 ; U15.6@7294.41,4816.71 7265.19,4816.71
DB_SRAM2.NOE: U8.C20 U15.41 | length 2588.7
  Top Layer w4: U8.C20@5606.54,4650.1 ccw(c5606.54,4667.82) 5619.07,4655.29 ; U8.C20@5613.88,4642.76 cw(c5631.6,4642.76) 5619.07,4655.29 ; v1@5648.52,4923.87 cw(c5648.52,4900.94) 5664.74,4917.16 cw(c5680.96,4933.37) v1@5658.02,4933.37 ; v1@5648.52,4927.87 cw(c5648.52,4914.6) 5657.91,4923.99 cw(c5667.3,4933.37) v1@5654.02,4933.37 ; v1(5648.52,4933.37) 5672.86,4909.04 5673.78,4908.12 5673.78,4818.78 5630.4,4775.4 5630.4,4741.18 5630.4,4682.64 cw(c5591.72,4682.64) 5619.07,4655.29
  MidLayer2 w4: v1(5648.52,4933.37) 5807.11,4933.37 5832.94,4959.21 5963.71,4959.21 6073.52,4849.39 6073.52,4842.04 6090.52,4825.04 6118.31,4825.04 6143.35,4800 6356.17,4800 6469.17,4913 6519.82,4913 6556.86,4950.04 6556.86,5010.71 6540.19,5027.37 6540.19,5065.04 6575.15,5100 v1(6590,5100) ; v1@5652.41,4929.49 cw(c5661.8,4920.1) 5661.8,4933.37 cw(c5661.8,4946.65) v1@5652.41,4937.26 ; v1@5655.24,4926.66 cw(c5671.46,4910.44) 5671.46,4933.37 cw(c5671.46,4956.31) v1@5655.24,4940.09
  Bottom Layer w4: U15.41@6845.59,4876.22 6873.52,4876.22 6873.52,4883.37 6926.52,4936.37 6926.52,5078.39 6921.54,5083.37 6856.86,5083.37 6840.19,5066.71 6735,5066.71 ; U15.41@6863.15,4880.22 ccw(c6863.15,4897.65) 6875.47,4885.32 ; U15.41@6863.15,4884.22 ccw(c6863.15,4911.3) 6882.3,4892.15 ; U15.41@6871.15,4876.22 cw(c6882.69,4876.22) 6874.53,4884.38 ; 6572.52,5097.37 ccw(c6572.52,5106.53) 6581.1,5103.33 cw(c6572.52,5106.53) 6572.52,5097.37 ; 6572.52,5097.37 6616.15,5097.37 ; 6572.52,5097.37 6616.15,5097.37 ; 6616.15,5097.37 cw(c6616.15,5122.13) 6597.25,5106.14 ccw(c6616.15,5122.13) 6616.15,5097.37 ; 6616.15,5097.37 6646.82,5066.71 6706.86,5066.71 ; 6706.86,5066.71 6735,5066.71 ; 6706.86,5066.71 6735,5066.71 ; 6573.4,5097.37 cw(c6573.4,5083.4) 6583.28,5093.28 ccw(c6573.4,5083.4) 6573.4,5097.37 ; 6578.29,5097.37 ccw(c6578.29,5104.38) 6584.85,5101.93 cw(c6578.29,5104.38) 6578.29,5097.37 ; v1@6594.2,5103.55 ccw(c6607.52,5114.83) 6607.52,5097.37 cw(c6607.52,5114.83) v1@6594.2,5103.55 ; v1@6596.72,5093.28 cw(c6606.6,5083.4) 6606.6,5097.37 ccw(c6606.6,5083.4) v1@6596.72,5093.28
DB_SRAM2.NWE: U8.M21 U15.17 | length 1931.3
  Top Layer w4: U8.M21@5645.91,4288.42 v3(5665.59,4308.11) ; U8.M21@5645.91,4295.77 ccw(c5645.91,4313.49) 5658.44,4300.96 ccw(c5670.97,4288.42) U8.M21@5653.25,4288.42 ; 5652.79,4295.31 cw(c5665.59,4282.5) 5665.59,4300.61 ccw(c5665.59,4282.5) 5652.79,4295.31 ; 5652.79,4295.31 ccw(c5639.98,4308.11) 5658.09,4308.11 cw(c5639.98,4308.11) 5652.79,4295.31
  MidLayer2 w4: v3@5666.24,4315.58 ccw(c5667.82,4333.62) 5679.46,4319.75 ; v3@5673.06,4307.46 cw(c5691.1,4305.88) 5679.46,4319.75 ; v1(7006.86,4309.37) 6997.52,4318.71 6783.52,4318.71 6774.19,4309.37 6720,4309.37 6706.82,4309.37 6688.12,4309.37 6687.29,4310.2 ; 5679.46,4319.75 cw(c5708.97,4290.24) 5708.97,4331.97 5728.47,4331.97 5802.59,4331.97 5822.01,4331.97 6020.97,4331.97 6021.44,4331.5 6123.13,4331.5 6140.13,4348.5 6234.44,4348.5 6258.4,4324.54 6333.6,4324.54 6341.6,4332.54 6446.48,4332.54 6474.44,4360.5 6515.81,4360.5 6538.46,4337.85 6538.46,4325.36 6555.44,4308.37 6630.52,4308.37 6635.36,4313.21 6684.29,4313.21 ; 6684.29,4313.21 6687.29,4310.2 ; 6684.29,4313.21 6687.29,4310.2
  Bottom Layer w4: v1(7006.86,4309.37) 7147.52,4450.04 7164.25,4466.77 U15.17@7294.41,4466.77 ; U15.17@7271.19,4461.11 ccw(c7257.54,4447.46) 7257.54,4466.77 ccw(c7257.54,4486.08) U15.17@7271.19,4472.43
DBSD.CLK: J30.5 U8.AE13 | length 5105.7
  Top Layer w4: v3(5311.26,3756.93) U8.AE13@5330.94,3776.61 ; U8.AE13@5323.6,3776.61 cw(c5305.88,3776.61) 5318.41,3764.08 cw(c5330.94,3751.55) U8.AE13@5330.95,3769.27 ; v1@5711.28,1151.28 cw(c5695.06,1135.06) 5718,1135.06 cw(c5740.93,1135.06) v1@5724.72,1151.28 ; v1@5714.11,1154.11 cw(c5704.72,1144.72) 5718,1144.72 cw(c5731.28,1144.72) v1@5721.89,1154.11 ; v1(5718,1158) 5718,1097 5729,1086 v1(5758,1086) ; v1@5751.28,1079.28 ccw(c5735.06,1063.06) 5735.06,1086 ccw(c5735.06,1108.93) v1@5751.28,1092.72 ; v1@5754.11,1082.11 ccw(c5744.72,1072.72) 5744.72,1086 ccw(c5744.72,1099.28) v1@5754.11,1089.89 ; 5324.06,3769.73 cw(c5311.26,3782.54) 5311.26,3764.43 ccw(c5311.26,3782.54) 5324.06,3769.73 ; 5324.06,3769.73 ccw(c5336.87,3756.93) 5318.76,3756.93 cw(c5336.87,3756.93) 5324.06,3769.73
  MidLayer1 w4: 5242.34,2902.19 5181.86,2841.71 5181.86,2720.35 5249.81,2652.4 5249.81,2592.31 5169.19,2511.69 5169.19,2489.5 5184.4,2474.29 5184.4,1881.84 5132.02,1829.46 5132.02,1449.29 5497.27,1084.04 5711.98,1084.04 5717.44,1089.5 5754.5,1089.5 v1(5758,1086) ; 5242.38,2902.19 5257.81,2917.62 5257.81,3000.09 5242.5,3015.4 5242.5,3057.5 v1(5245,3060) ; v3@5306.07,3751.74 cw(c5293.53,3739.2) 5311.26,3739.2 cw(c5328.99,3739.2) v3@5316.45,3751.74 ; v3(5311.26,3756.93) 5311.26,3679.25 5311.26,3638.82 5311.26,3632.26 5311.26,3601.26 5297.25,3587.25 5297.25,3522.75 5303.5,3516.5 5323.5,3516.5 5330,3510 5330,3491.62 5335.8,3485.82 5335.8,3448.9 v1(5330,3443.1) ; 5311.26,3738.82 cw(c5329.37,3738.82) 5316.56,3751.63 ccw(c5329.37,3738.82) 5311.26,3738.82 ; 5311.26,3738.82 ccw(c5293.15,3738.82) 5305.96,3751.63 cw(c5293.15,3738.82) 5311.26,3738.82
  MidLayer2 w4: v1(5245,3060) 5252.25,3060 5258.96,3066.71 5281.86,3066.71 5331.86,3116.71 5331.86,3257.08 5304.5,3284.44 5304.5,3383.35 5330,3408.85 v1(5330,3443.1)
  Bottom Layer w4: v1(5718,1158) 5732,1144 5771.23,1144 5852.23,1063 5986.19,1063 6082.48,966.71 6463.86,966.71 6488.86,991.71 6644.19,991.71 6684.53,1032.04 J30.5@6684.53,1128.35 ; J30.5@6669.79,1087.24 cw(c6634.23,1051.67) 6684.53,1051.67 cw(c6734.82,1051.67) J30.5@6699.26,1087.24 ; J30.5@6672.62,1090.06 cw(c6643.88,1061.33) 6684.53,1061.33 cw(c6725.17,1061.33) J30.5@6696.43,1090.06 ; J30.5@6675.45,1092.89 cw(c6653.54,1070.98) 6684.53,1070.98 cw(c6715.51,1070.98) J30.5@6693.6,1092.89
DBSD.CMD: J30.2 U8.Y14 | length 4555.4
  Top Layer w4: v3(5350.63,3953.78) U8.Y14@5370.31,3973.46 ; U8.Y14@5362.97,3973.46 cw(c5345.25,3973.46) 5357.78,3960.93 cw(c5370.31,3948.4) U8.Y14@5370.31,3966.12 ; 5363.43,3966.58 cw(c5350.63,3979.39) 5350.63,3961.28 ccw(c5350.63,3979.39) 5363.43,3966.58 ; 5363.43,3966.58 ccw(c5376.24,3953.78) 5358.13,3953.78 cw(c5376.24,3953.78) 5363.43,3966.58
  MidLayer1 w4: v1@5264.02,3483.37 cw(c5241.09,3483.37) 5257.31,3467.16 cw(c5273.52,3450.94) v1@5273.52,3473.87 ; v1@5268.02,3483.37 cw(c5254.75,3483.37) 5264.14,3473.99 cw(c5273.52,3464.6) v1@5273.52,3477.87 ; v1(5273.52,3483.37) 5255.86,3465.71 5255.86,3228.37 5267.52,3216.71 5305.88,3216.71 5311.84,3216.71 5326.02,3202.53 5326.02,3197.56 5326.02,3002.6 5323.42,3000 5277.5,3000 5265.81,2988.31 5265.81,2517.33 5265.19,2516.71 5242.77,2494.28 5200.4,2451.92 5200.4,1875.21 5195.5,1870.31 5195.5,1795 5195.5,1761.69 5156.02,1722.21 5156.02,1634.02 5156.02,1620 5156.02,1530 5156.02,1475.87 5156.02,1460.52 5391.54,1225 5440,1225 5790.19,1225.04 5873.52,1141.71 ; v1@5867.28,1124.72 ccw(c5852.21,1139.79) 5873.52,1139.79 ; v1@5870.11,1121.89 ccw(c5861.87,1130.13) 5873.52,1130.13 ; v1@5873.52,1118 5873.52,1141.71 ; 5873.52,1132.2 ccw(c5887.89,1132.2) v1@5877.85,1121.93 ; v1@5880.64,1124.79 cw(c5897.18,1141.71) 5873.52,1141.71
  Bottom Layer w4: v1@5266.81,3490.09 ccw(c5250.59,3506.31) 5273.52,3506.31 ccw(c5296.46,3506.31) v1@5280.24,3490.09 ; v1@5269.64,3487.26 ccw(c5260.25,3496.65) 5273.52,3496.65 ccw(c5286.8,3496.65) v1@5277.41,3487.26 ; v1(5273.52,3483.37) 5273.52,3573.52 5280,3580 ; 5279.97,3580.03 5305.44,3605.5 5335.12,3605.5 5335.12,3630.82 5335.12,3638.82 5335.12,3836.73 5335.12,3930.27 cw(c5349.17,3930.27) 5339.24,3940.2 ; v3@5343.16,3953.13 cw(c5325.12,3951.55) 5338.99,3939.91 cw(c5352.86,3928.27) v3@5351.28,3946.31 ; v1@5875.29,1116.71 6091.19,1116.71 6141.9,1066 6190.73,1066 6191.28,1066.54 6205.77,1066.54 6206.31,1066 6382,1066 6388.86,1072.86 ; v1@5877.89,1121.89 ccw(c5890.4,1134.4) 5890.4,1116.71 ; v1@5880.72,1111.28 cw(c5893.82,1098.18) 5893.82,1116.71 ; v1@5880.72,1124.72 ccw(c5900.05,1144.05) 5900.05,1116.71 ; J30.2@6382.14,1082.25 cw(c6378.93,1072.86) 6388.86,1072.86 ; J30.2@6383.43,1086.03 cw(c6380.84,1078.45) 6388.86,1078.45 cw(c6396.87,1078.45) J30.2@6394.29,1086.03 ; J30.2@6388.86,1128.35 6388.86,1072.86 ; J30.2@6395.58,1082.25 ccw(c6398.78,1072.86) 6388.86,1072.86
  other v1: 5874,1118
DBSD.DAT0: J30.7 U8.AD24 | length 8306.6
  Top Layer w4: U8.AD24@5764.02,3808.64 cw(c5764.02,3790.92) 5776.55,3803.45 cw(c5789.08,3815.98) U8.AD24@5771.36,3815.98 ; U8.AD24@5764.02,3815.98 v3(5783.7,3796.3) ; v1@6441.81,3776.66 cw(c6425.59,3760.44) 6448.52,3760.44 cw(c6471.46,3760.44) v1@6455.24,3776.66 ; v1@6444.64,3779.49 cw(c6435.25,3770.1) 6448.52,3770.1 cw(c6461.8,3770.1) v1@6452.41,3779.49 ; v1(6448.52,3783.37) 6448.52,3660 6456.86,3651.67 v1(6456.86,3625.04) ; v1@6450.14,3631.76 ccw(c6433.92,3647.98) 6456.86,3647.98 ccw(c6479.79,3647.98) v1@6463.57,3631.76 ; v1@6452.97,3628.93 ccw(c6443.58,3638.32) 6456.86,3638.32 ccw(c6470.14,3638.32) v1@6460.75,3628.93 ; v1@6843.28,1194.72 ccw(c6827.06,1210.93) 6850,1210.93 ccw(c6872.93,1210.93) v1@6856.72,1194.72 ; v1@6846.11,1191.89 ccw(c6836.72,1201.28) 6850,1201.28 ccw(c6863.28,1201.28) v1@6853.89,1191.89 ; v1(6850,1188) 6850,1244.19 6855.81,1250 6855.81,1331.81 6900.19,1376.19 6972.5,1376.19 7001.65,1405.34 7005.47,1409.15 7023.66,1409.15 7040.62,1392.19 7050.25,1392.19 7057.88,1399.81 7072.37,1399.81 7080,1392.19 7104.43,1392.19 7140.12,1356.5 7164.25,1356.5 v1@7200.38,1320.38 ; 7178.42,1342.33 cw(c7154.09,1318) v1@7188.5,1318 ; 7185.25,1335.51 cw(c7167.74,1318) v1@7192.5,1318 ; 7189.9,1330.86 ccw(c7198,1338.96) v1@7198,1327.5 ; 7192.08,1328.68 cw(c7181.4,1318) v1@7196.5,1318 ; 5770.9,3809.1 cw(c5758.09,3796.3) 5776.2,3796.3 ccw(c5758.09,3796.3) 5770.9,3809.1 ; 5770.9,3809.1 ccw(c5783.7,3821.91) 5783.7,3803.8 cw(c5783.7,3821.91) 5770.9,3809.1
  Bottom Layer w4: v3@5782.4,3788.91 cw(c5779.25,3771.08) 5794.09,3781.47 ; v3@5791.09,3795 ccw(c5808.92,3791.85) 5794.09,3781.47 ; v1(6448.52,3783.37) 6491.19,3826.04 6832.35,3826.04 6893.31,3887 6968.82,3887 7014.36,3932.54 7014.36,4063.04 7029.79,4078.48 7109.04,4078.48 7137.82,4049.71 7208.11,4049.71 7241.28,4082.87 7263.05,4082.87 7286.05,4105.87 7396.71,4105.87 7396.84,4106 7800.31,4106 7833,4073.31 7833,3710 7840,3703 7928,3703 7947.87,3722.87 7987.13,3722.87 8005,3705 8143.07,3705 8303,3545.07 8303,2422.75 8231.19,2350.94 8231.19,1756 8231.36,1755.83 8231.36,1599.51 8210,1578.15 8074.84,1578.15 8005.06,1508.37 7881.86,1508.37 7759.36,1385.87 7609.13,1385.87 7498,1497 7332.25,1497 7221.75,1386.5 7206.51,1386.5 7198,1377.99 v1(7198,1318) v1@7199.38,1318 ; v1@6448.52,3788.87 ccw(c6448.52,3802.15) 6457.91,3792.76 ccw(c6467.3,3783.37) v1@6454.02,3783.37 ; v1@6448.52,3792.87 ccw(c6448.52,3815.81) 6464.74,3799.59 ccw(c6480.96,3783.37) v1@6458.02,3783.37 ; v1@6450.14,3618.32 ccw(c6433.92,3602.11) 6433.92,3625.04 ccw(c6433.92,3647.98) v1@6450.14,3631.76 ; v1@6452.97,3621.15 ccw(c6443.58,3611.76) 6443.58,3625.04 ccw(c6443.58,3638.32) v1@6452.97,3628.93 ; v1(6456.86,3625.04) 6296.25,3625.04 6277.09,3605.87 6252.81,3605.87 6225.31,3633.37 6195,3633.37 6182.19,3620.56 6182.19,3473.36 6172.33,3463.5 6053.92,3463.5 6020.71,3496.71 6000.01,3496.71 5838.28,3496.72 5827.5,3507.5 5827.5,3602.5 5807.47,3622.53 5807.47,3630.82 5807.47,3638.82 5807.47,3640.41 5807.47,3698.67 5807.47,3756.93 ccw(c5783.7,3756.93) 5800.51,3773.74 5794.09,3781.47 ; v1@6850,1178.5 cw(c6850,1150.18) J30.7@6870.03,1170.2 ; v1@6850,1182.5 cw(c6850,1163.83) 6863.2,1177.03 ; v1@6851.12,1189.12 6860.08,1180.16 J30.7@6873.52,1166.71 ; v1@6859.5,1188 ccw(c6877.05,1188) J30.7@6864.64,1175.59 ; 6862.92,1177.31 ccw(c6876.87,1191.25) J30.7@6877.6,1171.55 ; J30.7@6864.27,1175.97 cw(c6854.8,1166.5) J30.7@6866.76,1160.49 ; v1@7191.28,1324.72 ccw(c7175.06,1340.93) 7198,1340.93 ccw(c7220.94,1340.93) v1@7204.72,1324.72 ; v1@7194.11,1321.89 ccw(c7184.72,1331.28) 7198,1331.28 ccw(c7211.28,1331.28) v1@7201.89,1321.89
DBSD.DAT1: J30.8 U8.AF25 | length 4188.8
  Top Layer w4: v1@5811.7,3499.2 5811.7,3496.3 v1(5814.63,3493.37) 5827.25,3506 5827.25,3596.19 5827.25,3638.82 5827.25,3697.36 ; v1(6565,1549) 6566,1548 6566,1376.75 6594,1348.75 6594,1332 ; 6593.5,1332.5 6594,1332 ; v1@6808.47,1073.43 ccw(c6792.71,1089.18) 6815,1089.18 ; v1@6811.3,1070.6 ccw(c6802.37,1079.53) 6815,1079.53 ; v1@6815,1065 6815,1066.71 v1@6815,1066.9 ; 6815,1080.45 ccw(c6828.93,1080.45) v1@6819.08,1070.6 ; 6815,1090.1 ccw(c6838.58,1090.1) v1@6821.91,1073.43 ; v1(6815.19,1066.71) v1@6815,1066.9 ; 5815.92,3724.71 cw(c5828.45,3737.24) 5810.73,3737.24 ccw(c5828.45,3737.24) 5815.92,3724.71 ; 5815.92,3724.71 ccw(c5803.39,3712.18) 5803.39,3729.9 cw(c5803.39,3712.18) 5815.92,3724.71 ; 5815.92,3724.71 cw(c5788.57,3697.36) 5827.25,3697.36 ; 5815.92,3724.71 cw(c5788.57,3697.36) 5827.25,3697.36 ; 6594,1332 6594,1288 6622.81,1259.19 ; 6622.81,1259.19 6623.5,1258.5 ; 6622.81,1259.19 6623.5,1258.5 ; 6623.5,1258.5 6698.03,1258.5 6732.2,1224.33 6744.34,1212.19 ; 6744.34,1212.19 6758,1212.19 ; 6744.34,1212.19 6758,1212.19 ; 6758,1212.19 6778.43,1212.19 6815,1175.62 v1@6815,1066.9
  MidLayer1 w4: v1@5810.1,3493.37 5810.1,3494.1 5812,3496 v1(5814.63,3493.37) 5840,3493.37 ; v1@5818.51,3489.49 cw(c5827.9,3480.1) 5827.9,3493.37 cw(c5827.9,3506.65) v1@5818.51,3497.26 ; v1@5821.34,3486.66 cw(c5837.56,3470.44) 5837.56,3493.37 cw(c5837.56,3516.31) v1@5821.34,3500.09 ; 5890.36,2677.83 5890.36,2705 ; v1@6555.5,1549 ccw(c6532.56,1549) 6548.78,1565.22 ccw(c6565,1581.43) v1@6565,1558.5 ; v1@6559.5,1549 ccw(c6546.22,1549) 6555.61,1558.39 ccw(c6565,1567.78) v1@6565,1554.5 ; v1(6565,1549) 6536.19,1577.81 6536.19,1587.38 6440.19,1683.37 ; 5840,3493.37 5840.15,3493.37 ; 5840,3493.37 5840.15,3493.37 ; 5840.15,3493.37 5848.52,3485 5848.52,3478.52 5848.52,3441.71 ; 5848.52,3425 5848.52,3441.71 ; 5848.52,3425 5848.52,3441.71 ; 5848.52,3425 5848.52,3363.85 5874.52,3337.85 5874.52,3191.71 5890.19,3176.04 5890.19,3016.71 5860.98,2987.5 5858.5,2985.02 5858.5,2962.75 5877.5,2943.75 5877.5,2919.44 ; 5858.19,2890 5858.19,2900.12 ; 5858.19,2890 5858.19,2830.13 5897.69,2790.62 5897.69,2776.13 5890.36,2768.79 5890.36,2705 ; 5858.19,2890 5858.19,2900.12 ; 5858.19,2900.12 5860.56,2902.5 ; 5860.56,2902.5 5877.5,2919.44 ; 5860.56,2902.5 5877.5,2919.44 ; 5890.36,2705 5890.36,2639.17 5904.31,2625.21 5965.35,2564.17 5965.35,2400 5965.35,2394.53 6044.94,2314.94 ; 6044.94,2314.94 6049.7,2310.19 ; 6044.94,2314.94 6049.7,2310.19 ; 6049.7,2310.19 6050.68,2309.21 6111.05,2309.21 6195.92,2224.33 6195.92,2129 ; 6195.92,2107.62 6195.92,2129 ; 6195.92,2107.62 6195.92,2129 ; 6195.92,2107.62 6206.86,2096.68 6206.86,2035.37 6432.6,1809.64 ; 6432.6,1809.64 6440.19,1802.04 ; 6432.6,1809.64 6440.19,1802.04 ; 6440.19,1683.37 6440.19,1703 ; 6440.19,1683.37 6440.19,1703 ; 6440.19,1703 6440.19,1802.04
  Bottom Layer w4: v1@6815.19,1057.21 cw(c6815.19,1034.27) 6831.41,1050.49 cw(c6847.63,1066.71) v1@6824.69,1066.71 ; v1@6815.19,1061.21 cw(c6815.19,1047.93) 6824.58,1057.32 cw(c6833.97,1066.71) v1@6820.69,1066.71 ; v1(6815.19,1066.71) 6839.9,1042 6934,1042 6945.16,1053.16 ; J30.8@6930.74,1086.92 cw(c6898.4,1053.16) 6945.16,1053.16 ; J30.8@6931.86,1083.37 6931.86,1128.35 6931.86,1133.37 6938.16,1133.37 J30.8@6938.16,1128.35 ; J30.8@6933.51,1089.81 cw(c6907.37,1062.53) 6945.16,1062.53 cw(c6982.94,1062.53) J30.8@6956.8,1089.81 ; J30.8@6936.28,1092.7 cw(c6916.35,1071.9) 6945.16,1071.9 cw(c6973.96,1071.9) J30.8@6954.03,1092.7 ; J30.8@6945.16,1128.35 6945.16,1053.16 ; J30.8@6959.57,1086.92 ccw(c6991.91,1053.16) 6945.16,1053.16
DBSD.DAT2: J30.9 U8.W16 | length 8970.7
  Top Layer w4: 3197.19,2056.09 3197.19,1412.81 v1(3270,1340) ; 3197.19,2143.44 3197.19,2287.81 3256.86,2347.48 3256.86,2365 3189.19,2432.67 3189.19,2644.19 3203.37,2658.37 v1(3339.52,2658.37) ; 3197.3,2056.2 3197.3,2143.33 ; v1@3260.5,1340 ccw(c3237.56,1340) 3253.78,1356.22 ccw(c3270,1372.43) v1@3270,1349.5 ; v1@3264.5,1340 ccw(c3251.22,1340) 3260.61,1349.39 ccw(c3270,1358.78) v1@3270,1345.5 ; v1@3332.81,2651.66 ccw(c3316.59,2635.44) 3316.59,2658.37 ccw(c3316.59,2681.31) v1@3332.81,2665.09 ; v1@3335.64,2654.49 ccw(c3326.25,2645.1) 3326.25,2658.37 ccw(c3326.25,2671.65) v1@3335.64,2662.26 ; U8.W16@5449.05,4005.49 cw(c5449.05,3987.77) 5461.59,4000.3 cw(c5474.12,4012.83) U8.W16@5456.4,4012.83 ; U8.W16@5449.06,4012.83 v3(5468.74,3993.15) ; 5455.94,4005.95 cw(c5443.13,3993.15) 5461.24,3993.15 ccw(c5443.13,3993.15) 5455.94,4005.95 ; 5455.94,4005.95 ccw(c5468.74,4018.76) 5468.74,4000.65 cw(c5468.74,4018.76) 5455.94,4005.95
  MidLayer2 w4: v1@3263.28,1346.72 ccw(c3247.06,1362.93) 3270,1362.93 ccw(c3292.93,1362.93) v1@3276.72,1346.72 ; v1@3266.11,1343.89 ccw(c3256.72,1353.28) 3270,1353.28 ccw(c3283.28,1353.28) v1@3273.89,1343.89 ; v1(3270,1340) 3270,1613.18 3273.52,1616.71 3290.19,1633.37 4284,1633.37 4334,1683.37 4815.19,1683.37 5283.36,1215.21 5557.33,1215.21 5587.4,1245.29 5683.63,1245.29 5720.71,1208.21 5898.01,1208.21 5923,1233.21 6035.73,1233.21 6051.73,1217.21 6130.86,1138.08 v1(6130.86,1133.37) ; v1(3339.52,2658.37) 3590.19,2658.37 3698.52,2766.71 4648.52,2766.71 4740.19,2858.37 5122.52,2858.37 5148.52,2884.37 5148.52,3058.52 5199.28,3109.28 ; v1@3343.41,2654.49 cw(c3352.8,2645.1) 3352.8,2658.37 cw(c3352.8,2671.65) v1@3343.41,2662.26 ; v1@3346.24,2651.66 cw(c3362.46,2635.44) 3362.46,2658.37 cw(c3362.46,2681.31) v1@3346.24,2665.09 ; 5198.89,3108.89 5248.02,3158.02 5248.02,3387.9 5295.12,3435 5295.12,3448.52 v1(5318.3,3471.7) ; v1@5308.8,3471.7 cw(c5285.86,3471.7) 5302.08,3455.48 cw(c5318.3,3439.26) v1@5318.3,3462.2 ; v1@5312.8,3471.7 cw(c5299.52,3471.7) 5308.91,3462.31 cw(c5318.3,3452.92) v1@5318.3,3466.2
  Bottom Layer w4: v1@5310.69,3466.01 ccw(c5299.33,3457.5) 5299.33,3471.7 ; v1@5310.69,3477.39 cw(c5299.33,3485.9) 5299.33,3471.7 ; v1(5318.3,3471.7) 5299.32,3471.7 ; v3@5468.09,3985.68 cw(c5466.51,3967.64) 5480.38,3979.28 ; v3@5476.21,3992.5 ccw(c5494.25,3990.92) 5480.38,3979.28 ; v1(6130.86,1133.37) 6185.01,1133.37 J30.9@6185.01,1128.35 ; v1@6134.75,1129.49 cw(c6144.14,1120.1) 6144.14,1133.37 cw(c6144.14,1146.65) v1@6134.75,1137.26 ; v1@6137.57,1126.66 cw(c6153.79,1110.44) 6153.79,1133.37 cw(c6153.79,1156.31) v1@6137.57,1140.09 ; 6149.77,1133.37 cw(c6149.77,1087.36) J30.9@6182.8,1119.41 ; 6153.85,1133.37 ccw(c6153.85,1166.51) J30.9@6177.27,1143.08 ; 6159.23,1133.37 cw(c6159.23,1096.53) J30.9@6185.67,1122.19 ; 6163.5,1133.37 ccw(c6163.5,1156.85) J30.9@6180.1,1140.25 ; 6168.69,1133.37 cw(c6168.69,1105.71) J30.9@6188.54,1124.98 ; 5299.32,3471.7 5292.66,3478.36 5292.66,3493.59 5283,3503.25 5283,3570.22 5310.28,3597.5 5344.6,3597.5 5355.1,3608 5432,3608 5435,3605 5490,3605 5492.6,3607.6 5492.6,3836.73 5492.6,3856.15 5492.6,3930.27 5492.6,3949.77 ccw(c5450.87,3949.77) 5480.38,3979.28
DBSD.DAT3: J30.1 U8.Y12 | length 5075.9
  Top Layer w4: v1@4963.02,1300.04 ccw(c4940.09,1300.04) 4956.31,1316.26 ccw(c4972.52,1332.48) v1@4972.52,1309.54 ; v1@4967.02,1300.04 ccw(c4953.75,1300.04) 4963.14,1309.43 ccw(c4972.52,1318.82) v1@4972.52,1305.54 ; v1(4972.52,1300.04) 4936.58,1335.99 4936.58,1402.3 4862,1476.88 4862,2488.52 4865.19,2491.71 4898.52,2525.04 4898.52,3441.71 4908.32,3451.5 4922.06,3451.5 4979.5,3451.5 v1(4987,3444) ; v3(5271.89,3953.78) U8.Y12@5291.57,3973.46 ; U8.Y12@5284.23,3973.46 cw(c5266.51,3973.46) 5279.04,3960.93 cw(c5291.57,3948.4) U8.Y12@5291.57,3966.12 ; 5284.69,3966.58 cw(c5271.89,3979.39) 5271.89,3961.28 ccw(c5271.89,3979.39) 5284.69,3966.58 ; 5284.69,3966.58 ccw(c5297.5,3953.78) 5279.39,3953.78 cw(c5297.5,3953.78) 5284.69,3966.58
  Bottom Layer w4: v1(4972.52,1300.04) 5185,1300.04 5214.96,1330 5255,1330 5285.29,1299.71 5484.71,1299.71 5496.86,1311.86 5496.86,1395 5500.23,1398.37 5902.56,1398.37 5998.52,1302.41 5998.52,1208.37 6015.19,1191.71 6283.29,1191.71 6290.43,1184.57 ; v1@4976.41,1296.15 cw(c4985.8,1286.76) 4985.8,1300.04 cw(c4985.8,1313.32) v1@4976.41,1303.93 ; v1@4979.24,1293.32 cw(c4995.46,1277.11) 4995.46,1300.04 cw(c4995.46,1322.98) v1@4979.24,1306.76 ; v1@4987,3434.5 cw(c4987,3411.56) 5003.22,3427.78 cw(c5019.43,3444) v1@4996.5,3444 ; v1@4987,3438.5 cw(c4987,3425.22) 4996.39,3434.61 cw(c5005.78,3444) v1@4992.5,3444 ; v1(4987,3444) 5016,3415 5200,3415 5218.31,3415 5230.02,3426.71 5230.02,3440.02 5230.02,3445 5230.02,3561.34 5256.38,3587.7 5256.38,3592.7 5256.38,3605 5256.38,3630.82 5256.38,3638.82 5256.38,3661.95 5256.38,3720.21 5256.38,3778.47 5256.38,3836.73 5256.38,3856.15 5256.38,3916.34 5256.38,3930.27 cw(c5270.43,3930.27) 5260.5,3940.2 ; v3@5264.42,3953.13 cw(c5246.38,3951.55) 5260.25,3939.91 cw(c5274.12,3928.27) v3@5272.54,3946.31 ; J30.1@6283.25,1174.28 ccw(c6279.47,1184.57) 6290.43,1184.57 ; J30.1@6284.63,1170.53 ccw(c6281.58,1178.84) 6290.43,1178.84 ccw(c6299.28,1178.84) J30.1@6296.23,1170.53 ; J30.1@6290.43,1128.35 6290.43,1184.57 ; J30.1@6297.61,1174.28 cw(c6301.39,1184.57) 6290.43,1184.57
DBSD.DETECT: U8.AD14 U68.4 | length 2854.3
  Top Layer w4: v3(5350.63,3796.3) U8.AD14@5370.31,3815.98 ; U8.AD14@5362.97,3815.98 cw(c5345.25,3815.98) 5357.78,3803.45 cw(c5370.31,3790.92) U8.AD14@5370.31,3808.64 ; 5363.43,3809.1 cw(c5350.63,3821.91) 5350.63,3803.8 ccw(c5350.63,3821.91) 5363.43,3809.1 ; 5363.43,3809.1 ccw(c5376.24,3796.3) 5358.13,3796.3 cw(c5376.24,3796.3) 5363.43,3809.1
  MidLayer1 w4: v1(5274.86,1759.71) 5399.19,1884.04 5399.19,2413.02 5388.84,2423.37 5339.86,2472.35 5339.86,2540.11 5352.5,2552.75 5352.5,2567.25 5347.19,2572.56 5347.19,2586.62 5333.5,2600.31 5333.5,2639.77 5347.19,2653.46 5347.19,2731.31 5339.86,2738.65 5339.86,2763.67 5372.81,2796.63 5372.81,2832.38 5366.81,2838.38 5366.81,2908.67 5395.5,2937.36 5395.5,2945.5 5411.5,2961.5 5411.5,3035.19 5423.52,3047.21 5423.52,3154.04 5401.62,3175.95 5401.62,3230.43 5374.11,3257.94 5374.11,3291.44 5340.2,3325.35 5340.2,3339.85 5350.45,3350.1 5360.1,3350.1 5368.6,3358.6 5368.6,3371.88 5347.69,3392.79 5347.69,3420.14 5360.06,3432.5 5360.06,3460.49 5351.8,3468.75 5351.8,3492.45 5346,3498.25 5346,3512.75 5360.29,3527.04 5360.29,3576.02 5335.12,3601.19 5335.12,3630.82 5335.12,3638.82 5335.12,3679.25 5335.12,3772.79 cw(c5349.17,3772.79) 5339.24,3782.72 ; v1@5274.86,1765.21 ccw(c5274.86,1778.49) 5284.25,1769.1 ccw(c5293.64,1759.71) v1@5280.36,1759.71 ; v1@5274.86,1769.21 ccw(c5274.86,1792.14) 5291.07,1775.93 ccw(c5307.29,1759.71) v1@5284.36,1759.71 ; v3@5343.16,3795.65 cw(c5325.12,3794.07) 5338.99,3782.43 cw(c5352.86,3770.79) v3@5351.28,3788.83
  Bottom Layer w4: v1@5268.14,1766.43 ccw(c5251.92,1782.64) 5274.86,1782.64 ccw(c5297.79,1782.64) v1@5281.57,1766.43 ; v1@5270.97,1763.6 ccw(c5261.58,1772.99) 5274.86,1772.99 ccw(c5288.14,1772.99) v1@5278.75,1763.6 ; v1(5274.86,1759.71) 5274.86,1794.86 5280.37,1800.37 5469.63,1800.37 5477.6,1792.4 U68.4@5477.6,1745.12 ; U68.4@5470.66,1765.84 ccw(c5453.91,1782.58) 5477.6,1782.58 ccw(c5501.28,1782.58) U68.4@5484.54,1765.84 ; U68.4@5473.49,1763.01 ccw(c5463.57,1772.93) 5477.6,1772.93 ccw(c5491.63,1772.93) U68.4@5481.71,1763.01
DBSD.PROTECT: U8.AC14 U67.4 | length 3188.9
  Top Layer w4: v3(5350.63,3835.67) U8.AC14@5370.31,3855.35 ; U8.AC14@5362.97,3855.35 cw(c5345.25,3855.35) 5357.78,3842.82 cw(c5370.31,3830.29) U8.AC14@5370.31,3848.01 ; 5363.43,3848.47 cw(c5350.63,3861.28) 5350.63,3843.17 ccw(c5350.63,3861.28) 5363.43,3848.47 ; 5363.43,3848.47 ccw(c5376.24,3835.67) 5358.13,3835.67 cw(c5376.24,3835.67) 5363.43,3848.47
  MidLayer1 w4: v1@5264.02,1483.37 ccw(c5241.09,1483.37) 5257.31,1499.59 ccw(c5273.52,1515.81) v1@5273.52,1492.87 ; v1@5268.02,1483.37 ccw(c5254.75,1483.37) 5264.14,1492.76 ccw(c5273.52,1502.15) v1@5273.52,1488.87 ; v1(5273.52,1483.37) 5248.52,1508.37 5248.52,1770 5261.9,1783.37 5287.21,1783.37 5391.19,1887.35 5391.19,2409.71 5385.52,2415.37 5331.86,2469.04 5326.69,2474.21 5326.69,2543.56 5317.5,2552.75 5317.5,2646.39 5331.19,2660.08 5331.19,2724.69 5309.19,2746.69 5309.19,2835.69 5350.36,2876.86 5350.36,2929.35 5339.36,2940.35 5339.36,2993.31 5342.02,2995.98 5342.02,3241.23 ; 5342.02,3143.33 5342.02,3241.23 ; v3@5343.16,3835.02 cw(c5325.12,3833.44) 5338.99,3821.8 ; v3@5351.28,3828.2 ccw(c5352.86,3810.16) 5338.99,3821.8 ; 5338.99,3821.8 ccw(c5368.5,3792.29) 5326.77,3792.29 5326.77,3772.79 5326.77,3698.67 5326.77,3679.25 5326.77,3638.82 5326.77,3630.82 5326.77,3598.23 5352.29,3572.71 5352.29,3530.35 5338,3516.06 5338,3494.94 5343.8,3489.14 5343.8,3465.44 5352.06,3457.18 5352.06,3435.82 5308.8,3392.56 5308.8,3274.45 5342.02,3241.23
  Bottom Layer w4: v1@5266.81,1476.66 cw(c5250.59,1460.44) 5273.52,1460.44 cw(c5296.46,1460.44) v1@5280.24,1476.66 ; v1@5269.64,1479.49 cw(c5260.25,1470.1) 5273.52,1470.1 cw(c5286.8,1470.1) v1@5277.41,1479.49 ; v1(5273.52,1483.37) 5273.52,1450 5282.15,1441.37 5473,1441.37 5477.6,1445.97 ; U67.4@5473.47,1452.44 cw(c5470.47,1445.97) 5477.6,1445.97 ; U67.4@5477.6,1475.12 5477.6,1445.97 ; U67.4@5481.73,1452.44 ccw(c5484.72,1445.97) 5477.6,1445.97
DBUSB#.DMINUS: J9.2 U18.6 U19.9 | length 815.1
  MidLayer1 w5: v4@7385.17,559.04 cw(c7372.37,546.23) 7390.47,546.23 cw(c7408.58,546.23) v4@7395.78,559.04 ; v4(7390.47,564.34) 7390.47,269.53 7398.5,261.5 ; v2@7393.69,252.97 ccw(c7388.55,261.5) 7398.5,261.5 ; v2@7397.01,243.5 v2(7398.5,245) 7398.5,261.5 ; v2@7403.31,252.97 cw(c7408.46,261.5) 7398.5,261.5
  Bottom Layer w5: v2@7391.92,251.58 ccw(c7376.02,267.48) 7398.5,267.48 ccw(c7420.98,267.48) v2@7405.09,251.58 ; J9.2@7393.31,370.47 ccw(c7380.78,383) 7398.5,383 ccw(c7416.23,383) J9.2@7403.7,370.47 ; v2(7398.5,245) J9.2@7398.5,320 7398.5,451.1 7405,457.6 U18.6@7447.24,457.6 ; U18.6@7433.36,449.62 ccw(c7414.11,430.37) 7414.11,457.6 ccw(c7414.11,484.83) U18.6@7433.36,465.57 ; U18.6@7436.9,453.16 ccw(c7426.18,442.44) 7426.18,457.6 ccw(c7426.18,472.76) U18.6@7436.9,462.04
  Bottom Layer w8: v4@7386.23,568.58 ccw(c7375.99,578.82) 7390.47,578.82 ccw(c7404.96,578.82) v4@7394.72,568.58 ; v4(7390.47,564.34) U19.9@7390.47,595.67
DBUSB#.DPLUS: J9.3 U18.1 U19.8 | length 878.2
  MidLayer1 w5: v2(7367.01,242.01) 7381.47,256.47 7381.47,541.46 7370,552.93 7370,586.84 v4(7410.16,627) ; v4@7402.66,627 cw(c7384.55,627) 7397.35,614.2 cw(c7410.16,601.39) v4@7410.16,619.5
  Bottom Layer w5: U18.1@7352.76,457.6 7382.4,457.6 ; v2@7360.42,248.59 ccw(c7344.53,264.49) 7367.01,264.49 ccw(c7389.49,264.49) v2@7373.59,248.59 ; J9.3@7361.82,269.53 cw(c7349.28,257) 7367.01,257 cw(c7384.73,257) J9.3@7372.2,269.53 ; J9.3@7362.04,370.68 ccw(c7351.61,382.01) 7367.01,382.01 ; v2@7365,240 v2(7367.01,242.01) J9.3@7367.01,320 7367.01,382.01 ; U18.1@7367.41,450.47 cw(c7382.4,438.26) 7382.4,457.6 ; U18.1@7367.41,464.72 ccw(c7382.4,476.94) 7382.4,457.6 ; J9.3@7371.98,370.68 cw(c7382.4,382.01) 7367.01,382.01 ; 7367.01,382.01 7389.5,404.5 7389.5,450.5 7382.4,457.6
  Bottom Layer w8: v4@7405.91,622.76 cw(c7395.67,612.51) 7410.16,612.51 cw(c7424.64,612.51) v4@7414.4,622.76 ; U19.8@7410.16,595.67 v4(7410.16,627)
DBUSB#.VBUS: J9.1 R108.2 R110.1 | length 1963.4
  Top Layer w4: v1@7553.51,1018.28 cw(c7537.85,1002.62) 7560,1002.62 ; v1@7556.34,1021.11 cw(c7547.51,1012.28) 7560,1012.28 ; 7560,1001.51 cw(c7583.72,1001.51) v1@7566.95,1018.28 ; 7560,1011.16 cw(c7574.07,1011.16) v1@7564.12,1021.11 ; v1@7560.23,1024.77 7560,1025 7560,970 7595,935 7595,875 7577.85,857.85 v1(7577.85,427.15) ; v1@7571.13,433.86 ccw(c7554.92,450.08) 7577.85,450.08 ccw(c7600.79,450.08) v1@7584.57,433.86 ; v1@7573.96,431.04 ccw(c7564.57,440.43) 7577.85,440.43 ccw(c7591.13,440.43) v1@7581.74,431.04
  MidLayer2 w4: v1(7435,425) 7473.48,425 7560.23,511.75 v1(7560.23,1025) ; v1@7438.89,421.11 cw(c7448.28,411.72) 7448.28,425 cw(c7448.28,438.28) v1@7438.89,428.89 ; v1@7441.72,418.28 cw(c7457.94,402.06) 7457.94,425 cw(c7457.94,447.93) v1@7441.72,431.72 ; v1@7553.51,1018.28 cw(c7537.3,1002.06) 7560.23,1002.06 cw(c7583.17,1002.06) v1@7566.95,1018.28 ; v1@7556.34,1021.11 cw(c7546.95,1011.72) 7560.23,1011.72 cw(c7573.51,1011.72) v1@7564.12,1021.11
  Bottom Layer w4: J9.1@7424.45,370.82 ccw(c7411.07,384.21) 7430,384.21 ccw(c7448.93,384.21) J9.1@7435.54,370.82 ; v1@7428.28,418.28 cw(c7412.06,402.06) 7435,402.06 cw(c7457.94,402.06) v1@7441.72,418.28 ; J9.1@7430,320 7430,395 7435,400 v1(7435,425) ; v1@7431.11,421.11 cw(c7421.72,411.72) 7435,411.72 cw(c7448.28,411.72) v1@7438.89,421.11 ; R108.2@7526.18,990 7551.82,990 7560,998.18 7560,1025 v1(7560.23,1025) ; R108.2@7529.94,986.24 cw(c7539.02,977.16) 7539.02,990 cw(c7539.02,1002.84) R108.2@7529.94,993.76 ; R108.2@7532.77,983.41 cw(c7548.68,967.5) 7548.68,990 cw(c7548.68,1012.5) R108.2@7532.77,996.59 ; R110.1@7536.18,435 7555,435 ; R110.1@7543.59,429.35 cw(c7555,420.66) 7555,435 ; R110.1@7543.59,440.65 ccw(c7555,449.34) 7555,435 ; v1@7553.51,1018.28 cw(c7537.85,1002.62) 7560,1002.62 ; v1@7556.34,1021.11 cw(c7547.51,1012.28) 7560,1012.28 ; 7560,1001.51 cw(c7583.72,1001.51) v1@7566.95,1018.28 ; 7560,1011.16 cw(c7574.07,1011.16) v1@7564.12,1021.11 ; v1(7577.85,427.15) 7562.85,427.15 7555,435
DBUSB.D0: U8.AF19 U19.18 | length 5369.3
  Top Layer w4: 5544.82,3445.62 5544.82,3450 ; v1@5552.25,3425.68 ccw(c5529.32,3425.68) 5545.54,3441.9 ccw(c5561.75,3458.12) v1@5561.75,3435.18 ; v1@5556.25,3425.68 ccw(c5542.98,3425.68) 5552.37,3435.07 ccw(c5561.75,3444.46) v1@5561.75,3431.18 ; v1@5561.75,3428.68 v1(5561.75,3425.68) 5544.82,3442.62 5544.82,3450 ; 5544.82,3450 5544.82,3460.37 5555.25,3470.8 5562.02,3470.8 5585.9,3494.68 5586.01,3494.68 5595.11,3503.78 5595.11,3590.89 5591,3595 5591,3630 5591.03,3638.82 5591.03,3697.36 ; 5579.7,3724.71 cw(c5592.23,3737.24) 5574.51,3737.24 ccw(c5592.23,3737.24) 5579.7,3724.71 ; 5579.7,3724.71 ccw(c5567.17,3712.18) 5567.17,3729.9 cw(c5567.17,3712.18) 5579.7,3724.71 ; 5579.7,3724.71 cw(c5552.35,3697.36) 5591.03,3697.36 ; 5579.7,3724.71 cw(c5552.35,3697.36) 5591.03,3697.36
  MidLayer1 w4: v1@5468.62,3204.03 cw(c5445.68,3204.03) 5461.9,3187.81 cw(c5478.12,3171.59) v1@5478.12,3194.53 ; v1@5472.62,3204.03 cw(c5459.34,3204.03) 5468.73,3194.64 cw(c5478.12,3185.25) v1@5478.12,3198.53 ; v1(5478.12,3204.03) 5440.19,3166.1 5440.19,3041.25 5427.5,3028.56 ; v4@7289,681.1 cw(c7269.69,681.1) 7283.34,667.45 cw(c7297,653.79) v4@7297,673.1 ; v4(7297,681.1) 7257.6,641.71 6545.9,641.71 5962.35,1225.25 5945.9,1241.71 ; 5427.5,3007.44 5427.5,3028.56 ; 5427.5,3007.44 5427.5,2954.88 5411.5,2938.88 5411.5,2930.73 5382.81,2902.04 5382.81,2845 5388.81,2839 5388.81,2790 5361.19,2762.38 5361.19,2742.81 5415.19,2688.81 5415.19,1662.38 5402.19,1649.38 5402.19,1342.81 5503.29,1241.71 5740,1241.71 5784.23,1241.71 ; 5427.5,3007.44 5427.5,3028.56 ; 5784.23,1241.71 5784.39,1241.87 5945.73,1241.87 5945.9,1241.71 ; 5784.23,1241.71 5945.9,1241.71
  MidLayer2 w4: v1(5478.12,3204.03) 5533.78,3204.03 5564.5,3234.75 5564.5,3298.11 5539.36,3323.25 5539.36,3382.54 5561.75,3404.94 ; v1@5482.01,3200.14 cw(c5491.4,3190.75) 5491.4,3204.03 cw(c5491.4,3217.31) v1@5482.01,3207.92 ; v1@5484.84,3197.31 cw(c5501.05,3181.09) 5501.05,3204.03 cw(c5501.05,3226.96) v1@5484.84,3210.75 ; v1@5555.55,3418.49 cw(c5543.86,3404.94) 5561.75,3404.94 ; v1@5558.16,3421.52 cw(c5551.39,3413.67) 5561.75,3413.67 cw(c5572.12,3413.67) v1@5565.35,3421.52 ; v1(5561.75,3425.68) 5561.75,3404.94 ; v1@5567.96,3418.49 ccw(c5579.65,3404.94) 5561.75,3404.94
  Bottom Layer w8: U19.18@7265.67,681.1 v4(7297,681.1) ; v4@7292.76,676.86 ccw(c7282.51,666.62) 7282.51,681.1 ccw(c7282.51,695.59) v4@7292.76,685.35
DBUSB.D1: U8.Y19 U19.19 | length 4931.3
  Top Layer w4: U8.Y19@5567.17,3966.12 cw(c5567.17,3948.4) 5579.7,3960.93 cw(c5592.23,3973.46) U8.Y19@5574.51,3973.46 ; U8.Y19@5567.17,3973.46 v3(5586.85,3953.78) ; 5574.05,3966.58 cw(c5561.24,3953.78) 5579.35,3953.78 ccw(c5561.24,3953.78) 5574.05,3966.58 ; 5574.05,3966.58 ccw(c5586.85,3979.39) 5586.85,3961.28 cw(c5586.85,3979.39) 5574.05,3966.58
  MidLayer1 w4: v1@5547.36,3367.71 cw(c5524.42,3367.71) 5540.64,3351.49 cw(c5556.86,3335.27) v1@5556.86,3358.21 ; v1@5551.36,3367.71 cw(c5538.08,3367.71) 5547.47,3358.32 cw(c5556.86,3348.93) v1@5556.86,3362.21 ; v1(5556.86,3367.71) 5539.36,3350.21 5539.36,3343.54 5539.36,3325 5539.36,3299.23 5562.2,3276.38 5562.2,3234.85 5580.9,3216.15 5580.9,3201.65 5558.64,3179.39 5558.64,2971.2 5522.12,2934.68 5522.12,2435 5522.12,2305.88 5522.12,1867.88 5526.19,1863.81 5581.02,1808.98 5581.02,1751.16 5731.86,1600.33 5731.86,1600.04 5923.52,1408.37 6014.24,1408.37 6288.7,1133.91 6288.7,1000.89 6506.21,783.37 7200,783.37 7225,758.37 7240.19,758.37 7256.86,741.71 7256.86,723.31 v4(7234.34,700.79) ; v4@7234.34,708.79 ccw(c7234.34,728.1) 7247.99,714.44 ccw(c7261.66,700.79) v4@7242.34,700.79
  Bottom Layer w4: v1(5556.86,3367.71) 5508.04,3416.52 5508.04,3441.06 5497.79,3451.31 5485.94,3451.31 5459.9,3477.35 5459.9,3527.95 5469.2,3537.25 5469.2,3550.95 5479.45,3561.2 5509.05,3561.2 5518.95,3551.3 5541.05,3551.3 5580,3590.25 5580,3600 5587.81,3607.81 5602.36,3607.81 5602.36,3630.82 5602.36,3638.82 5602.36,3778.47 5602.36,3836.73 5602.36,3921.1 ccw(c5569.23,3921.27) 5597.27,3938.92 ; v3@5585.55,3946.39 cw(c5582.4,3928.56) 5597.24,3938.95 cw(c5612.07,3949.33) v3@5594.24,3952.48
  Bottom Layer w8: v4(7234.34,700.79) U19.19@7265.67,700.79 ; v4@7238.58,696.54 cw(c7248.82,686.3) 7248.82,700.79 cw(c7248.82,715.27) v4@7238.58,705.03
DBUSB.D2: U8.AG19 U19.20 | length 4724.1
  Top Layer w4: v1@5537.1,3482.4 5537.3,3482.4 5562.3,3482.4 5574.27,3494.37 5582.59,3502.69 ; v1@5541.19,3477.91 cw(c5552.03,3467.07) 5552.03,3482.4 ; v1@5541.19,3485.69 ccw(c5549.13,3493.63) 5549.13,3482.4 ; v1@5544.02,3475.08 cw(c5561.68,3457.42) 5561.68,3482.4 ; v1@5544.02,3488.52 ccw(c5558.79,3503.29) 5558.79,3482.4 ; 5582.69,3578.3 5582.69,3578 ; 5582.86,3502.86 5582.69,3502.69 5582.59,3502.69 ; 5579.7,3685.34 ccw(c5567.17,3672.8) 5567.17,3690.53 cw(c5567.17,3672.8) 5579.7,3685.34 ; 5579.7,3685.34 cw(c5592.23,3697.87) 5574.51,3697.87 ccw(c5592.23,3697.87) 5579.7,3685.34 ; 5579.7,3685.34 cw(c5572.52,3678.16) 5582.67,3678.16 ; 5579.7,3685.34 cw(c5572.52,3678.16) 5582.67,3678.16 ; 5582.59,3502.69 5582.69,3502.8 5582.69,3578 ; 5582.69,3578 5582.69,3591 5582.69,3630.82 5582.67,3638.82 5582.67,3678.16
  MidLayer1 w4: v1@5527.8,3481.8 cw(c5504.86,3481.8) 5521.08,3465.58 cw(c5537.3,3449.36) v1@5537.3,3472.3 ; v1@5531.8,3481.8 cw(c5518.52,3481.8) 5527.91,3472.41 cw(c5537.3,3463.02) v1@5537.3,3476.3 ; v1@5537.1,3481.7 5536.82,3481.42 v1@5536.82,3481.32 ; v1(5537.3,3481.8) v1@5536.82,3481.32 ; v4@7289,720.47 cw(c7269.69,720.47) 7283.34,706.82 cw(c7297,693.16) v4@7297,712.47 ; 5470,3393.69 5490.39,3373.3 ; 5470,3393.69 5490.39,3373.3 ; 5470,3393.69 5470,3445 5480,3455 5510.5,3455 v1@5536.82,3481.32 ; 5490.39,3268.32 5515.35,3243.36 5515.35,3176.92 5509.72,3171.29 5509.72,3126.65 5505,3121.93 5505,3046.5 5535.81,3015.69 5535.81,2971 5506.12,2941.31 5506.12,1915 5474.5,1883.38 5474.5,1747.06 6088.19,1133.37 6496.5,725.04 7055,725.04 ; 5490.39,3268.32 5490.39,3283.08 ; 5490.39,3268.32 5490.39,3283.08 ; 5490.39,3283.08 5490.39,3373.3 ; 7055,725.04 7098.52,725.04 ; 7055,725.04 7098.52,725.04 ; 7098.52,725.04 7149.96,725.04 7195,680 7256.53,680 v4@7290.19,713.66 ; v4@7290.19,713.66 v4(7297,720.47) 7290.19,720.47 v4@7290.19,713.66
  Bottom Layer w8: U19.20@7265.67,720.47 v4(7297,720.47) ; v4@7292.76,716.23 ccw(c7282.51,705.99) 7282.51,720.47 ccw(c7282.51,734.96) v4@7292.76,724.72
DBUSB.D3: U8.AA16 U19.21 | length 4690.1
  Top Layer w4: U8.AA16@5449.05,3926.75 cw(c5449.05,3909.03) 5461.59,3921.56 cw(c5474.12,3934.09) U8.AA16@5456.4,3934.09 ; U8.AA16@5449.06,3934.09 v3(5468.74,3914.41) ; 5455.94,3927.21 cw(c5443.13,3914.41) 5461.24,3914.41 ccw(c5443.13,3914.41) 5455.94,3927.21 ; 5455.94,3927.21 ccw(c5468.74,3940.02) 5468.74,3921.91 cw(c5468.74,3940.02) 5455.94,3927.21
  MidLayer1 w4: v1(5539,3274.7) 5527.2,3262.9 5527.2,3215.64 5550.64,3192.19 5550.64,2974.51 5514.12,2937.99 5514.12,1955 5514.12,1911.69 5482.5,1880.06 5482.5,1841.31 5482.5,1802.5 5535,1750 5535,1697.88 5548.52,1684.35 5651.25,1581.63 5706.54,1526.33 5942.88,1290 6162.88,1070 6208.27,1070 6279.9,998.37 ; 7215,740 7214.84,740.16 ; v4@7228.68,734.5 ccw(c7215.03,720.85) 7215.03,740.16 ccw(c7215.02,759.47) v4@7228.68,745.81 ; v4(7234.34,740.16) 7214.84,740.16 ; 6279.9,998.37 6284.9,993.37 ; 6279.9,998.37 6284.9,993.37 ; 6284.9,993.37 6503.23,775.04 7179.96,775.04 7214.84,740.16
  MidLayer2 w4: v3@5468.09,3906.94 cw(c5466.51,3888.9) 5480.38,3900.54 ; v3@5476.21,3913.76 ccw(c5494.25,3912.18) 5480.38,3900.54 ; v1@5532.28,3281.42 ccw(c5516.06,3297.63) 5539,3297.63 ccw(c5561.93,3297.63) v1@5545.72,3281.42 ; v1@5535.11,3278.59 ccw(c5525.72,3287.98) 5539,3287.98 ccw(c5552.28,3287.98) v1@5542.89,3278.59 ; v1(5539,3274.7) 5539,3300.98 5528.69,3311.29 ; 5480.38,3900.54 cw(c5450.87,3871.03) 5492.6,3871.03 5492.6,3851.53 5492.6,3777.41 5492.6,3757.99 5492.6,3585 5492.6,3573.86 5497.26,3569.2 5519.8,3546.66 5519.8,3467.48 5532.04,3455.24 5532.04,3409.2 5523.36,3400.52 5523.36,3316.62 ; 5523.36,3316.62 5528.69,3311.29 ; 5523.36,3316.62 5528.69,3311.29
  Bottom Layer w8: v4(7234.34,740.16) U19.21@7265.67,740.16 ; v4@7238.58,735.91 cw(c7248.82,725.67) 7248.82,740.16 cw(c7248.82,754.64) v4@7238.58,744.4
DBUSB.D4: U8.AE28 U19.22 | length 5632.2
  Top Layer w4: v1@5659.24,2482.41 ccw(c5649.29,2494.81) 5665.19,2494.81 ; v1(5665.19,2475) 5665.19,2494.81 ; v1@5671.14,2482.41 cw(c5681.09,2494.81) 5665.19,2494.81 ; U8.AE28@5921.5,3776.61 5941.18,3776.61 5949.18,3776.61 5975.92,3776.61 5978.19,3774.35 5978.19,3761.75 5985,3754.94 5985,3736.98 6015.19,3706.79 v1@6015.19,3700.04 ; U8.AE28@5926.69,3771.42 cw(c5939.22,3758.89) 5939.22,3776.61 cw(c5939.22,3794.34) U8.AE28@5926.69,3781.81 ; v1@6116.39,2610.43 ccw(c6102.51,2598.21) 6102.51,2616.71 ; v1@6116.39,2622.98 cw(c6102.51,2635.21) 6102.51,2616.71 ; v1@6119.4,2613.07 ccw(c6111.36,2606) 6111.36,2616.71 ccw(c6111.36,2627.42) v1@6119.4,2620.34 ; v1(6123.52,2616.71) 6102.51,2616.71 ; 5665.19,2494.81 5640.19,2519.81 5640.19,2608.37 5656.86,2625.04 5675,2625.04 5685,2615.04 5685,2510 5728.13,2466.87 5920,2466.87 5952.67,2466.87 6102.51,2616.71
  MidLayer1 w4: v1@5658.47,2468.28 cw(c5642.26,2452.06) 5665.19,2452.06 cw(c5688.13,2452.06) v1@5671.91,2468.28 ; v1@5661.3,2471.11 cw(c5651.91,2461.72) 5665.19,2461.72 cw(c5678.47,2461.72) v1@5669.08,2471.11 ; v1(5665.19,2475) 5665.19,2444.69 5673.52,2436.35 5673.52,2179.1 5694.25,2158.37 5948.5,2158.37 5952.68,2154.19 6055.81,2154.19 6065.19,2144.81 6065.19,2092.71 6023.52,2051.04 6015.02,2042.54 6015.02,1889.98 6027.81,1877.19 6027.81,1822.62 6023.52,1818.34 6023.52,1593.02 6116.84,1499.71 6348.52,1268.02 6348.52,1136.29 6684.77,800.04 7256.8,800.04 v4(7297,759.84) ; v1@6118.96,2625.04 ccw(c6114.75,2632.74) 6123.52,2632.74 ; v1(6123.52,2616.71) 6123.52,2632.74 ; v1@6123.52,3598.87 cw(c6123.52,3575.94) 6139.74,3592.16 cw(c6155.96,3608.37) v1@6133.02,3608.37 ; v1@6123.52,3602.87 cw(c6123.52,3589.6) 6132.91,3598.99 cw(c6142.3,3608.37) v1@6129.02,3608.37 ; v1(6123.52,3608.37) 6156.86,3575.04 6156.86,3371.45 6166.19,3362.12 6166.19,3295 6166.19,3267.77 6168.5,3265.46 6168.5,3218.88 6168.5,3181.69 6070.86,3084.04 6070.86,3025.04 6070.86,3020 6070.86,2979.59 6075.81,2974.63 6075.81,2933.37 6075.81,2909.95 6070.86,2905 6070.86,2890 6070.86,2846.73 6056.52,2832.39 6056.52,2826.52 6056.52,2795 6056.52,2721.52 6055,2720 6055,2701.26 6123.52,2632.74 ; v1@6128.09,2625.04 cw(c6132.3,2632.74) 6123.52,2632.74 ; v4@7289,759.84 ccw(c7269.69,759.84) 7283.34,773.5 ccw(c7297,787.16) v4@7297,767.84
  Bottom Layer w4: v1(6018.62,3698.2) 6047.03,3698.2 6056.86,3688.37 6056.86,3666.71 6081.86,3641.71 6090.19,3641.71 v1(6123.52,3608.37) ; v1@6022.5,3694.31 cw(c6031.89,3684.92) 6031.89,3698.2 cw(c6031.89,3711.48) v1@6022.5,3702.09 ; v1@6025.33,3691.48 cw(c6041.55,3675.27) 6041.55,3698.2 cw(c6041.55,3721.14) v1@6025.33,3704.92 ; v1@6114.02,3608.37 ccw(c6091.09,3608.37) 6107.31,3624.59 ccw(c6123.52,3640.81) v1@6123.52,3617.87 ; v1@6118.02,3608.37 ccw(c6104.75,3608.37) 6114.13,3617.76 ccw(c6123.52,3627.15) v1@6123.52,3613.87
  Bottom Layer w8: U19.22@7265.67,759.84 v4(7297,759.84) ; v4@7292.76,755.6 ccw(c7282.51,745.36) 7282.51,759.84 ccw(c7282.51,774.33) v4@7292.76,764.09
DBUSB.D5: U8.AH21 U19.23 | length 4232.9
  Top Layer w4: v1(5626,3444) 5627.11,3445.11 5627.11,3597.11 5645.91,3615.91 5645.91,3630.82 5645.91,3638.82 U8.AH21@5645.91,3658.5 ; U8.AH21@5640.71,3653.31 cw(c5628.18,3640.78) 5645.91,3640.78 cw(c5663.63,3640.78) U8.AH21@5651.1,3653.31
  MidLayer1 w4: v1@5619.28,3437.28 cw(c5603.06,3421.06) 5626,3421.06 cw(c5648.93,3421.06) v1@5632.72,3437.28 ; v1@5622.11,3440.11 cw(c5612.72,3430.72) 5626,3430.72 cw(c5639.28,3430.72) v1@5629.89,3440.11 ; v1(5626,3444) 5626,3391.17 5631.5,3385.67 5631.5,3295 5625.19,3288.69 5625.19,3214.79 5657.69,3182.29 5657.69,2938.19 5625.71,2906.21 5625.71,2861.54 5661.5,2825.75 5661.5,2704.93 5539.35,2582.79 5539.35,2500.18 5605.81,2433.72 5605.81,2362.01 5655.41,2312.41 5655.41,2174.59 5688.29,2141.71 5806.86,2141.71 5832.5,2116.06 5832.5,2055.92 5821,2044.42 5821,1937.06 5809.5,1925.56 5809.5,1885.33 5833,1861.83 5833,1772.23 5915.19,1690.04 6113.52,1491.71 6340.52,1264.71 6340.52,1132.98 6681.79,791.71 7222.16,791.71 v4(7234.34,779.53) 7231.86,779.52 v4@7231.86,779.71
  Bottom Layer w8: v4(7234.34,779.53) U19.23@7265.67,779.53 ; v4@7238.58,775.28 cw(c7248.82,765.04) 7248.82,779.53 cw(c7248.82,794.01) v4@7238.58,783.77
DBUSB.D6: U8.AG21 U19.24 | length 4849.8
  Top Layer w4: U8.AG21@5645.91,3690.53 cw(c5645.91,3672.8) 5658.44,3685.34 ; U8.AG21@5653.25,3697.87 ccw(c5670.97,3697.87) 5658.44,3685.34 ; v1@5698.56,3383.58 ccw(c5675.63,3383.58) 5691.85,3399.8 ccw(c5708.06,3416.02) v1@5708.06,3393.08 ; v1@5702.56,3383.58 ccw(c5689.29,3383.58) 5698.67,3392.97 ccw(c5708.06,3402.36) v1@5708.06,3389.08 ; v1(5708.06,3383.58) 5685,3406.64 5685,3416.56 5636.5,3465.06 5636.5,3590.5 5661.41,3615.41 5661.41,3630.82 5661.41,3638.82 5661.41,3678.16 ccw(c5651.26,3678.16) 5658.44,3685.34
  MidLayer1 w4: v1@5706.86,3382.37 v1(5708.06,3383.58) 5727.6,3364.04 5755.61,3364.04 ; v1@5708.06,3374.08 cw(c5708.06,3351.15) 5724.28,3367.36 cw(c5740.5,3383.58) v1@5717.56,3383.58 ; v1@5708.06,3378.08 cw(c5708.06,3364.8) 5717.45,3374.19 cw(c5726.84,3383.58) v1@5713.56,3383.58 ; 6136.61,2249.71 6139.25,2247.07 ; 5740.02,3224.96 5768.41,3253.35 ; 5740.02,3224.96 5768.41,3253.35 ; 5740.02,3224.96 5740.02,3063.85 5764.35,3039.52 5764.35,2984.41 5750.5,2970.56 5750.5,2937.97 5761.59,2926.87 5761.59,2881.34 ; 5755.61,3364.04 5768.41,3351.23 ; 5755.61,3364.04 5768.41,3351.23 ; 5761.59,2865 5761.59,2842.65 5805.5,2798.74 5805.5,2758.75 5837.5,2726.75 5837.5,2703.75 5836.5,2702.75 5836.5,2680.75 5856.86,2660.39 5856.86,2627.04 5856.86,2604 5856.86,2575.04 5940.19,2491.71 5940.19,2275.04 5965.19,2250.04 6115,2250.04 6136.27,2250.04 6139.25,2247.07 ; 5761.59,2865 5761.59,2881.34 ; 5761.59,2865 5761.59,2881.34 ; 5768.41,3253.35 5768.41,3351.23 ; 6139.25,2247.07 6171.92,2214.39 6171.92,2138.94 ; 6171.92,2130 6171.92,2138.94 ; 6171.92,2130 6171.92,2138.94 ; 6171.92,2130 6171.92,2097.68 6181.81,2087.79 6181.81,2034 ; 6181.81,2024.06 6181.81,2034 ; 6181.81,2024.06 6361.59,1844.29 6375,1830.87 6375,1734.82 ; 6181.81,2024.06 6181.81,2034 ; 6368.19,1728 6368.19,1700 6381,1687.18 6381,1610.06 6413.5,1577.56 ; 6368.19,1728 6375,1734.82 ; 6368.19,1728 6375,1734.82 ; 6413.5,1378.81 6414.81,1377.5 ; 6413.5,1378.81 6413.5,1565 ; 6413.5,1378.81 6414.81,1377.5 ; 6413.5,1565 6413.5,1577.56 ; 6413.5,1565 6413.5,1577.56 ; 6414.81,1377.5 6418.19,1374.12 6418.19,1313.57 ; 6418.19,1310 6418.19,1278 6472,1224.19 6506,1224.19 6520.43,1238.61 6579.69,1238.61 6586.11,1232.19 6680,1232.19 ; 6418.19,1310 6418.19,1313.57 ; 6418.19,1310 6418.19,1313.57 ; 6680,1232.19 6700.88,1232.19 ; 6680,1232.19 6700.88,1232.19 ; 6700.88,1232.19 6723.87,1232.19 ; 6723.87,1232.19 6740.25,1215.81 ; 6723.87,1232.19 6740.25,1215.81 ; 6740.25,1215.81 6774.81,1215.81 ; 6774.81,1215.81 6836.12,1154.5 ; 6774.81,1215.81 6836.12,1154.5 ; 6836.12,1154.5 7032.25,958.37 7036.13,958.37 ; 7036.13,958.37 v1(7115.19,958.37) 7036.13,958.37 ; 7092.26,958.37 cw(c7092.26,935.44) 7108.47,951.66 ccw(c7092.26,935.44) 7092.26,958.37 ; 7092.26,958.37 ccw(c7092.26,981.31) 7108.47,965.09 cw(c7092.26,981.31) 7092.26,958.37 ; 7101.91,958.37 cw(c7101.91,945.1) 7111.3,954.49 ccw(c7101.91,945.1) 7101.91,958.37 ; 7101.91,958.37 ccw(c7101.91,971.65) 7111.3,962.26 cw(c7101.91,971.65) 7101.91,958.37
  MidLayer2 w4: v1@7108.47,951.66 cw(c7092.26,935.44) 7115.19,935.44 cw(c7138.13,935.44) v1@7121.91,951.66 ; v1@7111.3,954.49 cw(c7101.91,945.1) 7115.19,945.1 cw(c7128.47,945.1) v1@7119.08,954.49 ; v1(7115.19,958.37) 7115.19,833.37 7149.35,799.21 v4(7297,799.21) ; v4@7291.34,793.56 ccw(c7277.68,779.89) 7277.68,799.21 ccw(c7277.69,818.52) v4@7291.34,804.87
  Bottom Layer w8: U19.24@7282.51,799.21 cw(c7282.51,784.73) 7292.76,794.97 ccw(c7282.51,784.73) U19.24@7282.51,799.21 ; U19.24@7282.51,799.21 ccw(c7282.51,813.7) 7292.76,803.46 cw(c7282.51,813.7) U19.24@7282.51,799.21 ; U19.24@7265.67,799.21 v4(7297,799.21) U19.24@7265.67,799.21