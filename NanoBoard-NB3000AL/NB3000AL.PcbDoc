# Altium PCB NB3000AL.PcbDoc (part 63 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetR162_2: R162.2 U30.H5 | length 4340.1
  Top Layer w4: v2(6290,1714) 6315.19,1739.19 6315.19,1933.19 v2(6338,1956) ; v2@6328.19,1956 cw(c6304.5,1956) 6321.25,1939.25 cw(c6338,1922.5) v2@6338,1946.19 ; v2@6332.19,1956 cw(c6318.16,1956) 6328.08,1946.08 cw(c6338,1936.16) v2@6338,1950.19 ; v3(6852.52,1904.37) U30.H5@6872.2,1884.68 ; U30.H5@6864.86,1884.68 ccw(c6847.14,1884.68) 6859.67,1897.22 ccw(c6872.2,1909.75) U30.H5@6872.2,1892.03 ; v2(7136,1256) 7179.5,1256 7195,1240.5 7534.5,1240.5 7581.02,1287.02 7581.02,1435.96 7591.81,1446.74 7591.81,1670.97 7625.15,1704.31 7700,1704.31 7729.69,1734 7752,1734 v2(7760,1734) ; v2@7140.11,1251.89 cw(c7150.03,1241.97) 7150.03,1256 cw(c7150.03,1270.03) v2@7140.11,1260.11 ; v2@7142.94,1249.06 cw(c7159.69,1232.31) 7159.69,1256 cw(c7159.69,1279.69) v2@7142.94,1262.94 ; v2@7753.06,1727.06 ccw(c7736.31,1710.31) 7736.31,1734 ccw(c7736.31,1757.69) v2@7753.06,1740.94 ; v2@7755.89,1729.89 ccw(c7745.97,1719.97) 7745.97,1734 ccw(c7745.97,1748.03) v2@7755.89,1738.11 ; 6865.32,1891.57 cw(c6878.13,1904.37) 6860.02,1904.37 ccw(c6878.13,1904.37) 6865.32,1891.57 ; 6865.32,1891.57 ccw(c6852.52,1878.76) 6852.52,1896.87 cw(c6852.52,1878.76) 6865.32,1891.57
  MidLayer1 w4: v2(6181,1505) 6235,1559 6245,1569 v1(6245,1605) v1@6245,1600 ; v2@6181,1510.81 ccw(c6181,1524.84) 6190.92,1514.92 ccw(c6200.84,1505) v2@6186.81,1505 ; v2@6181,1514.81 ccw(c6181,1538.5) 6197.75,1521.75 ccw(c6214.5,1505) v2@6190.81,1505 ; v1@6238.28,1598.28 cw(c6222.06,1582.06) 6245,1582.06 cw(c6267.93,1582.06) v1@6251.72,1598.28 ; v1@6241.11,1601.11 cw(c6231.72,1591.72) 6245,1591.72 cw(c6258.28,1591.72) v1@6248.89,1601.11
  MidLayer2 w4: v2@6174.7,1497.47 cw(c6163.43,1484) 6181,1484 ; v2@6177.27,1500.54 cw(c6170.59,1492.56) 6181,1492.56 cw(c6191.4,1492.56) v2@6184.73,1500.54 ; v2(6181,1505) 6181,1493.07 6181,1484 ; v2@6187.3,1497.47 ccw(c6198.57,1484) 6181,1484 ; v2(6338,1956) 6382.69,1956 6389.15,1949.54 6395,1949.54 6463.04,1949.54 6467.31,1953.81 6528.34,1953.81 6557.94,1924.21 6580,1924.21 6590.02,1924.21 6621.79,1924.21 6626.12,1919.88 6735.47,1919.88 6829.01,1919.88 cw(c6829.01,1905.83) 6838.94,1915.76 ; v2@6342.11,1951.89 cw(c6352.03,1941.97) 6352.03,1956 cw(c6352.03,1970.03) v2@6342.11,1960.11 ; v2@6344.94,1949.06 cw(c6361.69,1932.31) 6361.69,1956 cw(c6361.69,1979.69) v2@6344.94,1962.94 ; v3@6845.05,1903.72 ccw(c6827.01,1902.14) 6838.65,1916.01 ccw(c6850.29,1929.88) v3@6851.87,1911.84 ; 6975,1369.14 7001.98,1369.14 7031.12,1340 7049.33,1340 7058.27,1348.94 7105.87,1348.94 7118.81,1336 7118.81,1311.19 7136,1294 ; 6990.67,1369.14 6953.95,1369.14 6936.81,1352 6887.5,1352 6863.62,1328.13 6822.06,1328.13 6808.37,1341.81 6770.62,1341.81 6758.71,1329.9 6717.35,1329.9 6679.75,1367.5 6502.73,1367.5 6477.11,1341.88 6449.1,1341.88 6390.1,1400.88 6363.31,1400.88 6351.38,1412.81 6303.64,1412.81 6275.64,1440.81 6258.06,1440.81 6232.66,1466.21 6207.86,1466.21 6199.86,1474.21 6190.79,1474.21 6181,1484 ; 7122.81,1307.19 7136,1294 ; v2@7129.06,1262.94 ccw(c7112.31,1279.69) 7136,1279.69 ccw(c7159.69,1279.69) v2@7142.94,1262.94 ; v2@7131.89,1260.11 ccw(c7121.97,1270.03) 7136,1270.03 ccw(c7150.03,1270.03) v2@7140.11,1260.11 ; v2(7136,1256) 7136,1294
  Bottom Layer w4: v1@6238.28,1611.72 ccw(c6222.06,1627.93) 6245,1627.93 ccw(c6267.93,1627.93) v1@6251.72,1611.72 ; v1@6241.11,1608.89 ccw(c6231.72,1618.28) 6245,1618.28 ccw(c6258.28,1618.28) v1@6248.89,1608.89 ; v1(6245,1605) 6245,1700 6259,1714 v2(6290,1714) ; v2@6283.06,1707.06 ccw(c6266.31,1690.31) 6266.31,1714 ccw(c6266.31,1737.69) v2@6283.06,1720.94 ; v2@6285.89,1709.89 ccw(c6275.97,1699.97) 6275.97,1714 ccw(c6275.97,1728.03) v2@6285.89,1718.11 ; v2(7760,1734) 7795,1769 7904.82,1769 R162.2@7908.82,1765 R162.2@7905.13,1768.69 ; v2@7760,1739.81 ccw(c7760,1753.84) 7769.92,1743.92 ccw(c7779.84,1734) v2@7765.81,1734 ; v2@7760,1743.81 ccw(c7760,1767.5) 7776.75,1750.75 ccw(c7793.5,1734) v2@7769.81,1734 ; 7878.59,1768.69 cw(c7878.59,1735.27) R162.2@7902.23,1758.9 ; 7888.25,1768.69 cw(c7888.25,1744.92) R162.2@7905.06,1761.73 ; 7894.05,1768.69 ccw(c7894.05,1780.26) R162.2@7902.23,1772.08 ; R162.2@7897.91,1768.69 cw(c7897.91,1754.58) R162.2@7907.89,1764.56
NetR163_2: R163.2 U30.H14 | length 1318
  Top Layer w4: U30.H14@7226.54,1884.68 v3(7246.22,1904.37) ; U30.H14@7226.54,1892.03 ccw(c7226.54,1909.75) 7239.07,1897.22 ccw(c7251.6,1884.68) U30.H14@7233.88,1884.68 ; 7233.42,1891.57 cw(c7246.22,1878.76) 7246.22,1896.87 ccw(c7246.22,1878.76) 7233.42,1891.57 ; 7233.42,1891.57 ccw(c7220.61,1904.37) 7238.72,1904.37 cw(c7220.61,1904.37) 7233.42,1891.57
  MidLayer1 w4: v3@7247.52,1911.76 ccw(c7250.67,1929.59) 7261.05,1914.76 ; v3@7253.61,1903.07 cw(c7271.44,1899.92) 7261.05,1914.76 ; v2@7599.88,2002.5 ccw(c7589.5,1995.46) 7589.5,2008 ccw(c7589.5,2020.54) v2@7599.88,2013.5 ; v2(7608,2008) 7589.5,2008 7581.5,2000 ; 7261.08,1914.79 cw(c7278.73,1886.75) 7278.9,1919.88 7335.62,1919.88 7369.69,1885.81 7397.38,1885.81 7408.48,1874.71 7456.21,1874.71 7579.23,1997.73 ; 7579.23,1997.73 7581.5,2000 ; 7579.23,1997.73 7581.5,2000
  MidLayer2 w4: v2@7601.06,2001.06 ccw(c7584.31,1984.31) 7584.31,2008 ccw(c7584.31,2031.69) v2@7601.06,2014.94 ; v2@7603.89,2003.89 ccw(c7593.97,1993.97) 7593.97,2008 ccw(c7593.97,2022.03) v2@7603.89,2012.11 ; v2(7608,2008) 7578,2008 7570.5,2000.5 7570.5,1985.25 7570.5,1970.75 7570.5,1949.5 7574.43,1945.57 7595.69,1945.57 7610,1945.57 7839.43,1945.57 v2(7870,1915) ; v2@7860.19,1915 ccw(c7836.5,1915) 7853.25,1931.75 ccw(c7870,1948.5) v2@7870,1924.81 ; v2@7864.19,1915 ccw(c7850.16,1915) 7860.08,1924.92 ccw(c7870,1934.84) v2@7870,1920.81
  Bottom Layer w4: v2(7870,1915) 7889.58,1934.58 7900.03,1934.58 7908.82,1943.37 R163.2@7908.82,1981.67 ; v2@7870,1920.81 ccw(c7870,1934.84) 7879.92,1924.92 ccw(c7889.84,1915) v2@7875.81,1915 ; v2@7870,1924.81 ccw(c7870,1948.5) 7886.75,1931.75 ccw(c7903.5,1915) v2@7879.81,1915 ; R163.2@7902.23,1974.59 cw(c7886.32,1958.68) 7908.82,1958.68 cw(c7931.32,1958.68) R163.2@7915.41,1974.59 ; R163.2@7905.06,1977.41 cw(c7895.98,1968.33) 7908.82,1968.33 cw(c7921.66,1968.33) R163.2@7912.58,1977.41
NetR196_1: R196.1 U37.2 | length 310.8
  Bottom Layer w4: U37.2@3594.16,6013.06 ccw(c3577.42,5996.31) 3577.42,6020 ccw(c3577.42,6043.69) U37.2@3594.16,6026.94 ; U37.2@3596.99,6015.89 ccw(c3587.07,6005.97) 3587.07,6020 ccw(c3587.07,6034.03) U37.2@3596.99,6024.11 ; R196.1@3609.59,6147.92 cw(c3593.68,6132.01) 3616.18,6132.01 cw(c3638.68,6132.01) R196.1@3622.77,6147.92 ; R196.1@3612.42,6150.75 cw(c3603.34,6141.67) 3616.18,6141.67 cw(c3629.02,6141.67) R196.1@3619.94,6150.75 ; U37.2@3614.88,6020 3575,6020 3570,6025 3570,6085 3616.18,6131.18 R196.1@3616.18,6155
NetR198_1: R198.1 U72.4 | length 446.4
  Bottom Layer w4: R198.1@3858.82,6010 3928.82,6080 4083.13,6080 U72.4@4118.24,6044.88 ; R198.1@3858.82,6015.81 ccw(c3858.82,6029.84) R198.1@3868.74,6019.92 ; R198.1@3858.82,6019.81 ccw(c3858.82,6043.5) 3875.57,6026.75 ; R198.1@3864.14,6010.49 cw(c3875.79,6010.49) R198.1@3867.55,6018.73 ; R198.1@3868.14,6010.49 cw(c3889.45,6010.49) 3874.38,6025.56 ; 4090.02,6073.11 ccw(c4106.46,6089.55) U72.4@4114.75,6067.83 ; 4094.38,6068.74 ccw(c4108.87,6083.23) U72.4@4116.17,6064.09 ; 4098.75,6064.38 ccw(c4111.28,6076.91) U72.4@4117.6,6060.35 ; 4103.11,6060.02 ccw(c4113.69,6070.59) U72.4@4119.02,6056.62
NetR200_1: R200.1 U71.4 | length 273.9
  Bottom Layer w4: R200.1@4487.23,5907.08 ccw(c4471.32,5922.99) 4493.82,5922.99 ccw(c4516.32,5922.99) R200.1@4500.41,5907.08 ; R200.1@4490.06,5904.25 ccw(c4480.98,5913.33) 4493.82,5913.33 ccw(c4506.66,5913.33) R200.1@4497.58,5904.25 ; R200.1@4493.82,5900 4493.82,5948.82 4528.24,5983.24 U71.4@4528.24,6044.88 ; U71.4@4521.31,6024.16 cw(c4504.56,6007.42) 4528.24,6007.42 cw(c4551.93,6007.42) U71.4@4535.18,6024.16 ; U71.4@4524.14,6026.99 cw(c4514.22,6017.07) 4528.24,6017.07 cw(c4542.27,6017.07) U71.4@4532.35,6026.99
NetR211_2: R211.2 U46.2 | length 164.7
  Bottom Layer w4: U46.2@1731.54,5670.08 1780.52,5670.08 ; U46.2@1771.41,5664.96 cw(c1780.52,5659.4) 1780.52,5670.08 ; U46.2@1771.41,5675.19 ccw(c1780.52,5680.75) 1780.52,5670.08 ; R211.2@1812.23,5663.41 ccw(c1796.32,5647.5) 1796.32,5670 ccw(c1796.32,5692.5) R211.2@1812.23,5676.59 ; R211.2@1815.06,5666.24 ccw(c1805.98,5657.16) 1805.98,5670 ccw(c1805.98,5682.84) R211.2@1815.06,5673.76 ; R211.2@1818.82,5670 1780.6,5670 1780.52,5670.08
NetR213_2: R213.2 U70.7 | length 191.1
  Bottom Layer w4: U70.7@7886.85,3833.67 7958.67,3833.67 7977.88,3852.88 R213.2@7977.88,3945
NetR244_2: R244.2 U54.4 | length 223.2
  Bottom Layer w4: U54.4@6202.4,5966.29 cw(c6202.4,5953.92) 6211.15,5962.67 ; U54.4@6202.4,5989.88 6202.4,5971.42 R244.2@6258.82,5915 ; U54.4@6204.21,5976.1 ccw(c6219.9,5976.1) U54.4@6208.81,5965.01 ; U54.4@6208.21,5976.1 ccw(c6233.55,5976.1) 6215.63,5958.18 ; U54.4@6212.21,5976.1 ccw(c6247.21,5976.1) 6222.46,5951.36 ; 6242.07,5931.75 ccw(c6258.82,5948.5) R244.2@6258.82,5924.81 ; 6243.26,5930.56 cw(c6228.19,5915.49) R244.2@6249.5,5915.49 ; R244.2@6248.9,5924.92 ccw(c6258.82,5934.84) R244.2@6258.82,5920.81 ; R244.2@6250.09,5923.73 cw(c6241.85,5915.49) R244.2@6253.5,5915.49
NetR247_2: R247.2 U55.5 | length 413
  Bottom Layer w4: U55.5@6562.76,6425 6605,6425 6610,6420 6610,6365 6615,6360 6673.82,6360 R247.2@6753.82,6440 ; U55.5@6574.16,6419.5 cw(c6587.44,6406.22) 6587.44,6425 cw(c6587.44,6443.78) U55.5@6574.16,6430.5 ; U55.5@6576.99,6416.67 cw(c6597.1,6396.56) 6597.1,6425 cw(c6597.1,6453.44) U55.5@6576.99,6433.33 ; 6737.07,6423.25 cw(c6753.82,6406.5) R247.2@6753.82,6430.19 ; 6738.26,6424.44 ccw(c6723.19,6439.51) R247.2@6744.5,6439.51 ; R247.2@6743.9,6430.08 cw(c6753.82,6420.16) R247.2@6753.82,6434.19 ; R247.2@6745.09,6431.27 ccw(c6736.85,6439.51) R247.2@6748.5,6439.51
NetR249_2: R249.2 U56.13 | length 150.1
  Bottom Layer w4: U56.13@6715.44,6303.09 ccw(c6708.61,6309.92) 6718.27,6309.92 ccw(c6727.92,6309.92) U56.13@6721.1,6303.09 ; U56.13@6718.27,6289.33 6718.27,6320.66 6703.48,6335.44 6703.48,6358.16 6715.98,6370.66 6731.75,6370.66 6742.41,6360 R249.2@6753.82,6360
NetR250_2: R250.2 U56.15 | length 365.4
  Bottom Layer w4: U56.15@6764.33,6262.95 6817.05,6262.95 6835.69,6244.31 6835.69,6219.52 6835.69,6211.14 6839.21,6207.62 6900,6207.62 6930.79,6207.62 6973.17,6250 R250.2@6983.82,6250 ; U56.15@6778.09,6260.12 cw(c6784.92,6253.3) 6784.92,6262.95 cw(c6784.92,6272.61) U56.15@6778.09,6265.78 ; 6955.72,6232.55 cw(c6983.82,6204.45) R250.2@6983.82,6244.19 ; 6962.55,6239.38 cw(c6983.82,6218.11) R250.2@6983.82,6248.19 ; 6969.38,6246.21 cw(c6983.82,6231.77) R250.2@6983.82,6252.19
NetR251_2: R251.2 U56.16 | length 603.5
  Top Layer w4: v4@6733,6235.27 cw(c6733,6215.95) 6746.66,6229.61 cw(c6760.31,6243.27) v4@6741,6243.27 ; v4(6733,6243.27) 6755,6221.27 6755,6116.23 6775.37,6095.86 ; 6773.52,6097.71 6775.37,6095.86 ; v1@6964.47,6089.32 ccw(c6948.26,6073.11) 6948.26,6096.04 ccw(c6948.26,6118.98) v1@6964.47,6102.76 ; v1@6967.3,6092.15 ccw(c6957.91,6082.76) 6957.91,6096.04 ccw(c6957.91,6109.32) v1@6967.3,6099.93 ; v1(6971.19,6096.04) 6917.67,6096.04 6905,6083.37 6787.86,6083.37 6775.37,6095.86
  Bottom Layer w4: v1(6971.19,6096.04) 6983.82,6108.67 ; R251.2@6977.61,6122.56 cw(c6965.18,6108.67) 6983.82,6108.67 ; R251.2@6980.27,6125.54 cw(c6973.18,6117.61) 6983.82,6117.61 cw(c6994.46,6117.62) R251.2@6987.36,6125.54 ; R251.2@6983.82,6130 6983.82,6108.67 ; R251.2@6990.03,6122.56 ccw(c7002.46,6108.67) 6983.82,6108.67
  Bottom Layer w8: v4(6733,6243.27) U56.16@6764.33,6243.27 ; v4@6737.24,6239.03 cw(c6747.48,6228.78) 6747.48,6243.27 cw(c6747.48,6257.75) v4@6737.24,6247.51
NetR257_1: R257.1 U61.16 | length 748.8
  Top Layer w4: U61.16@5862.45,2256.02 ccw(c5855.62,2262.85) 5865.28,2262.85 ccw(c5874.93,2262.85) U61.16@5868.1,2256.02 ; U61.16@5865.27,2240 5865.27,2295.79 v1(5881.86,2312.37) ; v1@5872.36,2312.37 cw(c5849.42,2312.37) 5865.64,2296.16 cw(c5881.86,2279.94) v1@5881.86,2302.87 ; v1@5876.36,2312.37 cw(c5863.08,2312.37) 5872.47,2302.99 cw(c5881.86,2293.6) v1@5881.86,2306.87 ; v1(5890,2085) R257.1@5916.33,2085 ; v1@5893.89,2081.11 cw(c5903.28,2071.72) 5903.28,2085 cw(c5903.28,2098.28) v1@5893.89,2088.89 ; v1@5896.72,2078.28 cw(c5912.93,2062.06) 5912.93,2085 cw(c5912.93,2107.93) v1@5896.72,2091.72
  Bottom Layer w4: v1(5881.86,2312.37) 5881.86,2242.71 5910.76,2213.81 5977.38,2213.81 6003.81,2187.38 6003.81,2068.81 5999.19,2064.19 5910.81,2064.19 v1(5890,2085) ; v1@5890,2075.5 cw(c5890,2052.56) 5906.22,2068.78 cw(c5922.43,2085) v1@5899.5,2085 ; v1@5890,2079.5 cw(c5890,2066.22) 5899.39,2075.61 cw(c5908.78,2085) v1@5895.5,2085
NetR258_1: R258.1 U61.23 | length 960.1
  Top Layer w4: v1@5975.14,2330.99 cw(c5958.92,2314.77) 5981.86,2314.77 cw(c6004.79,2314.77) v1@5988.57,2330.99 ; v1@5977.97,2333.82 cw(c5968.58,2324.43) 5981.86,2324.43 cw(c5995.14,2324.43) v1@5985.75,2333.82 ; v1(5981.86,2337.71) 5981.86,2285.04 6003.07,2263.83 U61.23@6003.07,2240 ; U61.23@6000.24,2256.02 ccw(c5993.41,2262.85) 6003.07,2262.85 ; 6003.07,2262.85 ccw(c6012.73,2262.85) U61.23@6005.9,2256.02 ; v1@6061.28,2062.72 ccw(c6051.85,2072.15) 6065.19,2072.15 ; v1@6065.19,2058.37 6065.19,2079.04 ; 6065.19,2071.55 ccw(c6078.4,2071.55) v1@6071.06,2060.57 ; v1@6073.28,2063.9 cw(c6083.41,2079.04) 6065.19,2079.04 ; R258.1@6098.48,2078.41 ccw(c6082.58,2062.5) 6082.58,2085 ccw(c6082.58,2107.5) R258.1@6098.48,2091.59 ; R258.1@6101.31,2081.24 ccw(c6092.23,2072.16) 6092.23,2085 ccw(c6092.23,2097.84) R258.1@6101.31,2088.76 ; R258.1@6105.07,2085 6071.15,2085 6065.19,2079.04
  Bottom Layer w4: v1@5975.67,2344.92 ccw(c5964.13,2358.37) 5981.86,2358.37 ; v1@5978.28,2341.88 ccw(c5971.59,2349.67) 5981.86,2349.67 ccw(c5992.12,2349.67) v1@5985.44,2341.88 ; v1(5981.86,2337.71) 5981.86,2358.37 ; v1@5988.04,2344.92 cw(c5999.58,2358.37) 5981.86,2358.37 ; v1@6061.28,2062.72 ccw(c6045.06,2078.93) 6068,2078.93 ccw(c6090.93,2078.93) v1@6074.72,2062.72 ; v1@6064.11,2059.89 ccw(c6054.72,2069.28) 6068,2069.28 ccw(c6081.28,2069.28) v1@6071.89,2059.89 ; v1@6067.56,2056 v1(6068,2056) 6068,2061.18 6068,2098 6107.81,2137.81 6107.81,2140 6107.81,2357.42 6065.19,2400.04 6045,2400.04 6023.52,2400.04 5995.04,2400.04 5981.86,2386.86 5981.86,2358.37
NetR259_1: R259.1 U61.30 | length 516.6
  Top Layer w4: U61.30@6138.88,2256.67 ccw(c6136.93,2260.08) 6140.87,2260.08 ; U61.30@6140.86,2240 6140.87,2260.08 ; U61.30@6142.85,2256.67 cw(c6144.8,2260.08) 6140.87,2260.08 ; R259.1@6293.82,2085 6345.5,2136.68 6345.5,2219.25 6333.19,2231.56 6333.19,2245.56 6278.87,2299.88 6217.72,2299.88 6156.12,2299.88 6142,2285.76 6142,2261.22 6140.87,2260.08 ; R259.1@6293.82,2090.81 ccw(c6293.82,2104.84) R259.1@6303.74,2094.92 ; R259.1@6293.82,2094.81 ccw(c6293.82,2118.5) 6310.57,2101.75 ; R259.1@6299.14,2085.49 cw(c6310.79,2085.49) R259.1@6302.55,2093.73 ; R259.1@6303.14,2085.49 cw(c6324.45,2085.49) 6309.38,2100.56
NetR260_1: R260.1 U61.110 | length 656.7
  Top Layer w4: v1(5481.86,2658.37) 5493.93,2646.31 U61.110@5516.83,2646.31 ; U61.110@5500.81,2643.48 ccw(c5493.98,2636.65) 5493.98,2646.31 ccw(c5493.98,2655.96) U61.110@5500.81,2649.13
  Bottom Layer w4: R260.1@5061.18,2775 5156.81,2775 5169.82,2788 5245.25,2788 5264.5,2768.75 5264.5,2764.44 5378.9,2650.04 5445,2650.04 5453.33,2658.37 v1(5481.86,2658.37) ; R260.1@5064.94,2771.24 cw(c5074.02,2762.16) 5074.02,2775 cw(c5074.02,2787.84) R260.1@5064.94,2778.76 ; R260.1@5067.77,2768.41 cw(c5083.68,2752.5) 5083.68,2775 cw(c5083.68,2797.5) R260.1@5067.77,2781.59 ; v1@5475.14,2651.66 ccw(c5458.92,2635.44) 5458.92,2658.37 ccw(c5458.92,2681.31) v1@5475.14,2665.09 ; v1@5477.97,2654.49 ccw(c5468.58,2645.1) 5468.58,2658.37 ccw(c5468.58,2671.65) v1@5477.97,2662.26
NetR261_1: R261.1 U61.127 | length 885.3
  Top Layer w4: v1@5474,2320.5 cw(c5474,2297) 5490.61,2313.62 ; v1@5474,2324.5 cw(c5474,2310.66) 5483.79,2320.45 ; v1(5474,2330) 5474,2330.23 5492.57,2311.66 U61.127@5516.83,2311.66 ; v1@5479.5,2330 ccw(c5492.22,2330) 5483.23,2321.01 ; v1@5483.5,2330 ccw(c5505.87,2330) 5490.05,2314.18 ; U61.127@5500.81,2308.83 ccw(c5493.98,2302) 5493.98,2311.66 ccw(c5493.98,2321.32) U61.127@5500.81,2314.49
  MidLayer2 w4: v1@5100.14,2273.43 ccw(c5083.92,2289.64) 5106.86,2289.64 ccw(c5129.79,2289.64) v1@5113.57,2273.43 ; v1@5102.97,2270.6 ccw(c5093.58,2279.99) 5106.86,2279.99 ccw(c5120.14,2279.99) v1@5110.75,2270.6 ; v1(5106.86,2266.71) 5106.86,2379.23 5161.5,2433.87 5370.36,2433.87 5474,2330.23 v1(5474,2330) ; 5457.62,2346.61 cw(c5441,2330) v1@5464.5,2330 ; 5458.18,2346.05 ccw(c5474,2361.87) v1@5474,2339.5 ; 5464.45,2339.79 cw(c5454.66,2330) v1@5468.5,2330 ; 5465.01,2339.23 ccw(c5474,2348.22) v1@5474,2335.5
  Bottom Layer w4: R261.1@5061.18,2271.82 5087.08,2271.82 5092.19,2266.71 v1(5106.86,2266.71) ; R261.1@5064.94,2268.06 cw(c5074.02,2258.98) 5074.02,2271.82 cw(c5074.02,2284.66) R261.1@5064.94,2275.58 ; R261.1@5067.77,2265.23 cw(c5083.68,2249.32) 5083.68,2271.82 cw(c5083.68,2294.32) R261.1@5067.77,2278.41
NetR262_1: R262.1 U61.128 | length 868.3
  Top Layer w4: v1(5473.52,2273.71) 5491.79,2291.98 U61.128@5516.83,2291.98 ; v1@5473.52,2279.21 ccw(c5473.52,2292.49) 5482.91,2283.1 ccw(c5492.3,2273.71) v1@5479.02,2273.71 ; v1@5473.52,2283.21 ccw(c5473.52,2306.14) 5489.74,2289.93 ccw(c5505.96,2273.71) v1@5483.02,2273.71 ; U61.128@5500.81,2289.15 ccw(c5493.98,2282.32) 5493.98,2291.98 ccw(c5493.98,2301.63) U61.128@5500.81,2294.8
  MidLayer2 w4: v1(5109.52,2191.71) 5146.86,2191.71 5205.19,2133.37 5371.9,2133.37 5473.52,2235 v1(5473.52,2273.71) ; v1@5113.41,2187.82 cw(c5122.8,2178.43) 5122.8,2191.71 cw(c5122.8,2204.99) v1@5113.41,2195.6 ; v1@5116.24,2184.99 cw(c5132.46,2168.77) 5132.46,2191.71 cw(c5132.46,2214.64) v1@5116.24,2198.43 ; v1@5466.81,2266.99 cw(c5450.59,2250.77) 5473.52,2250.77 cw(c5496.46,2250.77) v1@5480.24,2266.99 ; v1@5469.64,2269.82 cw(c5460.25,2260.43) 5473.52,2260.43 cw(c5486.8,2260.43) v1@5477.41,2269.82
  Bottom Layer w4: R262.1@5061.18,2215.91 5084.09,2215.91 5108.29,2191.71 v1(5109.52,2191.71) ; R262.1@5064.94,2212.15 cw(c5074.02,2203.07) 5074.02,2215.91 cw(c5074.02,2228.75) R262.1@5064.94,2219.67 ; R262.1@5067.77,2209.32 cw(c5083.68,2193.41) 5083.68,2215.91 cw(c5083.68,2238.41) R262.1@5067.77,2222.5 ; 5091.2,2208.8 ccw(c5109.52,2227.12) v1@5109.52,2201.21 ; 5094.18,2205.82 cw(c5080.06,2191.71) v1@5100.02,2191.71 ; 5098.03,2201.97 ccw(c5109.52,2213.46) v1@5109.52,2197.21
NetR263_1: R263.1 U61.1 | length 1659.1
  Top Layer w4: v1(4960,2475) 4961.35,2475 4975.5,2460.85 4975.5,2418.43 4947.69,2390.62 4947.69,2217.31 4975,2190 5046.56,2190 v1(5048.52,2188.04) ; 5020.86,2190 cw(c5020.86,2160.38) v1@5041.81,2181.32 ; 5030.32,2190 ccw(c5030.32,2206.25) v1@5041.81,2194.76 ; 5030.52,2190 cw(c5030.52,2170.03) v1@5044.64,2184.15 ; 5562.03,2262.78 cw(c5552.44,2253.19) U61.1@5566,2253.19 ; U61.1@5565.93,2258.88 ccw(c5570,2262.94) U61.1@5570,2257.19 ; U61.1@5570,2240 5570,2254.81 5552.19,2272.62 5552.19,2299.16 5577.5,2324.47 5577.5,2337.35 v1(5637.52,2397.37) ; v1@5628.02,2397.37 cw(c5605.09,2397.37) 5621.31,2381.16 cw(c5637.52,2364.94) v1@5637.52,2387.87 ; v1@5632.02,2397.37 cw(c5618.75,2397.37) 5628.14,2387.99 cw(c5637.52,2378.6) v1@5637.52,2391.87
  MidLayer2 w4: v1(4960,2475) 5018.37,2533.37 5211.69,2533.37 5236.69,2508.37 5568.56,2508.37 5637.52,2439.41 v1(5637.52,2397.37) ; v1@4960,2480.5 ccw(c4960,2493.78) 4969.39,2484.39 ccw(c4978.78,2475) v1@4965.5,2475 ; v1@4960,2484.5 ccw(c4960,2507.43) 4976.22,2491.22 ccw(c4992.43,2475) v1@4969.5,2475 ; v1@5630.81,2404.09 ccw(c5614.59,2420.31) 5637.52,2420.31 ccw(c5660.46,2420.31) v1@5644.24,2404.09 ; v1@5633.64,2401.26 ccw(c5624.25,2410.65) 5637.52,2410.65 ccw(c5650.8,2410.65) v1@5641.41,2401.26
  Bottom Layer w4: v1(5048.52,2188.04) 5061.18,2175.38 ; R263.1@5057.11,2168.87 ccw(c5053.94,2175.38) 5061.18,2175.38 ; R263.1@5061.18,2160 5061.18,2175.38 ; R263.1@5065.26,2168.87 cw(c5068.42,2175.38) 5061.18,2175.38
NetR267_2: R267.2 R279.2 U30.H4 | length 8992.2
  Top Layer w4: v3(6813.15,1904.37) U30.H4@6832.83,1884.68 ; U30.H4@6825.49,1884.68 ccw(c6807.77,1884.68) 6820.3,1897.22 ccw(c6832.83,1909.75) U30.H4@6832.83,1892.03 ; v1@7927,5972 v1(7935,5980) ; v1@7932.64,5975.03 cw(c7921.01,5950.48) R279.2@7948.17,5950.48 ; v1@7934.36,5978.64 cw(c7924,5956.8) R279.2@7948.17,5956.8 ; v1@7935,5972 7948,5972 ; v1@7936.07,5982.26 cw(c7927,5963.13) 7948.17,5963.13 ; R267.2@7937.78,5985.87 cw(c7930,5969.45) 7948.17,5969.45 ; R267.2@7939.5,5989.49 cw(c7933,5975.77) 7948.17,5975.77 ; R279.2@7941.58,5953.75 ccw(c7925.68,5969.66) 7948.17,5969.66 ccw(c7970.67,5969.66) R279.2@7954.76,5953.75 ; R279.2@7944.41,5950.92 ccw(c7935.33,5960) 7948.17,5960 ccw(c7961.01,5960) R279.2@7951.93,5950.92 ; R267.2@7944.41,5992.75 cw(c7935.33,5983.67) 7948.17,5983.67 cw(c7961.01,5983.67) R267.2@7951.93,5992.75 ; R279.2@7948.17,5946.67 7948.17,5980 R267.2@7948.17,5997 ; 7948.17,5974.01 cw(c7970.67,5974.01) R267.2@7954.76,5989.92 ; 6825.95,1891.57 cw(c6838.76,1904.37) 6820.65,1904.37 ccw(c6838.76,1904.37) 6825.95,1891.57 ; 6825.95,1891.57 ccw(c6813.15,1878.76) 6813.15,1896.87 cw(c6813.15,1878.76) 6825.95,1891.57
  MidLayer1 w4: v2@6344.06,2233.06 cw(c6327.26,2216.26) 6351.02,2216.26 ; v2@6346.89,2235.89 cw(c6336.91,2225.91) 6351.02,2225.91 ; 6351.02,2216.37 cw(c6374.63,2216.37) v2@6357.94,2233.06 ; 6351.02,2226.03 cw(c6364.97,2226.03) v2@6355.11,2235.89 ; v2(6351,2240) 6351.02,2022.79 6399.61,1974.21 6414.11,1974.21 6425,1985.1 6425,2044 6439,2058 6489,2058 6539.89,2007.11 6539.89,2005.36 6583.44,1961.81 6622.19,1961.81 6655.77,1928.23 6668,1928.23 ; v2(6581,2422) 6590.52,2431.52 6590.52,2441.34 6605.19,2456 6605.19,2456.19 6605.38,2456.19 6615.81,2466.62 6615.81,2508.74 6724.61,2617.54 6729.77,2617.54 6882.19,2769.96 6882.19,2880.37 7186.82,3185 v2(7255,3185) ; 6665.67,1928.23 6668,1928.23 ; 6736.34,1928.23 6750.27,1928.23 ; v3@6805.76,1903.07 ccw(c6787.93,1899.92) 6798.32,1914.76 ; v3@6811.85,1911.76 cw(c6808.7,1929.59) 6798.32,1914.76 ; v2@7248.06,3178.06 ccw(c7231.31,3161.31) 7231.31,3185 ccw(c7231.31,3208.69) v2@7248.06,3191.94 ; v2@7250.89,3180.89 ccw(c7240.97,3170.97) 7240.97,3185 ccw(c7240.97,3199.03) v2@7250.89,3189.11 ; v1@7928.28,5973.28 cw(c7912.06,5957.06) 7935,5957.06 cw(c7957.94,5957.06) v1@7941.72,5973.28 ; v1@7931.11,5976.11 cw(c7921.72,5966.72) 7935,5966.72 cw(c7948.28,5966.72) v1@7938.89,5976.11 ; v1(7935,5980) 7935,5945.81 7959,5921.81 7959,5511.18 7950.81,5503 7950.81,5385.42 7979.95,5356.28 8078.19,5258.04 8078.27,5258.04 8232.52,5103.79 8232.52,5069.02 8233.35,5068.19 8233.35,5063.22 8232.52,5062.39 8232.52,4591.47 8221,4579.94 8221,4250.06 8241,4230.06 8241,3876.08 8150.23,3785.31 8149.41,3784.48 8149.41,2935.78 8165.19,2920 v1(8165.19,2791.71) ; v1@8158.47,2798.43 ccw(c8142.26,2814.64) 8165.19,2814.64 ccw(c8188.13,2814.64) v1@8171.91,2798.43 ; v1@8161.3,2795.6 ccw(c8151.91,2804.99) 8165.19,2804.99 ccw(c8178.47,2804.99) v1@8169.08,2795.6 ; 6668,1928.23 6676.15,1928.23 6750.27,1928.23 ; 6750.27,1928.23 6773.52,1928.23 cw(c6773.52,1904.46) 6789.74,1921.84 6798.32,1914.76
  MidLayer2 w4: v2@7483.06,2571.94 ccw(c7473.56,2581.44) 7487,2581.44 ; 7487,2580.69 ccw(c7499.56,2580.69) v2@7493.02,2569.96 ; v2(7490,2565) 7487,2565 7487,2587.81 ; v2@7495.11,2573.38 cw(c7503.9,2587.81) 7487,2587.81 ; v2@7708,2966.12 cw(c7692.13,2949.86) 7714.86,2949.86 ; v2@7710.8,2968.98 cw(c7701.4,2959.35) 7714.86,2959.35 cw(c7728.32,2959.35) v2@7718.92,2968.98 ; v2(7714.86,2973.14) 7714.86,2949.86 ; v2@7721.71,2966.12 ccw(c7737.58,2949.86) 7714.86,2949.86 ; 7487,2587.81 7455,2619.81 7455,2749.75 7483.25,2778 7543,2778 7714.86,2949.86
  Bottom Layer w4: v2@6341.19,2240 ccw(c6317.5,2240) 6334.25,2256.75 ccw(c6351,2273.5) v2@6351,2249.81 ; v2@6345.19,2240 ccw(c6331.16,2240) 6341.08,2249.92 ccw(c6351,2259.84) v2@6351,2245.81 ; v2(6351,2240) 6331,2260 6331,2379.69 6348.81,2397.5 6408.31,2397.5 6420.36,2409.55 6491.3,2409.55 6503.56,2421.81 ; 6519.38,2421.81 6503.56,2421.81 ; v2@6574.06,2415.06 ccw(c6557.31,2398.31) 6557.31,2422 ccw(c6557.31,2445.69) v2@6574.06,2428.94 ; v2@6576.89,2417.89 ccw(c6566.97,2407.97) 6566.97,2422 ccw(c6566.97,2436.03) v2@6576.89,2426.11 ; v2(6581,2422) 6503.75,2422 6503.56,2421.81 ; v2@7248.06,3178.06 cw(c7231.31,3161.31) 7255,3161.31 cw(c7278.69,3161.31) v2@7261.94,3178.06 ; v2@7250.89,3180.89 cw(c7240.97,3170.97) 7255,3170.97 cw(c7269.03,3170.97) v2@7259.11,3180.89 ; v2(7255,3185) 7255,3140 7274.19,3120.81 7331.7,3120.81 7542.88,3120.81 7596.69,3067 7705,3067 7714.86,3057.14 v2(7714.86,2973.14) ; v2(7490,2565) 7487,2565 7488,2566 7540,2566 7547.63,2558.37 7618.86,2558.37 7640.89,2580.41 7642.67,2582.19 7742.15,2582.19 7765.77,2605.81 7794.44,2605.81 7800.21,2600.04 7971.56,2600.04 7987.56,2616.04 8021.52,2616.04 8037.86,2599.71 8203.54,2599.71 8215,2611.16 8215,2710.19 8165.19,2760 v1(8165.19,2791.71) ; v2@7494.11,2560.89 cw(c7506.44,2548.56) 7506.44,2566 ; v2@7496.94,2558.06 cw(c7516.1,2538.9) 7516.1,2566 ; v2@7496.94,2571.94 ccw(c7511.27,2586.27) 7511.27,2566 ; v2@7707.92,2980.08 ccw(c7691.17,2996.83) 7714.86,2996.83 ccw(c7738.54,2996.83) v2@7721.79,2980.08 ; v2@7710.75,2977.25 ccw(c7700.83,2987.17) 7714.86,2987.17 ccw(c7728.89,2987.17) v2@7718.97,2977.25 ; v1@8158.47,2784.99 cw(c8142.26,2768.77) 8165.19,2768.77 cw(c8188.13,2768.77) v1@8171.91,2784.99 ; v1@8161.3,2787.82 cw(c8151.91,2778.43) 8165.19,2778.43 cw(c8178.47,2778.43) v1@8169.08,2787.82
NetR268_2: R268.2 R280.2 U30.J4 | length 8111.4
  Top Layer w4: v2@6523.55,1810.74 ccw(c6519.86,1818) 6528,1818 ccw(c6536.14,1818) v2@6532.45,1810.74 ; v2(6528,1802) 6528,1818 6517.81,1828.19 6517.81,1912.43 6537.81,1932.43 6540,1934.62 6540,2045.5 6540,2110 v2(6540,2210) ; v3(6813.15,1825.63) U30.J4@6832.83,1845.31 ; U30.J4@6825.49,1845.31 cw(c6807.77,1845.31) 6820.3,1832.78 cw(c6832.83,1820.25) U30.J4@6832.83,1837.97 ; R280.2@7709.59,5953.75 ccw(c7693.68,5969.66) 7716.18,5969.66 ccw(c7738.68,5969.66) 7722.77,5953.75 ccw(c7739.06,5970.04) 7739.06,5947 ; R268.2@7709.59,5989.92 cw(c7693.68,5974.01) 7716.18,5974.01 cw(c7738.68,5974.01) R268.2@7722.77,5989.92 ; v2@7710,2872.19 cw(c7710,2848.5) 7726.75,2865.25 cw(c7743.5,2882) v2@7719.81,2882 ; v2@7710,2876.19 cw(c7710,2862.16) 7719.92,2872.08 cw(c7729.84,2882) v2@7715.81,2882 ; v2(7710,2882) 7756,2836 7756,2830 7756,2743.18 7757,2742.18 v2(7757,2701) ; R280.2@7712.42,5950.92 ccw(c7703.34,5960) 7716.18,5960 ccw(c7729.02,5960) 7719.94,5950.92 ccw(c7729.4,5960.38) 7729.4,5947 ; R268.2@7712.42,5992.75 cw(c7703.34,5983.67) 7716.18,5983.67 cw(c7729.02,5983.67) R268.2@7719.94,5992.75 ; R268.2@7716.18,5997 R280.2@7716.18,5947 ; R280.2@7719.94,5943.4 cw(c7728.64,5934.7) 7728.64,5947 ; R280.2@7721.14,5941.71 R280.2@7716.18,5946.67 R280.2@7716.18,5947 ; R280.2@7722.77,5940.57 cw(c7738.3,5925.04) 7738.3,5947 ; v1@7758.28,5940.28 ccw(c7742.06,5924.06) 7742.06,5947 ccw(c7742.06,5969.93) v1@7758.28,5953.72 ; v1@7761.11,5943.11 ccw(c7751.72,5933.72) 7751.72,5947 ccw(c7751.72,5960.28) v1@7761.11,5950.89 ; v1(7765,5947) R280.2@7716.18,5947 ; 6825.95,1838.43 cw(c6813.15,1851.24) 6813.15,1833.13 ccw(c6813.15,1851.24) 6825.95,1838.43 ; 6825.95,1838.43 ccw(c6838.76,1825.63) 6820.65,1825.63 cw(c6838.76,1825.63) 6825.95,1838.43
  MidLayer1 w4: v2@6425.06,2515.06 cw(c6408.31,2498.31) 6432,2498.31 cw(c6455.69,2498.31) v2@6438.94,2515.06 ; v2@6427.89,2517.89 cw(c6417.97,2507.97) 6432,2507.97 cw(c6446.03,2507.97) v2@6436.11,2517.89 ; v2(6432,2522) 6432,2454 6482,2404 v2(6512,2404) ; v2@6505.06,2397.06 ccw(c6488.31,2380.31) 6488.31,2404 ccw(c6488.31,2427.69) v2@6505.06,2410.94 ; v2@6507.89,2399.89 ccw(c6497.97,2389.97) 6497.97,2404 ccw(c6497.97,2418.03) v2@6507.89,2408.11 ; v2@6530,1800 6550,1800 ; v2@6532.84,1805.21 ccw(c6542.55,1811.64) 6542.55,1800 ; v2@6534.94,1795.06 cw(c6546.86,1783.14) 6546.86,1800 ; v2@6536.18,1807.42 ccw(c6550,1816.58) 6550,1800 ; 6736.34,1801.77 6750.27,1801.77 ; v3@6805.76,1826.93 cw(c6787.93,1830.08) 6798.32,1815.24 ; v3@6811.85,1818.24 ccw(c6808.7,1800.41) 6798.32,1815.24 ; 6550,1800 6578,1828 6627.19,1828 6642.5,1812.69 6653.42,1801.77 6660,1801.77 6676.15,1801.77 6750.27,1801.77 ; 6750.27,1801.77 6773.52,1801.77 ccw(c6773.52,1825.54) 6789.74,1808.16 6798.32,1815.24
  MidLayer2 w4: v2@6512,2394.19 cw(c6512,2370.5) 6528.75,2387.25 cw(c6545.5,2404) v2@6521.81,2404 ; v2@6512,2398.19 cw(c6512,2384.16) 6521.92,2394.08 cw(c6531.84,2404) v2@6517.81,2404 ; v2(6512,2404) 6532.35,2383.65 6532.35,2358.13 6549.61,2340.87 6569.71,2340.87 6581.84,2353 6617,2353 6632.35,2337.65 6632.35,2264.35 6578,2210 v2(6540,2210) ; v2@6544.11,2205.89 cw(c6554.03,2195.97) 6554.03,2210 cw(c6554.03,2224.03) v2@6544.11,2214.11 ; v2@6546.94,2203.06 cw(c6563.69,2186.31) 6563.69,2210 cw(c6563.69,2233.69) v2@6546.94,2216.94 ; v1(7765,5947) 7860.06,5947 7878.06,5965 7925,5965 7932.5,5957.5 7972.25,5957.5 8082.5,5957.5 8084.19,5955.81 ; v1@7768.89,5943.11 cw(c7778.28,5933.72) 7778.28,5947 cw(c7778.28,5960.28) v1@7768.89,5950.89 ; v1@7771.72,5940.28 cw(c7787.94,5924.06) 7787.94,5947 cw(c7787.94,5969.93) v1@7771.72,5953.72 ; v2(8047.78,2873.78) 8035,2886.56 8035,3150 8343,3458 8343,3680.82 8148.19,3875.63 8148.19,3966.19 8256.86,4074.86 8256.86,5291.86 8285,5320 8285,5755 8095,5945 ; 8084.19,5955.81 8095,5945 ; 8084.19,5955.81 8095,5945
  Bottom Layer w4: v2@6436.11,2517.89 cw(c6446.03,2507.97) 6446.03,2522 cw(c6446.03,2536.03) v2@6436.11,2526.11 ; v2@6438.94,2515.06 cw(c6455.69,2498.31) 6455.69,2522 cw(c6455.69,2545.69) v2@6438.94,2528.94 ; v2@6441.16,2523.04 6442.2,2522 6488.49,2522 6495.45,2515.04 6552.21,2515.04 6609.71,2572.54 6770.1,2572.54 6775.37,2577.81 6836.06,2577.81 6882.75,2624.5 6897.25,2624.5 6919.37,2602.37 6958.19,2602.37 6982.69,2626.87 7023.69,2626.87 7031.69,2618.87 7131.65,2618.87 7388.48,2875.71 7487.11,2875.71 7489.28,2877.87 7495,2877.87 7503.77,2877.87 7594.19,2877.87 7597.06,2875 7620,2875 7645,2875 7687.13,2875 7694.13,2882 v2(7710,2882) ; v2@7756,2700 7757,2700 7874,2700 v2(8047.78,2873.78) ; v2(7757,2701) 7756,2702 v2@7757,2702 ; v2@7761.11,2705.11 ccw(c7773.44,2717.44) 7773.44,2700 ; v2@7763.94,2694.06 cw(c7778.27,2679.73) 7778.27,2700 ; v2@7763.94,2707.94 ccw(c7783.1,2727.1) 7783.1,2700 ; v2@8037.97,2873.78 cw(c8014.28,2873.78) 8031.03,2857.03 cw(c8047.78,2840.28) v2@8047.78,2863.97 ; v2@8041.97,2873.78 cw(c8027.94,2873.78) 8037.86,2863.86 cw(c8047.78,2853.94) v2@8047.78,2867.97
NetR269_2: R269.2 R281.2 U30.H3 | length 10701.1
  Top Layer w4: v2(5596,1711) 5614.04,1729.04 5728.42,1729.04 5755,1755.62 5755,1895.96 5774.12,1915.07 v2(5774.12,1973.82) v2@5770.19,1969.89 ; v2@5596,1716.81 ccw(c5596,1730.84) 5605.92,1720.92 ccw(c5615.84,1711) v2@5601.81,1711 ; v2@5596,1720.81 ccw(c5596,1744.5) 5612.75,1727.75 ccw(c5629.5,1711) v2@5605.81,1711 ; v2@5767.18,1966.89 cw(c5750.43,1950.14) 5774.12,1950.14 cw(c5797.8,1950.14) v2@5781.06,1966.89 ; v2@5770.01,1969.71 cw(c5760.09,1959.79) 5774.12,1959.79 cw(c5788.15,1959.79) v2@5778.23,1969.71 ; v3(6773.78,1904.37) U30.H3@6793.46,1884.68 ; U30.H3@6786.12,1884.68 ccw(c6768.4,1884.68) 6780.93,1897.22 ccw(c6793.46,1909.75) U30.H3@6793.46,1892.03 ; R269.2@7941.58,5838.92 cw(c7925.68,5823.01) 7948.17,5823.01 cw(c7970.67,5823.01) R269.2@7954.76,5838.92 ; R269.2@7941.58,5853.08 ccw(c7925.68,5868.99) 7948.17,5868.99 ccw(c7970.67,5868.99) R269.2@7954.76,5853.08 ; R281.2@7941.58,5889.25 cw(c7925.68,5873.34) 7948.17,5873.34 cw(c7970.67,5873.34) R281.2@7954.76,5889.25 ; R269.2@7944.41,5841.75 cw(c7935.33,5832.67) 7948.17,5832.67 cw(c7961.01,5832.67) R269.2@7951.93,5841.75 ; R269.2@7944.41,5850.25 ccw(c7935.33,5859.33) 7948.17,5859.33 ccw(c7961.01,5859.33) R269.2@7951.93,5850.25 ; R281.2@7944.41,5892.08 cw(c7935.33,5883) 7948.17,5883 cw(c7961.01,5883) R281.2@7951.93,5892.08 ; R281.2@7948.17,5896.33 R269.2@7948.17,5846 7948.17,5795 7967,5776.17 7967,5361.67 8252,5076.67 8252,4598.19 8307.81,4542.38 8307.81,4507.81 8240.02,4440.02 8240.02,4092.8 8215,4067.77 8215,3657.5 8277.5,3595 8277.5,3082.5 v2(8280,3080) ; v2@8273.06,3086.94 ccw(c8262.35,3097.65) 8277.5,3097.65 ; 8277.5,3100.06 ccw(c8300.06,3100.06) v2@8284.11,3084.11 ; 8277.5,3109.72 ccw(c8309.72,3109.72) v2@8286.94,3086.94 ; 6786.58,1891.57 cw(c6799.39,1904.37) 6781.28,1904.37 ccw(c6799.39,1904.37) 6786.58,1891.57 ; 6786.58,1891.57 ccw(c6773.78,1878.76) 6773.78,1896.87 cw(c6773.78,1878.76) 6786.58,1891.57
  MidLayer1 w4: v2@5596,1701.19 cw(c5596,1677.5) 5612.75,1694.25 ; v2@5596,1705.19 cw(c5596,1691.16) 5605.92,1701.08 cw(c5615.84,1711) v2@5601.81,1711 ; v2(5596,1711) 5620.79,1686.21 5634.38,1686.21 5921.04,1399.55 5953.27,1399.55 v2(6037.81,1315) ; v2@5605.81,1711 ccw(c5629.5,1711) 5612.75,1694.25 ; v2@6028,1315 ccw(c6004.31,1315) 6021.06,1331.75 ccw(c6037.81,1348.5) v2@6037.81,1324.81 ; v2@6032,1315 ccw(c6017.97,1315) 6027.89,1324.92 ccw(c6037.81,1334.84) v2@6037.81,1320.81 ; v2(6443.3,2032.3) 6462.79,2012.81 6467.56,2012.81 6558.56,1921.81 6561,1921.81 ; v2@6444.07,2031.53 6460.7,2014.9 ; 6560.34,1921.81 6561,1921.81 ; v3@6766.39,1903.07 ccw(c6748.56,1899.92) 6758.95,1914.76 ; v3@6772.48,1911.76 cw(c6769.33,1929.59) 6758.95,1914.76 ; v2@7440.21,1162.08 ccw(c7424.95,1178) 7447,1178 ccw(c7469.05,1178) v2@7453.79,1162.08 ; v2@7442.98,1159.19 ccw(c7433.94,1168.62) 7447,1168.62 ccw(c7460.06,1168.62) v2@7451.02,1159.19 ; v2(7447,1155) 7447,1178 7482,1213 7482,1434 7464,1452 7464,1472 7476,1484 7498,1484 7536,1522 7536,1537.43 7585.86,1587.29 7591.36,1587.29 7736.62,1732.55 7736.62,1735.81 7754.62,1753.81 7755.81,1753.81 7830.5,1828.5 7830.5,1951.13 7825.81,1955.82 7825.81,1970.31 7842.19,1986.69 7842.19,1997.38 7852.62,2007.81 7865.81,2007.81 v2(7911,2053) ; v2@7901.19,2053 cw(c7877.5,2053) 7894.25,2036.25 cw(c7911,2019.5) v2@7911,2043.19 ; v2@7905.19,2053 cw(c7891.16,2053) 7901.08,2043.08 cw(c7911,2033.16) v2@7911,2047.19 ; v2@8024.06,2371.94 ccw(c8007.31,2388.69) 8031,2388.69 ccw(c8054.69,2388.69) v2@8037.94,2371.94 ; v2@8026.89,2369.11 ccw(c8016.97,2379.03) 8031,2379.03 ccw(c8045.03,2379.03) v2@8035.11,2369.11 ; 8029.97,2868.81 8029.97,3020.97 v2(8118.21,3109.21) ; 8030,2868.81 8031,2867.81 v2(8031,2365) ; v2@8108.4,3109.21 cw(c8084.71,3109.21) 8101.46,3092.46 cw(c8118.21,3075.71) v2@8118.21,3099.4 ; v2@8112.4,3109.21 cw(c8098.37,3109.21) 8108.29,3099.29 cw(c8118.21,3089.37) v2@8118.21,3103.4 ; 6453.22,2022.38 cw(c6463.14,2032.3) 6449.11,2032.3 ccw(c6463.14,2032.3) 6453.22,2022.38 ; 6453.22,2022.38 ccw(c6443.3,2012.46) 6443.3,2026.49 cw(c6443.3,2012.46) 6453.22,2022.38 ; 6460.05,2015.55 cw(c6476.8,2032.3) 6453.11,2032.3 ccw(c6476.8,2032.3) 6460.05,2015.55 ; 6460.05,2015.55 ccw(c6443.3,1998.8) 6443.3,2022.49 cw(c6443.3,1998.8) 6460.05,2015.55 ; 6561,1921.81 6611.38,1921.81 6613.31,1919.88 6741.1,1919.88 cw(c6741.27,1886.75) 6758.92,1914.79
  MidLayer2 w4: v2@5770.19,1974 5773.65,1970.54 5805.77,1970.54 5812.23,1977 6169.63,1977 6196.63,2004 6249.86,2004 6268.05,2022.19 6337.38,2022.19 6347.49,2032.3 v2(6443.3,2032.3) ; v2@6037.81,1305.19 cw(c6037.81,1281.5) 6054.56,1298.25 cw(c6071.31,1315) v2@6047.62,1315 ; v2@6037.81,1309.19 cw(c6037.81,1295.16) 6047.73,1305.08 cw(c6057.65,1315) v2@6043.62,1315 ; v2(6037.81,1315) 6262,1090.81 6262,1048.25 6335.25,975 6483.69,975 6550.65,908.04 6961.54,908.04 7044.87,991.37 7188.5,1135 7427,1135 v2(7447,1155) ; v2@6436.36,2025.36 ccw(c6419.62,2008.62) 6419.62,2032.3 ccw(c6419.62,2055.99) v2@6436.36,2039.24 ; v2@6439.19,2028.19 ccw(c6429.27,2018.27) 6429.27,2032.3 ccw(c6429.27,2046.33) v2@6439.19,2036.41 ; v2@7437.19,1155 cw(c7413.5,1155) 7430.25,1138.25 cw(c7447,1121.5) v2@7447,1145.19 ; v2@7441.19,1155 cw(c7427.16,1155) 7437.08,1145.08 cw(c7447,1135.16) v2@7447,1149.19
  Bottom Layer w4: v2@7912,2046 7911,2047 v2(7911,2053) 7957.11,2053 8007.19,2103.08 8007.19,2268 8043.81,2304.62 8043.81,2319.38 8031,2332.19 v2(8031,2365) ; v2@7915.11,2048.89 cw(c7925.03,2038.97) 7925.03,2053 cw(c7925.03,2067.03) v2@7915.11,2057.11 ; v2@7917.94,2046.06 cw(c7934.69,2029.31) 7934.69,2053 cw(c7934.69,2076.69) v2@7917.94,2059.94 ; v2@8024.06,2358.06 cw(c8007.31,2341.31) 8031,2341.31 cw(c8054.69,2341.31) v2@8037.94,2358.06 ; v2@8026.89,2360.89 cw(c8016.97,2350.97) 8031,2350.97 cw(c8045.03,2350.97) v2@8035.11,2360.89 ; v2(8118.21,3109.21) 8119,3110 8250,3110 v2(8280,3080) ; v2@8122.32,3105.1 cw(c8134.15,3093.27) 8134.15,3110 ; v2@8122.32,3113.32 ccw(c8130.32,3121.32) 8130.32,3110 ; v2@8125.15,3102.27 cw(c8143.81,3083.61) 8143.81,3110 ; v2@8125.15,3116.15 ccw(c8139.98,3130.98) 8139.98,3110 ; v2@8270.19,3080 ccw(c8246.5,3080) 8263.25,3096.75 ccw(c8280,3113.5) v2@8280,3089.81 ; v2@8274.19,3080 ccw(c8260.16,3080) 8270.08,3089.92 ccw(c8280,3099.84) v2@8280,3085.81
NetR270_2: R270.2 R282.2 U30.J5 | length 8287.7
  Top Layer w4: v2(6090,2328) 6145.82,2328 6165.94,2307.88 6283.7,2307.88 6321.04,2270.55 6477.77,2270.55 6539.36,2332.13 6539.36,2405.55 6598,2464.19 v2(6598,2474) ; v2@6094.11,2323.89 cw(c6104.03,2313.97) 6104.03,2328 cw(c6104.03,2342.03) v2@6094.11,2332.11 ; v2@6096.94,2321.06 cw(c6113.69,2304.31) 6113.69,2328 cw(c6113.69,2351.69) v2@6096.94,2334.94 ; 6574.31,2440.5 ccw(c6540.82,2474) v2@6588.19,2474 ; 6581.14,2447.33 ccw(c6554.47,2474) v2@6592.19,2474 ; 6587.97,2454.16 ccw(c6568.13,2474) v2@6596.19,2474 ; 6594.8,2460.99 ccw(c6581.79,2474) v2@6600.19,2474 ; v3(6852.52,1825.63) U30.J5@6872.2,1845.31 ; U30.J5@6864.86,1845.31 cw(c6847.14,1845.31) 6859.67,1832.78 cw(c6872.2,1820.25) U30.J5@6872.2,1837.97 ; R270.2@7709.59,5853.08 ccw(c7693.68,5868.99) 7716.18,5868.99 ccw(c7738.68,5868.99) R270.2@7722.77,5853.08 ; R282.2@7709.59,5889.25 cw(c7693.68,5873.34) 7716.18,5873.34 cw(c7738.68,5873.34) R282.2@7722.77,5889.25 ; R270.2@7712.42,5850.25 ccw(c7703.34,5859.33) 7716.18,5859.33 ccw(c7729.02,5859.33) R270.2@7719.94,5850.25 ; R282.2@7712.42,5892.08 cw(c7703.34,5883) 7716.18,5883 cw(c7729.02,5883) R282.2@7719.94,5892.08 ; R270.2@7716.18,5846 7716.18,5870 ; R282.2@7716.18,5896.33 7716.18,5870 ; v1@8250.5,3665 ccw(c8227.56,3665) 8243.78,3681.22 ccw(c8260,3697.43) v1@8260,3674.5 ; v1@8254.5,3665 ccw(c8241.22,3665) 8250.61,3674.39 ccw(c8260,3683.78) v1@8260,3670.5 ; v1(8260,3665) 8223,3702 8223,4064.46 8250,4091.46 8250,4438.69 8315.81,4504.5 8315.81,4545.69 8300.69,4560.81 8260,4601.5 8260,5079.99 7975,5364.99 7975,5901.12 7961.98,5914.14 7934.37,5914.14 7925,5904.77 7925,5883.91 7911.09,5870 7716.18,5870 ; 6865.32,1838.43 cw(c6852.52,1851.24) 6852.52,1833.13 ccw(c6852.52,1851.24) 6865.32,1838.43 ; 6865.32,1838.43 ccw(c6878.13,1825.63) 6860.02,1825.63 cw(c6878.13,1825.63) 6865.32,1838.43
  MidLayer1 w4: v2@6071.06,1800.94 ccw(c6054.31,1817.69) 6078,1817.69 ccw(c6101.69,1817.69) v2@6084.94,1800.94 ; v2@6073.89,1798.11 ccw(c6063.97,1808.03) 6078,1808.03 ccw(c6092.03,1808.03) v2@6082.11,1798.11 ; v2@6077.06,2149.06 cw(c6060.31,2132.31) 6084,2132.31 cw(c6107.69,2132.31) v2@6090.94,2149.06 ; v2@6079.89,2151.89 cw(c6069.97,2141.97) 6084,2141.97 cw(c6098.03,2141.97) v2@6088.11,2151.89 ; v2(6084,2156) 6084,2100.2 6074.02,2090.22 6056.6,2072.8 6050,2066.2 6023.02,2039.23 6023.02,1896.96 6055.77,1864.21 6066.02,1853.96 6078,1841.98 v2@6078,1794.31 ; v2@6078,1794.31 v2(6078,1794) v2@6078,1794.31
  MidLayer2 w4: v2(6078,1794) 6162.24,1794 6168.11,1799.87 6175.24,1807 6291.8,1807 6324.8,1840 6436.18,1840 6466,1810.19 6494,1810.19 6504,1820.19 6564,1820.19 6571.63,1827.81 6596.19,1827.81 ; v2@6082.11,1789.89 cw(c6092.03,1779.97) 6092.03,1794 cw(c6092.03,1808.03) v2@6082.11,1798.11 ; v2@6084.94,1787.06 cw(c6101.69,1770.31) 6101.69,1794 cw(c6101.69,1817.69) v2@6084.94,1800.94 ; 6838.94,1814.24 cw(c6829.01,1824.17) 6829.01,1810.12 6735.47,1810.12 6645.07,1810.12 6633,1822.19 6617.31,1822.19 6601.81,1822.19 ; v3@6845.05,1826.28 cw(c6827.01,1827.86) 6838.65,1813.99 cw(c6850.29,1800.12) v3@6851.87,1818.16 ; v2(7168,2586) 7171.5,2582.5 7204.5,2582.5 7248,2626 7248,2684.15 7410.67,2846.81 7417.02,2846.81 7565,2994.79 7565,3355.2 7567.68,3357.88 7686.8,3477 7868.26,3477 7879.05,3466.21 8055,3466.21 8074.89,3466.21 8119.89,3466.21 8260,3606.31 v1(8260,3665) ; v1@8253.28,3658.28 cw(c8237.06,3642.06) 8260,3642.06 cw(c8282.94,3642.06) v1@8266.72,3658.28 ; v1@8256.11,3661.11 cw(c8246.72,3651.72) 8260,3651.72 cw(c8273.28,3651.72) v1@8263.89,3661.11 ; 6596.19,1827.81 6601.81,1822.19 ; 6596.19,1827.81 6601.81,1822.19
  Bottom Layer w4: v2@6077.06,2162.94 ccw(c6060.31,2179.69) 6084,2179.69 ccw(c6107.69,2179.69) v2@6090.94,2162.94 ; v2@6079.89,2160.11 ccw(c6069.97,2170.03) 6084,2170.03 ccw(c6098.03,2170.03) v2@6088.11,2160.11 ; v2@6083.06,2321.06 cw(c6066.31,2304.31) 6090,2304.31 cw(c6113.69,2304.31) v2@6096.94,2321.06 ; v2(6084,2156) 6084,2229 6090,2235 v2(6090,2328) ; v2@6085.89,2323.89 cw(c6075.97,2313.97) 6090,2313.97 cw(c6104.03,2313.97) v2@6094.11,2323.89 ; v2@6591.06,2480.94 ccw(c6574.31,2497.69) 6598,2497.69 ccw(c6621.69,2497.69) v2@6604.94,2480.94 ; v2@6593.89,2478.11 ccw(c6583.97,2488.03) 6598,2488.03 ccw(c6612.03,2488.03) v2@6602.11,2478.11 ; v2(6598,2474) 6598,2515.58 6622.97,2540.54 6716.61,2540.54 6740,2540.54 6783.35,2540.54 6788.62,2545.81 6862.62,2545.81 6881.62,2564.81 6903.82,2564.81 6905.51,2566.5 6952.81,2566.5 6967.57,2566.5 6985.69,2584.62 6995.94,2594.87 7010.44,2594.87 7018.44,2586.87 7061.06,2586.87 7091.44,2556.5 7105,2556.5 7112.56,2556.5 7138.5,2556.5 7166,2584 v2(7168,2586) ; v2@7158.19,2586 cw(c7134.5,2586) 7151.25,2569.25 cw(c7168,2552.5) v2@7168,2576.19 ; v2@7162.19,2586 cw(c7148.16,2586) 7158.08,2576.08 cw(c7168,2566.16) v2@7168,2580.19
NetR272_1: R272.1 U61.120 | length 150.4
  Top Layer w4: R272.1@5445,2461.33 5461.62,2444.71 5487.11,2444.71 5491.86,2449.46 U61.120@5516.83,2449.46 ; R272.1@5445.49,2452.01 cw(c5445.49,2430.7) 5460.56,2445.77 ; R272.1@5445.49,2456.01 cw(c5445.49,2444.36) R272.1@5453.73,2452.6 ; R272.1@5450.81,2461.24 ccw(c5464.1,2461.02) R272.1@5454.7,2451.63 ; R272.1@5454.81,2461.18 ccw(c5477.23,2460.81) 5461.37,2444.95 ; U61.120@5500.81,2446.63 ccw(c5493.98,2439.8) 5493.98,2449.46 ccw(c5493.98,2459.11) U61.120@5500.81,2452.28
NetR273_1: R273.1 U61.119 | length 550.1
  Top Layer w4: v1(5393,2597) 5441.82,2597 R273.1@5445,2593.82 ; v1@5396.89,2593.11 cw(c5406.28,2583.72) 5406.28,2597 cw(c5406.28,2610.28) v1@5396.89,2600.89 ; v1@5399.72,2590.28 cw(c5415.93,2574.06) 5415.93,2597 cw(c5415.93,2619.93) v1@5399.72,2603.72 ; 5414.33,2597 cw(c5414.33,2563.64) R273.1@5437.92,2587.23 ; 5423.99,2597 cw(c5423.99,2573.3) R273.1@5440.75,2590.06 ; 5429.69,2597 ccw(c5429.69,2608.64) R273.1@5437.92,2600.41 ; v1(5480.19,2466.71) 5482.62,2469.14 U61.119@5516.83,2469.14 ; v1@5484.08,2462.82 cw(c5499.34,2447.56) U61.119@5499.34,2469.14 ; v1@5486.91,2459.99 cw(c5509,2437.9) U61.119@5509,2469.14 ; v1@5486.91,2473.43 ccw(c5497.25,2483.77) 5497.25,2469.14 ; U61.119@5500.81,2466.31 ccw(c5493.98,2459.48) 5493.98,2469.14 ccw(c5493.98,2478.8) U61.119@5500.81,2471.97
  Bottom Layer w4: v1@5386.28,2590.28 cw(c5370.06,2574.06) 5393,2574.06 cw(c5415.93,2574.06) v1@5399.72,2590.28 ; v1@5389.11,2593.11 cw(c5379.72,2583.72) 5393,2583.72 cw(c5406.28,2583.72) v1@5396.89,2593.11 ; v1(5393,2597) 5393,2553.9 v1(5480.19,2466.71) ; v1@5470.69,2466.71 ccw(c5447.76,2466.71) 5463.97,2482.93 ccw(c5480.19,2499.14) v1@5480.19,2476.21 ; v1@5474.69,2466.71 ccw(c5461.41,2466.71) 5470.8,2476.1 ccw(c5480.19,2485.49) v1@5480.19,2472.21
NetR274_1: R274.1 U62.5 | length 185.5
  Bottom Layer w4: R274.1@5225,956.18 5248.52,956.18 5269.71,935 ; R274.1@5229.25,952.42 cw(c5238.33,943.34) 5238.33,956.18 cw(c5238.33,969.02) R274.1@5229.25,959.94 ; R274.1@5232.08,949.59 cw(c5247.99,933.68) 5247.99,956.18 cw(c5247.99,978.68) R274.1@5232.08,962.77 ; U62.5@5282.08,928.42 ccw(c5269.71,920.07) 5269.71,935 ; U62.5@5282.08,941.58 cw(c5269.71,949.92) 5269.71,935 ; U62.5@5285.4,930.65 ccw(c5277.23,925.14) 5277.23,935 ccw(c5277.23,944.86) U62.5@5285.4,939.35 ; U62.5@5297.76,935 5269.71,935
NetR275_1: R275.1 U63.5 | length 184.2
  Bottom Layer w4: R275.1@5475,913.82 5498.82,913.82 5520,935 ; R275.1@5479.25,910.06 cw(c5488.33,900.98) 5488.33,913.82 cw(c5488.33,926.66) R275.1@5479.25,917.58 ; R275.1@5482.08,907.23 cw(c5497.99,891.32) 5497.99,913.82 cw(c5497.99,936.32) R275.1@5482.08,920.41 ; U63.5@5532.01,928.53 ccw(c5520,920.63) 5520,935 ; U63.5@5532.01,941.47 cw(c5520,949.37) 5520,935 ; U63.5@5535.35,930.72 ccw(c5527.42,925.51) 5527.42,935 ccw(c5527.42,944.49) U63.5@5535.35,939.28 ; U63.5@5547.76,935 5520,935
NetR276_1: R276.1 U64.5 | length 185.5
  Bottom Layer w4: R276.1@5725,956.18 5748.52,956.18 5769.71,935 ; R276.1@5729.25,952.42 cw(c5738.33,943.34) 5738.33,956.18 cw(c5738.33,969.02) R276.1@5729.25,959.94 ; R276.1@5732.08,949.59 cw(c5747.99,933.68) 5747.99,956.18 cw(c5747.99,978.68) R276.1@5732.08,962.77 ; U64.5@5782.08,928.42 ccw(c5769.71,920.07) 5769.71,935 ; U64.5@5782.08,941.58 cw(c5769.71,949.92) 5769.71,935 ; U64.5@5785.4,930.65 ccw(c5777.23,925.14) 5777.23,935 ccw(c5777.23,944.86) U64.5@5785.4,939.35 ; U64.5@5797.76,935 5769.71,935
NetR314_2: R314.2 U70.2 | length 295.4
  Bottom Layer w4: R314.2@8020,4055 R314.2@8020.24,4055 8060,4055 8068.19,4046.81 8068.19,3980 ; 8068.19,3981.81 8068.19,3980 ; U70.2@8108.19,3835 8085,3835 8068.19,3851.81 8068.19,3980
NetTP11_1: TP11.1 U27.2 Y3.1 | length 881.1
  Top Layer w4: 3544.51,4139.85 ccw(c3572.77,4168.12) TP11.1@3575,4128.2 ; 3544.51,4139.85 cw(c3516.24,4111.58) TP11.1@3556.15,4109.35 ; TP11.1@3548.16,4109.8 ccw(c3492.29,4112.92) 3531.86,4152.5 ; TP11.1@3552.16,4109.57 ccw(c3504.26,4112.25) 3538.18,4146.17 ccw(c3572.1,4180.09) TP11.1@3574.78,4132.2 ; TP11.1@3560.15,4109.13 ccw(c3528.22,4110.91) 3550.83,4133.53 ccw(c3573.44,4156.14) TP11.1@3575.23,4124.21 ; U27.2@3562.76,4357.72 ccw(c3554.42,4349.38) 3554.42,4361.18 ccw(c3554.42,4372.99) U27.2@3562.76,4364.64 ; TP11.1@3574.56,4136.19 cw(c3571.43,4192.07) 3531.86,4152.5 ; TP11.1@3576.12,4108.23 3531.86,4152.5 ; Y3.1@3605.78,4462.24 cw(c3589.03,4445.49) 3612.72,4445.49 cw(c3636.4,4445.49) Y3.1@3619.65,4462.24 ; Y3.1@3608.61,4465.06 cw(c3598.69,4455.14) 3612.72,4455.14 cw(c3626.75,4455.14) Y3.1@3616.83,4465.06 ; Y3.1@3612.72,4480.98 3612.72,4442.28 3632.26,4422.74 3632.26,4377.26 3616.18,4361.18 U27.2@3592.8,4361.18 3541.86,4361.18 3531.86,4351.18 3531.86,4152.5 ; U27.2@3620.26,4361.18 cw(c3630.11,4361.18) 3623.14,4368.14 ; U27.2@3624.26,4361.18 cw(c3643.76,4361.18) 3629.97,4374.97
NetU3_9: U3.9 U3.10 | length 187.9
  Bottom Layer w4: U3.9@4076.5,1072.05 4109.02,1072.05 4109.02,1097.64 U3.10@4076.5,1097.64 ; U3.9@4100.15,1074.88 ccw(c4078.72,1096.31) 4109.02,1096.31 ; U3.10@4100.15,1094.81 cw(c4078.72,1073.38) 4109.02,1073.38 ; U3.9@4102.98,1072.05 ccw(c4088.38,1086.65) 4109.02,1086.65 ; U3.10@4102.98,1097.64 cw(c4088.38,1083.04) 4109.02,1083.04 ; U3.9@4105.8,1069.22 ccw(c4098.03,1076.99) 4109.02,1076.99 ; U3.10@4105.8,1100.47 cw(c4098.03,1092.69) 4109.02,1092.69
NetU27_1: U27.1 Y3.4 | length 216
  Top Layer w4: Y3.4@3577.28,4459.36 cw(c3577.28,4442.36) 3589.3,4454.38 ; Y3.4@3577.28,4480.98 3577.28,4466.4 3620,4423.69 3620,4395 ; Y3.4@3583.09,4469.17 ccw(c3603.81,4469.17) 3589.16,4454.52 ; Y3.4@3587.09,4469.17 ccw(c3617.47,4469.17) 3595.99,4447.7 ; U27.1@3592.8,4386.77 3611.77,4386.77 3620,4395 ; U27.1@3615.91,4390.23 ccw(c3606.04,4400.1) 3620,4400.1 ; U27.1@3617.52,4391.3 ccw(c3616,4395) 3620,4395 ; 3620,4397.06 ccw(c3629.65,4397.06) U27.1@3622.83,4390.23 ; U27.1@3622.19,4390.76 cw(c3625.19,4395) 3620,4395
NetU37_4: U37.4 U72.2 | length 583
  Bottom Layer w4: U37.4@3725.12,6057.4 3852.4,6057.4 4005,6210 4065,6210 4080.84,6194.16 U72.2@4080.84,6155.12 ; U37.4@3743.01,6053.29 cw(c3752.93,6043.37) 3752.93,6057.4 cw(c3752.93,6071.43) U37.4@3743.01,6061.51 ; U37.4@3745.84,6050.46 cw(c3762.58,6033.72) 3762.58,6057.4 cw(c3762.58,6081.09) U37.4@3745.84,6064.34 ; U72.2@4073.91,6175.84 ccw(c4057.16,6192.58) 4080.84,6192.58 ccw(c4104.53,6192.58) U72.2@4087.78,6175.84 ; U72.2@4076.73,6173.01 ccw(c4066.81,6182.93) 4080.84,6182.93 ccw(c4094.87,6182.93) U72.2@4084.95,6173.01
NetU38_4: U38.4 U71.2 | length 704.5
  Bottom Layer w4: 4282.97,6085.15 ccw(c4323.24,6125.42) U38.4@4323.24,6068.47 ; 4289.8,6078.32 ccw(c4323.24,6111.77) U38.4@4323.24,6064.47 ; 4296.63,6071.5 ccw(c4323.24,6098.11) U38.4@4323.24,6060.47 ; 4303.46,6064.67 ccw(c4323.24,6084.45) U38.4@4323.24,6056.47 ; 4310.29,6057.84 ccw(c4323.24,6070.8) U38.4@4323.24,6052.47 ; U38.4@4323.24,6044.88 4273.13,6095 4225,6095 4220,6100 4220,6200 4235,6215 4480,6215 4490.84,6204.16 U71.2@4490.84,6155.12