# Altium PCB NB3000AL.PcbDoc (part 49 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Bottom Layer w12: J33.B38@-785.98,2731.6 -678.25,2731.6 v1(-659.81,2750.04) -658.04,2751.81 v1(-470,2751.81) ; J33.B38@-711.58,2726.1 cw(c-698.3,2712.82) -698.3,2731.6 cw(c-698.3,2750.38) J33.B38@-711.58,2737.1 ; v1(-668.14,2708.37) -667.96,2708.19 v1(-470,2708.19) ; v1@-665.31,2750.04 cw(c-678.59,2750.04) -669.2,2740.65 cw(c-659.81,2731.26) v1@-659.81,2744.54 ; v1@-664.25,2704.49 cw(c-655.31,2695.55) -655.31,2708.19 ; v1@-664.25,2712.26 ccw(c-654.42,2722.1) -654.42,2708.19 ; v1@-655.92,2746.15 cw(c-642.26,2732.49) -642.26,2751.81 ; v1@-473.89,2704.3 ccw(c-483.28,2694.91) -483.28,2708.19 ccw(c-483.28,2721.47) v1@-473.89,2712.08 ; v1@-473.89,2747.92 ccw(c-483.28,2738.53) -483.28,2751.81 ccw(c-483.28,2765.09) v1@-473.89,2755.7 ; C21.2@-299.33,2745 -263.81,2745 -259.81,2749 -258.81,2750.04 v1(-248.48,2750.04) ; C21.2@-295.22,2740.89 cw(c-285.3,2730.97) -285.3,2745 ; C21.2@-295.22,2749.11 ccw(c-285.3,2759.03) -285.3,2745 ; C20.2@-280.63,2665 -239.81,2665 ; C13.2@-279.33,3906.82 C7.2@-220.67,3906.82 -220.67,3924.33 -212.63,3932.37 ; C13.2@-275.22,3902.71 cw(c-265.3,3892.79) -265.3,3906.82 ; C13.2@-275.22,3910.93 ccw(c-265.3,3920.85) -265.3,3906.82 ; -273.92,2745 ccw(c-273.92,2775.49) v1@-252.36,2753.93 ; C20.2@-270.95,2655.32 cw(c-247.59,2631.96) -247.59,2665 cw(c-247.59,2698.04) C20.2@-270.95,2674.68 ; v1@-238.36,2684.49 cw(c-247.75,2675.1) -234.48,2675.1 cw(c-221.2,2675.1) v1@-230.59,2684.49 ; v1(-234.48,2688.37) -234.48,2670.33 -239.81,2665 ; C7.2@-226.03,3903.73 cw(c-213.41,3910.99) -223.71,3921.29 ; v1(-225,2600) -233,2608 -233,2616.59 ; C7.2@-224.78,3902.71 ccw(c-234.7,3892.79) -234.7,3906.82 ccw(c-234.7,3920.85) -224.78,3910.93 ccw(c-234.7,3920.85) -220.67,3920.85 ccw(c-206.64,3920.85) C7.2@-216.56,3910.93 ; v1@-223.88,2605.38 cw(c-221.55,2616.59) -233,2616.59 ; C7.2@-215.63,3909.71 cw(c-199.33,3919.08) -212.63,3932.37 ; NT1.2@-194.76,5662.8 -142.79,5662.79 -136.48,5656.48 v1(-136.48,5633.37) -134.81,5631.71 v1(-134.81,5550.04) ; NT1.2@-187.87,5655.9 cw(c-171.23,5639.26) -171.23,5662.79 cw(c-171.23,5686.33) NT1.2@-187.87,5669.69 ; C18.2@-179.33,4239.55 -130.65,4239.54 v1(-130.48,4239.37) ; C18.2@-175.22,4235.44 cw(c-165.3,4225.52) -165.3,4239.54 ; C18.2@-175.22,4243.65 ccw(c-165.3,4253.57) -165.3,4239.54 ; v1@-175.03,2024.15 cw(c-184.42,2014.76) -171.14,2014.76 cw(c-157.86,2014.76) v1@-167.25,2024.15 ; v1(-171.14,2028.04) -171.14,1986.14 -161.69,1976.69 U45.1@-135.93,1976.69 ; -144.16,4239.54 cw(c-144.16,4225.69) v1@-134.36,4235.49 ; -143.34,4239.54 ccw(c-143.34,4252.24) v1@-134.36,4243.26 ; v1@-140.36,5629.49 cw(c-153.78,5616.07) -134.81,5616.07 ; v1@-140.36,5637.26 ccw(c-149.75,5646.65) -136.48,5646.65 ccw(c-123.2,5646.65) v1@-132.59,5637.26 ; v1@-138.7,5553.93 ccw(c-148.09,5563.32) -134.81,5563.32 ccw(c-121.53,5563.32) v1@-130.92,5553.93 ; v1@-135.98,3915.37 ccw(c-149.25,3915.37) -139.86,3924.76 ccw(c-130.48,3934.15) v1@-130.48,3920.87 ; v1(-130.48,3915.37) -147.48,3932.37 -212.63,3932.37 ; R111.2@199.3,1046.74 cw(c191.56,1030) 210,1030 ; R111.2@210,1069.88 210,1030 ; R111.2@220.7,1046.74 ccw(c228.44,1030) 210,1030 ; v1@361.3,1007.82 ccw(c351.91,998.43) 351.91,1011.71 ccw(c351.91,1024.99) v1@361.3,1015.6 ; v1@369.08,1007.82 cw(c378.72,998.18) 378.72,1011.81 ; v1@369.08,1015.6 ccw(c378.22,1024.74) 378.22,1011.81 ; C87.2@439.24,1011.81 365.19,1011.81 v1(365.19,1011.71) 228.29,1011.71 210,1030 ; v2(639.92,5670.08) U59.15@704.59,5670.08 ; v2@644.03,5665.97 cw(c653.95,5656.05) 653.95,5670.08 cw(c653.95,5684.11) v2@644.03,5674.19 ; U59.15@677.44,5664.58 ccw(c664.16,5651.3) 664.16,5670.08 ccw(c664.16,5688.86) U59.15@677.44,5675.58 ; v1@872.29,1599.08 ccw(c862.9,1608.47) 876.18,1608.47 ccw(c889.46,1608.47) v1@880.07,1599.08 ; v1(876.18,1595.19) R206.2@876.18,1625 ; C151.2@1137.78,5420.08 1169.92,5420.08 1250,5340 v1(1330,5340) ; C151.2@1141.89,5415.97 cw(c1151.81,5406.05) 1151.81,5420.08 cw(c1151.81,5434.11) C151.2@1141.89,5424.19 ; v1@1326.11,5336.11 ccw(c1316.72,5326.72) 1316.72,5340 ccw(c1316.72,5353.28) v1@1326.11,5343.89 ; v1(1525,5365) 1630,5365 1635,5370 1635,5401.16 ; v1@1528.89,5361.11 cw(c1538.28,5351.72) 1538.28,5365 cw(c1538.28,5378.28) v1@1528.89,5368.89 ; U46.7@1695.94,5415.97 ccw(c1686.02,5406.05) 1686.02,5420.08 ccw(c1686.02,5434.11) U46.7@1695.94,5424.19 ; U46.6@1695.94,5465.97 ccw(c1686.02,5456.05) 1686.02,5470.08 ccw(c1686.02,5484.11) U46.6@1695.94,5474.19 ; U46.7@1731.54,5420.08 1653.92,5420.08 1635,5401.16 ; U46.6@1731.54,5470.08 1645.08,5470.08 1635,5460 1635,5401.16 ; C152.1@1819.33,5470 1845.19,5495.86 v1(1845.19,5556.71) ; C152.1@1819.33,5475.81 ccw(c1819.33,5489.84) 1829.25,5479.92 ccw(c1839.17,5470) C152.1@1825.14,5470 ; v1@1841.3,5552.82 cw(c1831.91,5543.43) 1845.19,5543.43 cw(c1858.47,5543.43) v1@1849.08,5552.82 ; v1@1957.29,1598.89 ccw(c1947.9,1608.28) 1961.18,1608.28 ccw(c1974.46,1608.28) v1@1965.07,1598.89 ; v1(1961.18,1595) R204.2@1961.18,1625 ; v1(2035,5555) 2053.82,5555 R52.2@2063.82,5545 ; v1@2038.89,5551.11 cw(c2048.28,5541.72) 2048.28,5555 cw(c2048.28,5568.28) v1@2038.89,5558.89 ; 2052.94,5531.08 ccw(c2039.51,5544.51) R52.2@2058.5,5544.51 ; C50.1@2055.22,5404.11 ccw(c2045.3,5414.03) 2059.33,5414.03 ccw(c2073.36,5414.03) C50.1@2063.44,5404.11 ; C50.1@2059.33,5400 2059.33,5440.37 2052,5447.71 2048.52,5447.71 2040.19,5456.04 2040.19,5518.33 2063.82,5541.96 R52.2@2063.82,5545 ; R52.2@2060.06,5549.25 ccw(c2050.98,5558.33) 2063.82,5558.33 ccw(c2076.66,5558.33) R52.2@2067.58,5549.25 ; R51.2@2060.06,5594.08 cw(c2050.98,5585) 2063.82,5585 ; R51.2@2060.06,5602.59 ccw(c2050.98,5611.67) 2063.82,5611.67 ccw(c2076.66,5611.67) R51.2@2067.58,5602.59 ; R47.2@2060.06,5647.41 cw(c2050.98,5638.33) 2063.82,5638.33 cw(c2076.66,5638.33) R47.2@2067.58,5647.41 ; R46.2@2060.06,5709.25 ccw(c2050.98,5718.33) 2063.82,5718.33 ccw(c2076.66,5718.33) R46.2@2067.58,5709.25 ; 2063.82,5585 cw(c2076.66,5585) R51.2@2067.58,5594.08 ; R47.2@2063.82,5651.67 R51.2@2063.82,5598.33 R52.2@2063.82,5545 ; R46.2@2063.82,5703.47 cw(c2111.53,5703.47) v1@2078.35,5737.76 ; R46.2@2063.82,5705 2063.82,5731.04 2066.15,5733.37 ; 2063.82,5731.79 cw(c2084.13,5731.79) v1@2070,5746.38 ; v1(2074.52,5741.71) 2066.15,5733.37 ; v1(2074.52,5741.71) 2066.19,5733.37 ; v1@2094.64,5179.08 ccw(c2085.25,5188.47) 2098.52,5188.47 ccw(c2111.8,5188.47) v1@2102.41,5179.08 ; v1(2098.52,5175.19) 2098.52,5266.37 2115.19,5283.04 2263.62,5283.04 2272.28,5291.71 U5.11@2272.28,5322.68 2272.28,5437.72 2252.85,5457.15 ; C43.2@2100.22,6040.89 cw(c2090.3,6030.97) 2104.33,6030.97 cw(c2118.36,6030.97) C43.2@2108.44,6040.89 ; 2104.33,6018.42 ccw(c2126.23,6018.42) v1@2110.75,6002.93 ; C43.2@2104.33,6045 2104.33,6001.57 v1(2106.86,5999.04) ; R45.2@2170,5157.69 ccw(c2194.17,5157.69) v1@2177.08,5140.6 ; R45.2@2170,5163.82 2170,5139.71 2170.19,5139.71 v1(2173.19,5136.71) ; U5.17@2193.54,5460.47 2249.53,5460.47 2252.85,5457.15 ; v1@2226.11,5778.89 ccw(c2216.72,5788.28) 2230,5788.28 ccw(c2243.28,5788.28) v1@2233.89,5778.89 ; v1(2230,5775) 2230,5795 2245,5810 2315,5810 2321.18,5803.82 R56.1@2321.18,5780 2342.5,5758.68 2342.5,5712.35 2331.34,5701.19 U5.29@2331.34,5657.32 ; v1@2231.97,5140.26 ccw(c2222.23,5150) 2236,5150 ; v1@2235.71,5136.52 2235.86,5136.52 v1@2236,5136.52 ; 2236,5149.31 ccw(c2248.79,5149.31) v1@2239.75,5140.26 ; R44.2@2236,5163.82 v1@2236,5136.52 ; v1@2236.67,5135.56 v1(2235.86,5136.37) v1@2236,5136.52 ; 2255,5455 2252.85,5457.15 ; 2267.34,5286.76 ccw(c2255.38,5298.72) U5.11@2272.28,5299.15 ; R43.2@2302,5163.82 R42.2@2368,5163.82 v1(2368,5135) ; R43.2@2306.25,5160.06 cw(c2315.33,5150.98) 2315.33,5163.82 cw(c2315.33,5176.66) R43.2@2306.25,5167.58 ; R56.1@2317.42,5784.25 ccw(c2308.34,5793.33) 2321.18,5793.33 ccw(c2334.02,5793.33) R56.1@2324.94,5784.25 ; R56.1@2321.18,5774.19 cw(c2321.18,5760.16) R56.1@2331.1,5770.08 ; R56.1@2326.5,5779.51 ccw(c2338.15,5779.51) R56.1@2329.91,5771.27 ; R42.2@2363.75,5160.06 ccw(c2354.67,5150.98) 2354.67,5163.82 ccw(c2354.67,5176.66) R42.2@2363.75,5167.58 ; v1@2364.11,5138.89 ccw(c2354.72,5148.28) 2368,5148.28 ccw(c2381.28,5148.28) v1@2371.89,5138.89 ; C44.2@2430.8,5733.82 ccw(c2440.39,5726.3) 2431.77,5717.68 ; v1@2431.3,5140.6 ccw(c2422.37,5149.53) 2435,5149.53 ; C44.2@2431.56,5734.11 ccw(c2421.64,5744.03) 2435.67,5744.03 ccw(c2449.7,5744.03) C44.2@2439.78,5734.11 ; C47.1@2431.56,5775.89 cw(c2421.64,5765.97) 2435.67,5765.97 cw(c2449.7,5765.97) 2439.78,5775.89 cw(c2449.7,5765.97) 2449.7,5780 ; R41.2@2434,5152.86 ccw(c2451.34,5152.86) 2439.08,5140.6 cw(c2448.93,5150.44) 2435,5150.44 ; C47.1@2439.78,5784.11 ccw(c2449.7,5794.03) 2449.7,5780 ; C44.2@2440.24,5726.41 ccw(c2451.11,5717.88) 2441.34,5708.11 ; 2445,5485 2445,5455 ; U5.35@2449.45,5657.32 2449.45,5700 2435.67,5713.78 C44.2@2435.67,5730 C47.1@2435.67,5775.04 ; v2@2464.19,5566.71 cw(c2450.16,5566.71) 2460.08,5556.79 cw(c2470,5546.87) v2@2470,5560.9 ; v2@2475.21,5564.14 ccw(c2489.68,5557.02) 2478.28,5545.62 ; v1@2484.23,5780 C47.1@2440.63,5780 ; v1@2486.11,5776.11 ccw(c2476.72,5766.72) 2476.72,5780 ccw(c2476.72,5793.28) v1@2486.11,5783.89 ; U5.45@2528.19,5440.79 2485.79,5440.79 2475,5430 2455,5430 2445,5440 2445,5455 ; U5.43@2528.19,5480.16 2489.84,5480.16 2470,5500 2445,5500 ; U5.40@2528.19,5539.21 2484.68,5539.21 2470,5553.9 v2(2470,5566.71) 2445,5541.71 2445,5500 ; v2(2565,5620) 2596.5,5620 2605,5611.5 Y2.4@2612.5,5611.5 ; v2@2569.11,5615.89 cw(c2579.03,5605.97) 2579.03,5620 cw(c2579.03,5634.03) v2@2569.11,5624.11 ; v2(2580,5680) C45.1@2614.33,5680 C45.1@2612.5,5680 ; v2@2584.11,5675.89 cw(c2594.03,5665.97) 2594.03,5680 cw(c2594.03,5694.03) v2@2584.11,5684.11 ; C45.1@2610.22,5675.89 ccw(c2600.3,5665.97) 2600.3,5680 ccw(c2600.3,5694.03) C45.1@2610.22,5684.11 ; C48.1@2615.67,6045 v1(2655,6045) ; C48.1@2619.78,6040.89 cw(c2629.7,6030.97) 2629.7,6045 cw(c2629.7,6059.03) C48.1@2619.78,6049.11 ; v1@2651.11,6041.11 ccw(c2641.72,6031.72) 2641.72,6045 ccw(c2641.72,6058.28) v1@2651.11,6048.89 ; C51.1@2655.67,5265 2760,5265 2765,5270 v1(2765,5290) 2765,5310 2695,5380 C46.1@2655.67,5380 ; C51.1@2659.78,5260.89 cw(c2669.7,5250.97) 2669.7,5265 cw(c2669.7,5279.03) C51.1@2659.78,5269.11 ; C46.1@2659.78,5375.89 cw(c2669.7,5365.97) 2669.7,5380 cw(c2669.7,5394.03) C46.1@2659.78,5384.11 ; Y2.2@2707.5,5448.5 2783.5,5448.5 2790.19,5455.19 v1(2790.19,5508.37) ; Y2.2@2722.7,5433.3 cw(c2759.41,5396.59) 2759.41,5448.5 cw(c2759.41,5500.41) Y2.2@2722.7,5463.7 ; v1@2761.11,5286.11 cw(c2751.72,5276.72) 2765,5276.72 cw(c2778.28,5276.72) v1@2768.89,5286.11 ; v1@2761.11,5293.89 ccw(c2751.72,5303.28) 2765,5303.28 ccw(c2778.28,5303.28) v1@2768.89,5293.89 ; v1@2786.3,5504.49 cw(c2776.91,5495.1) 2790.19,5495.1 cw(c2803.47,5495.1) v1@2794.08,5504.49 ; R64.1@2810.06,5725.75 cw(c2800.98,5716.67) 2813.82,5716.67 cw(c2826.66,5716.67) R64.1@2817.58,5725.75 ; 2813.82,5699.96 ccw(c2831.78,5699.96) v1@2819.08,5687.26 ; R64.1@2813.82,5730 2813.82,5684.75 v1(2815.19,5683.37) ; R61.2@2852.42,5154.25 ccw(c2843.34,5163.33) 2856.18,5163.33 ccw(c2869.02,5163.33) R61.2@2859.94,5154.25 ; R65.2@2852.42,5200.75 cw(c2843.34,5191.67) 2856.18,5191.67 cw(c2869.02,5191.67) R65.2@2859.94,5200.75 ; R61.2@2856.18,5150 R65.2@2856.18,5205 2904.23,5205 v1(2904.52,5204.71) ; R60.1@2856.18,5926 2887.63,5926 2900,5938.37 2915.19,5938.37 2960.19,5938.37 2973.52,5925.04 v1(2976.52,5925.04) ; R65.2@2859.94,5201.24 cw(c2869.02,5192.16) 2869.02,5205 cw(c2869.02,5217.84) R65.2@2859.94,5208.76 ; R60.1@2859.94,5922.24 cw(c2869.02,5913.16) 2869.02,5926 cw(c2869.02,5938.84) R60.1@2859.94,5929.76 ; C62.2@2877.75,1105.14 cw(c2849.17,1073.24) 2892.01,1073.24 cw(c2934.84,1073.24) C62.2@2906.27,1105.14 ; v1@2886.3,1050.26 ccw(c2872.52,1064.04) 2892.01,1064.04 ; v1(2890.19,1046.37) 2892.01,1044.56 2892.01,1046.37 C62.2@2892.01,1125 ; 2890.54,5205 cw(c2890.54,5190.72) v1@2900.64,5200.82 ; 2891.95,5205 ccw(c2891.95,5217.28) v1@2900.64,5208.6 ; C49.2@2959.89,5506.9 cw(c2923.41,5470.42) 2975,5470.42 cw(c3026.59,5470.42) C49.2@2990.11,5506.9 ; 2962.01,5936.55 ccw(c2976.52,5951.06) v1@2976.52,5930.54 ; v1@2971.11,5428.89 ccw(c2961.72,5438.28) 2975,5438.28 ccw(c2988.28,5438.28) v1@2978.89,5428.89 ; C40.2@2975,5142.01 2980.63,5136.37 v1(3055.19,5136.37) 3087.96,5136.37 C42.1@3104.33,5120 ; v1(2975,5425) C49.2@2975,5522.01 3037.22,5522.01 ; C40.2@2996.27,5154.51 ccw(c3031.73,5180.11) 3031.73,5136.37 ; C49.2@3007.71,5505.11 cw(c3037.22,5487.79) 3037.22,5522.01 ; C49.2@3007.71,5538.9 ccw(c3037.22,5556.22) 3037.22,5522.01 ; v1@3042.29,1598.89 ccw(c3032.9,1608.28) 3046.18,1608.28 ccw(c3059.46,1608.28) v1@3050.07,1598.89 ; v1(3046.18,1595) R202.2@3046.18,1625 ; v1@3051.3,5132.49 ccw(c3041.91,5123.1) 3041.91,5136.37 ccw(c3041.91,5149.65) v1@3051.3,5140.26 ; v1@3059.08,5132.49 cw(c3068.47,5123.1) 3068.47,5136.37 cw(c3068.47,5149.65) v1@3059.08,5140.26 ; C42.1@3098.52,5120 ccw(c3084.49,5120) 3094.41,5129.92 ccw(c3104.33,5139.84) C42.1@3104.33,5125.81 ; C53.1@3100.22,5495.89 ccw(c3090.3,5485.97) 3090.3,5500 ccw(c3090.3,5514.03) C53.1@3100.22,5504.11 ; C53.1@3104.33,5500 3059.23,5500 3037.22,5522.01 ; C41.1@3141.56,5349.11 ccw(c3131.64,5359.03) 3145.67,5359.03 ccw(c3159.7,5359.03) C41.1@3149.78,5349.11 ; v1@3141.78,5391.78 cw(c3132.39,5382.39) 3145.67,5382.39 cw(c3158.95,5382.39) v1@3149.56,5391.78 ; C41.1@3145.67,5345 v1(3145.67,5395.67) ; C52.1@3145.67,5725 3147.09,5726.42 3177.58,5726.42 v1(3181,5723) ; C52.1@3149.78,5720.89 cw(c3163.13,5707.53) 3163.13,5726.42 ; 3159.46,5726.42 cw(c3159.46,5701.46) v1@3177.11,5719.11 ; U6.11@3341.06,5469.84 3407.86,5469.84 ; U6.13@3341.06,5521.02 3398.52,5521.02 3407.86,5511.69 3407.86,5469.84 ; U6.15@3341.06,5572.2 3275,5572.2 3275,5617.86 3280.52,5623.39 U6.17@3341.06,5623.39 3456.61,5623.39 v1(3470,5610) ; v1@3396.11,6033.89 ccw(c3386.72,6043.28) 3400,6043.28 ccw(c3413.28,6043.28) v1@3403.89,6033.89 ; v1(3400,6030) 3400,6070 3425,6095 U36.5@3487.48,6095 ; v1(3465.19,1602.04) 3472.04,1602.04 3481.18,1611.18 ; v1@3466.65,1607.34 ccw(c3470.62,1621.74) 3481.18,1611.18 ; R208.2@3477.42,1630.75 cw(c3468.34,1621.67) 3481.18,1621.67 cw(c3494.02,1621.67) R208.2@3484.94,1630.75 ; v1@3481.11,5425.09 ccw(c3471.72,5434.47) 3485,5434.47 ccw(c3498.28,5434.47) v1@3488.89,5425.09 ; R208.2@3481.18,1635 3481.18,1611.18 ; C61.2@3482.01,1125 3490,1117.01 v1(3490,1060) ; v1@3485,5425.2 3485,5455 3470.16,5469.84 3407.86,5469.84 ; v1@3486.11,1063.89 ccw(c3476.72,1073.28) 3490,1073.28 ccw(c3503.28,1073.28) v1@3493.89,1063.89 ; v1@3526.02,5671.7 cw(c3539,5678.07) 3528.78,5688.29 ; v1@3527.97,5678.46 ccw(c3518.58,5687.84) 3531.86,5687.84 ccw(c3545.14,5687.84) 3535.75,5678.46 ccw(c3545.14,5687.84) 3545.14,5674.57 ccw(c3545.14,5661.29) v1@3535.75,5670.68 ; v1@3536.79,5676.99 cw(c3554.91,5685.89) 3540.64,5700.16 ; U6.10@3598.94,5469.84 3653.52,5469.84 3658.52,5474.84 3658.52,5483.37 ; U6.4@3598.94,5623.39 3653.52,5623.39 3658.52,5618.39 3658.52,5483.37 ; U6.2@3598.94,5674.57 v1(3531.86,5674.57) 3531.86,5691.37 3540.64,5700.16 ; U6.1@3598.94,5700.16 3540.64,5700.16 ; U37.3@3614.88,6057.4 3675.83,6057.4 v1(3677.52,6055.71) v1@3680,6058.18 ; U37.3@3632.77,6053.29 cw(c3642.69,6043.37) 3642.69,6057.4 cw(c3642.69,6071.43) U37.3@3632.77,6061.51 ; 3660.16,6057.4 cw(c3660.16,6038.34) v1@3673.64,6051.82 ; 3671.25,5483.37 ccw(c3671.25,5497.32) v1@3681.11,5487.46 ; 3672.19,5483.37 cw(c3672.19,5470.76) v1@3681.11,5479.68 ; v1@3681.86,5483.37 3658.52,5483.37 ; v1@3810,3959.5 cw(c3810,3946.22) 3819.39,3955.61 cw(c3828.78,3965) v1@3815.5,3965 ; v1(3810,3965) 3840,3935 3885,3935 ; R36.2@3825.24,1204.94 ccw(c3816.16,1214.02) 3829,1214.02 ccw(c3841.84,1214.02) R36.2@3832.76,1204.94 ; R36.2@3829,1201.18 3829,1227.04 3831.96,1230 3937.04,1230 3950,1217.04 v1(3950,1180) ; v1(3845,4200) 3903.82,4200 ; v1@3848.89,4196.11 cw(c3858.28,4186.72) 3858.28,4200 cw(c3858.28,4213.28) v1@3848.89,4203.89 ; C243.2@3857.62,5622.07 cw(c3847.7,5612.15) 3861.73,5612.15 cw(c3875.75,5612.15) C243.2@3865.83,5622.07 ; v1@3857.97,5590.79 ccw(c3848.9,5599.86) 3861.73,5599.86 ; C244.2@3861.72,5516.18 3910,5516.18 C259.2@3960.39,5516.18 v1(3960.39,5570.19) C229.2@3960.39,5626.18 ; 3861.73,5600.5 ccw(c3875.45,5600.5) v1@3865.75,5590.79 ; C243.2@3861.72,5626.18 3861.73,5586.9 3861.73,5586.71 v1@3861.86,5586.71 ; C244.2@3865.83,5512.07 cw(c3875.75,5502.15) 3875.75,5516.18 cw(c3875.75,5530.21) C244.2@3865.83,5520.29 ; v1@3876.11,6298.89 ccw(c3866.72,6308.28) 3880,6308.28 ccw(c3893.28,6308.28) v1@3883.89,6298.89 ; v1@3880,6293.14 NT47.1@3880,6340 ; 3896.25,5516.18 ccw(c3896.25,5530.12) v1@3906.11,5520.26 ; 3897.19,5516.18 cw(c3897.19,5503.56) v1@3906.11,5512.48 ; R312.1@3903.82,3900 3885,3918.82 3885,3935 ; R308.1@3903.82,3990 3903.82,3953.82 3885,3935 ; R311.1@3903.82,4170 3903.82,4200 ; R313.1@3903.82,4260 3903.82,4200 ; v1@3913.89,5512.48 cw(c3922.81,5503.56) 3922.81,5516.18 ; v1@3913.89,5520.26 ccw(c3923.75,5530.12) 3923.75,5516.18 ; v1@3939.64,1079.49 cw(c3930.25,1070.1) 3943.52,1070.1 cw(c3956.8,1070.1) v1@3947.41,1079.49 ; v1(3943.52,1083.37) 3943.52,1062.71 3943.22,1062.4 D2.1@3999.21,1062.4 ; v1@3946.11,1183.89 ccw(c3936.72,1193.28) 3950,1193.28 ccw(c3963.28,1193.28) v1@3953.89,1183.89 ; C259.2@3956.28,5512.07 ccw(c3946.36,5502.15) 3946.36,5516.18 ccw(c3946.36,5530.21) 3956.28,5520.29 ccw(c3946.36,5530.21) 3960.39,5530.21 ccw(c3974.42,5530.21) C259.2@3964.5,5520.29 ; C229.2@3956.28,5622.07 cw(c3946.36,5612.15) 3960.39,5612.15 cw(c3974.42,5612.15) C229.2@3964.5,5622.07 ; v1@3956.5,5566.3 cw(c3947.11,5556.92) 3960.39,5556.92 cw(c3973.66,5556.92) v1@3964.28,5566.3 ; v1@3956.5,5574.08 ccw(c3947.11,5583.47) 3960.39,5583.47 ccw(c3973.66,5583.47) v1@3964.28,5574.08 ; v1@3977.97,4032.15 cw(c3968.58,4022.76) 3981.86,4022.76 cw(c3995.14,4022.76) v1@3985.75,4032.15 ; v1(3981.86,4036.04) 3981.86,3998.14 4004.13,3975.87 4070.87,3975.87 4085,3990 R309.1@4133.82,3990 4163.82,3960 4220,3960 4240,3940 4240,3920 4220,3900 R310.1@4176.18,3900 ; D2.1@3989.94,1054.12 ccw(c3969.94,1034.11) 3969.94,1062.4 ccw(c3969.94,1090.69) D2.1@3989.94,1070.69 ; v1(4017.6,6097.6) 4107.6,6097.6 4118.24,6108.24 U72.3@4118.24,6155.12 ; U3.13@4076.5,1174.41 4090.19,1174.41 4090.19,1175.04 v1@4112.52,1175.04 ; C37.1@4098.67,949 v1(4124,949) ; U3.13@4101.62,1175.04 cw(c4101.62,1161.62) v1@4111.11,1171.11 ; U3.13@4101.82,1175.04 ccw(c4101.82,1188.18) v1@4111.11,1178.89 ; v1@4120.11,945.11 ccw(c4110.72,935.72) 4110.72,949 ccw(c4110.72,962.28) v1@4120.11,952.89 ; v1(4235,2615) 4242.73,2607.27 R305.1@4277.34,2607.27 ; v1@4238.89,2618.89 ccw(c4266.94,2646.94) R305.1@4266.94,2607.27 ; v1@4252,3054.5 cw(c4252,3041.22) 4261.39,3050.61 cw(c4270.78,3060) v1@4257.5,3060 ; v1(4252,3060) 4311.46,3000.54 4354.43,3000.54 4378.82,3024.93 R286.1@4378.82,3028.12 ; U3.7@4268.52,1046.46 cw(c4250.08,1028.02) 4276.16,1028.02 ; R34.2@4272.4,953.25 ccw(c4263.32,962.33) 4276.16,962.33 ccw(c4289,962.33) R34.2@4279.92,953.25 ; R34.2@4276.16,949 U3.7@4276.16,1043.84 ; R287.1@4277.34,2439.55 R304.1@4277.34,2495.45 R307.1@4277.34,2551.36 R305.1@4277.34,2607.27 ; R306.1@4277.34,2719.09 R303.1@4277.34,2663.18 R305.1@4277.34,2607.27 ; U3.7@4295,1046.46 4336.86,1046.46 4338.52,1048.12 v1@4338.52,1050.04 ; U3.5@4295,1097.64 4336.86,1097.64 4338.52,1095.97 v1@4338.52,1050.04 ; U3.7@4323.07,1046.46 ccw(c4323.07,1071.97) v1@4341.11,1053.93 ; U38.3@4323.24,6155.12 4323.24,6125.04 4323.52,6124.76 4323.52,6111.48 4334.96,6100.04 v1(4385,6100.04) 4490,6100.04 4520.04,6100.04 4528.24,6108.24 U71.3@4528.24,6155.12 ; 4338.52,1078.95 ccw(c4373.91,1078.95) 4348.89,1053.93 ccw(c4358.28,1063.32) 4358.28,1050.04 ccw(c4358.28,1036.76) v1@4348.89,1046.15 ; v1@4381.11,6096.15 ccw(c4371.72,6086.76) 4371.72,6100.04 ccw(c4371.72,6113.32) v1@4381.11,6103.93 ; v1@4388.89,6096.15 cw(c4398.28,6086.76) 4398.28,6100.04 cw(c4398.28,6113.32) v1@4388.89,6103.93 ; R38.1@4390.75,1050.06 ccw(c4381.67,1040.98) 4381.67,1053.82 ccw(c4381.67,1066.66) R38.1@4390.75,1057.58 ; R38.1@4395,1053.82 4374.19,1053.82 4370.52,1050.15 4370.52,1050.04 v1(4345,1050.04) v1@4338.52,1050.04 ; R289.1@4519.8,2085 4519.8,2149.8 4540,2170 4670,2170 4710,2210 4710,2505 4598.5,2616.5 4598.5,2643.09 4630,2674.59 4630,2710 v1(4592,2748) 4592,2727.31 ; C239.2@4528.95,1772.07 cw(c4519.03,1762.15) 4533.06,1762.15 cw(c4547.09,1762.15) C239.2@4537.17,1772.07 ; C221.2@4528.95,1890.29 ccw(c4519.03,1900.21) 4533.06,1900.21 ccw(c4547.09,1900.21) C221.2@4537.17,1890.29 ; C239.2@4533.06,1776.18 4533.06,1752.35 4539.06,1746.35 v1(4564.68,1746.35) ; C221.2@4533.06,1886.18 4533.06,1910 4539.06,1916 v1(4564.68,1916) ; v1@4558.77,1746.35 4584.39,1746.35 4590.39,1752.35 C224.2@4590.39,1776.18 ; v1@4560.79,1742.46 ccw(c4551.4,1733.08) 4551.4,1746.35 ccw(c4551.4,1759.63) v1@4560.79,1750.24 ; v1@4560.79,1912.11 ccw(c4551.4,1902.72) 4551.4,1916 ccw(c4551.4,1929.28) v1@4560.79,1919.89 ; v1@4568.57,1742.46 cw(c4577.96,1733.08) 4577.96,1746.35 cw(c4577.96,1759.63) v1@4568.57,1750.24 ; NT44.1@4569.76,2705.08 4592,2727.31 ; NT44.1@4573.91,2724.15 ccw(c4580.7,2738.61) 4592,2727.31 ; C224.2@4586.28,1772.07 cw(c4576.36,1762.15) 4590.39,1762.15 cw(c4604.42,1762.15) C224.2@4594.5,1772.07 ; C192.2@4586.28,1890.29 ccw(c4576.36,1900.21) 4590.39,1900.21 ccw(c4604.42,1900.21) C192.2@4594.5,1890.29 ; v1@4588.11,2744.11 cw(c4578.72,2734.72) 4592,2734.72 cw(c4605.28,2734.72) v1@4595.89,2744.11 ; C192.2@4590.39,1886.18 4590.39,1910 4596.39,1916 v1(4622,1916) ; v1@4592,2742.5 cw(c4592,2729.22) 4601.39,2738.61 cw(c4610.78,2748) v1@4597.5,2748 ; v1@4618.11,1912.11 ccw(c4608.72,1902.72) 4608.72,1916 ccw(c4608.72,1929.28) v1@4618.11,1919.89 ; v1(4625,1466) T1.1@4668,1466 ; v1@4628.89,1462.11 cw(c4638.28,1452.72) 4638.28,1466 cw(c4638.28,1479.28) v1@4628.89,1469.89 ; v1(4710,6105) NT48.1@4710,6335 ; v2(4716,4820) 4760,4820 4770,4810 4770,4780 4809.59,4740.41 C310.2@4809.59,4691.67 ; v2@4720.11,4815.89 cw(c4730.03,4805.97) 4730.03,4820 cw(c4730.03,4834.03) v2@4720.11,4824.11 ; v1@4736.11,4359.89 ccw(c4726.72,4369.28) 4740,4369.28 ccw(c4753.28,4369.28) v1@4743.89,4359.89 ; v1(4740,4356) 4740,4396 4749,4405 C320.2@4790,4405 ; v1(4740.19,3987.71) 4760.52,3987.71 4765.19,3983.04 ; v1@4744.08,3983.82 cw(c4753.47,3974.43) 4753.47,3987.71 cw(c4753.47,4000.99) v1@4744.08,3991.6 ; v2@4745,3884.19 cw(c4745,3842.79) 4774.28,3872.06 ; v2(4745,3890) v2@4750,3895 ; v2@4752,3894.34 C322.2@4790,3856.34 ; 4765.19,3982.78 4773.52,3974.45 C323.2@4790,3974.45 ; 4776.14,4405 ccw(c4776.14,4419.1) C320.2@4786.11,4409.13 ; 4777.3,4405 cw(c4777.3,4392.54) C320.2@4786.11,4401.35 ; C322.2@4784.19,3856.34 ccw(c4770.16,3856.34) 4780.08,3866.26 ccw(c4790,3876.18) C322.2@4790,3862.15 ; 4785,4385 4786,4385 ; C323.2@4785.89,3970.34 ccw(c4775.97,3960.42) 4775.97,3974.45 ccw(c4775.97,3988.48) C323.2@4785.89,3978.56 ; 4786,4384.61 cw(c4807.65,4384.61) C320.2@4793.58,4401.06 ; C320.2@4786,4402 4786,4385 ; C335.2@4790,4163.52 cw(c4790,4149.49) 4799.92,4159.41 cw(c4809.84,4169.33) C335.2@4795.81,4169.33 ; C335.2@4790,4169.33 4828.2,4131.13 5013.3,4131.13 5017.17,4135 ; C304.2@4790,4559.19 cw(c4790,4533.09) 4808.45,4551.55 ; C304.2@4790,4565 4795,4565 4850,4510 4850,4410 4825,4385 4786,4385 ; C310.2@4805.48,4695.78 ccw(c4795.56,4705.7) 4809.59,4705.7 ccw(c4823.62,4705.7) C310.2@4813.7,4695.78 ; v1(4860,4778) 4867.59,4770.41 C294.2@4888.33,4770.41 cw(c4888.33,4802.11) v1@4864.19,4781.56 ; v1@4869.64,5655.26 ccw(c4846.23,5678.67) C100.2@4879.33,5678.67 ; v1(4873.52,5651.37) 4874.52,5650.37 4875.33,5650.37 4879.33,5654.37 C100.2@4879.33,5680 ; R116.1@4875.06,5744.25 ccw(c4865.98,5753.33) 4878.82,5753.33 ccw(c4891.66,5753.33) R116.1@4882.58,5744.25 ; R116.1@4879.33,5739.49 R116.1@4878.82,5740 4878.82,5785 4888.52,5794.7 v1(4888.52,5818.37) ; v1@4884.64,5814.49 cw(c4875.25,5805.1) 4888.52,5805.1 cw(c4901.8,5805.1) v1@4892.41,5814.49 ; v1(4910.86,5455.37) 4915.86,5460.37 4923.14,5460.37 4924.5,5461.73 U21.25@4977.68,5461.73 ; v1@4914.75,5451.49 cw(c4939.48,5426.75) 4939.48,5461.73 ; C96.2@5076.56,5325.89 cw(c5066.64,5315.97) 5080.67,5315.97 cw(c5094.7,5315.97) C96.2@5084.78,5325.89 ; C96.2@5080.67,5330 5080.67,5264.33 5094.96,5250.04 v1(5118.86,5250.04) ; v1@5114.97,5246.15 ccw(c5105.58,5236.76) 5105.58,5250.04 ccw(c5105.58,5263.32) v1@5114.97,5253.93 ; v1@5131.3,5800.15 cw(c5121.99,5790.84) 5135.16,5790.84 ; U21.42@5135.16,5737.32 v1@5135.16,5804.01 ; 5135.16,5790.69 cw(c5148.55,5790.69) v1@5139.08,5800.15 ; C330.2@5178.56,3585.89 cw(c5203.06,3561.39) 5203.06,3596.04 ; C330.2@5180.17,3589.01 cw(c5188.52,3587.57) 5188.52,3596.04 v1(5234.52,3596.04) ; v1@5186.11,1476.11 cw(c5176.72,1466.72) 5190,1466.72 cw(c5203.28,1466.72) v1@5193.89,1476.11 ; v1(5190,1480) 5190,1375 5200,1365 5242.48,1365 U65.3@5242.6,1364.88 ; v1(5205,1620) 5240,1620 5242.6,1622.6 5242.6,1633.19 U66.3@5242.6,1634.88 ; v1@5208.89,1616.11 cw(c5218.28,1606.72) 5218.28,1620 cw(c5218.28,1633.28) v1@5208.89,1623.89 ; U21.46@5213.9,5731.74 U21.46@5213.9,5737.32 5213.9,5778.9 5223.21,5788.21 5235,5788.21 ; 5225.91,1620 ccw(c5225.91,1637.79) U66.3@5238.49,1625.21 ; 5228.28,1365 cw(c5228.28,1350.57) U65.3@5238.49,1360.77 ; 5228.85,1365 ccw(c5228.85,1378.63) U65.3@5238.49,1368.99 ; v1@5230.64,3592.15 ccw(c5221.25,3582.76) 5221.25,3596.04 ccw(c5221.25,3609.32) v1@5230.64,3599.93 ; U21.47@5233.58,5737.32 5233.58,5786.79 5235,5788.21 ; v2(5250,1000) 5275,1000 5306.54,1031.54 5388.46,1031.54 5425,995 5425,935 U62.2@5392.24,935 ; U21.48@5253.27,5737.32 5253.27,5778.27 5263.21,5788.21 ; v2@5254.11,995.89 cw(c5264.03,985.97) 5264.03,1000 cw(c5264.03,1014.03) v2@5254.11,1004.11 ; U21.11@5312.32,5481.42 v1(5357.86,5481.37) v1(5357.86,5481.37) ; v2(5315.07,3534.31) 5316.88,3532.5 5348.78,3532.5 5351.28,3535 5389.15,3535 5400.97,3523.19 5419.03,3523.19 5424.45,3528.61 5428.61,3528.61 5435.39,3535.39 v2(5435.39,3560.75) 5435.39,3579.61 5425,3590 C333.2@5410.67,3590 C333.2@5410,3590 ; v2@5319.17,3538.42 ccw(c5333.47,3552.71) 5333.47,3532.5 ; 5344.48,5481.42 cw(c5344.48,5468) v1@5353.97,5477.49 ; 5344.68,5481.42 ccw(c5344.68,5494.55) v1@5353.97,5485.26 ; v2@5350.89,5780.89 ccw(c5340.97,5770.97) 5340.97,5785 ccw(c5340.97,5799.03) v2@5350.89,5789.11 ; v2(5355,5785) 5315.64,5785 5312.43,5788.21 5263.21,5788.21 ; U62.2@5403.65,929.5 cw(c5416.93,916.22) 5416.93,935 cw(c5416.93,953.78) U62.2@5403.65,940.5 ; C332.2@5410.67,4790 5411.97,4790 5437.44,4815.47 v1(5453.86,4815.47) ; C332.2@5410.67,4795.81 ccw(c5410.67,4812.98) 5422.81,4800.84 ; C333.2@5411.26,3595.1 cw(c5412.5,3577.5) 5424.97,3589.97 ; C333.2@5413.7,3585.04 cw(c5421.53,3572.2) 5432.16,3582.84 ; C333.2@5414.78,3585.89 cw(c5424.7,3575.97) 5424.7,3590 ; C333.2@5414.78,3594.11 ccw(c5424.7,3604.03) 5424.7,3590 ; C332.2@5416.48,4790 cw(c5427.37,4790) C332.2@5419.67,4797.7 ; 5426.06,1600.39 cw(c5405.67,1580) v1@5434.5,1580 ; 5429.23,4807.26 cw(c5442.53,4793.95) v1@5451.29,4810.6 ; v2@5431.28,3556.64 cw(c5421.36,3546.72) 5435.39,3546.72 cw(c5449.42,3546.72) v2@5439.5,3556.64 ; v2@5431.28,3564.86 ccw(c5421.36,3574.78) 5435.39,3574.78 ccw(c5449.42,3574.78) v2@5439.5,3564.86 ; v1(5440,1580) 5440,1586.44 5428.17,1598.28 5428.17,1616.35 5446.91,1635.09 U68.3@5477.39,1635.09 ; C98.2@5440.67,5430 5469.37,5430 5484.37,5445 C99.1@5484.37,5515 5580,5515 v1(5594.54,5529.73) ; 5440.74,4818.77 cw(c5450.47,4809.04) v1@5456.89,4821.22 ; C98.2@5444.78,5425.89 cw(c5454.7,5415.97) 5454.7,5430 cw(c5454.7,5444.03) C98.2@5444.78,5434.11 ; v1@5445.12,1364.88 U67.3@5477.6,1364.88 U67.3@5477.48,1365 ; v1@5449.97,4811.58 ccw(c5440.58,4802.19) 5440.58,4815.47 ccw(c5440.58,4828.74) v1@5449.97,4819.36 ; v1@5453.89,1360.99 cw(c5463.28,1351.6) 5463.28,1364.88 cw(c5463.28,1378.16) v1@5453.89,1368.77 ; 5463.07,1635.09 cw(c5463.07,1620.36) U68.3@5473.49,1630.77 ; 5464.06,1635.09 ccw(c5464.06,1648.42) U68.3@5473.49,1638.99 ; U68.3@5477.6,1634.88 U68.3@5477.39,1635.09 ; U68.3@5478.38,1635.09 U68.3@5477.39,1635.09 ; v1@5480.48,5461.11 cw(c5471.09,5451.72) 5484.37,5451.72 cw(c5497.65,5451.72) v1@5488.26,5461.11 ; v1@5480.48,5468.89 ccw(c5471.09,5478.28) 5484.37,5478.28 ccw(c5497.65,5478.28) v1@5488.26,5468.89 ; v1@5482.17,1921.76 ccw(c5486.02,1934.89) 5495.7,1925.22 ; v1(5484,1928) 5498.48,1928 5510,1939.52 ; v1@5485.55,1933.28 ccw(c5492.52,1957) 5510,1939.52 ; C341.2@5489.74,1980.49 cw(c5458.44,1939.52) 5510,1939.52 ; C99.1@5494.05,5505.32 cw(c5517.41,5481.96) 5517.41,5515 cw(c5517.41,5548.04) C99.1@5494.05,5524.68 ; C341.2@5497.03,1990.03 cw(c5476.98,1963.79) 5510,1963.79 cw(c5543.02,1963.79) C341.2@5522.97,1990.03 ; C341.2@5510,2007.01 5510,1939.52 ; C340.2@5510,2407.01 5541.97,2375.04 5573.52,2375.04 5587.19,2375.04 5603.74,2391.59 5605.93,2391.59 C337.2@5610,2395.67 5599.29,2406.37 v1(5572.52,2406.37) ; C341.2@5530.26,1980.49 ccw(c5561.56,1939.52) 5510,1939.52 ; v1(5540.19,2218.04) 5545.86,2218.04 5547.19,2216.71 5573.96,2216.71 ; C258.2@5540.55,2714.63 cw(c5561.37,2715.87) 5546.62,2730.62 ; C258.2@5542.62,2719.11 ccw(c5532.7,2729.03) 5546.72,2729.03 ccw(c5560.75,2729.03) C258.2@5550.83,2719.11 ; v1@5544.08,2221.93 ccw(c5556.69,2234.54) 5556.69,2216.71 ; C258.2@5546.72,2715 5546.72,2730.72 v2@5565.5,2749.5 ; R302.1@5547.24,3075 5610,3075 5652.36,3032.64 5652.36,3020.9 5670,3003.26 5670,2953.55 5690.36,2933.19 5783.19,2933.19 5792.5,2942.5 5792.5,2942.91 5800,2950.41 5799.8,2950.61 5799.8,2978.38 v1(5783.18,2995) ; 5551.96,2735.96 cw(c5567,2720.92) v2@5567,2742.19 ; v1@5576.41,2402.49 cw(c5585.8,2393.1) 5585.8,2406.37 cw(c5585.8,2419.65) v1@5576.41,2410.26 ; v2@5593.89,3472.11 ccw(c5583.97,3482.03) 5598,3482.03 ccw(c5612.03,3482.03) v2@5602.11,3472.11 ; v1@5594.87,2612.6 cw(c5564.88,2578.89) C336.2@5610,2578.89 ; v1@5594.93,6073.89 ccw(c5585.54,6083.28) 5598.82,6083.28 ccw(c5612.1,6083.28) v1@5602.71,6073.89 ; v1@5594.93,6153.89 ccw(c5585.54,6163.28) 5598.82,6163.28 ccw(c5612.1,6163.28) v1@5602.71,6153.89 ; R119.2@5595.06,6110.75 cw(c5585.98,6101.67) 5598.82,6101.67 cw(c5611.66,6101.67) R119.2@5602.58,6110.75 ; 5596.36,2384.21 cw(c5610,2370.56) C337.2@5610,2389.86 ; v2(5598,3468) 5598,3528 5605,3535 5605,3589.45 C328.2@5605.55,3590 ; v1@5598.52,2611.21 cw(c5598.52,2597.93) 5607.91,2607.32 cw(c5617.3,2616.71) v1@5604.02,2616.71 ; v1(5598.52,2616.71) 5610,2605.23 ; v1(5598.82,6070) R119.2@5598.82,6115 ; v1(5598.82,6150) R120.1@5598.82,6175 ; C337.2@5599.75,2406.37 cw(c5599.75,2386.3) C337.2@5614.57,2399.84 ; C328.2@5601.44,3585.89 cw(c5592.85,3577.3) 5605,3577.3 ; v1@5602.84,2621.56 cw(c5588.66,2605.62) 5610,2605.62 ; 5605,3574.64 cw(c5620.91,3574.64) C328.2@5609.66,3585.89 ; C339.2@5605.89,2004.78 ccw(c5595.97,2014.7) 5610,2014.7 ccw(c5624.03,2014.7) C339.2@5614.11,2004.78 ; C336.2@5605.89,2584.78 ccw(c5595.97,2594.7) 5610,2594.7 ccw(c5624.03,2594.7) C336.2@5614.11,2584.78 ; C336.2@5607.02,2586.1 cw(c5617.47,2567.05) 5632.82,2582.41 ; C339.2@5610,2000.67 5610,2024.04 ; C336.2@5610,2580.67 5610,2605.23 ; v2(5610,5470) 5679.21,5470 C256.2@5725.39,5516.18 ; v2@5614.11,5465.89 cw(c5624.03,5455.97) 5624.03,5470 cw(c5624.03,5484.03) v2@5614.11,5474.11 ; U63.2@5642.24,935 5680,935 5695,950 v1(5695,1045) ; 5642.6,2454 ccw(c5684.7,2496.1) C342.2@5701.59,2439.01 ; v1@5645.02,2066.71 cw(c5631.75,2066.71) 5641.14,2057.32 cw(c5650.52,2047.93) 5650.52,2061.21 cw(c5650.52,2047.93) 5659.91,2057.32 cw(c5669.3,2066.71) v1@5656.02,2066.71 ; v1(5645,4845) 5670,4845 5675,4840 5675,4800 5665,4790 C291.2@5646.89,4790 ; v1@5648.89,4841.11 cw(c5658.28,4831.72) 5658.28,4845 cw(c5658.28,4858.28) v1@5648.89,4848.89 ; U63.2@5653.65,929.5 cw(c5666.93,916.22) 5666.93,935 cw(c5666.93,953.78) U63.2@5653.65,940.5 ; C368.2@5654.94,1220.29 ccw(c5644.67,1230.55) 5659.19,1230.55 ; v1@5655.3,1289.82 cw(c5645.91,1280.43) 5659.19,1280.43 cw(c5672.47,1280.43) v1@5663.08,1289.82 ; v1@5656.86,1291.37 5659.05,1293.56 v1@5659.05,1293.71 ; 5656.86,2439.73 ccw(c5691.21,2474.08) C342.2@5705,2427.5 ; C368.2@5659.05,1216.18 5659.19,1216.32 v1(5659.19,1293.71) ; 5659.19,1229.86 ccw(c5672.73,1229.86) C368.2@5663.16,1220.29 ; 5669.28,2427.31 cw(c5648.98,2407.01) C342.2@5677.69,2407.01 ; 5671.13,2425.46 ccw(c5697.73,2452.06) C342.2@5708.4,2415.99 ; C185.2@5673.15,2044.08 ccw(c5711.06,2082) C185.2@5711.06,2028.38 ; C185.2@5675.18,2042.06 cw(c5640.13,2007.01) C185.2@5689.69,2007.01 ; v1@5691.11,1041.11 cw(c5681.72,1031.72) 5695,1031.72 cw(c5708.28,1031.72) v1@5698.89,1041.11 ; v1@5692.64,1048.71 v1@5695,1046.35 ; C367.2@5696.01,1330.55 cw(c5722.94,1303.62) 5722.94,1341.71 ; v1@5698.72,4764.21 cw(c5708.67,4771.35) 5700.01,4780.01 ; v1@5700.11,4771.89 ccw(c5690.72,4781.28) 5704,4781.28 ccw(c5717.28,4781.28) v1@5707.89,4771.89 ; C367.2@5700.39,1326.18 5715.92,1341.71 v1(5756.86,1341.71) 5772.39,1326.18 C249.2@5840.39,1326.18 ; C367.2@5700.39,1331.99 ccw(c5700.39,1346.02) 5710.31,1336.1 ccw(c5720.23,1326.18) C367.2@5706.2,1326.18 ; v1(5704,4768) 5704,4784 5710,4790 C307.2@5723.66,4790 5723.66,4828.66 5730,4835 v1(5765,4835) ; v1@5708.47,4771.21 cw(c5720.3,4779.7) 5710,4790 ; C185.2@5715,2007.01 5710.22,2007.01 v1(5650.52,2066.71) 5608.93,2025.11 ; C342.2@5715,2407.01 5708.52,2407.01 5708.52,2408.37 5691.86,2425.04 5671.55,2425.04 5631.86,2464.74 5631.86,2583.37 5622.28,2592.95 5610,2605.23 ; C307.2@5719.55,4794.11 ccw(c5709.63,4804.03) 5723.66,4804.03 ccw(c5737.69,4804.03) C307.2@5727.77,4794.11 ; C256.2@5719.58,5516.18 cw(c5705.55,5516.18) 5715.47,5506.26 cw(c5725.39,5496.34) C256.2@5725.39,5510.37 ; C255.2@5721.28,5622.07 cw(c5711.36,5612.15) 5725.39,5612.15 cw(c5739.42,5612.15) C255.2@5729.5,5622.07 ; C255.2@5725.39,5626.18 5725.39,5599.61 5730,5595 v2(5790,5595) ; R118.1@5735.06,6019.25 ccw(c5725.98,6028.33) 5738.82,6028.33 ccw(c5751.66,6028.33) R118.1@5742.58,6019.25 ; R118.1@5738.82,6015 5738.82,6057.67 v1@5739.52,6058.37 ; 5738.82,6039.37 cw(c5760.19,6039.37) v1@5745.08,6054.49 ; v1(5741.19,6058.37) v1@5739.52,6058.37 ; v3(5744.33,3993.15) 5744.63,3992.85 5763.83,3973.65 5989.2,3973.65 C305.2@5990,3974.45 ; v1@5746.69,6058.37 cw(c5763.99,6058.37) 5751.76,6070.61 ; v1@5752.97,1337.82 ccw(c5743.58,1328.43) 5743.58,1341.71 ccw(c5743.58,1354.99) v1@5752.97,1345.6 ; v1@5761.11,4831.11 ccw(c5751.72,4821.72) 5751.72,4835 ccw(c5751.72,4848.28) v1@5761.11,4838.89 ; 5763.41,6134.29 cw(c5783.31,6114.39) U20.2@5783.31,6142.54 ; C329.2@5765,3584.19 cw(c5765,3570.16) 5774.92,3580.08 cw(c5784.84,3590) C329.2@5770.81,3590 ; C329.2@5765,3590 v2@5790,3565 ; 5768.63,6139.52 cw(c5778.12,6130.03) U20.2@5782.67,6142.65 ; 5772.26,6141.71 ccw(c5772.26,6155.46) U20.2@5781.98,6145.73 ; C329.2@5776.54,3578.46 cw(c5758.09,3560) v2@5784.19,3560 ; v1@5783.18,2989.5 cw(c5783.18,2976.22) 5792.57,2985.61 cw(c5801.96,2995) v1@5788.68,2995 ; v2@5785.89,5590.89 ccw(c5775.97,5580.97) 5775.97,5595 ccw(c5775.97,5609.03) v2@5785.89,5599.11 ; U20.2@5792.17,6141.71 5770.82,6141.71 ; U20.2@5792.17,6144.41 5773.52,6144.41 5770.82,6141.71 ; v1(5795,5554.23) 5827.52,5554.04 5864.43,5554.04 ; v1@5798.87,5550.32 cw(c5808.2,5540.88) 5808.28,5554.16 cw(c5808.36,5567.43) v1@5798.91,5558.1 ; C250.2@5836.28,1212.07 cw(c5826.36,1202.15) 5840.39,1202.15 cw(c5854.42,1202.15) C250.2@5844.5,1212.07 ; C249.2@5836.28,1322.07 ccw(c5826.36,1312.15) 5826.36,1326.18 ccw(c5826.36,1340.21) C249.2@5836.28,1330.29 ; v1@5836.3,1128.93 ccw(c5826.91,1138.32) 5840.19,1138.32 ccw(c5853.47,1138.32) v1@5844.08,1128.93 ; v1(5840.19,1125.04) 5840.19,1183.18 5840.39,1183.37 C250.2@5840.39,1216.18 ; C226.2@5861.28,5520.29 ccw(c5851.36,5530.21) 5865.39,5530.21 ccw(c5879.42,5530.21) C226.2@5869.5,5520.29 ; C225.2@5861.28,5622.07 cw(c5851.36,5612.15) 5865.39,5612.15 cw(c5879.42,5612.15) C225.2@5869.5,5622.07 ; C226.2@5865.39,5516.18 C225.2@5865.39,5626.18 ; v1@5872.19,4791.54 cw(c5872.19,4778.26) 5881.58,4787.65 cw(c5890.97,4797.04) v1@5877.69,4797.04 ; v1(5872.19,4797.04) 5891.67,4777.56 C293.2@5891.67,4770.41 ; C324.2@5891.67,3609.59 v1@5941.51,3609.59 ; U64.2@5892.24,935 5923.52,935 ; U64.2@5894.54,935 cw(c5894.54,887.72) v1@5927.97,921.15 ; C324.2@5895.78,3605.48 cw(c5905.7,3595.56) 5905.7,3609.59 cw(c5905.7,3623.62) C324.2@5895.78,3613.7 ; U64.2@5903.65,929.5 cw(c5916.93,916.22) 5916.93,935 cw(c5916.93,953.78) U64.2@5903.65,940.5 ; R122.1@5912.42,6119.25 ccw(c5903.34,6128.33) 5916.18,6128.33 ccw(c5929.02,6128.33) R122.1@5919.94,6119.25 ; R121.1@5912.42,6170.75 cw(c5903.34,6161.67) 5916.18,6161.67 cw(c5929.02,6161.67) R121.1@5919.94,6170.75 ; R117.2@5916.18,6015 5964.23,6015 v1(5964.52,6014.71) ; R121.1@5916.18,6175 R122.1@5916.18,6115 5940.19,6115 v1(5945,6115) ; R117.2@5919.94,6011.24 cw(c5929.02,6002.16) 5929.02,6015 cw(c5929.02,6027.84) R117.2@5919.94,6018.76 ; 5927.97,3609.59 cw(c5927.97,3595.67) v1@5937.81,3605.51 ; 5928.88,3609.59 ccw(c5928.88,3622.22) v1@5937.81,3613.29 ; v1(5931.86,925.04) 5929.52,927.37 5929.52,929 5923.52,935 ; v1@5936.45,929.64 ccw(c5923.51,916.69) 5923.51,935 ; v1@5941.11,6111.11 ccw(c5931.72,6101.72) 5931.72,6115 ccw(c5931.72,6128.28) v1@5941.11,6118.89 ; v1(5941.7,3609.4) v1@5941.51,3609.59 ; v1@5945.59,3605.51 cw(c5955.43,3595.67) 5955.43,3609.59 ; v1@5945.59,3613.29 ccw(c5954.52,3622.22) 5954.52,3609.59 ; 5950.54,6015 cw(c5950.54,6000.72) v1@5960.64,6010.82 ; 5951.95,6015 ccw(c5951.95,6027.28) v1@5960.64,6018.6 ; C325.2@5966.3,3684.22 cw(c5956.38,3674.3) 5970.41,3674.3 cw(c5984.44,3674.3) C325.2@5974.52,3684.22 ; C325.2@5970.41,3688.33 5970.41,3620.41 5959.59,3609.59 v1@5941.51,3609.59 ; C309.2@5970.41,4691.67 6001.73,4691.67 6023.5,4669.91 6023.5,4643.5 6018.31,4638.31 v2(5986.07,4638.31) 5986.07,4616.47 5973.5,4603.91 5973.5,4581.5 C303.2@5990,4565 ; 5974.04,3973.65 ccw(c5974.04,3990.41) C305.2@5985.89,3978.56 ; C309.2@5974.52,4687.56 cw(c5984.44,4677.64) 5984.44,4691.67 cw(c5984.44,4705.7) C309.2@5974.52,4695.78 ; 5977.9,3973.65 cw(c5977.9,3962.35) C305.2@5985.89,3970.34 ; v2@5981.96,4634.2 cw(c5972.04,4624.28) 5986.07,4624.28 cw(c6000.09,4624.28) 5990.17,4634.2 cw(c6000.09,4624.28) 6000.09,4638.31 cw(c6000.09,4652.34) v2@5990.17,4642.42 ; v1@5982.11,4235.11 cw(c5963.06,4216.06) C334.2@5990,4216.06 ; C303.2@5984.19,4565 ccw(c5970.16,4565) 5980.08,4574.92 ccw(c5990,4584.84) C303.2@5990,4570.81 ; C321.2@5985.89,3810.89 cw(c5975.97,3800.97) 5990,3800.97 cw(c6004.03,3800.97) C321.2@5994.11,3810.89 ; v1(5986,4239) 5990,4235 C334.2@5990,4210.67 ; C321.2@5990,3815 5990,3795 v1@6006.86,3778.14 ; C319.2@5990,4446.89 5999.7,4446.89 6013.09,4433.5 6040.01,4433.5 v2(6045.69,4427.82) ; v1@5991.11,172.38 ccw(c5981.72,181.77) 5995,181.77 ccw(c6008.28,181.77) v1@5998.89,172.38 ; J29.GND1@5991.12,2278.67 6043.86,2278.67 ; v1@5995,168.3 v1(5995,168.5) J30.GND2@5995,260 ; v1@5996.11,5544.08 ccw(c5986.72,5553.47) 6000,5553.47 ccw(c6013.28,5553.47) v1@6003.89,5544.08 ; v1(6000,5540.19) 6000,5595 6015,5610 6070,5610 6113.31,5566.69 U60.1@6116.57,5566.69 ; v1(6003.69,3772.31) 6007.31,3772.31 v1@6010,3775 ; 6017.94,4433.5 cw(c6017.94,4400.07) v2@6041.58,4423.71 ; J29.GND1@6026.3,2266.25 cw(c6043.86,2260.05) 6043.86,2278.67 ; J29.GND1@6026.3,2291.09 ccw(c6043.86,2297.29) 6043.86,2278.67 ; 6043.86,2278.71 v1(6056.86,2291.71) ; 6075.87,5604.13 ccw(c6116.57,5644.83) U60.1@6116.57,5587.27 ; 6083.76,5596.24 cw(c6054.22,5566.69) U60.1@6096,5566.69 ; 6115.9,4654.88 cw(c6143.96,4654.88) v1@6126.04,4676.48 ; 6131.86,4655.75 6130,4655.75 ; U14.34@6174.25,4655.75 6170,4655.75 6130,4655.75 ; U54.3@6198.29,6082.23 cw(c6188.37,6072.31) 6202.4,6072.31 cw(c6216.43,6072.31) U54.3@6206.51,6082.23 ; U54.3@6202.4,6100.12 6202.4,6057.6 6215.96,6044.04 v1(6256.52,6044.04) ; v1@6212.52,4033.37 v1(6215.19,4036.04) ; C172.1@6221.56,6169.11 ccw(c6211.64,6179.03) 6225.67,6179.03 ccw(c6239.7,6179.03) 6229.78,6169.11 ccw(c6239.7,6179.03) 6239.7,6165 ; C172.1@6229.78,6160.89 cw(c6239.7,6150.97) 6239.7,6165 ; C172.1@6236.46,6165 ccw(c6236.46,6201.54) Y4.4@6262.3,6175.7 ; 6249.59,6165 cw(c6249.59,6139.68) Y4.4@6269.89,6154.82 ; v1@6252.64,6040.15 ccw(c6243.25,6030.76) 6243.25,6044.04 ccw(c6243.25,6057.32) v1@6252.64,6047.93 ; C168.2@6255.22,6210.89 ccw(c6245.3,6200.97) 6245.3,6215 ccw(c6245.3,6229.03) C168.2@6255.22,6219.11 ; C168.2@6259.33,6215 6240.67,6215 6225.67,6200 C172.1@6225.67,6165 ; Y4.4@6260.27,6147.65 ccw(c6225.67,6121.84) C172.1@6225.67,6165 ; v1@6260.3,6087.26 ccw(c6250.91,6096.65) 6264.19,6096.65 ccw(c6277.47,6096.65) v1@6268.08,6087.26 ; v1(6264.19,6083.37) 6264.19,6101.69 6277.5,6115 ; Y4.4@6264.19,6165 C172.1@6225.67,6165 ; Y4.4@6266.64,6133.95 cw(c6255.55,6115) 6277.5,6115 ; Y4.4@6277.5,6156.5 6277.5,6115 ; Y4.4@6288.36,6133.95 ccw(c6299.45,6115) 6277.5,6115 ; J29.6@6292.99,1366.37 cw(c6264.25,1337.63) 6304.9,1337.63 cw(c6345.54,1337.63) J29.6@6316.8,1366.37 ; J29.6@6304.9,1404.65 6304.9,1315.1 6321.96,1298.04 6333.88,1298.04 6347.65,1311.81 6401.34,1311.81 6442.97,1270.19 6461.03,1270.19 6487.03,1296.19 6535.34,1296.19 v1@6578.52,1339.37 ; v1@6368.61,6041.3 cw(c6359.22,6031.92) 6372.5,6031.92 cw(c6385.78,6031.92) v1@6376.39,6041.3 ; Y4.2@6372.5,5993.5 v1@6372.5,6045 ; v1(6440.19,1008.37) 6458.37,1008.37 6518.78,1068.78 ; v1@6444.08,1004.49 cw(c6453.47,995.1) 6453.47,1008.37 cw(c6453.47,1021.65) v1@6444.08,1012.26 ; C174.1@6496.56,5910.89 cw(c6486.64,5900.97) 6500.67,5900.97 cw(c6514.7,5900.97) C174.1@6504.78,5910.89 ; v1@6496.78,5880.41 ccw(c6487.39,5889.8) 6500.67,5889.8 ccw(c6513.95,5889.8) v1@6504.56,5880.41 ; v1(6500.67,5876.52) C174.1@6500.67,5915 ; J30.3@6508.83,1088.39 cw(c6494.48,1068.78) 6518.78,1068.78 ; J30.3@6518.78,1128.35 6518.78,1068.78 ; J30.3@6528.72,1088.39 ccw(c6543.08,1068.78) 6518.78,1068.78 ; v1@6550.64,4646.15 cw(c6541.25,4636.76) 6554.52,4636.76 cw(c6567.8,4636.76) v1@6558.41,4646.15 ; v1(6554.52,4650.04) 6554.52,4630.48 6560.75,4624.25 6571.86,4624.25 ; 6562.97,1323.82 ccw(c6544.79,1342) v1@6570.5,1342 ; J29.3@6569.07,1404.65 6578.52,1395.2 v1@6578.52,1339.37 ; 6571.86,4624.37 6571.86,4624.25 ; v1@6572.11,1345.89 ccw(c6556.63,1361.37) J29.3@6578.52,1361.37 ; v1(6576,1342) 6576,1341.9 v1@6578.52,1339.37 ; C173.1@6655.22,5910.89 cw(c6645.3,5900.97) 6659.33,5900.97 cw(c6673.36,5900.97) C173.1@6663.44,5910.89 ; U55.2@6657.24,6425 6681.86,6425 ; C173.1@6659.33,5915 6659.33,5815.67 6675,5800 v1(6705,5800) ; U55.2@6660.73,6421.55 ccw(c6669.4,6433.91) 6680.09,6423.23 ; U55.2@6667.62,6431.37 ccw(c6677.73,6445.79) 6690.19,6433.33 ; U55.2@6668.67,6419.51 cw(c6681.86,6406.4) 6681.86,6425 ; U55.2@6668.67,6430.49 ccw(c6681.86,6443.6) 6681.86,6425 ; v1@6674.4,4737.4 ccw(c6690.66,4753.66) 6690.66,4730.67 ; 6675.87,4624.25 cw(c6675.87,4599.87) v1@6693.11,4617.11 ; v1(6679,4742) 6690.33,4730.67 C77.2@6735,4730.67 6798.29,4667.37 6798.52,4667.37 6798.52,4658.08 6800.86,4655.75 U15.34@6845.59,4655.75 6885.19,4655.75 6887.52,4658.08 6887.52,4658.37 v1(6890.19,4658.37) ; v1@6682.89,4745.89 ccw(c6719.63,4782.63) 6719.63,4730.67 ; v1@6686.11,6496.11 cw(c6676.26,6486.26) 6690.19,6486.26 ; 6690.19,6487.18 cw(c6702.82,6487.18) v1@6693.89,6496.11 ; v1@6690.99,6500 6690.19,6499.2 6690.19,6433.33 ; J10.5@6690.99,6579.01 6695,6575 v1(6725,6575) ; v1(6697,4621) 6693.75,4624.25 6571.86,4624.25 ; v1@6701.11,5796.11 ccw(c6691.72,5786.72) 6691.72,5800 ccw(c6691.72,5813.28) v1@6701.11,5803.89 ; v1@6721.11,6571.11 ccw(c6711.72,6561.72) 6711.72,6575 ccw(c6711.72,6588.28) v1@6721.11,6578.89 ; v1(6728,2370) 6728.71,2370.71 6754.29,2370.71 NT5.2@6770,2355 ; v4@6730.17,6043.59 cw(c6714.83,6028.25) 6736.52,6028.25 ; C71.2@6730.89,4403.81 cw(c6720.97,4393.89) 6735,4393.89 cw(c6749.03,4393.89) C71.2@6739.11,4403.81 ; C77.2@6730.89,4726.56 ccw(c6720.97,4716.64) 6720.97,4730.67 ccw(c6720.97,4744.7) C77.2@6730.89,4734.78 ; v1(6731.86,1124.37) 6771.98,1124.37 J30.6@6775.95,1128.35 ; v1@6731.89,2366.11 cw(c6742.99,2355.01) 6742.99,2370.71 ; v1@6731.89,2373.89 ccw(c6739.57,2381.57) 6739.57,2370.71 ; v4@6733.52,6044.37 6736.52,6041.37 6736.52,6020.37 6740,6012 U56.28@6748.52,6008.37 ; C71.2@6735,4407.92 6735,4383.37 6735.19,4383.37 6748.52,4370.04 v1(6748.52,4335.04) ; C75.2@6735,4589.96 6760.08,4615.04 v1(6767.19,4615.04) ; C75.2@6735,4595.77 ccw(c6735,4609.8) 6744.92,4599.88 ccw(c6754.84,4589.96) C75.2@6740.81,4589.96 ; C77.2@6735,4724.86 cw(c6735,4710.83) 6744.92,4720.75 cw(c6754.84,4730.67) C77.2@6740.81,4730.67 ; C73.2@6735,4830.04 6735,4825.93 6768.19,4792.74 v1(6768.19,4789.37) ; v1@6735.75,1120.49 cw(c6745.14,1111.1) 6745.14,1124.37 cw(c6745.14,1137.65) v1@6735.75,1128.26 ; v1@6744.64,4338.93 ccw(c6735.25,4348.32) 6748.52,4348.32 ccw(c6761.8,4348.32) v1@6752.41,4338.93 ; C75.2@6745.66,4600.62 cw(c6767.19,4579.09) v1@6767.19,4609.54 ; 6751.9,1124.37 cw(c6751.9,1097.29) J30.6@6771.05,1116.44 ; 6756.42,4804.51 cw(c6741.29,4789.37) v1@6762.69,4789.37 ; 6762.32,2362.68 ccw(c6770,2370.36) NT5.2@6770,2359.5 ; U56.28@6764.33,6007.05 6764.65,6006.73 6788.31,6006.73 6795,6000.04 ; NT7.2@6800,2355 6815,2370 v1(6835,2370) v1@6840,2370 ; NT7.2@6800,2359.5 ccw(c6800,2370.36) 6807.68,2362.68 ; v1@6831.11,2366.11 ccw(c6821.72,2356.72) 6821.72,2370 ccw(c6821.72,2383.28) v1@6831.11,2373.89 ; U15.34@6870.57,4655.75 ccw(c6870.57,4678) v1@6886.3,4662.26 ; v1@7009,2933.5 cw(c7009,2920.22) 7018.39,2929.61 cw(c7027.78,2939) v1@7014.5,2939 ; v1(7009,2939) 7033,2915 7095,2915 7106.5,2926.5 7106.5,3078.75 7106.5,3128.12 7125,3146.62 7125,3158.68 R295.1@7106.5,3177.18 ; R246.2@7058.44,5858.3 ccw(c7057.29,5874.14) R246.2@7069.3,5863.75 ; R246.2@7060.1,5853.11 C170.1@7100.67,5900 ; v1@7092.84,335.69 cw(c7083.45,326.3) 7096.73,326.3 cw(c7110.01,326.3) v1@7100.62,335.69 ; J29.GND2@7093.48,2280 7093.48,2313.48 7119,2339 v1(7119,2351) ; C170.1@7094.87,5899.58 cw(c7080.88,5898.57) 7091.49,5889.39 cw(c7102.1,5880.21) C170.1@7101.09,5894.2 ; J30.GND1@7096.46,254.06 J30.GND1@7096.73,254.33 v1(7096.73,339.58) ; 7101.13,2321.13 ccw(c7071.25,2351) v1@7113.5,2351 ; R295.1@7106.18,3177.5 R295.1@7106.5,3177.18 ; R300.1@7106.18,3375 7106.5,3374.68 7106.5,3325.62 7106.5,3226.88 R295.1@7106.5,3177.18 ; R290.1@7106.18,3845 7106.18,3957.7 v1(7133.52,3985.04) ; v1@7128.02,3985.04 cw(c7114.75,3985.04) 7124.14,3975.65 cw(c7133.52,3966.26) v1@7133.52,3979.54 ; v1@7157.99,5954.04 C171.2@7157.99,6005 ; C171.2@7157.99,5963.13 ccw(c7178.13,5963.13) v1@7163.89,5948.89 ; v1@7240.3,554.49 cw(c7230.91,545.1) 7244.19,545.1 cw(c7257.47,545.1) v1@7248.08,554.49 ; v1@7240.3,562.26 ccw(c7230.91,571.65) 7244.19,571.65 ccw(c7257.47,571.65) v1@7248.08,562.26 ; C94.2@7249.33,509.19 cw(c7249.33,495.16) 7259.25,505.08 cw(c7269.17,515) C94.2@7255.14,515 ; v1(7280,320) J9.5@7304.02,320 ; v1@7283.89,316.11 cw(c7293.28,306.72) 7293.28,320 cw(c7293.28,333.28) v1@7283.89,323.89 ; U19.14@7292.05,595.67 7260.67,595.67 7244.19,579.19 v1(7244.19,558.37) 7244.19,520.14 C94.2@7249.33,515 7271.14,493.19 7350.94,493.19 U18.2@7352.76,495 ; U15.12@7294.41,4624.25 7347.86,4624.25 7348.52,4624.92 7348.52,4625.04 ; C91.1@7311.56,994.11 ccw(c7301.64,1004.03) 7315.67,1004.03 ccw(c7329.7,1004.03) C91.1@7319.78,994.11 ; C91.1@7315.67,990 7315.67,1015.67 7322.37,1022.37 ; 7323.7,493.19 ccw(c7323.7,518.15) U18.2@7341.35,500.5 ; 7332.44,493.19 cw(c7332.44,480.59) U18.2@7341.35,489.5 ; v1@7342.64,4639.49 cw(c7328.42,4625.27) 7348.52,4625.27 ; v1@7343.22,1010.27 ccw(c7322.38,998.37) 7322.38,1022.37 ; v1(7346.52,4643.37) 7348.52,4641.37 7348.52,4625.04 ; R291.1@7348.82,3205 7348.82,3253.82 v1(7365,3270) ; v1@7353.44,1012.21 cw(c7365.19,1010.5) 7365.19,1022.37 ; v1@7359.5,3270 cw(c7346.22,3270) 7355.61,3260.61 cw(c7365,3251.22) v1@7365,3264.5 ; 7366.17,4621.4 cw(c7334.73,4589.96) C74.2@7379.19,4589.96 ; C92.1@7375.22,994.11 ccw(c7365.3,1004.03) 7379.33,1004.03 ccw(c7393.36,1004.03) C92.1@7383.44,994.11 ; C92.1@7379.33,990 7379.33,1019.66 7376.62,1022.37 7365.19,1022.37 ; C76.2@7380.89,4403.81 cw(c7370.97,4393.89) 7385,4393.89 cw(c7399.03,4393.89) C76.2@7389.11,4403.81 ; C72.2@7380.89,4734.78 ccw(c7370.97,4744.7) 7385,4744.7 ccw(c7399.03,4744.7) C72.2@7389.11,4734.78 ; C78.2@7380.89,4875.49 ccw(c7370.97,4885.41) 7385,4885.41 ccw(c7399.03,4885.4) C78.2@7389.11,4875.49 ; 7381.86,1039.04 7365.19,1022.37 ; C76.2@7385,4407.92 7385,4391.71 7393.33,4383.37 7398.52,4383.37 7418.19,4363.71 v1(7418.19,4359.04) ; C74.2@7385,4589.96 7385,4602.37 7385.19,4602.37 ; C72.2@7385,4730.67 7385,4763.18 v1(7396.86,4775.04) 7456.86,4775.04 7473.52,4791.71 7473.52,4840.71 7469.52,4836.71 v1(7469.52,4836.6) ; C72.2@7385,4733.14 cw(c7438.76,4733.14) 7400.75,4771.15 cw(c7410.14,4761.76) 7410.14,4775.04 cw(c7410.14,4788.32) v1@7400.75,4778.93 ; 7385,4762.11 cw(c7409.79,4762.11) v1@7392.26,4779.64 ; C78.2@7385,4871.38 7385,4895.52 v1(7417.19,4927.71) ; C74.2@7390.81,4589.96 cw(c7434.35,4589.96) 7403.56,4620.75 ; R294.1@7391.18,3095 7391.18,3043.82 7410.63,3024.37 v1(7457.52,3024.37)