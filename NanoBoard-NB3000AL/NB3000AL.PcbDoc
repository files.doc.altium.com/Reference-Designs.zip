# Altium PCB NB3000AL.PcbDoc (part 57 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
LED_PWR: LED1.1 R39.2 | length 446.5
  Top Layer w4: LED1.1@7831.19,2444.65 LED1.1@7836.54,2450 ; LED1.1@7836.6,2451 7836.6,2373.9 7857.54,2352.96 7857.54,2266.03 7945.86,2177.71 v1(7948.52,2177.71)
  Bottom Layer w4: v1@7943.16,2185.55 ccw(c7936.22,2195.71) 7948.52,2195.71 ; R39.2@7944.89,2212.63 cw(c7931.86,2198.37) 7951.18,2198.37 ; R39.2@7947.59,2215.58 cw(c7940.15,2207.44) 7951.18,2207.44 cw(c7962.21,2207.44) R39.2@7954.77,2215.58 ; v1(7948.52,2177.71) 7948.52,2195.71 ; R39.2@7951.18,2220 7951.18,2198.36 ; v1@7953.88,2185.55 cw(c7960.83,2195.71) 7948.52,2195.71 ; R39.2@7957.47,2212.63 ccw(c7970.51,2198.37) 7951.18,2198.37 ; 7948.52,2195.71 7951.18,2198.36
LEDS#.LED0.BLUE: J28.9 R171.2 U32.4 | length 2334.4
  Top Layer w4: U32.4@3890.69,3940.4 ccw(c3883.86,3933.57) 3883.86,3943.23 ccw(c3883.86,3952.89) U32.4@3890.69,3946.06 ; U32.4@3920,3943.23 3881.86,3943.23 3873.52,3934.89 3873.52,3887.71 3881.86,3879.37 3985.86,3879.37 ; v2@4010.41,3467.28 ccw(c3993.67,3484.03) 4017.35,3484.03 ccw(c4041.04,3484.03) v2@4024.29,3467.28 ; v2@4013.24,3464.46 ccw(c4003.32,3474.38) 4017.35,3474.38 ccw(c4031.38,3474.38) v2@4021.46,3464.46 ; v2(4017.35,3460.35) 4017.35,3510.73 4073.52,3566.9 4073.52,3763.18 4065,3771.71 4015.19,3771.71 4006.86,3780.04 4006.86,3858.37 3992.19,3873.04 ; J28.9@4220.33,3972.22 ccw(c4210.31,3962.2) 4210.31,3976.38 ccw(c4210.31,3990.56) J28.9@4220.33,3980.53 ; J28.9@4248.52,3976.38 4189.66,3976.38 4185,3981.04 4092.52,3981.04 4089.7,3983.87 4070.29,3983.87 4006.86,3920.44 4006.86,3887.71 3992.19,3873.04 ; R171.2@4428.19,3257.08 cw(c4419.59,3245.75) 4433.82,3245.75 ; R171.2@4433.82,3265 4433.82,3245.75 ; R171.2@4439.45,3257.08 ccw(c4448.04,3245.75) 4433.82,3245.75 ; v1(4448.34,3231.23) 4448.52,3231.04 4433.82,3245.75 ; 3985.86,3879.37 3992.19,3873.04 ; 3985.86,3879.37 3992.19,3873.04
  MidLayer2 w4: v2(3995,3220) 4017.37,3242.37 4217.5,3242.37 4253.84,3278.71 v1(4353.52,3278.71) ; v2@3995,3225.81 ccw(c3995,3239.84) 4004.92,3229.92 ccw(c4014.84,3220) v2@4000.81,3220 ; v2@3995,3229.81 ccw(c3995,3253.5) 4011.75,3236.75 ccw(c4028.5,3220) v2@4004.81,3220 ; v1@4346.81,3271.99 ccw(c4330.59,3255.77) 4330.59,3278.71 ccw(c4330.59,3301.64) v1@4346.81,3285.43 ; v1@4349.64,3274.82 ccw(c4340.25,3265.43) 4340.25,3278.71 ccw(c4340.25,3291.99) v1@4349.64,3282.6
  Bottom Layer w4: v2@3988.06,3226.94 ccw(c3971.31,3243.69) 3995,3243.69 ccw(c4018.69,3243.69) v2@4001.94,3226.94 ; v2@3990.89,3224.11 ccw(c3980.97,3234.03) 3995,3234.03 ccw(c4009.03,3234.03) v2@3999.11,3224.11 ; v2(3995,3220) 3995,3278.14 4006.86,3290 4006.86,3317.98 4029.52,3340.65 4029.52,3427.37 4017.7,3439.2 4017.7,3460 v2(4017.35,3460.35) ; v2@4011.22,3452.69 cw(c4000.42,3439.2) 4017.7,3439.2 cw(c4036.25,3439.2) v2@4023.89,3453.03 ; v2@4013.72,3455.81 cw(c4007.08,3447.53) 4017.7,3447.53 ; 4017.7,3448.14 cw(c4028.26,3448.14) v2@4021.22,3456.01 ; v1(4353.52,3278.71) 4436.52,3278.71 4448.52,3266.71 4448.52,3231.04 v1(4448.34,3231.23) ; v1@4357.41,3274.82 cw(c4366.8,3265.43) 4366.8,3278.71 cw(c4366.8,3291.99) v1@4357.41,3282.6 ; v1@4360.24,3271.99 cw(c4376.46,3255.77) 4376.46,3278.71 cw(c4376.46,3301.64) v1@4360.24,3285.43 ; v1@4441.62,3237.95 ccw(c4424.95,3254.62) 4448.52,3254.62 ; v1@4444.45,3235.12 ccw(c4434.61,3244.96) 4448.52,3244.96 ; 4448.52,3244.05 ccw(c4461.16,3244.05) v1@4452.23,3235.12 ; 4448.52,3253.71 ccw(c4470.82,3253.71) v1@4455.05,3237.95
LEDS#.LED0.GREEN: J28.11 R172.2 U32.6 | length 1858.4
  Top Layer w4: U32.6@3920,3892.05 3962.2,3892.05 3970.52,3900.37 ; U32.6@3949.31,3889.22 cw(c3956.14,3882.39) 3956.14,3892.05 cw(c3956.14,3901.71) U32.6@3949.31,3894.88 ; v1@3979.02,3895.53 ccw(c3970.52,3890.51) 3970.52,3900.37 ; v1@3979.02,3905.21 cw(c3970.52,3910.24) 3970.52,3900.37 ; v1(3987.19,3900.37) 3970.52,3900.37 ; v1(4173.52,3656.37) 4198.52,3681.37 4274.19,3681.37 4288.86,3666.71 4402.29,3666.71 4403.45,3665.55 4403.45,3623.45 4490.19,3536.71 4519.54,3536.71 4525.19,3531.06 4525.19,3450 4515.19,3440 4515.19,3413.37 4523.52,3405.04 4531.86,3405.04 4540.19,3396.71 4540.19,3370.04 4510.52,3340.37 4439.82,3340.37 4433.82,3334.37 ; v1@4173.52,3661.87 ccw(c4173.52,3675.15) 4182.91,3665.76 ccw(c4192.3,3656.37) v1@4179.02,3656.37 ; v1@4173.52,3665.87 ccw(c4173.52,3688.81) 4189.74,3672.59 ccw(c4205.96,3656.37) v1@4183.02,3656.37 ; v1@4199.58,3932.31 cw(c4210.92,3920.98) 4210.92,3937.01 ; v1@4202.16,3937.01 J28.11@4246.61,3937.01 ; v1@4202.41,3929.49 cw(c4220.57,3911.33) J28.11@4220.57,3937.01 ; v1@4205.24,3926.66 cw(c4230.23,3901.67) J28.11@4230.23,3937.01 ; v1@4205.24,3940.09 ccw(c4212.69,3947.54) 4212.69,3937.01 ; R172.2@4431.98,3332.13 ccw(c4431.53,3334.37) 4433.82,3334.37 ; R172.2@4433.82,3322.5 4433.82,3334.37 ; R172.2@4435.66,3332.13 cw(c4436.11,3334.37) 4433.82,3334.37
  MidLayer1 w4: v1(3987.19,3900.37) 4054.79,3900.37 4095,3860.17 4095,3800.9 4149.02,3746.88 4173.52,3722.37 v1(4173.52,3656.37) ; v1@3991.08,3896.49 cw(c4000.47,3887.1) 4000.47,3900.37 cw(c4000.47,3913.65) v1@3991.08,3904.26 ; v1@3993.91,3893.66 cw(c4010.13,3877.44) 4010.13,3900.37 cw(c4010.13,3923.31) v1@3993.91,3907.09 ; v1@4166.81,3663.09 ccw(c4150.59,3679.31) 4173.52,3679.31 ccw(c4196.46,3679.31) v1@4180.24,3663.09 ; v1@4169.64,3660.26 ccw(c4160.25,3669.65) 4173.52,3669.65 ccw(c4186.8,3669.65) v1@4177.41,3660.26
  Bottom Layer w4: v1(3987.19,3900.37) 4020.19,3933.37 v1(4198.52,3933.37) ; v1@3987.19,3905.87 ccw(c3987.19,3919.15) 3996.58,3909.76 ccw(c4005.97,3900.37) v1@3992.69,3900.37 ; v1@3987.19,3909.87 ccw(c3987.19,3932.81) 4003.41,3916.59 ccw(c4019.63,3900.37) v1@3996.69,3900.37 ; v1@4191.81,3926.66 ccw(c4175.59,3910.44) 4175.59,3933.37 ccw(c4175.59,3956.31) v1@4191.81,3940.09 ; v1@4194.64,3929.49 ccw(c4185.25,3920.1) 4185.25,3933.37 ccw(c4185.25,3946.65) v1@4194.64,3937.26
LEDS#.LED0.RED: J28.6 R170.2 U32.2 | length 1936.4
  Top Layer w4: v1@3866.06,4001.06 ccw(c3882.12,4017.12) 3882.12,3994.41 ; v1@3868.89,4003.89 ccw(c3891.77,4026.77) U32.2@3891.77,3994.41 ; v1@3871.19,4000.04 3876.82,3994.41 U32.2@3920,3994.41 ; v1@3871.72,4006.72 ccw(c3901.43,4036.43) U32.2@3901.43,3994.41 ; U32.2@3890.69,3991.58 ccw(c3883.86,3984.75) 3883.86,3994.41 ccw(c3883.86,4004.07) U32.2@3890.69,3997.24 ; J28.6@4323.39,4035.43 4365.8,4035.43 v1@4373.52,4027.71 ; J28.6@4349.12,4035.43 ccw(c4349.12,4060.44) v1@4366.81,4042.76 ; J28.6@4349.67,4031.28 cw(c4359.69,4021.25) 4359.69,4035.43 cw(c4359.69,4049.61) J28.6@4349.67,4039.59 ; J28.6@4352.06,4035.43 cw(c4352.06,4014.57) 4366.81,4029.32 cw(c4350.59,4013.11) 4373.52,4013.11 cw(c4396.46,4013.11) v1@4380.24,4029.32 ; 4358.78,4035.43 ccw(c4358.78,4050.79) v1@4369.64,4039.93 ; 4361.71,4035.43 cw(c4361.71,4024.23) 4369.64,4032.15 cw(c4360.25,4022.76) 4373.52,4022.76 cw(c4386.8,4022.76) v1@4377.41,4032.15 ; v1(4373.52,4036.04) v1@4373.52,4027.71 ; v1@4401.52,3445.87 cw(c4401.52,3422.94) 4417.74,3439.16 cw(c4433.96,3455.37) v1@4411.02,3455.37 ; v1@4401.52,3449.87 cw(c4401.52,3436.6) 4410.91,3445.99 cw(c4420.3,3455.37) v1@4407.02,3455.37 ; v1(4401.52,3455.37) 4433.82,3423.08 R170.2@4433.82,3380 ; 4413.17,3928.07 cw(c4394.81,3909.71) v1@4420.77,3909.71 ; 4416.19,3925.05 ccw(c4430.27,3939.13) v1@4430.27,3919.21 ; 4419.99,3921.24 cw(c4408.47,3909.71) v1@4424.77,3909.71 ; R170.2@4427.23,3387.08 ccw(c4411.32,3402.99) 4433.82,3402.99 ccw(c4456.32,3402.99) R170.2@4440.41,3387.08 ; R170.2@4430.06,3384.25 ccw(c4420.98,3393.33) 4433.82,3393.33 ccw(c4446.66,3393.33) R170.2@4437.58,3384.25 ; v1(4430.27,3909.71) 4430.27,3910.96 4381.86,3959.37 4381.86,3990 4373.52,3998.33 v1@4373.52,4027.71
  MidLayer1 w4: v1@4394.81,3462.09 ccw(c4385.83,3471.07) 4398.52,3471.07 ; 4398.52,3475.9 ccw(c4422.04,3475.9) v1@4405.41,3459.26 ; 4398.52,3485.55 ccw(c4431.7,3485.55) v1@4408.24,3462.09 ; v1(4401.52,3455.37) 4398.52,3458.37 4398.52,3531.71 4443.86,3577.04 4443.86,3897.37 4430.27,3910.96 v1(4430.27,3909.71)
  Bottom Layer w4: v1(3865,4000) 3926.54,4061.54 4009.25,4061.54 4046,4024.79 4193.31,4024.79 4204.56,4036.04 v1(4373.52,4036.04) ; v1@3865,4005.5 ccw(c3865,4018.78) 3874.39,4009.39 ccw(c3883.78,4000) v1@3870.5,4000 ; v1@3865,4009.5 ccw(c3865,4032.43) 3881.22,4016.22 ccw(c3897.43,4000) v1@3874.5,4000 ; v1@4366.81,4029.32 ccw(c4350.59,4013.11) 4350.59,4036.04 ccw(c4350.59,4058.98) v1@4366.81,4042.76 ; v1@4369.64,4032.15 ccw(c4360.25,4022.76) 4360.25,4036.04 ccw(c4360.25,4049.32) v1@4369.64,4039.93
LEDS#.LED1.BLUE: J28.12 R174.2 U32.10 | length 4091.3
  Top Layer w4: v1@4033.47,3880.09 ccw(c4017.26,3896.31) 4040.19,3896.31 ccw(c4063.13,3896.31) v1@4046.91,3880.09 ; v1@4036.3,3877.26 ccw(c4026.91,3886.65) 4040.19,3886.65 ccw(c4053.47,3886.65) v1@4044.08,3877.26 ; v1(4040.19,3873.37) 4040.19,3915.19 4050.47,3925.46 4092.36,3925.46 4100.19,3917.64 U32.10@4138.5,3917.64 ; U32.10@4109.2,3914.81 ccw(c4102.37,3907.98) 4102.37,3917.64 ccw(c4102.37,3927.3) U32.10@4109.2,3920.47 ; J28.12@4323.39,3917.32 4364.14,3917.32 v1@4366.47,3914.99 ; J28.12@4337.25,3917.32 cw(c4337.25,3879.77) v1@4363.81,3906.32 ; J28.12@4346.91,3917.32 cw(c4346.91,3889.42) v1@4366.64,3909.15 ; 4356.57,3917.32 cw(c4356.57,3899.08) v1@4369.46,3911.98 ; 4357.93,3917.32 ccw(c4357.93,3925.64) v1@4363.81,3919.76 ; v1@4366.47,3914.76 v1@4368.19,3913.04 ; R174.2@5137.71,2687.47 cw(c5126.09,2674.08) 5143.82,2674.08 ; R174.2@5140.33,2690.49 cw(c5133.7,2682.85) 5143.82,2682.85 cw(c5153.94,2682.85) R174.2@5147.31,2690.49 ; R174.2@5143.82,2695 5143.82,2674.08 ; R174.2@5149.93,2687.47 ccw(c5161.55,2674.08) 5143.82,2674.08 ; v1(5165.19,2641.71) 5165.19,2652.71 5143.82,2674.08
  MidLayer1 w4: v1@4033.47,2615.09 ccw(c4017.26,2631.31) 4040.19,2631.31 ccw(c4063.13,2631.31) v1@4046.91,2615.09 ; v1@4036.3,2612.26 ccw(c4026.91,2621.65) 4040.19,2621.65 ccw(c4053.47,2621.65) v1@4044.08,2612.26 ; v1(4040.19,2608.37) 4040.19,3063.12 4158.1,3181.03 4257.18,3181.03 4273.52,3197.37 4273.52,3250.04 4280.52,3257.04 4280.52,3802.02 4370.52,3892.02 ; v1@4364.25,3905.91 cw(c4352.03,3892.02) 4370.52,3892.02 ; v1@4366.89,3908.91 cw(c4359.81,3900.87) 4370.52,3900.87 cw(c4381.23,3900.87) v1@4374.16,3908.91 ; v1(4370.52,3913.04) 4370.52,3892.02 ; v1@4376.8,3905.91 ccw(c4389.02,3892.02) 4370.52,3892.02
  MidLayer2 w4: v1@4033.47,2601.66 cw(c4017.26,2585.44) 4040.19,2585.44 cw(c4063.13,2585.44) v1@4046.91,2601.66 ; v1@4033.47,3880.09 ccw(c4017.26,3896.31) 4040.19,3896.31 ccw(c4063.13,3896.31) v1@4046.91,3880.09 ; v1@4036.3,2604.49 cw(c4026.91,2595.1) 4040.19,2595.1 cw(c4053.47,2595.1) v1@4044.08,2604.49 ; v1@4036.3,3877.26 ccw(c4026.91,3886.65) 4040.19,3886.65 ccw(c4053.47,3886.65) v1@4044.08,3877.26 ; v1(4040.19,2608.37) 4040.19,2494.81 4049,2486 4344.25,2486 4350.75,2492.5 4372.25,2492.5 4378.75,2486 4433.37,2486 4465.69,2518.32 4465.69,2520.54 4494.69,2549.54 4586.5,2549.54 4635.19,2598.23 4635.19,2607.81 4685.08,2657.71 4903.15,2657.71 4944.48,2616.37 5061.37,2616.37 5095,2650 5113.37,2650 5121.67,2641.71 v1(5165.19,2641.71) ; v1(4040.19,3873.37) 4040.19,3965.19 4047,3972 4181.85,3972 4195.47,3958.37 4325.19,3958.37 v1(4370.52,3913.04) ; v1@4361.02,3913.04 ccw(c4338.09,3913.04) 4354.31,3929.26 ccw(c4370.52,3945.48) v1@4370.52,3922.54 ; v1@4365.02,3913.04 ccw(c4351.75,3913.04) 4361.14,3922.43 ccw(c4370.52,3931.82) v1@4370.52,3918.54 ; v1@5158.47,2634.99 ccw(c5142.26,2618.77) 5142.26,2641.71 ccw(c5142.26,2664.64) v1@5158.47,2648.43 ; v1@5161.3,2637.82 ccw(c5151.91,2628.43) 5151.91,2641.71 ccw(c5151.91,2654.99) v1@5161.3,2645.6
LEDS#.LED1.GREEN: J28.8 R175.2 U32.12 | length 3270.6
  Top Layer w4: U32.12@4109.2,3965.99 ccw(c4102.37,3959.16) 4102.37,3968.82 ccw(c4102.37,3978.48) U32.12@4109.2,3971.65 ; U32.12@4138.5,3968.82 4088.08,3968.82 4081.86,3975.04 4072.77,3975.04 4015.19,3917.46 4015.19,3858.37 4056.86,3816.71 4148.52,3816.71 4190.19,3858.37 4190.19,3891.71 4215.19,3916.71 4273.19,3916.71 4289.86,3933.37 4350.86,3933.37 4365.19,3947.71 ; J28.8@4323.39,3996.06 4355.39,3996.06 ; J28.8@4350.67,3993.26 cw(c4355.39,3990.7) 4355.39,3996.06 ; J28.8@4350.67,3998.87 ccw(c4355.39,4001.42) 4355.39,3996.06 ; v1(4681.86,2600.04) 4698.86,2617.04 4698.86,2746.73 4581.86,2863.73 4581.86,3000.04 4615.19,3033.37 4615.19,3475.04 4606.86,3483.37 4606.86,3550 4588.15,3568.71 4503.45,3568.71 4465.19,3606.96 4465.19,3666.1 4453.5,3677.79 4453.5,3703.88 4446.52,3710.85 4446.52,3748.01 4440.69,3753.85 4440.69,3872.21 4365.19,3947.71 ; v1@4681.86,2605.54 ccw(c4681.86,2618.82) 4691.25,2609.43 ccw(c4700.64,2600.04) v1@4687.36,2600.04 ; v1@4681.86,2609.54 ccw(c4681.86,2632.48) 4698.07,2616.26 ccw(c4714.29,2600.04) v1@4691.36,2600.04 ; R175.2@5138.56,2749.31 cw(c5131.76,2739.36) 5143.82,2739.36 ; R175.2@5143.82,2757.5 5143.82,2739.35 ; R175.2@5149.08,2749.31 ccw(c5155.88,2739.36) 5143.82,2739.36 ; v1(5190.19,2591.71) 5190.19,2591.96 5147.69,2634.46 5147.69,2658.89 5126.5,2680.08 5126.5,2722.04 5142.15,2737.69 5143.82,2739.35 ; 4355.39,3996.06 4365.19,3986.26 4365.19,3947.71
  MidLayer2 w4: v1(4681.86,2600.04) 4715.52,2633.71 4893.21,2633.71 4934.54,2592.37 5114.75,2592.37 5122.42,2600.04 5144.71,2600.04 5153.04,2591.71 v1(5190.19,2591.71) ; v1@4681.86,2605.54 ccw(c4681.86,2618.82) 4691.25,2609.43 ccw(c4700.64,2600.04) v1@4687.36,2600.04 ; v1@4681.86,2609.54 ccw(c4681.86,2632.48) 4698.07,2616.26 ccw(c4714.29,2600.04) v1@4691.36,2600.04 ; v1@5183.47,2584.99 ccw(c5167.26,2568.77) 5167.26,2591.71 ccw(c5167.26,2614.64) v1@5183.47,2598.43 ; v1@5186.3,2587.82 ccw(c5176.91,2578.43) 5176.91,2591.71 ccw(c5176.91,2604.99) v1@5186.3,2595.6
LEDS#.LED1.RED: J28.10 R173.2 U32.8 | length 3024.7
  Top Layer w4: v1@4117.43,3847.33 ccw(c4106.51,3860.37) 4123.52,3860.37 ; v1@4120,3844.26 ccw(c4113.68,3851.81) 4123.52,3851.81 ccw(c4133.37,3851.81) v1@4127.05,3844.26 ; 4123.33,3860.37 ccw(c4123.33,3864.97) U32.8@4127.89,3864.37 ; v1(4123.52,3840.04) 4123.52,3860.37 ; 4127.9,3860.37 ccw(c4127.9,3864.36) U32.8@4131.85,3863.84 ; v1@4129.62,3847.33 cw(c4140.53,3860.37) 4123.52,3860.37 ; 4132.46,3860.37 ccw(c4132.46,3863.76) U32.8@4135.82,3863.32 ; 4137.02,3860.37 ccw(c4137.02,3863.16) U32.8@4139.78,3862.8 ; U32.8@4138.5,3866.46 4123.52,3866.46 4123.52,3860.37 ; 4141.58,3860.37 ccw(c4141.58,3862.56) U32.8@4143.75,3862.27 ; 4146.14,3860.37 ccw(c4146.14,3861.96) U32.8@4147.71,3861.75 ; 4150.71,3860.37 ccw(c4150.71,3861.36) U32.8@4151.68,3861.23 ; 4155.27,3860.37 ccw(c4155.27,3860.75) U32.8@4155.65,3860.7 ; U32.8@4164.01,3862.58 ccw(c4165.77,3869.58) U32.8@4170.88,3864.48 ; U32.8@4164.98,3866.46 ccw(c4167.77,3877.56) 4175.87,3869.47 ; U32.8@4165.96,3870.34 ccw(c4169.77,3885.54) 4180.86,3874.46 ; J28.10@4297.11,3952.54 ccw(c4287.08,3942.51) 4287.08,3956.69 ccw(c4287.08,3970.87) J28.10@4297.11,3960.85 ; J28.10@4323.39,3956.69 4190.19,3956.69 4180.86,3947.36 4180.86,3874.46 ; v1(5098.19,2816.37) 5103.9,2816.37 5107.52,2820 R173.2@5143.82,2820 ; v1@5099.25,2815.31 cw(c5110.56,2804) 5110.56,2820 ; v1@5102.08,2812.49 cw(c5120.22,2794.35) 5120.22,2820 ; v1@5104.91,2809.66 cw(c5129.88,2784.69) 5129.88,2820 ; v1@5104.91,2823.09 ccw(c5112.37,2830.56) 5112.37,2820 ; R173.2@5137.23,2813.41 ccw(c5121.32,2797.5) 5121.32,2820 ccw(c5121.32,2842.5) R173.2@5137.23,2826.59 ; R173.2@5140.06,2816.24 ccw(c5130.98,2807.16) 5130.98,2820 ccw(c5130.98,2832.84) R173.2@5140.06,2823.76 ; 4123.52,3860.37 4166.77,3860.37 4180.86,3874.46
  MidLayer2 w4: v1(4058.52,3508.37) 4123.37,3508.37 4127,3512 4127,3593.84 4089.69,3631.15 ; v1@4062.41,3504.49 cw(c4071.8,3495.1) 4071.8,3508.37 cw(c4071.8,3521.65) v1@4062.41,3512.26 ; v1@4065.24,3501.66 cw(c4081.46,3485.44) 4081.46,3508.37 cw(c4081.46,3531.31) v1@4065.24,3515.09 ; v1@4116.81,3833.32 cw(c4100.59,3817.11) 4123.52,3817.11 cw(c4146.46,3817.11) v1@4130.24,3833.32 ; v1@4119.64,3836.15 cw(c4110.25,3826.76) 4123.52,3826.76 cw(c4136.8,3826.76) v1@4127.41,3836.15 ; v1(4123.52,3840.04) 4123.52,3686.1 4089.69,3652.27 ; 4089.69,3631.15 4089.69,3652.27 ; 4089.69,3631.15 4089.69,3652.27
  Bottom Layer w4: v1@4051.81,3501.66 cw(c4044.1,3493.95) 4055,3493.95 ; 4055,3476.93 cw(c4089.97,3476.93) v1@4065.24,3501.66 ; 4055,3486.59 cw(c4080.31,3486.59) v1@4062.41,3504.49 ; 4055,3496.25 cw(c4070.65,3496.25) v1@4059.58,3507.31 ; v1(4058.52,3508.37) 4055,3504.85 4055,3470 4085,3440 4085,3420 ; 4085.07,3419.93 4053.52,3388.37 4053.52,3324.98 4060.19,3318.31 4060.19,3030.04 4117.69,2972.54 4366.03,2972.54 4368.53,2975.04 4411.86,2975.04 4481.02,2905.87 4654.13,2905.87 4752.5,2807.5 5089.32,2807.5 v1(5098.19,2816.37) ; 5053.83,2807.5 ccw(c5053.83,2860.74) v1@5091.47,2823.09 ; 5063.49,2807.5 ccw(c5063.49,2851.08) v1@5094.3,2820.26 ; 5073.14,2807.5 ccw(c5073.14,2841.42) v1@5097.13,2817.44 ; 5082.8,2807.5 ccw(c5082.8,2831.76) v1@5099.96,2814.61
LEDS#.LED2.BLUE: J28.16 R177.2 U33.4 | length 2349.7
  Top Layer w4: J28.16@4323.39,3838.58 4418.32,3838.58 ; J28.16@4349.67,3834.43 cw(c4359.69,3824.4) 4359.69,3838.58 cw(c4359.69,3852.76) J28.16@4349.67,3842.74 ; 4431.86,3825.04 4418.32,3838.58 ; v1(4565.19,3211.37) 4598.52,3244.71 4598.52,3325.04 4590.19,3333.37 4573.52,3333.37 4559.19,3347.71 4559.19,3535 4533.48,3560.71 4500.13,3560.71 4456.86,3603.98 4456.86,3650 4456.86,3663.12 4445.5,3674.48 4445.5,3700.56 4438.52,3707.54 4438.52,3744.7 4432.69,3750.54 4432.69,3824.21 4418.32,3838.58 ; v1@4565.19,3216.87 ccw(c4565.19,3230.15) 4574.58,3220.76 ccw(c4583.97,3211.37) v1@4570.69,3211.37 ; v1@4565.19,3220.87 ccw(c4565.19,3243.81) 4581.41,3227.59 ccw(c4597.63,3211.37) v1@4574.69,3211.37 ; v1@5007.47,3015.09 ccw(c4991.26,3031.31) 5014.19,3031.31 ccw(c5037.13,3031.31) v1@5020.91,3015.09 ; v1@5010.3,3012.26 ccw(c5000.91,3021.65) 5014.19,3021.65 ccw(c5027.47,3021.65) v1@5018.08,3012.26 ; v1(5014.19,3008.37) 5014.19,3054.19 5048.23,3088.23 U33.4@5125,3088.23 ; U33.4@5095.69,3085.4 ccw(c5088.86,3078.57) 5088.86,3088.23 ccw(c5088.86,3097.88) U33.4@5095.69,3091.06
  Bottom Layer w4: R177.2@4414.59,3077.92 cw(c4398.68,3062.01) 4421.18,3062.01 ; R177.2@4416.81,3093.72 ccw(c4412.95,3100.99) 4421.18,3100.99 ; R177.2@4417.42,3080.75 cw(c4408.34,3071.67) 4421.18,3071.67 cw(c4434.02,3071.67) R177.2@4424.94,3080.75 ; R177.2@4425.55,3093.72 cw(c4429.41,3100.99) 4421.18,3100.99 ; R177.2@4427.77,3077.92 ccw(c4443.68,3062.01) 4421.18,3062.01 ; 4556.86,3168.32 cw(c4608.24,3168.32) v1@4571.91,3204.66 ; 4556.86,3177.98 cw(c4598.59,3177.98) v1@4569.08,3207.49 ; 4556.86,3187.64 cw(c4588.93,3187.64) v1@4566.25,3210.31 ; 4556.86,3197.29 cw(c4579.27,3197.29) v1@4563.42,3213.14 ; v1(4565.19,3211.37) 4556.86,3203.04 4556.86,3166.71 4548.52,3158.37 4520.54,3158.37 4507.88,3171.04 4472.5,3171.04 4443.5,3142.03 4443.5,3123.31 4421.18,3100.99 ; v1@5007.47,3001.66 ccw(c4991.26,2985.44) 4991.26,3008.37 ccw(c4991.26,3031.31) v1@5007.47,3015.09 ; v1@5010.3,3004.49 ccw(c5000.91,2995.1) 5000.91,3008.37 ccw(c5000.91,3021.65) v1@5010.3,3012.26 ; v1(5014.19,3008.37) 4965.13,3008.37 4921.8,2965.04 4606.86,2965.04 4538.52,3033.37 4449.82,3033.37 4421.18,3062.01 ; 4421.18,3062.01 R177.2@4421.18,3085 4421.18,3100.99
LEDS#.LED2.GREEN: J28.18 R178.2 U33.6 | length 2695.9
  Top Layer w4: J28.18@4323.39,3799.21 4361.39,3799.21 4413.18,3747.42 4422.52,3738.07 4422.52,3691.71 4420.82,3690 v1(4420,3690) ; J28.18@4349.67,3795.06 cw(c4359.69,3785.03) 4359.69,3799.21 cw(c4359.69,3813.39) J28.18@4349.67,3803.37 ; U33.6@5125,3037.05 5162.85,3037.05 5172.69,3027.2 5172.69,3024.46 5173.52,3023.63 v1(5173.52,3008.37) ; U33.6@5154.31,3034.22 cw(c5161.14,3027.39) 5161.14,3037.05 cw(c5161.14,3046.7) U33.6@5154.31,3039.88
  Bottom Layer w4: 4404.43,3125.13 cw(c4421.18,3108.38) R178.2@4421.18,3132.06 ; 4405.62,3126.31 ccw(c4390.55,3141.38) R178.2@4411.86,3141.38 ; R178.2@4411.26,3131.96 cw(c4421.18,3122.04) R178.2@4421.18,3136.06 ; R178.2@4412.45,3133.14 ccw(c4404.21,3141.38) R178.2@4415.86,3141.38 ; v1(4420,3690) 4420.82,3690 4422.52,3691.71 4405.86,3675.04 4123.52,3675.04 4090.19,3641.71 4090.19,3607.46 4131.36,3566.29 4131.36,3489.22 4140.52,3480.06 4140.52,3199.71 4231.86,3108.37 4387.68,3108.37 R178.2@4421.18,3141.88 4432.02,3141.88 4469.52,3179.37 4510.86,3179.37 4521.02,3169.21 4539.21,3169.21 4547.19,3177.19 4547.19,3242.27 4579.96,3275.04 4627.86,3275.04 4631.86,3271.04 4631.86,3133.37 4648.52,3116.71 4698.52,3116.71 4740.19,3075.04 4740.19,3050.37 4756.86,3033.71 4945.21,3033.71 4968.24,3056.74 4986.37,3074.87 5059.65,3074.87 5074.3,3074.87 5140.8,3008.37 v1(5173.52,3008.37) ; R178.2@4421.18,3139.69 ccw(c4421.18,3160.58) 4435.96,3145.81 ; R178.2@4421.18,3143.69 ccw(c4421.18,3174.24) 4442.78,3152.63 ; R178.2@4428.2,3146.3 ccw(c4428.2,3166.03) 4442.15,3152.08 ; v1@5166.81,3001.66 ccw(c5150.59,2985.44) 5150.59,3008.37 ccw(c5150.59,3031.31) v1@5166.81,3015.09 ; v1@5169.64,3004.49 ccw(c5160.25,2995.1) 5160.25,3008.37 ccw(c5160.25,3021.65) v1@5169.64,3012.26
LEDS#.LED2.RED: J28.13 R176.2 U33.2 | length 2549.9
  Top Layer w4: J28.13@4246.61,3897.64 4281.86,3897.64 ; J28.13@4273.12,3893.73 cw(c4281.86,3885.93) 4281.86,3897.64 ; J28.13@4273.12,3901.55 ccw(c4281.86,3909.34) 4281.86,3897.64 ; 4451.86,3210 4458.56,3216.71 ; v1(4473.52,3216.71) 4458.56,3216.71 ; v1@5066.81,3115.09 ccw(c5050.59,3131.31) 5073.52,3131.31 ccw(c5096.46,3131.31) v1@5080.24,3115.09 ; v1@5069.64,3112.26 ccw(c5060.25,3121.65) 5073.52,3121.65 ccw(c5086.8,3121.65) v1@5077.41,3112.26 ; v1(5073.52,3108.37) 5073.52,3133.52 5079.41,3139.41 U33.2@5125,3139.41 ; 4281.86,3897.64 4283.52,3895.97 4283.52,3828.71 4295.52,3816.71 4356.71,3816.71 4370.58,3830.58 4415,3830.58 ; 4415,3830.58 4423.86,3821.73 ; 4415,3830.58 4423.86,3821.73 ; 4423.86,3821.73 4424.69,3820.9 4424.69,3775.4 4424.69,3760 4424.69,3747.23 4430.52,3741.39 4430.52,3704.22 4437.5,3697.25 4437.5,3690 ; 4437.5,3671.16 4437.5,3682.75 4437.5,3690 ; 4437.5,3671.16 4448.52,3660.14 4448.52,3654.27 4448.52,3640 4448.52,3601 4496.82,3552.71 4529.19,3552.71 4551.19,3530.71 4551.19,3312.9 4530,3291.71 4425.19,3291.71 4415.19,3281.71 4415.19,3216.71 4423.52,3208.37 4450.23,3208.37 4458.56,3216.71 ; 4437.5,3671.16 4437.5,3690
  MidLayer1 w4: v1@4473.52,3207.21 cw(c4473.52,3184.27) 4489.74,3200.49 cw(c4505.96,3216.71) v1@4483.02,3216.71 ; v1@4473.52,3211.21 cw(c4473.52,3197.93) 4482.91,3207.32 cw(c4492.3,3216.71) v1@4479.02,3216.71 ; v1(4473.52,3216.71) 4515.19,3175.04 4515.19,3009.37 v1(4559.52,2965.04) ; v1@4550.02,2965.04 ccw(c4527.09,2965.04) 4543.31,2981.26 ccw(c4559.52,2997.48) v1@4559.52,2974.54 ; v1@4554.02,2965.04 ccw(c4540.75,2965.04) 4550.14,2974.43 ccw(c4559.52,2983.82) v1@4559.52,2970.54
  MidLayer2 w4: v1(4559.52,2965.04) 4700.19,2965.04 4706.86,2958.37 4828.37,2958.37 4978.37,3108.37 v1(5073.52,3108.37) ; v1@4563.41,2961.15 cw(c4572.8,2951.76) 4572.8,2965.04 cw(c4572.8,2978.32) v1@4563.41,2968.93 ; v1@4566.24,2958.32 cw(c4582.46,2942.11) 4582.46,2965.04 cw(c4582.46,2987.98) v1@4566.24,2971.76 ; v1@5066.81,3101.66 ccw(c5050.59,3085.44) 5050.59,3108.37 ccw(c5050.59,3131.31) v1@5066.81,3115.09 ; v1@5069.64,3104.49 ccw(c5060.25,3095.1) 5060.25,3108.37 ccw(c5060.25,3121.65) v1@5069.64,3112.26
  Bottom Layer w4: R176.2@4421.18,3198.75 4440.86,3198.75 ; R176.2@4428.39,3192.85 cw(c4440.86,3182.64) 4440.86,3198.75 ; R176.2@4428.39,3204.65 ccw(c4440.86,3214.86) 4440.86,3198.75 ; 4455.42,3208.37 ccw(c4455.42,3221.63) v1@4468.22,3218.15 ; 4460.66,3208.37 ccw(c4460.66,3220.21) v1@4472.08,3217.1 ; v1@4464.36,3219.2 cw(c4450.19,3223.06) 4450.19,3208.37 ; v1(4473.52,3216.71) 4465.19,3208.37 4450.19,3208.37 ; 4440.86,3198.75 4440.86,3199.04 4450.19,3208.37
LEDS#.LED3.BLUE: J28.19 R180.2 U33.10 | length 2447.3
  Top Layer w4: v1@4133.47,3623.43 ccw(c4117.26,3639.64) 4140.19,3639.64 ccw(c4163.13,3639.64) v1@4146.91,3623.43 ; v1@4136.3,3620.6 ccw(c4126.91,3629.99) 4140.19,3629.99 ccw(c4153.47,3629.99) v1@4144.08,3620.6 ; v1(4140.19,3616.71) 4140.19,3710.19 4180,3750 4180,3775 4185,3780 4246.14,3780 J28.19@4246.61,3779.53 ; 4209.17,3780 cw(c4209.17,3764.21) J28.19@4220.33,3775.37 ; 4211.45,3780 ccw(c4211.45,3792.57) J28.19@4220.33,3783.68 ; v1(5260,3035) 5260.15,3035 5287.79,3062.64 U33.10@5343.5,3062.64 ; U33.10@5314.2,3059.81 ccw(c5307.37,3052.98) 5307.37,3062.64 ccw(c5307.37,3072.29) U33.10@5314.2,3065.47
  Bottom Layer w4: v1@4140.19,3607.21 cw(c4140.19,3584.27) 4156.41,3600.49 cw(c4172.63,3616.71) v1@4149.69,3616.71 ; v1@4140.19,3611.21 cw(c4140.19,3597.93) 4149.58,3607.32 cw(c4158.97,3616.71) v1@4145.69,3616.71 ; v1(4140.19,3616.71) 4190.19,3566.71 4190.19,3487.37 4156.86,3454.04 4156.86,3206 4191.82,3171.04 4281.04,3171.04 4281.37,3171.37 4390.19,3171.37 4398.52,3179.71 ; R180.2@4412.74,3251.67 ccw(c4406.52,3248.76) 4406.52,3255.62 ; R180.2@4412.74,3259.58 cw(c4406.52,3262.49) 4406.52,3255.62 ; R180.2@4421.18,3255.62 4406.52,3255.62 ; v1@5253.28,3028.28 ccw(c5237.06,3012.06) 5237.06,3035 ccw(c5237.06,3057.93) v1@5253.28,3041.72 ; v1@5256.11,3031.11 ccw(c5246.72,3021.72) 5246.72,3035 ccw(c5246.72,3048.28) v1@5256.11,3038.89 ; v1@5260.15,3035.15 v1(5260,3035) 5233.21,3035 5194.97,3073.25 5130,3073.25 5098.56,3073.25 5080.93,3090.87 4735.67,3090.87 4706.86,3119.69 4706.86,3183.37 4673.52,3216.71 4673.52,3275.04 4665.19,3283.37 4569.86,3283.37 4481.86,3195.37 4462.9,3195.37 4438.56,3171.04 4407.19,3171.04 4403.19,3175.04 4398.52,3179.71 ; 4398.52,3179.71 4398.52,3247.62 4406.52,3255.62
LEDS#.LED3.GREEN: J28.15 R181.2 U33.12 | length 2888.9
  Top Layer w4: v1@4150.14,3773.43 ccw(c4133.92,3789.64) 4156.86,3789.64 ccw(c4179.79,3789.64) v1@4163.57,3773.43 ; v1@4152.97,3770.6 ccw(c4143.58,3779.99) 4156.86,3779.99 ccw(c4170.14,3779.99) v1@4160.75,3770.6 ; v1(4156.86,3766.71) 4156.86,3808.37 4206.75,3858.27 J28.15@4246.61,3858.27 J28.15@4248.52,3858.27 ; J28.15@4220.33,3854.11 ccw(c4210.31,3844.09) 4210.31,3858.27 ccw(c4210.31,3872.45) J28.15@4220.33,3862.42 ; v1(5215.19,3083.37) 5245.64,3113.82 U33.12@5343.5,3113.82 ; v1@5215.19,3088.87 ccw(c5215.19,3102.15) 5224.58,3092.76 ccw(c5233.97,3083.37) v1@5220.69,3083.37 ; v1@5215.19,3092.87 ccw(c5215.19,3115.81) 5231.41,3099.59 ccw(c5247.63,3083.37) v1@5224.69,3083.37 ; U33.12@5314.2,3110.99 ccw(c5307.37,3104.16) 5307.37,3113.82 ccw(c5307.37,3123.48) U33.12@5314.2,3116.65
  Bottom Layer w4: v1(4156.86,3766.71) 4175.67,3766.71 ; v1@4164.5,3761.07 cw(c4175.67,3752.84) 4175.67,3766.71 ; v1@4164.5,3772.35 ccw(c4175.67,3780.58) 4175.67,3766.71 ; R181.2@4421.18,3312.5 4421.18,3299.71 4415.85,3294.37 ; 4440,3692.63 4440,3708.69 4368.31,3780.37 4189.33,3780.37 4175.67,3766.71 ; 4440.19,3692.63 4440.19,3674.04 4432.86,3666.71 4211.71,3666.71 4200,3655 4200,3485.87 4164.86,3450.73 4164.86,3272.39 4187.21,3250.04 4240.19,3250.04 4273.52,3216.71 4306.86,3216.71 4315.19,3225.04 4315.19,3287.71 4327.52,3300.04 4357.86,3300.04 4363.52,3294.37 4415.85,3294.37 ; v1@5205.69,3083.37 ccw(c5182.76,3083.37) 5198.97,3099.59 ccw(c5215.19,3115.81) v1@5215.19,3092.87 ; v1@5209.69,3083.37 ccw(c5196.41,3083.37) 5205.8,3092.76 ccw(c5215.19,3102.15) v1@5215.19,3088.87 ; v1(5215.19,3083.37) 5197.1,3101.47 5151.08,3101.47 5126.67,3125.87 5060,3125.87 5033,3098.87 4738.98,3098.87 4715.02,3122.84 4715.02,3197.25 4715.19,3197.42 4715.19,3266.71 4690.19,3291.71 4418.51,3291.71 4415.85,3294.37
LEDS#.LED3.RED: J28.17 R179.2 U33.8 | length 3665.4
  Top Layer w4: v1(4198.19,3822.04) 4201.86,3818.37 v1@4205.19,3818.37 ; v1@4199.25,3823.1 ccw(c4209.4,3833.25) 4209.4,3818.9 ; v1@4202.08,3825.93 ccw(c4219.06,3842.91) J28.17@4219.06,3818.9 ; v1@4204.91,3815.32 cw(c4213.54,3806.69) 4213.54,3818.9 ; v1@4204.91,3828.76 ccw(c4228.71,3852.56) J28.17@4228.71,3818.9 ; v1@4205.71,3818.9 J28.17@4246.61,3818.9 ; U33.8@5343.5,3011.46 5343.5,3011 5346.13,3008.37 5385.48,3008.37 5392,3014.9 5393.1,3014.9 v1(5394,3014) ; U33.8@5357.48,3008.37 ccw(c5357.48,3050.52) v1@5387.28,3020.72 ; U33.8@5367.14,3008.37 ccw(c5367.14,3040.86) v1@5390.11,3017.89 ; U33.8@5369.98,3011.46 ccw(c5376.73,3017.29) 5376.73,3008.37 ; 5376.8,3008.37 ccw(c5376.8,3031.2) v1@5392.94,3015.06
  MidLayer1 w4: v1@3908.47,3231.76 ccw(c3892.26,3247.98) 3915.19,3247.98 ccw(c3938.13,3247.98) v1@3921.91,3231.76 ; v1@3911.3,3228.93 ccw(c3901.91,3238.32) 3915.19,3238.32 ccw(c3928.47,3238.32) v1@3919.08,3228.93 ; v1(3915.19,3225.04) 3915.19,3283.37 3956.86,3325.04 3991.19,3325.04 4140.19,3474.04 4140.19,3505.04 4155.15,3520 4210.15,3520 4240.19,3550.04 4240.19,3780.04 v1(4198.19,3822.04) ; v1@4198.19,3812.54 cw(c4198.19,3789.61) 4214.41,3805.82 cw(c4230.63,3822.04) v1@4207.69,3822.04 ; v1@4198.19,3816.54 cw(c4198.19,3803.26) 4207.58,3812.65 cw(c4216.97,3822.04) v1@4203.69,3822.04 ; v1(4506.86,3316.71) 4573.52,3383.37 4598.52,3383.37 4615.19,3366.71 4615.19,3208.37 4640.19,3183.37 4640.19,3108.37 4665.19,3083.37 ; v1@4506.86,3322.21 ccw(c4506.86,3335.49) 4516.25,3326.1 ccw(c4525.64,3316.71) v1@4512.36,3316.71 ; v1@4506.86,3326.21 ccw(c4506.86,3349.14) 4523.07,3332.93 ccw(c4539.29,3316.71) v1@4516.36,3316.71 ; v1@4678.24,3077.28 ccw(c4665.19,3066.37) 4665.19,3083.37 ; v1@4678.24,3089.47 cw(c4665.19,3100.38) 4665.19,3083.37 ; v1@4681.31,3079.85 ccw(c4673.75,3073.53) 4673.75,3083.37 ccw(c4673.75,3093.22) v1@4681.31,3086.9 ; v1(4685.52,3083.37) 4665.19,3083.37
  MidLayer2 w4: v1(3915.19,3225.04) 3940.52,3250.37 4214.19,3250.37 4295.19,3331.37 v1(4349.52,3331.37) ; v1@3915.19,3230.54 ccw(c3915.19,3243.82) 3924.58,3234.43 ccw(c3933.97,3225.04) v1@3920.69,3225.04 ; v1@3915.19,3234.54 ccw(c3915.19,3257.48) 3931.41,3241.26 ccw(c3947.63,3225.04) v1@3924.69,3225.04 ; v1@4342.81,3324.66 ccw(c4326.59,3308.44) 4326.59,3331.37 ccw(c4326.59,3354.31) v1@4342.81,3338.09 ; v1@4345.64,3327.49 ccw(c4336.25,3318.1) 4336.25,3331.37 ccw(c4336.25,3344.65) v1@4345.64,3335.26
  Bottom Layer w4: v1(4349.52,3331.37) 4411.37,3331.37 4421.18,3341.18 R179.2@4421.18,3369.38 ; v1@4353.41,3327.49 cw(c4362.8,3318.1) 4362.8,3331.37 cw(c4362.8,3344.65) v1@4353.41,3335.26 ; v1@4356.24,3324.66 cw(c4372.46,3308.44) 4372.46,3331.37 cw(c4372.46,3354.31) v1@4356.24,3338.09 ; R179.2@4414.59,3362.29 cw(c4398.68,3346.39) 4421.18,3346.39 cw(c4443.68,3346.39) R179.2@4427.77,3362.29 ; R179.2@4417.42,3365.12 cw(c4408.34,3356.04) 4421.18,3356.04 cw(c4434.02,3356.04) R179.2@4424.94,3365.12 ; R179.2@4421.18,3359.56 cw(c4421.18,3335.88) 4437.93,3352.63 ; R179.2@4421.18,3363.56 cw(c4421.18,3349.54) R179.2@4431.1,3359.46 ; R179.2@4426.5,3368.88 ccw(c4438.15,3368.88) R179.2@4429.91,3360.64 ; R179.2@4429.85,3360.7 4473.85,3316.71 v1(4506.86,3316.71) ; R179.2@4430.5,3368.88 ccw(c4451.81,3368.88) 4436.74,3353.81 ; v1@4500.14,3309.99 ccw(c4483.92,3293.77) 4483.92,3316.71 ccw(c4483.92,3339.64) v1@4500.14,3323.43 ; v1@4502.97,3312.82 ccw(c4493.58,3303.43) 4493.58,3316.71 ccw(c4493.58,3329.99) v1@4502.97,3320.6 ; v1@4685.52,3073.87 cw(c4685.52,3050.94) 4701.74,3067.16 cw(c4717.96,3083.37) v1@4695.02,3083.37 ; v1@4685.52,3077.87 cw(c4685.52,3064.6) 4694.91,3073.99 cw(c4704.3,3083.37) v1@4691.02,3083.37 ; v1(4685.52,3083.37) 4743.19,3025.71 4948.52,3025.71 4989.69,3066.87 5070.99,3066.87 5148.69,2989.17 5160.36,2977.5 5275.98,2977.5 5290.19,2991.71 5326.5,2991.71 5349.7,3014.9 5393.1,3014.9 v1(5394,3014) ; 5368.89,3014.9 cw(c5368.89,2988.89) v1@5387.28,3007.28 ; 5373.24,3014.9 ccw(c5373.24,3034.76) v1@5387.28,3020.72 ; 5378.55,3014.9 cw(c5378.55,2998.55) v1@5390.11,3010.11
LEDS#.LED4.BLUE: J28.22 R183.2 U34.4 | length 6301.9
  Top Layer w4: J28.22@4323.39,3720.47 4361.39,3720.47 4364.79,3723.88 4395,3723.88 4401.5,3717.38 4401.5,3685.5 4402.5,3684.5 4402.5,3682.75 4412.75,3672.5 4414.5,3672.5 4440.19,3646.81 4440.19,3598.02 4493.5,3544.71 4522.86,3544.71 4533.19,3534.37 v1(4533.19,3425.04) ; J28.22@4349.67,3716.32 cw(c4359.69,3706.29) 4359.69,3720.47 cw(c4359.69,3734.66) J28.22@4349.67,3724.63 ; v1@4526.47,3431.76 ccw(c4510.26,3447.98) 4533.19,3447.98 ccw(c4556.13,3447.98) v1@4539.91,3431.76 ; v1@4529.3,3428.93 ccw(c4519.91,3438.32) 4533.19,3438.32 ccw(c4546.47,3438.32) v1@4537.08,3428.93 ; v1(6771.52,3075.04) 6779.52,3083.04 6779.52,3090.89 6781.85,3093.23 U34.4@6820,3093.23 ; U34.4@6790.69,3090.4 ccw(c6783.86,3083.57) 6783.86,3093.23 ccw(c6783.86,3102.89) U34.4@6790.69,3096.06
  MidLayer1 w4: v1@4225.14,2440.09 ccw(c4208.92,2456.31) 4231.86,2456.31 ccw(c4254.79,2456.31) v1@4238.57,2440.09 ; v1@4227.97,2437.26 ccw(c4218.58,2446.65) 4231.86,2446.65 ccw(c4245.14,2446.65) v1@4235.75,2437.26 ; v1(4231.86,2433.37) 4231.86,2494.08 4344.5,2606.72 4344.5,2610.56 4359.44,2625.5 4372.87,2625.5 4423.19,2675.82 4423.19,3104.44 4415.19,3112.44 4415.19,3315.04 4505.15,3405 4513.15,3405 v1(4533.19,3425.04) ; v1@4523.69,3425.04 cw(c4500.76,3425.04) 4516.97,3408.82 cw(c4533.19,3392.61) v1@4533.19,3415.54 ; v1@4527.69,3425.04 cw(c4514.41,3425.04) 4523.8,3415.65 cw(c4533.19,3406.26) v1@4533.19,3419.54 ; v1(6723.86,2523.04) 6807.82,2607 v1(6890,2607) ; v1@6723.86,2528.54 ccw(c6723.86,2541.82) 6733.25,2532.43 ccw(c6742.64,2523.04) v1@6729.36,2523.04 ; v1@6723.86,2532.54 ccw(c6723.86,2555.48) 6740.07,2539.26 ccw(c6756.29,2523.04) v1@6733.36,2523.04 ; v1@6883.28,2600.28 ccw(c6867.06,2584.06) 6867.06,2607 ccw(c6867.06,2629.93) v1@6883.28,2613.72 ; v1@6886.11,2603.11 ccw(c6876.72,2593.72) 6876.72,2607 ccw(c6876.72,2620.28) v1@6886.11,2610.89
  MidLayer2 w4: v1(4231.86,2433.37) 4260.48,2462 4325.62,2462 4346.12,2441.5 4434.13,2441.5 4497.69,2505.06 4497.69,2507.29 4507.94,2517.54 4599.75,2517.54 4631.59,2549.37 4943.31,2549.37 4951.94,2558 4975.69,2558 4984.19,2549.5 5218.19,2549.5 5242.65,2525.04 5574.52,2525.04 5674.86,2424.71 5674.86,2202.77 5723.44,2154.19 6018.79,2154.19 6036.85,2136.12 6306.12,2136.12 v1(6318,2148) ; v1@4231.86,2438.87 ccw(c4231.86,2452.15) 4241.25,2442.76 ccw(c4250.64,2433.37) v1@4237.36,2433.37 ; v1@4231.86,2442.87 ccw(c4231.86,2465.81) 4248.07,2449.59 ccw(c4264.29,2433.37) v1@4241.36,2433.37 ; v1(6771.52,3075.04) 6823.52,3075.04 6905.5,2993.06 6905.5,2622.5 v1(6890,2607) ; v1@6775.41,3071.15 cw(c6784.8,3061.76) 6784.8,3075.04 cw(c6784.8,3088.32) v1@6775.41,3078.93 ; v1@6778.24,3068.32 cw(c6794.46,3052.11) 6794.46,3075.04 cw(c6794.46,3097.98) v1@6778.24,3081.76
  Bottom Layer w4: R183.2@4421.18,3426.25 4461.25,3426.25 4470,3435 4490,3435 4499.96,3425.04 v1(4533.19,3425.04) ; R183.2@4424.94,3422.49 cw(c4434.02,3413.41) 4434.02,3426.25 cw(c4434.02,3439.09) R183.2@4424.94,3430.01 ; R183.2@4427.77,3419.66 cw(c4443.68,3403.75) 4443.68,3426.25 cw(c4443.68,3448.75) R183.2@4427.77,3432.84 ; v1@4526.47,3418.32 ccw(c4510.26,3402.11) 4510.26,3425.04 ccw(c4510.26,3447.98) v1@4526.47,3431.76 ; v1@4529.3,3421.15 ccw(c4519.91,3411.76) 4519.91,3425.04 ccw(c4519.91,3438.32) v1@4529.3,3428.93 ; v1@6320.23,2148 6356.24,2148 6368.81,2160.57 6368.81,2258.94 6451.91,2342.04 6481.58,2342.04 6539.58,2400.04 6657.41,2400.04 6723.86,2466.48 v1(6723.86,2523.04) ; v1@6321.89,2144.11 cw(c6331.28,2134.72) 6331.28,2148 cw(c6331.28,2161.28) v1@6321.89,2151.89 ; v1@6324.72,2141.28 cw(c6340.93,2125.06) 6340.93,2148 cw(c6340.93,2170.93) v1@6324.72,2154.72 ; v1@6717.14,2516.32 cw(c6700.92,2500.11) 6723.86,2500.11 cw(c6746.79,2500.11) v1@6730.57,2516.32 ; v1@6719.97,2519.15 cw(c6710.58,2509.76) 6723.86,2509.76 cw(c6737.14,2509.76) v1@6727.75,2519.15
LEDS#.LED4.GREEN: J28.25 R184.2 U34.6 | length 3789
  Top Layer w4: J28.25@4246.61,3661.42 4277.34,3661.42 ; J28.25@4268.58,3663.54 cw(c4269.58,3650.05) 4279.14,3659.61 ; J28.25@4268.88,3659.55 cw(c4270.43,3638.55) 4285.31,3653.44 ; J28.25@4270.04,3660.07 cw(c4274.36,3655.6) 4278.76,3660 ; J28.25@4272.82,3657.19 cw(c4277.19,3652.67) 4281.63,3657.12 ; J28.25@4274.21,3659.28 cw(c4277.34,3658.06) 4277.34,3661.42 ; J28.25@4274.21,3663.55 ccw(c4277.34,3664.77) 4277.34,3661.42 ; v1(4416.52,3512.04) 4386.86,3541.71 4295.52,3541.71 4287.19,3550.04 4287.19,3651.56 4277.34,3661.42 ; U34.6@6820,3042.05 6823.52,3042.05 6823.52,3041.71 v1(6881.86,3041.71) ; U34.6@6849.31,3039.22 cw(c6855.32,3033.21) 6855.32,3041.71 ; U34.6@6849.31,3044.88 ccw(c6856.96,3052.53) 6856.96,3041.71 ; v1@6875.14,3034.99 ccw(c6858.92,3018.77) 6858.92,3041.71 ccw(c6858.92,3064.64) v1@6875.14,3048.43 ; v1@6877.97,3037.82 ccw(c6868.58,3028.43) 6868.58,3041.71 ccw(c6868.58,3054.99) v1@6877.97,3045.6
  Bottom Layer w4: v1@4410.62,3504.6 cw(c4393.31,3482.75) R184.2@4421.18,3482.75 ; v1@4413.11,3507.73 cw(c4399.87,3491.03) R184.2@4421.18,3491.03 ; v1@4415.59,3510.87 cw(c4406.43,3499.3) 4421.18,3499.3 ; v1(4416.52,3512.04) 4421.18,3507.38 R184.2@4421.18,3483.12 4421.26,3483.04 4515.52,3483.04 4559.86,3438.71 4594.19,3438.71 4605.52,3450.04 4623.52,3450.04 4631.86,3441.71 4631.86,3418.96 4642.38,3408.44 4669.99,3408.44 4673.52,3411.98 4673.52,3503.52 4681.52,3511.52 4731.08,3511.52 4821.52,3421.07 4821.52,3318.96 4871.98,3268.5 4939.4,3268.5 4966.69,3241.21 5103.36,3241.21 5152.36,3192.21 5227.36,3192.21 5230.65,3195.5 5285.65,3195.5 5298.83,3208.68 5339.64,3208.68 5357.15,3226.2 5434.2,3226.2 5436.3,3224.1 5511.8,3224.1 5521.87,3214.03 5552.52,3183.37 5603.88,3183.37 5612.21,3175.04 5612.21,3159.69 5613.52,3158.37 5630.86,3141.04 6036.61,3141.04 6075.05,3179.49 6075.05,3197.12 6089.99,3212.05 6090.12,3212.05 6104.57,3226.51 6119.06,3241 6197.82,3241 6206.86,3250.04 6298.15,3250.04 6299.31,3248.87 6330.69,3248.87 6344.82,3263 6533.69,3263 6571.81,3224.87 6723.33,3224.87 6731.33,3216.87 6807.28,3216.87 6833.11,3242.71 6852.88,3242.71 6881.02,3214.56 6881.02,3042.54 v1(6881.86,3041.71) ; R184.2@4417.42,3487.38 ccw(c4408.34,3496.46) 4421.18,3496.46 ccw(c4434.02,3496.46) R184.2@4424.94,3487.38 ; 4421.18,3500.35 cw(c4428.22,3500.35) v1@4423.24,3505.32 ; R184.2@4424.94,3479.36 cw(c4433.82,3470.49) 4433.82,3483.04 ; R184.2@4424.94,3486.89 ccw(c4434.23,3496.17) 4434.23,3483.04 ; R184.2@4427.77,3476.54 cw(c4443.48,3460.83) 4443.48,3483.04 ; R184.2@4427.77,3489.71 ccw(c4443.88,3505.83) 4443.88,3483.04
LEDS#.LED4.RED: J28.20 R182.2 U34.2 | length 4569.9
  Top Layer w4: J28.20@4323.39,3759.84 4355.52,3759.84 ; J28.20@4350.64,3756.98 cw(c4355.52,3754.25) 4355.52,3759.84 ; J28.20@4350.64,3762.71 ccw(c4355.52,3765.44) 4355.52,3759.84 ; v1(4369.19,3753.04) 4360.86,3761.37 4357.06,3761.37 4355.52,3759.84 ; U34.2@6820,3144.41 6823.52,3144.41 6823.52,3141.71 6848.52,3141.71 6865.19,3158.37 6865.19,3174.37 v1(6847.86,3191.71) ; U34.2@6846.48,3144.41 ccw(c6846.48,3155.87) 6854.58,3147.77 ; U34.2@6846.48,3148.41 ccw(c6846.48,3169.52) 6861.41,3154.59 ; v1@6847.86,3182.21 cw(c6847.86,3159.27) 6864.07,3175.49 cw(c6880.29,3191.71) v1@6857.36,3191.71 ; v1@6847.86,3186.21 cw(c6847.86,3172.93) 6857.25,3182.32 cw(c6866.64,3191.71) v1@6853.36,3191.71
  MidLayer1 w4: v1@4362.47,3759.76 ccw(c4346.26,3775.98) 4369.19,3775.98 ccw(c4392.13,3775.98) v1@4375.91,3759.76 ; v1@4365.3,3756.93 ccw(c4355.91,3766.32) 4369.19,3766.32 ccw(c4382.47,3766.32) v1@4373.08,3756.93 ; v1(4369.19,3753.04) 4369.19,3856.75 4406.86,3894.41 4406.86,3926.04 4415.19,3934.37 4445,3934.37 4454.52,3924.85 4454.52,3660 ; v1@4442.42,3557.32 ccw(c4431.47,3570.39) 4448.52,3570.39 ; v1@4444.99,3554.26 ccw(c4438.65,3561.82) 4448.52,3561.82 ccw(c4458.4,3561.82) v1@4452.06,3554.26 ; v1(4448.52,3550.04) 4448.52,3570.39 ; v1@4454.63,3557.32 cw(c4465.58,3570.39) 4448.52,3570.39 ; v1@4749.02,3381.37 ccw(c4726.09,3381.37) 4742.31,3397.59 ccw(c4758.52,3413.81) v1@4758.52,3390.87 ; v1@4753.02,3381.37 ccw(c4739.75,3381.37) 4749.14,3390.76 ccw(c4758.52,3400.15) v1@4758.52,3386.87 ; v1(4758.52,3381.37) 4737.74,3402.16 4737.74,3426.49 4731.86,3432.37 4665.19,3499.04 4665.19,3619.37 4626.19,3658.37 4456.15,3658.37 4454.52,3660 ; 4448.52,3570.39 4454.52,3576.39 4454.52,3660
  Bottom Layer w4: R182.2@4419.71,3538.25 ccw(c4425.57,3547.16) 4433.1,3539.62 ; R182.2@4421.18,3540 4433.48,3540 4443.52,3550.04 v1(4448.52,3550.04) ; R182.2@4421.91,3541.59 ccw(c4428.32,3551.35) 4436.58,3543.09 ; v1@4749.02,3381.37 cw(c4726.09,3381.37) 4742.31,3365.16 cw(c4758.52,3348.94) v1@4758.52,3371.87 ; v1@4753.02,3381.37 cw(c4739.75,3381.37) 4749.14,3371.99 cw(c4758.52,3362.6) v1@4758.52,3375.87 ; v1(4758.52,3381.37) 4739.19,3362.04 4739.19,3285.02 4775.02,3249.19 4775.02,3226.13 4764.77,3215.88 4755.88,3215.88 4731.19,3191.19 4731.19,3190.79 4731.02,3190.62 4731.02,3129.46 4745.61,3114.87 5026.37,3114.87 5053.37,3141.87 5133.3,3141.87 5157.71,3117.47 5223.6,3117.47 5285.56,3055.5 5570.79,3055.5 5628,2998.29 5628,2969.86 5676.67,2921.19 5768.06,2921.19 5773.75,2915.5 5830.44,2915.5 5841.44,2904.5 5928.44,2904.5 5959.94,2936 5984,2936 6000,2920 6062,2920 6068,2914 6068,2866.04 6082,2852.04 6305.52,2852.04 6319.86,2866.37 6416.52,2866.37 6525.19,2975.04 6745.54,2975.04 6770.21,2999.71 6834.71,2999.71 6847.86,3012.86 v1(6847.86,3191.71) ; v1@6841.14,3184.99 cw(c6824.92,3168.77) 6847.86,3168.77 cw(c6870.79,3168.77) v1@6854.57,3184.99 ; v1@6843.97,3187.82 cw(c6834.58,3178.43) 6847.86,3178.43 cw(c6861.14,3178.43) v1@6851.75,3187.82
LEDS#.LED5.BLUE: J28.27 R186.2 U34.10 | length 5229.8
  Top Layer w4: J28.27@4220.33,3617.89 ccw(c4210.31,3607.87) 4210.31,3622.05 ccw(c4210.31,3636.23) J28.27@4220.33,3626.2 ; J28.27@4246.61,3622.05 4177.05,3622.05 4140.19,3585.19 4140.19,3532.37 4147.52,3525.04 4276.52,3525.04 4284.86,3516.71 4284.86,3433.37 4293.19,3425.04 4390.19,3425.04 4406.86,3408.37 4406.86,3391.71 4390.19,3375.04 4390.19,3225.36 4390.69,3224.86 4390.69,3219.89 4389.7,3218.9 4389.7,3133.87 v1(4465.19,3058.37) ; v1@4455.69,3058.37 ccw(c4432.76,3058.37) 4448.97,3074.59 ccw(c4465.19,3090.81) v1@4465.19,3067.87 ; v1@4459.69,3058.37 ccw(c4446.41,3058.37) 4455.8,3067.76 ccw(c4465.19,3077.15) v1@4465.19,3063.87 ; U34.10@7038.5,3067.64 7040.19,3067.64 7040.19,3066.71 7065.19,3066.71 7081.86,3050.04 7081.86,2973.71 v1(7058.19,2950.04) ; v1@7058.19,2955.54 ccw(c7058.19,2968.82) 7067.58,2959.43 ccw(c7076.97,2950.04) v1@7063.69,2950.04 ; v1@7058.19,2959.54 ccw(c7058.19,2982.48) 7074.41,2966.26 ccw(c7090.63,2950.04) v1@7067.69,2950.04 ; U34.10@7064.98,3063.64 cw(c7064.98,3055.73) 7070.58,3061.32 ; U34.10@7068.98,3067.64 ccw(c7080.39,3067.64) 7072.33,3059.57
  MidLayer1 w4: v1@6591.81,2331.76 ccw(c6574.9,2348.67) 6598.81,2348.67 ; v1@6594.64,2328.93 ccw(c6584.55,2339.01) 6598.81,2339.01 ; v1(6598.52,2325.04) 6598.81,2325.33 6598.81,2438.31 6623.32,2462.82 6625,2464.5 6625,2506.62 6698.38,2580 6740.5,2580 6755.87,2595.36 6755.87,2599.05 6755.87,2612.74 6899.02,2755.89 6899.02,2760.86 6898.52,2761.35 6898.52,2769.44 7058.19,2929.1 ; 6598.81,2337.63 ccw(c6611.11,2337.63) v1@6602.41,2328.93 ; 6598.81,2347.28 ccw(c6620.77,2347.28) v1@6605.24,2331.76 ; v1@7051.93,2942.89 cw(c7039.87,2929.1) 7058.19,2929.1 ; v1@7054.57,2945.9 cw(c7047.58,2937.92) 7058.19,2937.92 cw(c7068.8,2937.92) v1@7061.81,2945.9 ; v1(7058.19,2950.04) 7058.19,2929.1 ; v1@7064.45,2942.89 ccw(c7076.51,2929.1) 7058.19,2929.1
  MidLayer2 w4: v1@5291.81,2959.99 cw(c5275.59,2943.77) 5298.52,2943.77 cw(c5321.46,2943.77) v1@5305.24,2959.99 ; v1@5294.64,2962.82 cw(c5285.25,2953.43) 5298.52,2953.43 cw(c5311.8,2953.43) v1@5302.41,2962.82 ; v1(5298.52,2966.71) 5298.52,2928.63 5325.61,2901.54 5390.54,2901.54 5466.81,2977.81 5487.94,2977.81 5565.19,2900.56 5565.19,2882.04 5595.82,2851.41 5613.69,2833.54 5717.41,2833.54 5771.65,2779.3 5784.45,2779.3 5819.5,2744.25 5819.5,2740.5 5842.81,2717.19 5927.81,2717.19 6059,2586 6301.61,2586 6372.69,2514.92 6372.69,2400 ; 6372.69,2401.58 6372.69,2373.31 6437.63,2308.37 6581.86,2308.37 v1(6598.52,2325.04) ; v1@6589.02,2325.04 cw(c6566.09,2325.04) 6582.31,2308.82 cw(c6598.52,2292.61) v1@6598.52,2315.54 ; v1@6593.02,2325.04 cw(c6579.75,2325.04) 6589.14,2315.65 cw(c6598.52,2306.26) v1@6598.52,2319.54
  Bottom Layer w4: v1(4465.19,3058.37) 4540.19,3058.37 4585.49,3103.68 4650.86,3103.68 4656.86,3097.68 ; v1@4469.08,3054.49 cw(c4478.47,3045.1) 4478.47,3058.37 cw(c4478.47,3071.65) v1@4469.08,3062.26 ; v1@4471.91,3051.66 cw(c4488.13,3035.44) 4488.13,3058.37 cw(c4488.13,3081.31) v1@4471.91,3065.09 ; R186.2@4649.59,3077.92 cw(c4632.05,3060.38) 4656.86,3060.38 ; 4652.33,3102.2 cw(c4642.4,3092.28) R186.2@4655,3086.07 ; R186.2@4652.42,3080.75 cw(c4641.71,3070.03) 4656.86,3070.03 ; 4656.18,3097.01 4656.85,3097.68 ; 4656.28,3098.25 cw(c4647.69,3089.67) R186.2@4658.59,3084.31 ; 4656.86,3063.64 cw(c4677.05,3063.64) R186.2@4662.77,3077.92 ; R186.2@4656.86,3085 4656.86,3041.71 4680.86,3017.71 4951.84,3017.71 4993,3058.87 5067.68,3058.87 5140.69,2985.86 5168.17,2958.37 5202.93,2958.37 5211.37,2966.81 v1@5298.42,2966.81 ; 5275.34,2966.81 cw(c5275.34,2943.52) v1@5291.81,2959.99 ; 5275.84,2966.81 ccw(c5275.84,2989.39) v1@5291.81,2973.43 ; 5285,2966.81 cw(c5285,2953.18) v1@5294.64,2962.82 ; 5285.5,2966.81 ccw(c5285.5,2979.74) v1@5294.64,2970.6
LEDS#.LED5.GREEN: J28.21 R187.2 U34.12 | length 4981.8
  Top Layer w4: v1(4198.52,3758.37) 4198.52,3748.16 4206.52,3740.16 J28.21@4246.61,3740.16 ; J28.21@4220.33,3736 ccw(c4210.31,3725.98) 4210.31,3740.16 ccw(c4210.31,3754.34) J28.21@4220.33,3744.31 ; v1@6958.47,3040.09 ccw(c6942.26,3056.31) 6965.19,3056.31 ccw(c6988.13,3056.31) v1@6971.91,3040.09 ; v1@6961.3,3037.26 ccw(c6951.91,3046.65) 6965.19,3046.65 ccw(c6978.47,3046.65) v1@6969.08,3037.26 ; v1(6965.19,3033.37) 6965.19,3095.19 6988.82,3118.82 U34.12@7038.5,3118.82 U34.12@7040.19,3118.82 ; U34.12@7009.2,3115.99 ccw(c7002.37,3109.16) 7002.37,3118.82 ccw(c7002.37,3128.48) U34.12@7009.2,3121.65
  MidLayer1 w4: v1@4570.52,3611.21 cw(c4570.52,3588.27) 4586.74,3604.49 cw(c4602.96,3620.71) v1@4580.02,3620.71 ; v1@4570.52,3615.21 cw(c4570.52,3601.93) 4579.91,3611.32 cw(c4589.3,3620.71) v1@4576.02,3620.71 ; v1(4570.52,3620.71) 4615.19,3576.04 4620.02,3571.21 4620.02,3503.79 4632.11,3491.71 4656.86,3491.71 4728.77,3419.8 4728.77,3268.95 4707.19,3247.37 4707.19,3164.71 v1(4686.19,3143.71) ; v1@4686.19,3149.21 ccw(c4686.19,3162.49) 4695.58,3153.1 ccw(c4704.97,3143.71) v1@4691.69,3143.71 ; v1@4686.19,3153.21 ccw(c4686.19,3176.14) 4702.41,3159.93 ccw(c4718.63,3143.71) v1@4695.69,3143.71
  MidLayer2 w4: v1(4198.52,3758.37) 4265.19,3758.37 4415.19,3608.37 4440.19,3608.37 4452.52,3620.71 v1(4570.52,3620.71) ; v1@4202.41,3754.49 cw(c4211.8,3745.1) 4211.8,3758.37 cw(c4211.8,3771.65) v1@4202.41,3762.26 ; v1@4205.24,3751.66 cw(c4221.46,3735.44) 4221.46,3758.37 cw(c4221.46,3781.31) v1@4205.24,3765.09 ; v1@4563.81,3613.99 ccw(c4547.59,3597.77) 4547.59,3620.71 ccw(c4547.59,3643.64) v1@4563.81,3627.43 ; v1@4566.64,3616.82 ccw(c4557.25,3607.43) 4557.25,3620.71 ccw(c4557.25,3633.99) v1@4566.64,3624.6
  Bottom Layer w4: v1@4570.52,3611.21 cw(c4570.52,3588.27) 4586.74,3604.49 cw(c4602.96,3620.71) v1@4580.02,3620.71 ; v1@4570.52,3615.21 cw(c4570.52,3601.93) 4579.91,3611.32 cw(c4589.3,3620.71) v1@4576.02,3620.71 ; v1(4570.52,3620.71) 4616.19,3575.04 4660.15,3575.04 4700.39,3534.79 4760.79,3534.79 4778.04,3517.54 4789.11,3517.54 4840.97,3465.68 4840.97,3357.97 4914.44,3284.5 4935.56,3284.5 4939.27,3288.21 5079.07,3288.21 5159.07,3208.21 5220.73,3208.21 5224.03,3211.5 5279.03,3211.5 5292.21,3224.68 5333.01,3224.68 5350.53,3242.2 5440.82,3242.2 5442.92,3240.1 5519.55,3240.1 5537.45,3222.2 5551.95,3222.2 5556.15,3226.4 5572.16,3226.4 5620.21,3178.35 5620.21,3170.27 5641.27,3149.21 5798.69,3149.21 5872.99,3223.51 5872.99,3294.01 5897.94,3318.96 5912.44,3318.96 5922.69,3308.71 5922.69,3292.79 5935.48,3280 5944.9,3280 5969.9,3305 6004.81,3305 6012.62,3312.81 6041.56,3312.81 6062.46,3333.71 6152.23,3333.71 6160.4,3341.87 6267.65,3341.87 6275.81,3333.71 6440.17,3333.71 6464.83,3358.37 6532.37,3358.37 6578.37,3312.37 6646.94,3312.37 6660.36,3298.96 6660.36,3284.46 6650.11,3274.21 6635.61,3274.21 6625.61,3284.21 6607.94,3284.21 6597.69,3273.96 6597.69,3259.46 6607.94,3249.21 6732.94,3249.21 6741.28,3240.87 6755.77,3240.87 6781.61,3266.71 6862.82,3266.71 6905.02,3224.5 6905.02,3065.92 6921.73,3049.21 6949.36,3049.21 v1(6965.19,3033.37) ; R187.2@4656.18,3141.88 4679.69,3141.87 4686.19,3135.37 v1(4686.19,3143.71) ; R187.2@4658.83,3141.87 ccw(c4658.83,3171.07) v1@4679.47,3150.43 ; R187.2@4659.94,3138.11 cw(c4669.02,3129.03) 4669.02,3141.87 cw(c4669.02,3154.72) R187.2@4659.94,3145.64 ; 4667.68,3141.87 cw(c4667.68,3125.2) v1@4679.47,3136.99 ; 4668.49,3141.87 ccw(c4668.49,3161.41) v1@4682.3,3147.6