# Altium PCB NB3000AL.PcbDoc (part 44 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Top Layer w4: v2@4564,4540.19 cw(c4564,4516.5) 4580.75,4533.25 cw(c4597.5,4550) v2@4573.81,4550 ; v2@4564,4544.19 cw(c4564,4530.16) 4573.92,4540.08 cw(c4583.84,4550) v2@4569.81,4550 ; v2(4564,4550) 4595.5,4518.5 4595.5,4495.75 4607.75,4483.5 4611.25,4483.5 4624.15,4470.59 4690.75,4470.59 4707.5,4487.34 4717.75,4497.59 4732.25,4497.59 4768.08,4461.77 4827.22,4461.77 4827.58,4461.41 4878.16,4461.41 cw(c4878.16,4451.26) 4885.34,4458.44 ; v2@4716,4810.19 cw(c4716,4786.5) 4732.75,4803.25 cw(c4749.5,4820) v2@4725.81,4820 ; v2@4716,4814.19 cw(c4716,4800.16) 4725.92,4810.08 cw(c4735.84,4820) v2@4721.81,4820 ; v2(4716,4820) 4778,4758 4778,4647 4782.24,4642.76 U8.C1@4858.5,4642.76 ; v2@4721.75,4128.5 4738.5,4128.5 ; v2@4728.69,4132.56 ccw(c4738.49,4142.36) 4738.49,4128.5 ; v2@4731.2,4122.97 cw(c4738.49,4120.92) 4738.49,4128.5 ; v2@4734,4268 4745.1,4279.1 ; v1(4740.19,3987.71) v1@4741.45,3988.97 ; 4744.71,4278.71 4750,4284 4777.06,4284 4782.06,4279 4803.5,4279 4819,4263.5 4837.76,4263.5 4838.82,4264.56 4878.16,4264.56 cw(c4878.16,4254.41) 4885.34,4261.59 ; v2(4745,3890) 4750,3895 v2@4750,3898 ; v2@4750.8,3890.41 cw(c4767.97,3891.62) 4755.8,3903.8 ; v2@4750.81,3890 cw(c4772.08,3890) 4757.04,3905.04 ; 4752.45,3900.45 4768,3916 4768.63,3916 4781,3916 4783.59,3918.59 4798.34,3918.59 4878.16,3918.59 ccw(c4878.16,3928.74) 4885.34,3921.56 ; v2@4754.79,3890.69 cw(c4779.56,3892.44) 4762,3910 ; v2@4754.81,3890 cw(c4785.74,3890) 4763.87,3911.87 ; 4762,3910 4752,3900 ; v2@4784.01,3717.77 ccw(c4774.59,3729.97) 4790,3729.97 ; v2@4786.45,3714.6 ccw(c4780.87,3721.83) 4790,3721.83 ccw(c4799.13,3721.83) v2@4793.55,3714.6 ; v2(4790,3710) 4790,3729.97 ; v2@4795.99,3717.77 cw(c4805.41,3729.97) 4790,3729.97 ; U8.AF1@4853.31,3732.05 ccw(c4840.78,3719.52) 4840.78,3737.24 ; U8.AF1@4853.31,3742.44 cw(c4840.78,3754.97) 4840.78,3737.24 ; U8.C1@4853.31,4637.56 ccw(c4840.78,4625.03) 4840.78,4642.76 ccw(c4840.78,4660.48) U8.C1@4853.31,4647.95 ; v1@4860,4768.5 cw(c4860,4740.74) 4879.63,4760.37 ; v1@4860,4772.5 cw(c4860,4754.39) 4872.8,4767.2 ; v1(4860,4778) 4862,4778 4882.37,4757.63 4882.37,4741.18 4882.37,4701.84 ; v1@4869.5,4778 ccw(c4887.61,4778) 4874.8,4765.2 ; 4878,4115.44 4839,4115.44 4785.31,4115.44 4772.25,4128.5 4738.5,4128.5 ; 4878.16,4115.44 ccw(c4878.16,4125.59) 4885.34,4118.41 ; U8.AA2@4890.53,3934.09 cw(c4872.81,3934.09) 4885.34,3921.56 ; U8.T2@4890.53,4130.94 cw(c4872.81,4130.94) 4885.34,4118.41 ; U8.N2@4890.53,4249.05 ccw(c4872.81,4249.05) 4885.34,4261.59 ; U8.H2@4890.53,4445.91 ccw(c4872.81,4445.91) 4885.34,4458.44 ; U8.AA2@4897.87,3926.75 ccw(c4897.87,3909.03) 4885.34,3921.56 ; U8.T2@4897.87,4123.6 ccw(c4897.87,4105.88) 4885.34,4118.41 ; U8.N2@4897.87,4256.4 cw(c4897.87,4274.12) 4885.34,4261.59 ; U8.H2@4897.87,4453.25 cw(c4897.87,4470.97) 4885.34,4458.44 ; v2@4977,3592 5000.48,3615.48 5000.48,3678.16 ; v2@4977,3598.81 ccw(c4977,3615.25) 4988.63,3603.63 ; v1@4982.14,4808.32 cw(c4965.92,4792.11) 4988.86,4792.11 cw(c5011.79,4792.11) v1@4995.57,4808.32 ; v2@4982.81,3589 cw(c5004.08,3589) 4989.04,3604.04 ; v1@4984.97,4811.15 cw(c4975.58,4801.76) 4988.86,4801.76 cw(c5002.14,4801.76) v1@4992.75,4811.15 ; v2@4986.81,3589 cw(c5017.74,3589) 4995.87,3610.87 ; v1(4988.86,4815.04) 4988.86,4789.14 5000.48,4777.52 5000.48,4764.48 ; 5000.48,4750.48 5000.48,4764.48 ; v3(5035.67,3835.67) U8.AC6@5055.35,3855.35 ; v3(5035.67,3993.15) U8.W6@5055.35,4012.83 ; v3(5035.67,4111.26) U8.T6@5055.35,4130.94 ; v3(5035.67,4268.74) U8.N6@5055.35,4249.05 ; v3(5035.67,4386.85) U8.K6@5055.35,4367.17 ; v3(5035.67,4544.33) U8.F6@5055.35,4524.65 ; U8.AC6@5048.01,3855.35 cw(c5030.29,3855.35) 5042.82,3842.82 cw(c5055.35,3830.29) U8.AC6@5055.35,3848.01 ; U8.W6@5048.01,4012.83 cw(c5030.29,4012.83) 5042.82,4000.3 cw(c5055.35,3987.77) U8.W6@5055.35,4005.49 ; U8.T6@5048.01,4130.94 cw(c5030.29,4130.94) 5042.82,4118.41 cw(c5055.35,4105.88) U8.T6@5055.35,4123.6 ; U8.N6@5048.01,4249.05 ccw(c5030.29,4249.05) 5042.82,4261.59 ccw(c5055.35,4274.12) U8.N6@5055.35,4256.4 ; U8.K6@5048.01,4367.17 ccw(c5030.29,4367.17) 5042.82,4379.7 ccw(c5055.35,4392.23) U8.K6@5055.35,4374.51 ; U8.F6@5048.01,4524.65 ccw(c5030.29,4524.65) 5042.82,4537.18 ccw(c5055.35,4549.71) U8.F6@5055.35,4531.99 ; v1@5090,3600.23 v1(5090.19,3600.04) v1@5094.72,3604.57 ; v3(5114.41,4150.63) U8.R8@5134.09,4170.31 ; U33.7@5123.52,3011.46 U33.7@5125,3011.46 ; U8.R8@5126.75,4170.31 cw(c5109.03,4170.31) 5121.56,4157.78 cw(c5134.09,4145.25) U8.R8@5134.09,4162.97 ; v3(5153.78,3835.67) U8.AC9@5173.46,3855.35 ; v3(5153.78,3914.41) U8.AA9@5173.46,3934.09 ; v3(5153.78,4071.89) U8.U9@5173.46,4091.57 ; v3(5153.78,4150.63) U8.R9@5173.46,4170.31 ; v3(5153.78,4268.74) U8.N9@5173.46,4249.05 ; v3(5153.78,4347.48) U8.L9@5173.46,4327.8 ; v3(5153.78,4465.59) U8.H9@5173.46,4445.91 ; v3(5153.78,4544.33) U8.F9@5173.46,4524.65 ; 5157.96,3629.96 5157.96,3625 ; 5157.96,4750.04 5157.96,4773.96 ; v1@5161.28,4807.28 cw(c5145.06,4791.06) 5168,4791.06 cw(c5190.93,4791.06) v1@5174.72,4807.28 ; v1@5164.11,4810.11 cw(c5154.72,4800.72) 5168,4800.72 cw(c5181.28,4800.72) v1@5171.89,4810.11 ; U8.AG9@5166.12,3697.87 cw(c5148.4,3697.87) 5160.93,3685.34 ; U8.AC9@5166.12,3855.35 cw(c5148.4,3855.35) 5160.93,3842.82 cw(c5173.46,3830.29) U8.AC9@5173.46,3848.01 ; U8.AA9@5166.12,3934.09 cw(c5148.4,3934.09) 5160.93,3921.56 cw(c5173.46,3909.03) U8.AA9@5173.46,3926.75 ; U8.U9@5166.12,4091.57 cw(c5148.4,4091.57) 5160.93,4079.04 cw(c5173.46,4066.51) U8.U9@5173.46,4084.23 ; U8.R9@5166.12,4170.31 cw(c5148.4,4170.31) 5160.93,4157.78 cw(c5173.46,4145.25) U8.R9@5173.46,4162.97 ; U8.N9@5166.12,4249.05 ccw(c5148.4,4249.05) 5160.93,4261.59 ccw(c5173.46,4274.12) U8.N9@5173.46,4256.4 ; U8.L9@5166.12,4327.8 ccw(c5148.4,4327.8) 5160.93,4340.33 ccw(c5173.46,4352.86) U8.L9@5173.46,4335.14 ; U8.H9@5166.12,4445.91 ccw(c5148.4,4445.91) 5160.93,4458.44 ccw(c5173.46,4470.97) U8.H9@5173.46,4453.25 ; U8.F9@5166.12,4524.65 ccw(c5148.4,4524.65) 5160.93,4537.18 ccw(c5173.46,4549.71) U8.F9@5173.46,4531.99 ; U8.B9@5166.12,4682.13 ccw(c5148.4,4682.13) 5160.93,4694.66 ; v2(5168,3548) 5165.46,3550.54 5165.46,3587.43 5157.96,3594.94 5157.96,3625 ; v1(5168,4814) 5168,4784 5157.96,4773.96 ; U8.AG9@5173.46,3690.53 ccw(c5173.46,3672.8) 5160.93,3685.34 ; U8.B9@5173.46,4689.47 cw(c5173.46,4707.19) 5160.93,4694.66 ; v3(5193.15,4032.52) U8.V10@5212.83,4052.2 ; v3(5193.15,4111.26) U8.T10@5212.83,4130.94 ; v3(5193.15,4229.37) U8.P10@5212.83,4209.68 ; v3(5193.15,4308.11) U8.M10@5212.83,4288.42 ; v3(5193.15,4386.85) U8.K10@5212.83,4367.17 ; U8.V10@5205.49,4052.2 cw(c5187.77,4052.2) 5200.3,4039.67 cw(c5212.83,4027.14) U8.V10@5212.83,4044.86 ; U8.T10@5205.49,4130.94 cw(c5187.77,4130.94) 5200.3,4118.41 cw(c5212.83,4105.88) U8.T10@5212.83,4123.6 ; U8.P10@5205.49,4209.68 ccw(c5187.77,4209.68) 5200.3,4222.22 ccw(c5212.83,4234.75) U8.P10@5212.83,4217.03 ; U8.M10@5205.49,4288.42 ccw(c5187.77,4288.42) 5200.3,4300.96 ccw(c5212.83,4313.49) U8.M10@5212.83,4295.77 ; U8.K10@5205.49,4367.16 ccw(c5187.77,4367.16) 5200.3,4379.7 ccw(c5212.83,4392.23) U8.K10@5212.83,4374.51 ; v3(5232.52,3953.78) U8.Y11@5252.2,3973.46 ; v3(5232.52,3993.15) U8.W11@5252.2,4012.83 ; v3(5232.52,4071.89) U8.U11@5252.2,4091.57 ; v3(5232.52,4150.63) U8.R11@5252.2,4170.31 ; v3(5232.52,4268.74) U8.N11@5252.2,4249.05 ; v3(5232.52,4347.48) U8.L11@5252.2,4327.8 ; v3(5232.52,4426.22) U8.J11@5252.2,4406.54 ; U8.Y11@5244.86,3973.46 cw(c5227.14,3973.46) 5239.67,3960.93 cw(c5252.2,3948.4) U8.Y11@5252.2,3966.12 ; U8.W11@5244.86,4012.83 cw(c5227.14,4012.83) 5239.67,4000.3 cw(c5252.2,3987.77) U8.W11@5252.2,4005.49 ; U8.U11@5244.86,4091.57 cw(c5227.14,4091.57) 5239.67,4079.04 cw(c5252.2,4066.51) U8.U11@5252.2,4084.23 ; U8.R11@5244.86,4170.31 cw(c5227.14,4170.31) 5239.67,4157.78 cw(c5252.2,4145.25) U8.R11@5252.2,4162.97 ; U8.N11@5244.86,4249.05 ccw(c5227.14,4249.05) 5239.67,4261.59 ccw(c5252.2,4274.12) U8.N11@5252.2,4256.4 ; U8.L11@5244.86,4327.79 ccw(c5227.14,4327.79) 5239.67,4340.33 ccw(c5252.2,4352.86) U8.L11@5252.2,4335.14 ; U8.J11@5244.86,4406.54 ccw(c5227.14,4406.53) 5239.67,4419.07 ccw(c5252.2,4431.6) U8.J11@5252.2,4413.88 ; v3(5271.89,4032.52) U8.V12@5291.57,4052.2 ; v3(5271.89,4111.26) U8.T12@5291.57,4130.94 ; v3(5271.89,4229.37) U8.P12@5291.57,4209.68 ; v3(5271.89,4386.85) U8.K12@5291.57,4367.17 ; v1(5274,3448) 5276.04,3450.04 v1@5279.19,3450.04 ; U8.V12@5284.23,4052.2 cw(c5266.51,4052.2) 5279.04,4039.67 cw(c5291.57,4027.14) U8.V12@5291.57,4044.86 ; U8.T12@5284.23,4130.95 cw(c5266.51,4130.95) 5279.04,4118.41 cw(c5291.57,4105.88) U8.T12@5291.57,4123.6 ; U8.P12@5284.23,4209.68 ccw(c5266.51,4209.68) 5279.04,4222.22 ccw(c5291.57,4234.75) U8.P12@5291.57,4217.03 ; U8.K12@5284.23,4367.16 ccw(c5266.51,4367.16) 5279.04,4379.7 ccw(c5291.57,4392.23) U8.K12@5291.57,4374.51 ; U8.M12@5291.57,4281.08 cw(c5291.57,4263.36) 5304.11,4275.89 cw(c5316.64,4288.43) U8.M12@5298.92,4288.43 ; U8.M12@5291.57,4288.42 v3(5311.26,4268.74) U8.N13@5330.94,4249.05 ; v2(5305,4805) 5315.44,4794.56 5315.44,4750 ; 5305.85,3545.8 ccw(c5320.93,3545.8) v2@5314.07,3532.36 ; 5305.85,3552.33 ccw(c5324.27,3552.33) v2@5315.89,3535.92 ; 5305.85,3558.87 ccw(c5327.61,3558.87) v2@5317.71,3539.49 ; v3(5311.26,3835.67) U8.AC13@5330.94,3855.35 ; v3(5311.26,3993.15) U8.W13@5330.94,4012.83 ; v3(5311.26,4071.89) U8.U13@5330.94,4091.57 ; v3(5311.26,4150.63) U8.R13@5330.94,4170.31 ; v3(5311.26,4347.48) U8.L13@5330.94,4327.8 ; v3(5311.26,4544.33) U8.F13@5330.94,4524.65 ; v2(5315.07,3534.31) 5315.07,3532.07 5310.74,3527.74 5310.53,3527.74 5309.51,3528.75 5305.85,3532.42 5305.85,3534.31 5305.85,3565.4 ; 5315.44,4749.44 5315.44,4750 ; v2@5319.53,3543.05 cw(c5330.95,3565.4) 5305.85,3565.4 ; U8.AG13@5323.6,3697.87 cw(c5305.88,3697.87) 5318.41,3685.34 ; U8.AC13@5323.6,3855.35 cw(c5305.88,3855.35) 5318.41,3842.82 cw(c5330.94,3830.29) U8.AC13@5330.95,3848.01 ; U8.W13@5323.6,4012.83 cw(c5305.88,4012.83) 5318.41,4000.3 cw(c5330.94,3987.77) U8.W13@5330.95,4005.49 ; U8.U13@5323.6,4091.57 cw(c5305.88,4091.57) 5318.41,4079.04 cw(c5330.94,4066.51) U8.U13@5330.95,4084.23 ; U8.R13@5323.6,4170.31 cw(c5305.88,4170.31) 5318.41,4157.78 cw(c5330.94,4145.25) U8.R13@5330.94,4162.97 ; U8.N13@5323.6,4249.05 ccw(c5305.88,4249.05) 5318.41,4261.59 ccw(c5330.94,4274.12) U8.N13@5330.95,4256.4 ; U8.L13@5323.6,4327.79 ccw(c5305.88,4327.79) 5318.41,4340.33 ccw(c5330.94,4352.86) U8.L13@5330.95,4335.14 ; U8.F13@5323.6,4524.65 ccw(c5305.88,4524.65) 5318.41,4537.18 ccw(c5330.94,4549.71) U8.F13@5330.95,4531.99 ; U8.B13@5323.6,4682.13 ccw(c5305.88,4682.13) 5318.41,4694.66 ; U8.AG13@5330.95,3690.53 ccw(c5330.95,3672.8) 5318.41,3685.34 ; U8.B13@5330.95,4689.47 cw(c5330.95,4707.19) 5318.41,4694.66 ; v2(5340,2830) v2@5345,2825 ; v3(5350.63,4032.52) U8.V14@5370.31,4052.2 ; v3(5350.63,4111.26) U8.T14@5370.31,4130.94 ; v3(5350.63,4229.37) U8.P14@5370.31,4209.68 ; v3(5350.63,4308.11) U8.M14@5370.31,4288.42 ; v3(5350.63,4386.85) U8.K14@5370.31,4367.17 ; 5357.78,4379.7 cw(c5345.25,4367.17) U8.K14@5362.97,4367.17 ; 5357.78,4379.7 ccw(c5370.31,4392.23) U8.K14@5370.31,4374.51 ; U8.V14@5362.97,4052.2 cw(c5345.25,4052.2) 5357.78,4039.67 cw(c5370.31,4027.14) U8.V14@5370.31,4044.86 ; U8.T14@5362.97,4130.94 cw(c5345.25,4130.94) 5357.78,4118.41 cw(c5370.31,4105.88) U8.T14@5370.31,4123.6 ; U8.P14@5362.97,4209.68 ccw(c5345.25,4209.68) 5357.78,4222.22 ccw(c5370.31,4234.75) U8.P14@5370.31,4217.03 ; U8.M14@5362.97,4288.42 ccw(c5345.25,4288.42) 5357.78,4300.96 ccw(c5370.31,4313.49) U8.M14@5370.31,4295.77 ; U8.W15@5409.69,4005.49 cw(c5409.69,3987.77) 5422.22,4000.3 cw(c5434.75,4012.83) U8.W15@5417.03,4012.83 ; U8.W15@5409.68,4012.83 v3(5429.37,3993.15) ; U8.U15@5409.69,4084.23 cw(c5409.69,4066.51) 5422.22,4079.04 cw(c5434.75,4091.57) U8.U15@5417.03,4091.57 ; U8.U15@5409.68,4091.57 v3(5429.37,4071.89) ; U8.R15@5409.68,4162.97 cw(c5409.68,4145.25) 5422.22,4157.78 cw(c5434.75,4170.31) U8.R15@5417.03,4170.31 ; U8.R15@5409.68,4170.31 v3(5429.37,4150.63) ; U8.N15@5409.68,4249.05 v3(5429.37,4268.74) ; U8.N15@5409.69,4256.4 ccw(c5409.69,4274.12) 5422.22,4261.59 ccw(c5434.75,4249.05) U8.N15@5417.03,4249.05 ; U8.L15@5409.68,4327.8 v3(5429.37,4347.48) ; U8.L15@5409.69,4335.14 ccw(c5409.69,4352.86) 5422.22,4340.33 ccw(c5434.75,4327.8) U8.L15@5417.03,4327.8 ; v2@5428.45,3567.69 ccw(c5411.7,3584.43) 5435.39,3584.43 ccw(c5459.07,3584.43) v2@5442.33,3567.69 ; v2@5431.28,3564.86 ccw(c5421.36,3574.78) 5435.39,3574.78 ccw(c5449.42,3574.78) v2@5439.5,3564.86 ; v2@5437.06,3562.42 v2(5435.39,3560.75) 5435.39,3589.45 5440.2,3594.26 5450.25,3604.31 5464.83,3618.9 5464.83,3678.24 ; U8.AG16@5449.05,3690.53 cw(c5449.05,3672.8) 5461.59,3685.34 ; U8.AC16@5449.05,3848.01 cw(c5449.05,3830.29) 5461.59,3842.82 cw(c5474.12,3855.35) U8.AC16@5456.4,3855.35 ; U8.AC16@5449.06,3855.35 v3(5468.74,3835.67) ; U8.V16@5449.05,4044.86 cw(c5449.05,4027.14) 5461.59,4039.67 cw(c5474.12,4052.2) U8.V16@5456.4,4052.2 ; U8.V16@5449.06,4052.2 v3(5468.74,4032.52) ; U8.T16@5449.05,4123.6 cw(c5449.05,4105.88) 5461.59,4118.41 cw(c5474.12,4130.95) U8.T16@5456.4,4130.95 ; U8.T16@5449.06,4130.94 v3(5468.74,4111.26) U8.U17@5488.43,4091.57 ; U8.P16@5449.06,4209.68 v3(5468.74,4229.37) ; U8.P16@5449.06,4217.03 ccw(c5449.06,4234.75) 5461.59,4222.22 ccw(c5474.12,4209.68) U8.P16@5456.4,4209.68 ; U8.M16@5449.06,4288.42 v3(5468.74,4308.11) ; U8.M16@5449.05,4295.77 ccw(c5449.05,4313.49) 5461.59,4300.96 ccw(c5474.12,4288.42) U8.M16@5456.4,4288.42 ; U8.K16@5449.06,4367.17 v3(5468.74,4386.85) ; U8.K16@5449.05,4374.51 ccw(c5449.05,4392.23) 5461.59,4379.7 ccw(c5474.12,4367.16) U8.K16@5456.4,4367.16 ; U8.F16@5449.06,4524.65 v3(5468.74,4544.33) ; U8.F16@5449.05,4531.99 ccw(c5449.05,4549.71) 5461.59,4537.18 ccw(c5474.12,4524.65) U8.F16@5456.4,4524.65 ; U8.B16@5449.05,4689.47 ccw(c5449.05,4707.19) 5461.59,4694.66 ; v1(5453.86,4815.47) 5464.56,4804.76 5464.56,4763.79 5464.56,4701.84 cw(c5454.41,4701.84) 5461.59,4694.66 ; U8.AG16@5456.4,3697.87 ccw(c5474.12,3697.87) 5461.59,3685.34 ; U8.B16@5456.4,4682.13 cw(c5474.12,4682.13) 5461.59,4694.66 ; 5464.56,3678.16 ccw(c5454.41,3678.16) 5461.59,3685.34 ; U8.U17@5481.08,4091.57 ccw(c5463.36,4091.57) 5475.89,4104.11 ccw(c5488.43,4116.64) U8.U17@5488.43,4098.92 ; U8.W17@5488.42,4005.49 cw(c5488.42,3987.77) 5500.96,4000.3 cw(c5513.49,4012.83) U8.W17@5495.77,4012.83 ; U8.W17@5488.43,4012.83 v3(5508.11,3993.15) ; U8.R17@5488.43,4162.97 cw(c5488.42,4145.25) 5500.96,4157.78 cw(c5513.49,4170.31) U8.R17@5495.77,4170.31 ; U8.R17@5488.43,4170.31 v3(5508.11,4150.63) ; U8.N17@5488.43,4249.05 v3(5508.11,4268.74) ; U8.N17@5488.42,4256.4 ccw(c5488.42,4274.12) 5500.96,4261.59 ccw(c5513.49,4249.05) U8.N17@5495.77,4249.05 ; U8.L17@5488.43,4327.8 v3(5508.11,4347.48) ; U8.L17@5488.42,4335.14 ccw(c5488.42,4352.86) 5500.96,4340.33 ccw(c5513.49,4327.79) U8.L17@5495.77,4327.79 ; U8.Y18@5527.8,3966.12 cw(c5527.8,3948.4) 5540.33,3960.93 cw(c5552.86,3973.46) U8.Y18@5535.14,3973.46 ; U8.Y18@5527.8,3973.46 v3(5547.48,3953.78) ; U8.V18@5527.8,4044.86 cw(c5527.8,4027.14) 5540.33,4039.67 cw(c5552.86,4052.2) U8.V18@5535.14,4052.2 ; U8.V18@5527.8,4052.2 v3(5547.48,4032.52) ; U8.T18@5527.8,4123.6 cw(c5527.8,4105.88) 5540.33,4118.41 cw(c5552.86,4130.95) U8.T18@5535.14,4130.95 ; U8.T18@5527.8,4130.94 v3(5547.48,4111.26) ; U8.P18@5527.8,4209.68 v3(5547.48,4229.37) ; U8.P18@5527.8,4217.03 ccw(c5527.8,4234.75) 5540.33,4222.22 ccw(c5552.86,4209.68) U8.P18@5535.14,4209.68 ; U8.M18@5527.8,4288.42 v3(5547.48,4308.11) ; U8.M18@5527.8,4295.77 ccw(c5527.8,4313.49) 5540.33,4300.96 ccw(c5552.86,4288.42) U8.M18@5535.14,4288.42 ; U8.K18@5527.8,4367.17 v3(5547.48,4386.85) ; U8.K18@5527.8,4374.51 ccw(c5527.8,4392.23) 5540.33,4379.7 ccw(c5552.86,4367.16) U8.K18@5535.14,4367.16 ; U8.J18@5527.8,4406.54 v3(5547.48,4426.22) ; U8.J18@5527.8,4413.88 ccw(c5527.8,4431.6) 5540.33,4419.07 ccw(c5552.86,4406.53) U8.J18@5535.14,4406.54 ; U8.W19@5567.17,4005.49 cw(c5567.17,3987.77) 5579.7,4000.3 cw(c5592.23,4012.83) U8.W19@5574.51,4012.83 ; U8.W19@5567.17,4012.83 v3(5586.85,3993.15) ; U8.U19@5567.17,4084.23 cw(c5567.17,4066.51) 5579.7,4079.04 cw(c5592.23,4091.57) U8.U19@5574.51,4091.57 ; U8.U19@5567.17,4091.57 v3(5586.85,4071.89) ; U8.R19@5567.17,4162.97 cw(c5567.17,4145.25) 5579.7,4157.78 cw(c5592.23,4170.31) U8.R19@5574.51,4170.31 ; U8.R19@5567.17,4170.31 v3(5586.85,4150.63) ; U8.N19@5567.17,4249.05 v3(5586.85,4268.74) ; U8.N19@5567.17,4256.4 ccw(c5567.17,4274.12) 5579.7,4261.59 ccw(c5592.23,4249.05) U8.N19@5574.51,4249.05 ; U8.L19@5567.17,4327.8 v3(5586.85,4347.48) ; U8.L19@5567.17,4335.14 ccw(c5567.17,4352.86) 5579.7,4340.33 ccw(c5592.23,4327.8) U8.L19@5574.51,4327.8 ; v2@5598,3472.1 v2(5598,3468) 5611.11,3481.11 5611.11,3490 ; U8.AG20@5606.54,3690.53 cw(c5606.54,3672.8) 5619.07,3685.34 ; U8.AC20@5606.54,3848.01 cw(c5606.54,3830.29) 5619.07,3842.82 cw(c5631.6,3855.35) U8.AC20@5613.88,3855.35 ; U8.AC20@5606.54,3855.35 v3(5626.22,3835.67) ; U8.AA20@5606.54,3926.75 cw(c5606.54,3909.03) 5619.07,3921.56 cw(c5631.6,3934.09) U8.AA20@5613.88,3934.09 ; U8.AA20@5606.54,3934.09 v3(5626.22,3914.41) ; U8.T20@5606.54,4123.6 cw(c5606.54,4105.88) 5619.07,4118.41 cw(c5631.6,4130.94) U8.T20@5613.88,4130.94 ; U8.T20@5606.54,4130.94 v3(5626.22,4111.26) ; U8.P20@5606.54,4209.68 v3(5626.22,4229.37) ; U8.P20@5606.54,4217.03 ccw(c5606.54,4234.75) 5619.07,4222.22 ccw(c5631.6,4209.68) U8.P20@5613.88,4209.68 ; U8.M20@5606.54,4288.42 v3(5626.22,4308.11) ; U8.M20@5606.54,4295.77 ccw(c5606.54,4313.49) 5619.07,4300.96 ccw(c5631.6,4288.42) U8.M20@5613.88,4288.42 ; U8.K20@5606.54,4367.17 v3(5626.22,4386.85) ; U8.K20@5606.54,4374.51 ccw(c5606.54,4392.23) 5619.07,4379.7 ccw(c5631.6,4367.17) U8.K20@5613.88,4367.17 ; U8.H20@5606.54,4445.91 v3(5626.22,4465.59) ; U8.H20@5606.54,4453.25 ccw(c5606.54,4470.97) 5619.07,4458.44 ccw(c5631.6,4445.91) U8.H20@5613.88,4445.91 ; U8.F20@5606.54,4524.65 v3(5626.22,4544.33) ; U8.F20@5606.54,4531.99 ccw(c5606.54,4549.71) 5619.07,4537.18 ccw(c5631.6,4524.65) U8.F20@5613.88,4524.65 ; U8.B20@5606.54,4689.47 ccw(c5606.54,4707.19) 5619.07,4694.66 ; 5611.11,3485.21 5611.11,3490 ; U8.AG20@5613.88,3697.87 ccw(c5631.6,3697.87) 5619.07,3685.34 ; U8.B20@5613.88,4682.13 cw(c5631.6,4682.13) 5619.07,4694.66 ; v1(5640.19,3175.04) 5665.04,3175.04 NT40.2@5670,3180 ; v1@5644.08,3171.15 cw(c5653.47,3161.76) 5653.47,3175.04 cw(c5653.47,3188.32) v1@5644.08,3178.93 ; v1(5645,4845) 5655,4835 5655,4815 5622.04,4782.04 5622.04,4701.84 cw(c5611.89,4701.84) 5619.07,4694.66 ; v1@5646.91,3168.32 cw(c5663.13,3152.11) 5663.13,3175.04 cw(c5663.13,3197.98) v1@5646.91,3181.76 ; 5659.23,3175.04 ccw(c5659.23,3186.27) NT40.2@5667.17,3178.33 ; 5661.45,3175.04 cw(c5661.45,3166.95) NT40.2@5667.17,3172.67 ; U8.P22@5685.28,4209.68 v3(5704.96,4229.37) ; U8.P22@5685.28,4217.03 ccw(c5685.28,4234.75) 5697.81,4222.22 ccw(c5710.34,4209.68) U8.P22@5692.62,4209.68 ; U8.N22@5685.28,4249.05 v3(5704.96,4268.74) ; U8.N22@5685.28,4256.4 ccw(c5685.28,4274.12) 5697.81,4261.59 ccw(c5710.34,4249.05) U8.N22@5692.62,4249.05 ; U8.M22@5685.28,4288.42 v3(5704.96,4308.11) ; U8.M22@5685.28,4295.77 ccw(c5685.28,4313.49) 5697.81,4300.96 ccw(c5710.34,4288.42) U8.M22@5692.62,4288.42 ; v1@5699.15,4768 v1(5704,4768) ; U8.AC23@5724.65,3848.01 cw(c5724.65,3830.29) 5737.18,3842.82 cw(c5749.71,3855.35) U8.AC23@5731.99,3855.35 ; U8.AC23@5724.65,3855.35 v3(5744.33,3835.67) ; U8.W23@5724.65,4005.49 cw(c5724.65,3987.77) 5737.18,4000.3 cw(c5749.71,4012.83) U8.W23@5731.99,4012.83 ; U8.W23@5724.65,4012.83 v3(5744.33,3993.15) ; U8.T23@5724.65,4123.6 cw(c5724.65,4105.88) 5737.18,4118.41 cw(c5749.71,4130.94) U8.T23@5731.99,4130.94 ; U8.T23@5724.65,4130.94 v3(5744.33,4111.26) ; U8.P23@5724.65,4209.68 v3(5744.33,4229.37) ; U8.P23@5724.65,4217.03 ccw(c5724.65,4234.75) 5737.18,4222.22 ccw(c5749.71,4209.68) U8.P23@5731.99,4209.68 ; U8.N23@5724.65,4249.05 v3(5744.33,4268.74) ; U8.N23@5724.65,4256.4 ccw(c5724.65,4274.12) 5737.18,4261.59 ccw(c5749.71,4249.05) U8.N23@5731.99,4249.05 ; U8.K23@5724.65,4367.17 v3(5744.33,4386.85) ; U8.K23@5724.65,4374.51 ccw(c5724.65,4392.23) 5737.18,4379.7 ccw(c5749.71,4367.17) U8.K23@5731.99,4367.17 ; U8.F23@5724.65,4524.65 v3(5744.33,4544.33) ; U8.F23@5724.65,4531.99 ccw(c5724.65,4549.71) 5737.18,4537.18 ccw(c5749.71,4524.65) U8.F23@5731.99,4524.65 ; v1(5765,4835) 5768.96,4831.04 5802.96,4831.04 5813,4821 5813,4801 5779.52,4767.52 5779.52,4740 ; 5771.33,3577.54 ccw(c5790,3596.21) v2@5790,3569.81 ; 5774.05,3574.83 cw(c5759.22,3560) v2@5780.19,3560 ; 5778.16,3570.72 ccw(c5790,3582.56) v2@5790,3565.81 ; 5779.52,4741.18 5779.52,4740 ; 5780.88,3568 cw(c5772.88,3560) v2@5784.19,3560 ; v2@5788.87,3560 5768.5,3580.37 5768.5,3614.81 5779.52,3625.84 5779.52,3678.16 ; U8.AA27@5882.13,3926.75 cw(c5882.13,3909.03) 5894.66,3921.56 ; U8.T27@5882.13,4123.6 cw(c5882.13,4105.88) 5894.66,4118.41 ; U8.N27@5882.13,4256.4 ccw(c5882.13,4274.12) 5894.66,4261.59 ; U8.H27@5882.13,4453.25 ccw(c5882.13,4470.97) 5894.66,4458.44 ; U8.AA27@5889.47,3934.09 ccw(c5907.19,3934.09) 5894.66,3921.56 ; U8.T27@5889.47,4130.94 ccw(c5907.19,4130.94) 5894.66,4118.41 ; U8.N27@5889.47,4249.05 cw(c5907.19,4249.05) 5894.66,4261.59 ; U8.H27@5889.47,4445.91 cw(c5907.19,4445.91) 5894.66,4458.44 ; U8.AF28@5921.5,3737.24 5947.76,3737.24 5985.12,3699.88 5985.12,3624.88 v2(6010,3600) ; U8.AF28@5926.69,3732.05 cw(c5939.22,3719.52) 5939.22,3737.24 cw(c5939.22,3754.97) U8.AF28@5926.69,3742.44 ; U8.C28@5926.69,4637.56 cw(c5939.22,4625.03) 5939.22,4642.76 ; U8.C28@5926.69,4647.95 ccw(c5939.22,4660.48) 5939.22,4642.76 ; v2@5931.19,4791 cw(c5907.5,4791) 5924.25,4774.25 cw(c5941,4757.5) v2@5941,4781.19 ; v2@5935.19,4791 cw(c5921.16,4791) 5931.08,4781.08 cw(c5941,4771.16) v2@5941,4785.19 ; v2(5941,4791) 5897.63,4747.63 5897.63,4741.18 5897.63,4701.84 ; 5941.18,4264.56 5940,4264.56 ; v1(5941.7,3609.4) 5927.05,3609.4 5897.63,3638.82 5897.63,3678.16 ; v1@5976.5,4239 ccw(c5953.56,4239) 5969.78,4255.22 ccw(c5986,4271.43) v1@5986,4248.5 ; v2@5979.13,4631.37 ccw(c5962.38,4614.63) 5962.38,4638.31 ccw(c5962.38,4662) v2@5979.13,4645.25 ; v1@5980.5,4239 ccw(c5967.22,4239) 5976.61,4248.39 ccw(c5986,4257.78) v1@5986,4244.5 ; v2@5981.96,4634.2 ccw(c5972.04,4624.28) 5972.04,4638.31 ccw(c5972.04,4652.34) v2@5981.96,4642.42 ; v1(5986,4239) 5960.44,4264.56 5940,4264.56 ; v2(5986.07,4638.31) 5958.31,4638.31 5953.87,4642.76 5939.22,4642.76 ; v2@6000.19,3600 ccw(c5976.5,3600) 5993.25,3616.75 ccw(c6010,3633.5) v2@6010,3609.81 ; v2@6004.19,3600 ccw(c5990.16,3600) 6000.08,3609.92 ccw(c6010,3619.84) v2@6010,3605.81 ; v2(6045.69,4427.82) 6005.18,4427.82 5979.09,4453.91 5971.59,4461.41 5958.59,4461.41 5901.84,4461.41 ccw(c5901.84,4451.26) 5894.66,4458.44 ; v2(6054,4106) 6047.54,4099.54 5987.83,4099.54 5971.94,4115.44 5901.84,4115.44 cw(c5901.84,4125.59) 5894.66,4118.41 ; v2(6063.93,3891.33) 6063.3,3890.7 6030.48,3890.7 5995.58,3925.6 5948.19,3925.6 5941.18,3918.59 5901.84,3918.59 cw(c5901.84,3928.74) 5894.66,3921.56 ; v3(6734.41,1589.41) U30.R2@6754.09,1609.09 ; v3@6734.41,1596.91 ccw(c6734.41,1615.02) 6747.21,1602.21 ccw(c6760.02,1589.41) v3@6741.91,1589.41 ; v3(6734.41,2140.59) U30.B2@6754.09,2120.91 ; U30.B2@6746.75,2120.91 ccw(c6729.03,2120.91) 6741.56,2133.44 ccw(c6754.09,2145.97) U30.B2@6754.09,2128.25 ; v3(6773.78,1825.63) U30.J3@6793.46,1845.31 ; U30.J3@6786.12,1845.31 cw(c6768.4,1845.31) 6780.93,1832.78 cw(c6793.46,1820.25) U30.J3@6793.46,1837.97 ; v3(6813.15,1707.52) U30.M4@6832.83,1727.2 ; v3(6813.15,1786.26) U30.K4@6832.83,1805.94 ; v3(6813.15,1943.74) U30.G4@6832.83,1924.05 ; v3(6813.15,2022.48) U30.E4@6832.83,2002.8 ; U30.M4@6825.49,1727.2 cw(c6807.77,1727.2) 6820.3,1714.67 cw(c6832.83,1702.14) U30.M4@6832.83,1719.86 ; U30.K4@6825.49,1805.94 cw(c6807.77,1805.94) 6820.3,1793.41 cw(c6832.83,1780.88) U30.K4@6832.83,1798.6 ; U30.G4@6825.49,1924.05 ccw(c6807.77,1924.05) 6820.3,1936.59 ccw(c6832.83,1949.12) U30.G4@6832.83,1931.4 ; U30.E4@6825.49,2002.8 ccw(c6807.77,2002.8) 6820.3,2015.33 ccw(c6832.83,2027.86) U30.E4@6832.83,2010.14 ; v3(6852.52,1628.78) U30.P5@6872.2,1648.46 ; v3(6852.52,1707.52) U30.M5@6872.2,1727.2 ; v3(6852.52,2101.22) U30.C5@6872.2,2081.54 ; U30.P5@6864.86,1648.46 cw(c6847.14,1648.46) 6859.67,1635.93 cw(c6872.2,1623.4) U30.P5@6872.2,1641.12 ; U30.M5@6864.86,1727.2 cw(c6847.14,1727.2) 6859.67,1714.67 cw(c6872.2,1702.14) U30.M5@6872.2,1719.86 ; U30.C5@6864.86,2081.54 ccw(c6847.14,2081.54) 6859.67,2094.07 ccw(c6872.2,2106.6) U30.C5@6872.2,2088.88 ; v3(6931.26,1668.15) U30.N7@6950.94,1687.83 ; v3(6931.26,1825.63) U30.J7@6950.94,1845.31 ; v3(6931.26,1904.37) U30.H7@6950.94,1884.68 ; v3(6931.26,2061.85) U30.D7@6950.94,2042.17 ; U30.N7@6943.6,1687.83 cw(c6925.88,1687.83) 6938.41,1675.3 cw(c6950.94,1662.77) U30.N7@6950.94,1680.49 ; U30.J7@6943.6,1845.31 cw(c6925.88,1845.31) 6938.41,1832.78 cw(c6950.94,1820.25) U30.J7@6950.94,1837.97 ; U30.H7@6943.6,1884.68 ccw(c6925.88,1884.68) 6938.41,1897.22 ccw(c6950.94,1909.75) U30.H7@6950.94,1892.03 ; U30.D7@6943.6,2042.17 ccw(c6925.88,2042.16) 6938.41,2054.7 ccw(c6950.94,2067.23) U30.D7@6950.94,2049.51 ; v3(6970.63,1825.63) U30.J8@6990.32,1845.31 ; v3(6970.63,1904.37) U30.H8@6990.32,1884.68 ; U30.J8@6982.97,1845.31 cw(c6965.25,1845.31) 6977.78,1832.78 cw(c6990.31,1820.25) U30.J8@6990.31,1837.97 ; U30.H8@6982.97,1884.68 ccw(c6965.25,1884.68) 6977.78,1897.22 ccw(c6990.31,1909.75) U30.H8@6990.31,1892.03 ; U30.J9@7029.68,1837.97 cw(c7029.68,1820.25) 7042.22,1832.78 cw(c7054.75,1845.31) U30.J9@7037.03,1845.31 ; U30.J9@7029.69,1845.31 v3(7049.37,1825.63) ; U30.H9@7029.69,1884.68 v3(7049.37,1904.37) ; U30.H9@7029.68,1892.03 ccw(c7029.68,1909.75) 7042.22,1897.22 ccw(c7054.75,1884.68) U30.H9@7037.03,1884.68 ; U30.N10@7069.06,1680.49 cw(c7069.06,1662.77) 7081.59,1675.3 cw(c7094.12,1687.83) U30.N10@7076.4,1687.83 ; U30.N10@7069.06,1687.83 v3(7088.74,1668.15) ; U30.J10@7069.05,1837.97 cw(c7069.05,1820.25) 7081.59,1832.78 cw(c7094.12,1845.31) U30.J10@7076.4,1845.31 ; U30.J10@7069.06,1845.31 v3(7088.74,1825.63) ; U30.H10@7069.06,1884.68 v3(7088.74,1904.37) ; U30.H10@7069.05,1892.03 ccw(c7069.05,1909.75) 7081.59,1897.22 ccw(c7094.12,1884.68) U30.H10@7076.4,1884.68 ; U30.D10@7069.06,2042.17 v3(7088.74,2061.85) ; U30.D10@7069.06,2049.51 ccw(c7069.06,2067.23) 7081.59,2054.7 ccw(c7094.12,2042.16) U30.D10@7076.4,2042.17 ; v2(7070,2515) 7071.75,2515 7078,2508.75 7111.18,2475.57 R266.2@7111.18,2475 ; 7095.22,2491.53 cw(c7079.18,2475.49) R266.2@7101.86,2475.49 ; 7095.4,2491.35 ccw(c7111.18,2507.13) R266.2@7111.18,2484.81 ; R266.2@7102.05,2484.7 cw(c7092.84,2475.49) R266.2@7105.86,2475.49 ; R266.2@7102.23,2484.52 ccw(c7111.18,2493.47) R266.2@7111.18,2480.81 ; U30.P12@7147.8,1641.12 cw(c7147.8,1623.4) 7160.33,1635.93 cw(c7172.86,1648.46) U30.P12@7155.14,1648.46 ; U30.P12@7147.8,1648.46 v3(7167.48,1628.78) ; U30.G12@7147.8,1924.05 v3(7167.48,1943.74) ; U30.G12@7147.8,1931.4 ccw(c7147.8,1949.12) 7160.33,1936.59 ccw(c7172.86,1924.05) U30.G12@7155.14,1924.05 ; U30.E12@7147.8,2002.8 v3(7167.48,2022.48) ; U30.E12@7147.8,2010.14 ccw(c7147.8,2027.86) 7160.33,2015.33 ccw(c7172.86,2002.79) U30.E12@7155.14,2002.79 ; U30.C12@7147.8,2081.54 v3(7167.48,2101.22) ; U30.C12@7147.8,2088.88 ccw(c7147.8,2106.6) 7160.33,2094.07 ccw(c7172.86,2081.54) U30.C12@7155.14,2081.54 ; U30.M13@7187.17,1719.86 cw(c7187.17,1702.14) 7199.7,1714.67 cw(c7212.23,1727.2) U30.M13@7194.51,1727.2 ; U30.M13@7187.17,1727.2 v3(7206.85,1707.52) ; U30.K13@7187.17,1798.6 cw(c7187.17,1780.88) 7199.7,1793.41 cw(c7212.23,1805.94) U30.K13@7194.51,1805.94 ; U30.K13@7187.17,1805.94 v3(7206.85,1786.26) ; U30.H13@7187.17,1884.68 v3(7206.85,1904.37) ; U30.H13@7187.17,1892.03 ccw(c7187.17,1909.75) 7199.7,1897.22 ccw(c7212.23,1884.68) U30.H13@7194.51,1884.68 ; U30.G13@7187.17,1924.05 v3(7206.85,1943.74) ; U30.G13@7187.17,1931.4 ccw(c7187.17,1949.12) 7199.7,1936.59 ccw(c7212.23,1924.05) U30.G13@7194.51,1924.05 ; U30.E13@7187.17,2002.8 v3(7206.85,2022.48) ; U30.E13@7187.17,2010.14 ccw(c7187.17,2027.86) 7199.7,2015.33 ccw(c7212.23,2002.8) U30.E13@7194.51,2002.8 ; U30.R15@7265.91,1601.75 cw(c7265.91,1584.03) 7278.44,1596.56 cw(c7290.97,1609.09) U30.R15@7273.25,1609.09 ; U30.R15@7265.91,1609.09 v3(7285.59,1589.41) ; U30.B15@7265.91,2120.91 v3(7285.59,2140.59) ; U30.B15@7265.91,2128.25 ccw(c7265.91,2145.97) 7278.44,2133.44 ccw(c7290.97,2120.91) U30.B15@7273.25,2120.91 ; v2@4750,3898 4752,3900 ; v2@4750,3898 4752,3900 ; 4790,3729.97 4797.28,3737.24 4807.24,3737.24 ; 4807.24,3737.24 4815.24,3737.24 ; 4807.24,3737.24 4815.24,3737.24 ; 4815.24,3737.24 4840.78,3737.24 ; v6@4838.82,3632.18 v6(4838.82,3638.82) v6@4838.82,3632.18 ; v6@4838.82,3632.18 4838.82,3627.18 4842.43,3623.57 4847.43,3623.57 4879.07,3623.57 4882.37,3626.87 4882.37,3678.16 ; 4882.37,3678.16 cw(c4892.52,3678.16) 4885.34,3685.34 ; 4882.37,3678.16 cw(c4892.52,3678.16) 4885.34,3685.34 ; 4882.37,4701.84 ccw(c4892.52,4701.84) 4885.34,4694.66 ; 4882.37,4701.84 ccw(c4892.52,4701.84) 4885.34,4694.66 ; 4885.34,3685.34 cw(c4897.87,3672.8) 4897.87,3690.53 ccw(c4897.87,3672.8) 4885.34,3685.34 ; 4885.34,3685.34 ccw(c4872.81,3697.87) 4890.53,3697.87 cw(c4872.81,3697.87) 4885.34,3685.34 ; 4885.34,4694.66 ccw(c4897.87,4707.19) 4897.87,4689.47 cw(c4897.87,4707.19) 4885.34,4694.66 ; 4885.34,4694.66 cw(c4872.81,4682.13) 4890.53,4682.13 ccw(c4872.81,4682.13) 4885.34,4694.66 ; 5000.48,3678.16 cw(c5010.63,3678.16) 5003.45,3685.34 ; 5000.48,3678.16 cw(c5010.63,3678.16) 5003.45,3685.34 ; 5000.48,4701.84 ccw(c5010.63,4701.84) 5003.45,4694.66 ; 5000.48,4701.84 ccw(c5010.63,4701.84) 5003.45,4694.66 ; 5000.48,4701.84 5000.48,4741.18 5000.48,4764.48 ; 5003.45,3685.34 cw(c5015.98,3672.8) 5015.98,3690.53 ccw(c5015.98,3672.8) 5003.45,3685.34 ; 5003.45,3685.34 ccw(c4990.92,3697.87) 5008.64,3697.87 cw(c4990.92,3697.87) 5003.45,3685.34 ; 5003.45,4694.66 ccw(c5015.98,4707.19) 5015.98,4689.47 cw(c5015.98,4707.19) 5003.45,4694.66 ; 5003.45,4694.66 cw(c4990.92,4682.13) 5008.64,4682.13 ccw(c4990.92,4682.13) 5003.45,4694.66 ; 5048.47,3848.47 cw(c5035.67,3861.28) 5035.67,3843.17 ccw(c5035.67,3861.28) 5048.47,3848.47 ; 5048.47,3848.47 ccw(c5061.28,3835.67) 5043.17,3835.67 cw(c5061.28,3835.67) 5048.47,3848.47 ; 5048.47,4005.95 cw(c5035.67,4018.76) 5035.67,4000.65 ccw(c5035.67,4018.76) 5048.47,4005.95 ; 5048.47,4005.95 ccw(c5061.28,3993.15) 5043.17,3993.15 cw(c5061.28,3993.15) 5048.47,4005.95 ; 5048.47,4124.06 cw(c5035.67,4136.87) 5035.67,4118.76 ccw(c5035.67,4136.87) 5048.47,4124.06 ; 5048.47,4124.06 ccw(c5061.28,4111.26) 5043.17,4111.26 cw(c5061.28,4111.26) 5048.47,4124.06 ; 5048.47,4255.94 cw(c5061.28,4268.74) 5043.17,4268.74 ccw(c5061.28,4268.74) 5048.47,4255.94 ; 5048.47,4255.94 ccw(c5035.67,4243.13) 5035.67,4261.24 cw(c5035.67,4243.13) 5048.47,4255.94 ; 5048.47,4374.05 cw(c5061.28,4386.85) 5043.17,4386.85 ccw(c5061.28,4386.85) 5048.47,4374.05 ; 5048.47,4374.05 ccw(c5035.67,4361.24) 5035.67,4379.35 cw(c5035.67,4361.24) 5048.47,4374.05 ; 5048.47,4531.53 cw(c5061.28,4544.33) 5043.17,4544.33 ccw(c5061.28,4544.33) 5048.47,4531.53 ; 5048.47,4531.53 ccw(c5035.67,4518.72) 5035.67,4536.83 cw(c5035.67,4518.72) 5048.47,4531.53 ; 5127.21,4163.43 cw(c5114.41,4176.24) 5114.41,4158.13 ccw(c5114.41,4176.24) 5127.21,4163.43 ; 5127.21,4163.43 ccw(c5140.02,4150.63) 5121.91,4150.63 cw(c5140.02,4150.63) 5127.21,4163.43 ; 5157.96,3625 5157.96,3678.16 cw(c5168.11,3678.16) 5160.93,3685.34 ; 5157.96,4773.96 5157.96,4701.84 ccw(c5168.11,4701.84) 5160.93,4694.66 ; 5166.58,3848.47 cw(c5153.78,3861.28) 5153.78,3843.17 ccw(c5153.78,3861.28) 5166.58,3848.47 ; 5166.58,3848.47 ccw(c5179.39,3835.67) 5161.28,3835.67 cw(c5179.39,3835.67) 5166.58,3848.47 ; 5166.58,3927.21 cw(c5153.78,3940.02) 5153.78,3921.91 ccw(c5153.78,3940.02) 5166.58,3927.21 ; 5166.58,3927.21 ccw(c5179.39,3914.41) 5161.28,3914.41 cw(c5179.39,3914.41) 5166.58,3927.21 ; 5166.58,4084.69 cw(c5153.78,4097.5) 5153.78,4079.39 ccw(c5153.78,4097.5) 5166.58,4084.69 ; 5166.58,4084.69 ccw(c5179.39,4071.89) 5161.28,4071.89 cw(c5179.39,4071.89) 5166.58,4084.69 ; 5166.58,4163.43 cw(c5153.78,4176.24) 5153.78,4158.13 ccw(c5153.78,4176.24) 5166.58,4163.43 ; 5166.58,4163.43 ccw(c5179.39,4150.63) 5161.28,4150.63 cw(c5179.39,4150.63) 5166.58,4163.43 ; 5166.58,4255.94 cw(c5179.39,4268.74) 5161.28,4268.74 ccw(c5179.39,4268.74) 5166.58,4255.94 ; 5166.58,4255.94 ccw(c5153.78,4243.13) 5153.78,4261.24 cw(c5153.78,4243.13) 5166.58,4255.94 ; 5166.58,4334.68 cw(c5179.39,4347.48) 5161.28,4347.48 ccw(c5179.39,4347.48) 5166.58,4334.68 ; 5166.58,4334.68 ccw(c5153.78,4321.87) 5153.78,4339.98 cw(c5153.78,4321.87) 5166.58,4334.68 ; 5166.58,4452.79 cw(c5179.39,4465.59) 5161.28,4465.59 ccw(c5179.39,4465.59) 5166.58,4452.79 ; 5166.58,4452.79 ccw(c5153.78,4439.98) 5153.78,4458.09 cw(c5153.78,4439.98) 5166.58,4452.79 ; 5166.58,4531.53 cw(c5179.39,4544.33) 5161.28,4544.33 ccw(c5179.39,4544.33) 5166.58,4531.53 ; 5166.58,4531.53 ccw(c5153.78,4518.72) 5153.78,4536.83 cw(c5153.78,4518.72) 5166.58,4531.53 ; 5205.95,4045.32 cw(c5193.15,4058.13) 5193.15,4040.02 ccw(c5193.15,4058.13) 5205.95,4045.32 ; 5205.95,4045.32 ccw(c5218.76,4032.52) 5200.65,4032.52 cw(c5218.76,4032.52) 5205.95,4045.32 ; 5205.95,4124.06 cw(c5193.15,4136.87) 5193.15,4118.76 ccw(c5193.15,4136.87) 5205.95,4124.06 ; 5205.95,4124.06 ccw(c5218.76,4111.26) 5200.65,4111.26 cw(c5218.76,4111.26) 5205.95,4124.06 ; 5205.95,4216.57 cw(c5218.76,4229.37) 5200.65,4229.37 ccw(c5218.76,4229.37) 5205.95,4216.57 ; 5205.95,4216.57 ccw(c5193.15,4203.76) 5193.15,4221.87 cw(c5193.15,4203.76) 5205.95,4216.57 ; 5205.95,4295.31 cw(c5218.76,4308.11) 5200.65,4308.11 ccw(c5218.76,4308.11) 5205.95,4295.31 ; 5205.95,4295.31 ccw(c5193.15,4282.5) 5193.15,4300.61 cw(c5193.15,4282.5) 5205.95,4295.31 ; 5205.95,4374.05 cw(c5218.76,4386.85) 5200.65,4386.85 ccw(c5218.76,4386.85) 5205.95,4374.05 ; 5205.95,4374.05 ccw(c5193.15,4361.24) 5193.15,4379.35 cw(c5193.15,4361.24) 5205.95,4374.05 ; 5245.32,3966.58 cw(c5232.52,3979.39) 5232.52,3961.28 ccw(c5232.52,3979.39) 5245.32,3966.58 ; 5245.32,3966.58 ccw(c5258.13,3953.78) 5240.02,3953.78 cw(c5258.13,3953.78) 5245.32,3966.58 ; 5245.32,4005.95 cw(c5232.52,4018.76) 5232.52,4000.65 ccw(c5232.52,4018.76) 5245.32,4005.95 ; 5245.32,4005.95 ccw(c5258.13,3993.15) 5240.02,3993.15 cw(c5258.13,3993.15) 5245.32,4005.95 ; 5245.32,4084.69 cw(c5232.52,4097.5) 5232.52,4079.39 ccw(c5232.52,4097.5) 5245.32,4084.69 ; 5245.32,4084.69 ccw(c5258.13,4071.89) 5240.02,4071.89 cw(c5258.13,4071.89) 5245.32,4084.69 ; 5245.32,4163.43 cw(c5232.52,4176.24) 5232.52,4158.13 ccw(c5232.52,4176.24) 5245.32,4163.43 ; 5245.32,4163.43 ccw(c5258.13,4150.63) 5240.02,4150.63 cw(c5258.13,4150.63) 5245.32,4163.43 ; 5245.32,4255.94 cw(c5258.13,4268.74) 5240.02,4268.74 ccw(c5258.13,4268.74) 5245.32,4255.94 ; 5245.32,4255.94 ccw(c5232.52,4243.13) 5232.52,4261.24 cw(c5232.52,4243.13) 5245.32,4255.94 ; 5245.32,4334.68 cw(c5258.13,4347.48) 5240.02,4347.48 ccw(c5258.13,4347.48) 5245.32,4334.68 ; 5245.32,4334.68 ccw(c5232.52,4321.87) 5232.52,4339.98 cw(c5232.52,4321.87) 5245.32,4334.68 ; 5245.32,4413.42 cw(c5258.13,4426.22) 5240.02,4426.22 ccw(c5258.13,4426.22) 5245.32,4413.42 ; 5245.32,4413.42 ccw(c5232.52,4400.61) 5232.52,4418.72 cw(c5232.52,4400.61) 5245.32,4413.42 ; 5284.69,4045.32 cw(c5271.89,4058.13) 5271.89,4040.02 ccw(c5271.89,4058.13) 5284.69,4045.32 ; 5284.69,4045.32 ccw(c5297.5,4032.52) 5279.39,4032.52 cw(c5297.5,4032.52) 5284.69,4045.32 ; 5284.69,4124.06 cw(c5271.89,4136.87) 5271.89,4118.76 ccw(c5271.89,4136.87) 5284.69,4124.06 ; 5284.69,4124.06 ccw(c5297.5,4111.26) 5279.39,4111.26 cw(c5297.5,4111.26) 5284.69,4124.06 ; 5284.69,4216.57 cw(c5297.5,4229.37) 5279.39,4229.37 ccw(c5297.5,4229.37) 5284.69,4216.57 ; 5284.69,4216.57 ccw(c5271.89,4203.76) 5271.89,4221.87 cw(c5271.89,4203.76) 5284.69,4216.57 ; 5284.69,4374.05 cw(c5297.5,4386.85) 5279.39,4386.85 ccw(c5297.5,4386.85) 5284.69,4374.05 ; 5284.69,4374.05 ccw(c5271.89,4361.24) 5271.89,4379.35 cw(c5271.89,4361.24) 5284.69,4374.05 ; 5298.46,4281.54 cw(c5285.65,4268.74) 5303.76,4268.74 ccw(c5285.65,4268.74) 5298.46,4281.54 ; 5298.46,4281.54 ccw(c5311.26,4294.35) 5311.26,4276.24 cw(c5311.26,4294.35) 5298.46,4281.54 ; 5300.02,3582 5300.15,3582.13 5300.15,3588.9 ; 5300.02,3582 5300.02,3571.23 5305.85,3565.4 ; 5300.02,3582 5300.02,3588.77 5300.15,3588.9 ; 5300.15,3588.9 5300.15,3608.5 5315.44,3623.78 5315.44,3678.16 cw(c5325.59,3678.16) 5318.41,3685.34 ; 5315.44,4750 5315.44,4701.84 ccw(c5325.59,4701.84) 5318.41,4694.66 ; 5324.06,3848.47 cw(c5311.26,3861.28) 5311.26,3843.17 ccw(c5311.26,3861.28) 5324.06,3848.47 ; 5324.06,3848.47 ccw(c5336.87,3835.67) 5318.76,3835.67 cw(c5336.87,3835.67) 5324.06,3848.47 ; 5324.06,4005.95 cw(c5311.26,4018.76) 5311.26,4000.65 ccw(c5311.26,4018.76) 5324.06,4005.95 ; 5324.06,4005.95 ccw(c5336.87,3993.15) 5318.76,3993.15 cw(c5336.87,3993.15) 5324.06,4005.95 ; 5324.06,4084.69 cw(c5311.26,4097.5) 5311.26,4079.39 ccw(c5311.26,4097.5) 5324.06,4084.69 ; 5324.06,4084.69 ccw(c5336.87,4071.89) 5318.76,4071.89 cw(c5336.87,4071.89) 5324.06,4084.69 ; 5324.06,4163.43 cw(c5311.26,4176.24) 5311.26,4158.13 ccw(c5311.26,4176.24) 5324.06,4163.43 ; 5324.06,4163.43 ccw(c5336.87,4150.63) 5318.76,4150.63 cw(c5336.87,4150.63) 5324.06,4163.43 ; 5324.06,4255.94 cw(c5336.87,4268.74) 5318.76,4268.74 ccw(c5336.87,4268.74) 5324.06,4255.94 ; 5324.06,4255.94 ccw(c5311.26,4243.13) 5311.26,4261.24 cw(c5311.26,4243.13) 5324.06,4255.94 ; 5324.06,4334.68 cw(c5336.87,4347.48) 5318.76,4347.48 ccw(c5336.87,4347.48) 5324.06,4334.68 ; 5324.06,4334.68 ccw(c5311.26,4321.87) 5311.26,4339.98 cw(c5311.26,4321.87) 5324.06,4334.68 ; 5324.06,4531.53 cw(c5336.87,4544.33) 5318.76,4544.33 ccw(c5336.87,4544.33) 5324.06,4531.53 ; 5324.06,4531.53 ccw(c5311.26,4518.72) 5311.26,4536.83 cw(c5311.26,4518.72) 5324.06,4531.53 ; 5363.43,4045.32 cw(c5350.63,4058.13) 5350.63,4040.02 ccw(c5350.63,4058.13) 5363.43,4045.32 ; 5363.43,4045.32 ccw(c5376.24,4032.52) 5358.13,4032.52 cw(c5376.24,4032.52) 5363.43,4045.32 ; 5363.43,4124.06 cw(c5350.63,4136.87) 5350.63,4118.76 ccw(c5350.63,4136.87) 5363.43,4124.06 ; 5363.43,4124.06 ccw(c5376.24,4111.26) 5358.13,4111.26 cw(c5376.24,4111.26) 5363.43,4124.06 ; 5363.43,4216.57 cw(c5376.24,4229.37) 5358.13,4229.37 ccw(c5376.24,4229.37) 5363.43,4216.57 ; 5363.43,4216.57 ccw(c5350.63,4203.76) 5350.63,4221.87 cw(c5350.63,4203.76) 5363.43,4216.57 ; 5363.43,4295.31 cw(c5376.24,4308.11) 5358.13,4308.11 ccw(c5376.24,4308.11) 5363.43,4295.31 ; 5363.43,4295.31 ccw(c5350.63,4282.5) 5350.63,4300.61 cw(c5350.63,4282.5) 5363.43,4295.31 ; 5363.43,4374.05 cw(c5376.24,4386.85) 5358.13,4386.85 ccw(c5376.24,4386.85) 5363.43,4374.05 ; 5363.43,4374.05 ccw(c5350.63,4361.24) 5350.63,4379.35 cw(c5350.63,4361.24) 5363.43,4374.05 ; 5416.57,4005.95 cw(c5403.76,3993.15) 5421.87,3993.15 ccw(c5403.76,3993.15) 5416.57,4005.95 ; 5416.57,4005.95 ccw(c5429.37,4018.76) 5429.37,4000.65 cw(c5429.37,4018.76) 5416.57,4005.95 ; 5416.57,4084.69 cw(c5403.76,4071.89) 5421.87,4071.89 ccw(c5403.76,4071.89) 5416.57,4084.69 ; 5416.57,4084.69 ccw(c5429.37,4097.5) 5429.37,4079.39 cw(c5429.37,4097.5) 5416.57,4084.69 ; 5416.57,4163.43 cw(c5403.76,4150.63) 5421.87,4150.63 ccw(c5403.76,4150.63) 5416.57,4163.43 ; 5416.57,4163.43 ccw(c5429.37,4176.24) 5429.37,4158.13 cw(c5429.37,4176.24) 5416.57,4163.43 ; 5416.57,4255.94 cw(c5429.37,4243.13) 5429.37,4261.24 ccw(c5429.37,4243.13) 5416.57,4255.94 ; 5416.57,4255.94 ccw(c5403.76,4268.74) 5421.87,4268.74 cw(c5403.76,4268.74) 5416.57,4255.94 ; 5416.57,4334.68 cw(c5429.37,4321.87) 5429.37,4339.98 ccw(c5429.37,4321.87) 5416.57,4334.68 ; 5416.57,4334.68 ccw(c5403.76,4347.48) 5421.87,4347.48 cw(c5403.76,4347.48) 5416.57,4334.68 ; 5455.94,3848.47 cw(c5443.13,3835.67) 5461.24,3835.67 ccw(c5443.13,3835.67) 5455.94,3848.47 ; 5455.94,3848.47 ccw(c5468.74,3861.28) 5468.74,3843.17 cw(c5468.74,3861.28) 5455.94,3848.47 ; 5455.94,4045.32 cw(c5443.13,4032.52) 5461.24,4032.52 ccw(c5443.13,4032.52) 5455.94,4045.32 ; 5455.94,4045.32 ccw(c5468.74,4058.13) 5468.74,4040.02 cw(c5468.74,4058.13) 5455.94,4045.32 ; 5455.94,4124.06 cw(c5443.13,4111.26) 5461.24,4111.26 ccw(c5443.13,4111.26) 5455.94,4124.06 ; 5455.94,4124.06 ccw(c5468.74,4136.87) 5468.74,4118.76 cw(c5468.74,4136.87) 5455.94,4124.06 ; 5455.94,4216.57 cw(c5468.74,4203.76) 5468.74,4221.87 ccw(c5468.74,4203.76) 5455.94,4216.57 ; 5455.94,4216.57 ccw(c5443.13,4229.37) 5461.24,4229.37 cw(c5443.13,4229.37) 5455.94,4216.57 ; 5455.94,4295.31 cw(c5468.74,4282.5) 5468.74,4300.61 ccw(c5468.74,4282.5) 5455.94,4295.31 ; 5455.94,4295.31 ccw(c5443.13,4308.11) 5461.24,4308.11 cw(c5443.13,4308.11) 5455.94,4295.31 ; 5455.94,4374.05 cw(c5468.74,4361.24) 5468.74,4379.35 ccw(c5468.74,4361.24) 5455.94,4374.05 ; 5455.94,4374.05 ccw(c5443.13,4386.85) 5461.24,4386.85 cw(c5443.13,4386.85) 5455.94,4374.05 ; 5455.94,4531.53 cw(c5468.74,4518.72) 5468.74,4536.83 ccw(c5468.74,4518.72) 5455.94,4531.53 ; 5455.94,4531.53 ccw(c5443.13,4544.33) 5461.24,4544.33 cw(c5443.13,4544.33) 5455.94,4531.53 ; 5481.54,4098.46 cw(c5494.35,4111.26) 5476.24,4111.26 ccw(c5494.35,4111.26) 5481.54,4098.46 ; 5481.54,4098.46 ccw(c5468.74,4085.65) 5468.74,4103.76 cw(c5468.74,4085.65) 5481.54,4098.46 ; 5495.31,4005.95 cw(c5482.5,3993.15) 5500.61,3993.15 ccw(c5482.5,3993.15) 5495.31,4005.95 ; 5495.31,4005.95 ccw(c5508.11,4018.76) 5508.11,4000.65 cw(c5508.11,4018.76) 5495.31,4005.95 ; 5495.31,4163.43 cw(c5482.5,4150.63) 5500.61,4150.63 ccw(c5482.5,4150.63) 5495.31,4163.43 ; 5495.31,4163.43 ccw(c5508.11,4176.24) 5508.11,4158.13 cw(c5508.11,4176.24) 5495.31,4163.43 ; 5495.31,4255.94 cw(c5508.11,4243.13) 5508.11,4261.24 ccw(c5508.11,4243.13) 5495.31,4255.94 ; 5495.31,4255.94 ccw(c5482.5,4268.74) 5500.61,4268.74 cw(c5482.5,4268.74) 5495.31,4255.94 ; 5495.31,4334.68 cw(c5508.11,4321.87) 5508.11,4339.98 ccw(c5508.11,4321.87) 5495.31,4334.68 ; 5495.31,4334.68 ccw(c5482.5,4347.48) 5500.61,4347.48 cw(c5482.5,4347.48) 5495.31,4334.68 ; 5534.68,3966.58 cw(c5521.87,3953.78) 5539.98,3953.78 ccw(c5521.87,3953.78) 5534.68,3966.58 ; 5534.68,3966.58 ccw(c5547.48,3979.39) 5547.48,3961.28 cw(c5547.48,3979.39) 5534.68,3966.58 ; 5534.68,4045.32 cw(c5521.87,4032.52) 5539.98,4032.52 ccw(c5521.87,4032.52) 5534.68,4045.32 ; 5534.68,4045.32 ccw(c5547.48,4058.13) 5547.48,4040.02 cw(c5547.48,4058.13) 5534.68,4045.32 ; 5534.68,4124.06 cw(c5521.87,4111.26) 5539.98,4111.26 ccw(c5521.87,4111.26) 5534.68,4124.06 ; 5534.68,4124.06 ccw(c5547.48,4136.87) 5547.48,4118.76 cw(c5547.48,4136.87) 5534.68,4124.06 ; 5534.68,4216.57 cw(c5547.48,4203.76) 5547.48,4221.87 ccw(c5547.48,4203.76) 5534.68,4216.57 ; 5534.68,4216.57 ccw(c5521.87,4229.37) 5539.98,4229.37 cw(c5521.87,4229.37) 5534.68,4216.57 ; 5534.68,4295.31 cw(c5547.48,4282.5) 5547.48,4300.61 ccw(c5547.48,4282.5) 5534.68,4295.31 ; 5534.68,4295.31 ccw(c5521.87,4308.11) 5539.98,4308.11 cw(c5521.87,4308.11) 5534.68,4295.31 ; 5534.68,4374.05 cw(c5547.48,4361.24) 5547.48,4379.35 ccw(c5547.48,4361.24) 5534.68,4374.05 ; 5534.68,4374.05 ccw(c5521.87,4386.85) 5539.98,4386.85 cw(c5521.87,4386.85) 5534.68,4374.05 ; 5534.68,4413.42 cw(c5547.48,4400.61) 5547.48,4418.72 ccw(c5547.48,4400.61) 5534.68,4413.42 ; 5534.68,4413.42 ccw(c5521.87,4426.22) 5539.98,4426.22 cw(c5521.87,4426.22) 5534.68,4413.42 ; 5574.05,4005.95 cw(c5561.24,3993.15) 5579.35,3993.15 ccw(c5561.24,3993.15) 5574.05,4005.95 ; 5574.05,4005.95 ccw(c5586.85,4018.76) 5586.85,4000.65 cw(c5586.85,4018.76) 5574.05,4005.95 ; 5574.05,4084.69 cw(c5561.24,4071.89) 5579.35,4071.89 ccw(c5561.24,4071.89) 5574.05,4084.69 ; 5574.05,4084.69 ccw(c5586.85,4097.5) 5586.85,4079.39 cw(c5586.85,4097.5) 5574.05,4084.69 ; 5574.05,4163.43 cw(c5561.24,4150.63) 5579.35,4150.63 ccw(c5561.24,4150.63) 5574.05,4163.43 ; 5574.05,4163.43 ccw(c5586.85,4176.24) 5586.85,4158.13 cw(c5586.85,4176.24) 5574.05,4163.43 ; 5574.05,4255.94 cw(c5586.85,4243.13) 5586.85,4261.24 ccw(c5586.85,4243.13) 5574.05,4255.94 ; 5574.05,4255.94 ccw(c5561.24,4268.74) 5579.35,4268.74 cw(c5561.24,4268.74) 5574.05,4255.94 ; 5574.05,4334.68 cw(c5586.85,4321.87) 5586.85,4339.98 ccw(c5586.85,4321.87) 5574.05,4334.68 ; 5574.05,4334.68 ccw(c5561.24,4347.48) 5579.35,4347.48 cw(c5561.24,4347.48) 5574.05,4334.68 ; 5611.11,3490 5611.11,3606.42 5622.04,3617.36 5622.04,3678.16 ccw(c5611.89,3678.16) 5619.07,3685.34 ; 5613.42,3848.47 cw(c5600.61,3835.67) 5618.72,3835.67 ccw(c5600.61,3835.67) 5613.42,3848.47 ; 5613.42,3848.47 ccw(c5626.22,3861.28) 5626.22,3843.17 cw(c5626.22,3861.28) 5613.42,3848.47 ; 5613.42,3927.21 cw(c5600.61,3914.41) v3@5618.72,3914.41 ; 5613.42,3927.21 ccw(c5626.22,3940.02) v3@5626.22,3921.91 ; 5613.42,3927.21 cw(c5600.61,3914.41) v3@5618.72,3914.41 ; 5613.42,3927.21 ccw(c5626.22,3940.02) v3@5626.22,3921.91 ; 5613.42,3927.21 ccw(c5626.22,3940.02) v3@5626.22,3921.91 ; 5613.42,3927.21 cw(c5600.61,3914.41) v3@5618.72,3914.41 ; 5613.42,4124.06 cw(c5600.61,4111.26) 5618.72,4111.26 ccw(c5600.61,4111.26) 5613.42,4124.06 ; 5613.42,4124.06 ccw(c5626.22,4136.87) 5626.22,4118.76 cw(c5626.22,4136.87) 5613.42,4124.06 ; 5613.42,4216.57 cw(c5626.22,4203.76) 5626.22,4221.87 ccw(c5626.22,4203.76) 5613.42,4216.57 ; 5613.42,4216.57 ccw(c5600.61,4229.37) 5618.72,4229.37 cw(c5600.61,4229.37) 5613.42,4216.57 ; 5613.42,4295.31 cw(c5626.22,4282.5) 5626.22,4300.61 ccw(c5626.22,4282.5) 5613.42,4295.31 ; 5613.42,4295.31 ccw(c5600.61,4308.11) 5618.72,4308.11 cw(c5600.61,4308.11) 5613.42,4295.31 ; 5613.42,4374.05 cw(c5626.22,4361.24) 5626.22,4379.35 ccw(c5626.22,4361.24) 5613.42,4374.05 ; 5613.42,4374.05 ccw(c5600.61,4386.85) 5618.72,4386.85 cw(c5600.61,4386.85) 5613.42,4374.05 ; 5613.42,4452.79 cw(c5626.22,4439.98) 5626.22,4458.09 ccw(c5626.22,4439.98) 5613.42,4452.79 ; 5613.42,4452.79 ccw(c5600.61,4465.59) 5618.72,4465.59 cw(c5600.61,4465.59) 5613.42,4452.79 ; 5613.42,4531.53 cw(c5626.22,4518.72) 5626.22,4536.83 ccw(c5626.22,4518.72) 5613.42,4531.53 ; 5613.42,4531.53 ccw(c5600.61,4544.33) 5618.72,4544.33 cw(c5600.61,4544.33) 5613.42,4531.53 ; 5692.16,4216.57 cw(c5704.96,4203.76) 5704.96,4221.87 ccw(c5704.96,4203.76) 5692.16,4216.57 ; 5692.16,4216.57 ccw(c5679.35,4229.37) 5697.46,4229.37 cw(c5679.35,4229.37) 5692.16,4216.57 ; 5692.16,4255.94 cw(c5704.96,4243.13) 5704.96,4261.24 ccw(c5704.96,4243.13) 5692.16,4255.94 ; 5692.16,4255.94 ccw(c5679.35,4268.74) 5697.46,4268.74 cw(c5679.35,4268.74) 5692.16,4255.94 ; 5692.16,4295.31 cw(c5704.96,4282.5) 5704.96,4300.61 ccw(c5704.96,4282.5) 5692.16,4295.31 ; 5692.16,4295.31 ccw(c5679.35,4308.11) 5697.46,4308.11 cw(c5679.35,4308.11) 5692.16,4295.31 ; 5731.53,3848.47 cw(c5718.72,3835.67) 5736.83,3835.67 ccw(c5718.72,3835.67) 5731.53,3848.47 ; 5731.53,3848.47 ccw(c5744.33,3861.28) 5744.33,3843.17 cw(c5744.33,3861.28) 5731.53,3848.47 ; 5731.53,4005.95 cw(c5718.72,3993.15) 5736.83,3993.15 ccw(c5718.72,3993.15) 5731.53,4005.95 ; 5731.53,4005.95 ccw(c5744.33,4018.76) 5744.33,4000.65 cw(c5744.33,4018.76) 5731.53,4005.95 ; 5731.53,4124.06 cw(c5718.72,4111.26) 5736.83,4111.26 ccw(c5718.72,4111.26) 5731.53,4124.06 ; 5731.53,4124.06 ccw(c5744.33,4136.87) 5744.33,4118.76 cw(c5744.33,4136.87) 5731.53,4124.06 ; 5731.53,4216.57 cw(c5744.33,4203.76) 5744.33,4221.87 ccw(c5744.33,4203.76) 5731.53,4216.57 ; 5731.53,4216.57 ccw(c5718.72,4229.37) 5736.83,4229.37 cw(c5718.72,4229.37) 5731.53,4216.57 ; 5731.53,4255.94 cw(c5744.33,4243.13) 5744.33,4261.24 ccw(c5744.33,4243.13) 5731.53,4255.94 ; 5731.53,4255.94 ccw(c5718.72,4268.74) 5736.83,4268.74 cw(c5718.72,4268.74) 5731.53,4255.94 ; 5731.53,4374.05 cw(c5744.33,4361.24) 5744.33,4379.35 ccw(c5744.33,4361.24) 5731.53,4374.05 ; 5731.53,4374.05 ccw(c5718.72,4386.85) 5736.83,4386.85 cw(c5718.72,4386.85) 5731.53,4374.05 ; 5731.53,4531.53 cw(c5744.33,4518.72) 5744.33,4536.83 ccw(c5744.33,4518.72) 5731.53,4531.53 ; 5731.53,4531.53 ccw(c5718.72,4544.33) 5736.83,4544.33 cw(c5718.72,4544.33) 5731.53,4531.53 ; 5776.55,3685.34 ccw(c5764.02,3672.8) 5764.02,3690.53 cw(c5764.02,3672.8) 5776.55,3685.34 ; 5776.55,3685.34 cw(c5789.08,3697.87) 5771.36,3697.87 ccw(c5789.08,3697.87) 5776.55,3685.34 ; 5776.55,3685.34 cw(c5769.37,3678.16) 5779.52,3678.16 ; 5776.55,3685.34 cw(c5769.37,3678.16) 5779.52,3678.16 ; 5776.55,4694.66 cw(c5764.02,4707.19) 5764.02,4689.47 ccw(c5764.02,4707.19) 5776.55,4694.66 ; 5776.55,4694.66 ccw(c5789.08,4682.13) 5771.36,4682.13 cw(c5789.08,4682.13) 5776.55,4694.66 ; 5776.55,4694.66 ccw(c5769.37,4701.84) 5779.52,4701.84 ; 5776.55,4694.66 ccw(c5769.37,4701.84) 5779.52,4701.84 ; 5779.52,4701.84 5779.52,4740 ; 5894.66,3685.34 ccw(c5882.13,3672.8) 5882.13,3690.53 cw(c5882.13,3672.8) 5894.66,3685.34 ; 5894.66,3685.34 cw(c5907.19,3697.87) 5889.47,3697.87 ccw(c5907.19,3697.87) 5894.66,3685.34