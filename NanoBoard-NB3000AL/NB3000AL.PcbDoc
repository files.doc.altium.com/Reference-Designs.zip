# Altium PCB NB3000AL.PcbDoc (part 28 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_A6: U7.D3 U8.C19 U12.29 U13.29 U16.5 U17.5 U61.91 | length 9437.6
  Top Layer w4: 5591.03,4764.97 5591.03,4760 ; 5613.79,4831.04 5624,4841.25 ; 5630.03,4873.54 ccw(c5609.57,4894) v1@5638.5,4894 ; 5636.02,4879.54 cw(c5648,4867.56) v1@5648,4884.5 ; 5636.85,4880.37 ccw(c5623.23,4894) v1@5642.5,4894 ; v1@5650.52,4894.04 5624,4867.52 5624,4841.25 ; v1@5775.97,2803.52 ccw(c5750.47,2829.02) U61.91@5786.54,2829.02 ; v1@5778.8,2800.69 ccw(c5760.13,2819.36) U61.91@5786.54,2819.36 ; v1@5781.63,2797.86 ccw(c5769.79,2809.7) 5786.54,2809.7 ; v1(5782.69,2796.8) 5782.69,2800.54 5786.54,2804.39 U61.91@5786.53,2837.34 ; U61.91@5783.71,2821.32 cw(c5776.88,2814.49) 5786.54,2814.49 cw(c5796.19,2814.49) U61.91@5789.36,2821.32 ; 5786.54,2810.45 ccw(c5796.34,2810.45) v1@5789.41,2803.52 ; U17.5@6170.59,4844.72 6240,4844.72 6251.35,4833.37 v1(6281.86,4833.37) ; U17.5@6193.81,4839.07 cw(c6207.46,4825.41) 6207.46,4844.72 cw(c6207.46,4864.04) U17.5@6193.81,4850.38 ; v1@6275.14,4826.66 ccw(c6258.92,4810.44) 6258.92,4833.37 ccw(c6258.92,4856.31) v1@6275.14,4840.09 ; v1@6277.97,4829.49 ccw(c6268.58,4820.1) 6268.58,4833.37 ccw(c6268.58,4846.65) v1@6277.97,4837.26 ; U13.29@6619.41,3387.05 6654.53,3387.05 ; U13.29@6643,3381.8 cw(c6654.53,3371.77) 6654.53,3387.05 ; U13.29@6643.01,3392.3 ccw(c6654.53,3402.32) 6654.53,3387.05 ; v1(6665.19,3397.71) 6654.53,3387.05 ; v1(6795.52,4855.37) 6806.18,4844.72 U16.5@6845.59,4844.72 ; U16.5@6822.37,4839.07 ccw(c6808.72,4825.41) 6808.72,4844.72 ccw(c6808.72,4864.04) U16.5@6822.37,4850.38 ; v1(7215.19,3266.71) 7251.86,3303.37 ; v1@7215.19,3272.21 ccw(c7215.19,3285.49) 7224.58,3276.1 ccw(c7233.97,3266.71) v1@7220.69,3266.71 ; v1@7215.19,3276.21 ccw(c7215.19,3299.14) 7231.41,3282.93 ccw(c7247.62,3266.71) v1@7224.69,3266.71 ; 7248.52,3300.04 7251.86,3303.37 ; 7255.71,3377.9 cw(c7270.29,3363.33) U12.29@7275.78,3383.19 ; 7258.86,3381.05 cw(c7265.2,3374.71) U12.29@7271.36,3381.23 ; 7260.57,3382.76 cw(c7272.39,3370.93) 7276.85,3387.05 ccw(c7270.86,3380.7) 7264.68,3386.87 ; 7261.77,3383.96 cw(c7268.03,3377.7) U12.29@7274.1,3384.14 ; 7265.42,3387.61 cw(c7274.49,3378.53) U12.29@7277.92,3390.9 ; U12.29@7269.46,3383.97 ccw(c7264.86,3382.06) 7264.86,3387.05 ; U12.29@7269.46,3390.12 cw(c7264.86,3392.04) 7264.86,3387.05 ; U12.29@7317.63,3381.39 cw(c7331.28,3367.73) 7331.28,3387.05 cw(c7331.28,3406.36) U12.29@7317.63,3392.7 ; v1@7350.14,3502.66 cw(c7333.92,3486.44) 7356.86,3486.44 cw(c7379.79,3486.44) v1@7363.57,3502.66 ; v1@7352.97,3505.49 cw(c7343.58,3496.1) 7356.86,3496.1 cw(c7370.14,3496.1) v1@7360.75,3505.49 ; v1(7356.86,3509.37) 7356.86,3395.37 7348.53,3387.05 7264.86,3387.05 ; 5579.7,4655.29 ccw(c5552.35,4682.64) 5591.03,4682.64 ; 5579.7,4655.29 cw(c5567.17,4667.82) 5567.17,4650.1 ccw(c5567.17,4667.82) 5579.7,4655.29 ; 5579.7,4655.29 ccw(c5592.23,4642.76) 5574.51,4642.76 cw(c5592.23,4642.76) 5579.7,4655.29 ; 5579.7,4655.29 ccw(c5552.35,4682.64) 5591.03,4682.64 ; 5591.03,4682.64 5591.03,4741.18 5591.03,4751.18 5591.03,4760 ; 5591.03,4760 5591.03,4808.28 5624,4841.25 ; 7251.86,3303.37 7252.05,3303.57 7256.86,3308.37 7256.86,3379.05 7264.86,3387.05
  Top Layer w8: U7.D3@7869.69,4544.06 v5(7889.37,4563.74) ; v5@7880.37,4563.74 cw(c7858.64,4563.74) 7874.01,4548.38 cw(c7889.37,4533.01) v5@7889.37,4554.74
  MidLayer1 w4: v1@6281.86,4823.87 cw(c6281.86,4800.94) 6298.07,4817.16 cw(c6314.29,4833.37) v1@6291.36,4833.37 ; v1@6281.86,4827.87 cw(c6281.86,4814.6) 6291.25,4823.99 cw(c6300.64,4833.37) v1@6287.36,4833.37 ; v1(6281.86,4833.37) 6304.23,4811 6600.9,4811 6628.52,4783.37 6722.52,4783.37 6746.52,4807.37 6815.19,4807.37 6823.52,4815.71 6823.52,4827.37 v1(6795.52,4855.37) ; v1@6795.52,4845.87 cw(c6795.52,4822.94) 6811.74,4839.16 cw(c6827.96,4855.37) v1@6805.02,4855.37 ; v1@6795.52,4849.87 cw(c6795.52,4836.6) 6804.91,4845.99 cw(c6814.3,4855.37) v1@6801.02,4855.37 ; v1@7741.81,3998.43 ccw(c7725.59,4014.64) 7748.52,4014.64 ccw(c7771.46,4014.64) v1@7755.24,3998.43 ; v1@7744.64,3995.6 ccw(c7735.25,4004.99) 7748.52,4004.99 ccw(c7761.8,4004.99) v1@7752.41,3995.6 ; v1(7748.52,3991.71) 7748.52,4266.71 7790.86,4309.04 7790.86,4375.04 7802.52,4386.71 7823.52,4386.71 7831.86,4395.04 7831.86,4535.71 7823.52,4544.04 7793.52,4544.04 7791.52,4546.04 7791.52,4620.37 7793.52,4622.37 7830.74,4622.37 v5(7889.37,4563.74) ; v5@7878.37,4563.74 ccw(c7851.82,4563.74) 7870.59,4582.52 ccw(c7889.37,4601.3) v5@7889.37,4574.74 ; v5@7882.37,4563.74 ccw(c7865.47,4563.74) 7877.42,4575.69 ccw(c7889.37,4587.64) v5@7889.37,4570.74
  MidLayer2 w4: v1@5641.28,4887.28 ccw(c5625.06,4871.06) 5625.06,4894 ccw(c5625.06,4916.93) v1@5641.28,4900.72 ; v1@5643.54,4894.04 v1@5650.52,4894.04 ; v1@5644.11,4890.11 ccw(c5634.72,4880.72) 5634.72,4894 ccw(c5634.72,4907.28) v1@5644.11,4897.89 ; v1(5648,4894) 5621,4894 5615.52,4899.48 5615.52,4944.69 5656.04,4985.21 5960.34,4985.21 6028,4917.54 6197.69,4917.54 6208.97,4906.26 v1(6281.86,4833.37) ; v1@6272.36,4833.37 ccw(c6249.42,4833.37) 6265.64,4849.59 ccw(c6281.86,4865.81) v1@6281.86,4842.87 ; v1@6276.36,4833.37 ccw(c6263.08,4833.37) 6272.47,4842.76 ccw(c6281.86,4852.15) v1@6281.86,4838.87 ; v1@6795.52,4845.87 cw(c6795.52,4822.94) 6811.74,4839.16 cw(c6827.96,4855.37) v1@6805.02,4855.37 ; v1@6795.52,4849.87 cw(c6795.52,4836.6) 6804.91,4845.99 cw(c6814.3,4855.37) v1@6801.02,4855.37 ; v1(6795.52,4855.37) 6859.19,4791.71 6859.4,4791.5 7118.12,4791.5 7177.82,4851.21 7254.09,4851.21 7261.26,4858.37 7483.19,4858.37 7649.85,4691.71 7823.52,4691.71 7854.96,4660.27 7854.96,4598.15 v5(7889.37,4563.74) ; v5@7878.37,4563.74 ccw(c7851.82,4563.74) 7870.59,4582.52 ccw(c7889.37,4601.3) v5@7889.37,4574.74 ; v5@7882.37,4563.74 ccw(c7865.47,4563.74) 7877.42,4575.69 ccw(c7889.37,4587.64) v5@7889.37,4570.74
  Bottom Layer w4: v1(5782.69,2796.8) 5800.89,2815 5953.29,2815 5982.33,2844.04 6312.19,2844.04 6326.52,2858.37 6420,2858.37 6428.37,2850 6604.53,2850 6630.49,2824.04 6824.9,2824.04 6899.9,2899.04 6986.21,2899.04 6992.75,2892.5 7136.83,2892.5 7156.36,2912.03 7156.36,3101.36 7215.19,3160.19 v1(7215.19,3266.71) 7189.7,3292.2 7189.7,3364.7 7180.18,3374.21 7165.79,3374.21 7139.63,3400.37 6956.94,3400.37 6911.57,3355 6838.63,3355 6820,3336.37 6695.52,3336.37 6665.19,3366.71 v1(6665.19,3397.71) ; v1@5782.69,2802.3 ccw(c5782.69,2815.58) 5792.08,2806.19 ccw(c5801.47,2796.8) v1@5788.19,2796.8 ; v1@5782.69,2806.3 ccw(c5782.69,2829.24) 5798.91,2813.02 ccw(c5815.13,2796.8) v1@5792.19,2796.8 ; v1@6658.47,3390.99 cw(c6642.26,3374.77) 6665.19,3374.77 cw(c6688.13,3374.77) v1@6671.91,3390.99 ; v1@6661.3,3393.82 cw(c6651.91,3384.43) 6665.19,3384.43 cw(c6678.47,3384.43) v1@6669.08,3393.82 ; v1@7205.69,3266.71 ccw(c7182.76,3266.71) 7198.97,3282.93 ccw(c7215.19,3299.14) v1@7215.19,3276.21 ; v1@7208.47,3259.99 cw(c7192.26,3243.77) 7215.19,3243.77 cw(c7238.13,3243.77) v1@7221.91,3259.99 ; v1@7209.69,3266.71 ccw(c7196.41,3266.71) 7205.8,3276.1 ccw(c7215.19,3285.49) v1@7215.19,3272.21 ; v1@7211.3,3262.82 cw(c7201.91,3253.43) 7215.19,3253.43 cw(c7228.47,3253.43) v1@7219.08,3262.82 ; v1(7356.86,3509.37) 7390,3542.52 7390,3691.52 7448.52,3750.04 ; v1@7356.86,3514.87 ccw(c7356.86,3528.15) 7366.25,3518.76 ccw(c7375.64,3509.37) v1@7362.36,3509.37 ; v1@7356.86,3518.87 ccw(c7356.86,3541.81) 7373.07,3525.59 ccw(c7389.29,3509.37) v1@7366.36,3509.37 ; v1@7741.81,3984.99 ccw(c7725.59,3968.77) 7725.59,3991.71 ccw(c7725.59,4014.64) v1@7741.81,3998.43 ; v1@7744.64,3987.82 ccw(c7735.25,3978.43) 7735.25,3991.71 ccw(c7735.25,4004.99) v1@7744.64,3995.6 ; v1(7748.52,3991.71) 7631.86,3991.71 7581.71,3991.71 7550,3960 7550,3851.52 ; 7448.52,3750.04 7550,3851.52 ; 7448.52,3750.04 7550,3851.52
DB_MEM.BUS_A7: U7.C3 U8.K21 U12.30 U13.30 U16.18 U17.18 U61.92 | length 11720.1
  Top Layer w4: U8.K21@5645.91,4367.17 v3(5665.59,4386.85) ; U8.K21@5645.91,4374.51 ccw(c5645.91,4392.23) 5658.44,4379.7 ccw(c5670.97,4367.17) U8.K21@5653.25,4367.17 ; U61.92@5764.55,2853.8 ccw(c5759.89,2860.44) 5768,2860.44 ; U61.92@5768,2838.49 5768,2860.44 ; 5768,2857.41 ccw(c5773.73,2857.41) U61.92@5769.68,2853.36 ; v1(5820,2898) 5778.25,2898 5761.59,2881.34 5761.59,2866.85 5768,2860.44 ; U17.18@6170.59,4435.28 6220,4435.28 ; U17.18@6193.81,4429.62 cw(c6207.46,4415.96) 6207.46,4435.28 cw(c6207.46,4454.59) U17.18@6193.81,4440.93 ; v1@6213.28,4463.28 cw(c6197.06,4447.06) 6220,4447.06 cw(c6242.93,4447.06) v1@6226.72,4463.28 ; v1@6216.11,4466.11 cw(c6206.72,4456.72) 6220,4456.72 cw(c6233.28,4456.72) v1@6223.89,4466.11 ; v1(6220,4470) 6220,4435.28 ; v1@6266.35,4420.2 ccw(c6257.86,4415.17) 6257.86,4425.04 ccw(c6257.86,4434.91) v1@6266.35,4429.88 ; v1@6267.81,4418.32 ccw(c6251.59,4402.11) 6251.59,4425.04 ccw(c6251.59,4447.98) v1@6267.81,4431.76 ; v1@6270.64,4421.15 ccw(c6261.25,4411.76) 6261.25,4425.04 ccw(c6261.25,4438.32) v1@6270.64,4428.93 ; v1(6274.52,4425.04) 6230.24,4425.04 6220,4435.28 ; U13.30@6619.41,3418.54 6673.02,3418.54 6676.85,3422.37 ; U13.30@6642.63,3412.89 cw(c6656.28,3399.23) 6656.28,3418.54 cw(c6656.28,3437.86) U13.30@6642.63,3424.2 ; v1(6642.86,3291.71) 6686.71,3291.71 6701.02,3306.02 6701.02,3398.2 6676.85,3422.37 ; v1@6646.75,3287.82 cw(c6656.14,3278.43) 6656.14,3291.71 cw(c6656.14,3304.99) v1@6646.75,3295.6 ; v1@6649.57,3284.99 cw(c6665.79,3268.77) 6665.79,3291.71 cw(c6665.79,3314.64) v1@6649.57,3298.43 ; v1(6698.52,3482.04) 6698.52,3444.04 6676.85,3422.37 ; v1(6801.52,4437.37) 6845.59,4437.37 6848.52,4437.37 6848.52,4435.28 U16.18@6845.59,4435.28 ; v1@6808.24,4430.66 cw(c6824.46,4414.44) 6824.46,4437.37 cw(c6824.46,4460.31) v1@6808.24,4444.09 ; v1(7210.86,3428.04) 7240.5,3428.04 7250,3418.54 U12.30@7294.41,3418.54 ; U12.30@7271.19,3412.89 ccw(c7257.54,3399.23) 7257.54,3418.54 ccw(c7257.54,3437.86) U12.30@7271.19,3424.2 ; 5652.79,4374.05 cw(c5665.59,4361.24) 5665.59,4379.35 ccw(c5665.59,4361.24) 5652.79,4374.05 ; 5652.79,4374.05 ccw(c5639.98,4386.85) 5658.09,4386.85 cw(c5639.98,4386.85) 5652.79,4374.05 ; 5797.06,2898 cw(c5797.06,2875.06) 5813.28,2891.28 ccw(c5797.06,2875.06) 5797.06,2898 ; 5797.06,2898 ccw(c5797.06,2920.93) 5813.28,2904.72 cw(c5797.06,2920.93) 5797.06,2898 ; 5806.72,2898 cw(c5806.72,2884.72) 5816.11,2894.11 ccw(c5806.72,2884.72) 5806.72,2898 ; 5806.72,2898 ccw(c5806.72,2911.28) 5816.11,2901.89 cw(c5806.72,2911.28) 5806.72,2898 ; 6698.52,3459.11 cw(c6721.46,3459.11) 6705.24,3475.32 ccw(c6721.46,3459.11) 6698.52,3459.11 ; 6698.52,3459.11 ccw(c6675.59,3459.11) 6691.81,3475.32 cw(c6675.59,3459.11) 6698.52,3459.11 ; 6698.52,3468.76 cw(c6711.8,3468.76) 6702.41,3478.15 ccw(c6711.8,3468.76) 6698.52,3468.76 ; 6698.52,3468.76 ccw(c6685.25,3468.76) 6694.64,3478.15 cw(c6685.25,3468.76) 6698.52,3468.76 ; 6814.8,4437.37 cw(c6814.8,4450.65) 6805.41,4441.26 ccw(c6814.8,4450.65) 6814.8,4437.37 ; 6814.8,4437.37 ccw(c6814.8,4424.1) 6805.41,4433.49 cw(c6814.8,4424.1) 6814.8,4437.37 ; 7224.14,3428.04 cw(c7224.14,3441.32) 7214.75,3431.93 ccw(c7224.14,3441.32) 7224.14,3428.04 ; 7224.14,3428.04 ccw(c7224.14,3414.76) 7214.75,3424.15 cw(c7224.14,3414.76) 7224.14,3428.04 ; 7233.79,3428.04 cw(c7233.79,3450.98) 7217.57,3434.76 ccw(c7233.79,3450.98) 7233.79,3428.04 ; 7233.79,3428.04 ccw(c7233.79,3405.11) 7217.57,3421.32 cw(c7233.79,3405.11) 7233.79,3428.04
  Top Layer w8: U7.C3@7909.06,4544.06 v5(7928.74,4563.74) ; v5@7919.74,4563.74 cw(c7898.01,4563.74) 7913.38,4548.38 cw(c7928.74,4533.01) v5@7928.74,4554.74
  MidLayer1 w4: v1(6274.52,4425.04) 6287.48,4438 6297.5,4438 6304.31,4431.19 6463.1,4431.19 6464.72,4432.81 6508.64,4432.81 6533.91,4407.54 6637.79,4407.54 6667.63,4437.37 v1(6801.52,4437.37) 6857.67,4437.37 6870,4425.04 6904.19,4425.04 6920,4440.85 6920,4483.87 6936.13,4500 6965,4500 6970,4495 6970,4482.58 6970,4468.08 6948.86,4446.94 6948.86,4431.34 6881.02,4363.5 6881.02,4345.13 6891.28,4334.87 6905.77,4334.87 6921.69,4350.79 6921.69,4362.94 6973.02,4414.27 6973.02,4443.94 6986,4456.91 6986,4501 6995,4510 7100,4510 7107.19,4502.81 7107.19,4416.71 7131.86,4392.04 7131.86,4317.36 7127,4312.5 7127,4242.75 ; 6648.03,3524.2 6648.03,3653.63 6666.78,3672.37 6690.17,3672.37 6758.34,3604.21 6762.84,3599.71 6803.54,3599.71 6815.19,3611.35 6815.19,3650.04 6856.86,3691.71 6856.86,3791.71 6870.15,3805 6950,3805 6970,3785 7035.86,3785 7057.52,3806.67 7057.52,4128.69 7127.5,4198.66 7127.5,4242.25 ; 6648.52,3523.71 6690.19,3482.04 v1(6698.52,3482.04) ; 6778.59,4437.37 cw(c6778.59,4414.44) 6794.81,4430.66 ccw(c6778.59,4414.44) 6778.59,4437.37 ; 6778.59,4437.37 ccw(c6778.59,4460.31) 6794.81,4444.09 cw(c6778.59,4460.31) 6778.59,4437.37 ; 6788.25,4437.37 cw(c6788.25,4424.1) 6797.64,4433.49 ccw(c6788.25,4424.1) 6788.25,4437.37 ; 6788.25,4437.37 ccw(c6788.25,4450.65) 6797.64,4441.26 cw(c6788.25,4450.65) 6788.25,4437.37 ; 6814.8,4437.37 cw(c6814.8,4450.65) 6805.41,4441.26 ccw(c6814.8,4450.65) 6814.8,4437.37 ; 6814.8,4437.37 ccw(c6814.8,4424.1) 6805.41,4433.49 cw(c6814.8,4424.1) 6814.8,4437.37 ; 6824.46,4437.37 cw(c6824.46,4460.31) 6808.24,4444.09 ccw(c6824.46,4460.31) 6824.46,4437.37 ; 6824.46,4437.37 ccw(c6824.46,4414.44) 6808.24,4430.66 cw(c6824.46,4414.44) 6824.46,4437.37 ; 6668.08,3504.15 ccw(c6698.52,3534.6) 6698.52,3491.54 cw(c6698.52,3534.6) 6668.08,3504.15 ; 6674.91,3497.32 ccw(c6698.52,3520.94) 6698.52,3487.54 cw(c6698.52,3520.94) 6674.91,3497.32 ; 6681.74,3490.49 ccw(c6698.52,3507.28) 6698.52,3483.54 cw(c6698.52,3507.28) 6681.74,3490.49
  MidLayer2 w4: v3@5666.24,4394.32 ccw(c5667.82,4412.36) 5679.46,4398.49 ; v3@5673.06,4386.2 cw(c5691.1,4384.62) 5679.46,4398.49 ; v1(5820,2898) 5883.79,2834.21 6302.71,2834.21 6351.88,2883.37 v1(6473.52,2883.37) ; v1@6213.28,4463.28 ccw(c6197.06,4447.06) 6197.06,4470 ccw(c6197.06,4492.93) v1@6213.28,4476.72 ; v1@6216.11,4466.11 ccw(c6206.72,4456.72) 6206.72,4470 ccw(c6206.72,4483.28) v1@6216.11,4473.89 ; v1(6220,4470) 6168,4470 6093.5,4395.5 6034.44,4395.5 6019.23,4410.71 5822.01,4410.71 5802.59,4410.71 5728.47,4410.71 5708.97,4410.71 ccw(c5708.97,4368.98) 5679.46,4398.49 ; v1(7210.86,3428.04) 7252.63,3469.82 7281.52,3498.71 7281.52,3871.73 7418.5,4008.71 7713.71,4008.71 7877.42,4172.42 7947.94,4172.42 7970.52,4195 v1(7970.52,4261.37) ; 5829.39,2888.61 cw(c5838.78,2898) 5825.5,2898 ccw(c5838.78,2898) 5829.39,2888.61 ; 5829.39,2888.61 ccw(c5820,2879.22) 5820,2892.5 cw(c5820,2879.22) 5829.39,2888.61 ; 5836.22,2881.78 cw(c5852.43,2898) 5829.5,2898 ccw(c5852.43,2898) 5836.22,2881.78 ; 5836.22,2881.78 ccw(c5820,2865.56) 5820,2888.5 cw(c5820,2865.56) 5836.22,2881.78 ; 6450.59,2883.37 cw(c6450.59,2860.44) 6466.81,2876.66 ccw(c6450.59,2860.44) 6450.59,2883.37 ; 6450.59,2883.37 ccw(c6450.59,2906.31) 6466.81,2890.09 cw(c6450.59,2906.31) 6450.59,2883.37 ; 6460.25,2883.37 cw(c6460.25,2870.1) 6469.64,2879.49 ccw(c6460.25,2870.1) 6460.25,2883.37 ; 6460.25,2883.37 ccw(c6460.25,2896.65) 6469.64,2887.26 cw(c6460.25,2896.65) 6460.25,2883.37 ; 7220.25,3437.43 cw(c7210.86,3446.82) 7210.86,3433.54 ccw(c7210.86,3446.82) 7220.25,3437.43 ; 7220.25,3437.43 ccw(c7229.64,3428.04) 7216.36,3428.04 cw(c7229.64,3428.04) 7220.25,3437.43 ; 7227.07,3444.26 cw(c7210.86,3460.48) 7210.86,3437.54 ccw(c7210.86,3460.48) 7227.07,3444.26 ; 7227.07,3444.26 ccw(c7243.29,3428.04) 7220.36,3428.04 cw(c7243.29,3428.04) 7227.07,3444.26 ; 7970.52,4238.44 cw(c7993.46,4238.44) 7977.24,4254.66 ccw(c7993.46,4238.44) 7970.52,4238.44 ; 7970.52,4238.44 ccw(c7947.59,4238.44) 7963.81,4254.66 cw(c7947.59,4238.44) 7970.52,4238.44 ; 7970.52,4248.1 cw(c7983.8,4248.1) 7974.41,4257.49 ccw(c7983.8,4248.1) 7970.52,4248.1 ; 7970.52,4248.1 ccw(c7957.25,4248.1) 7966.64,4257.49 cw(c7957.25,4248.1) 7970.52,4248.1
  Bottom Layer w4: v1(6473.52,2883.37) 6473.52,2912.06 6528.17,2966.71 6748.52,2966.71 6773.52,2991.71 6856.61,2991.71 6899.36,3034.46 6899.36,3048.96 6889.02,3059.29 6889.02,3217.87 6856.19,3250.71 6829.54,3250.71 6803.71,3224.87 6734.65,3224.87 6726.65,3232.87 6578.06,3232.87 6531,3279.94 6531,3310 6506.63,3334.37 6474.77,3334.37 6450.11,3309.71 6368.9,3309.71 6324.06,3264.87 6305.94,3264.87 6304.44,3266.37 6148.11,3266.37 6122.69,3291.79 6122.69,3306.29 6140.32,3323.92 6153.75,3323.92 6163.71,3333.87 6264.33,3333.87 6272.5,3325.71 6443.48,3325.71 6468.15,3350.37 6529.06,3350.37 6575.06,3304.37 6630.19,3304.37 v1(6642.86,3291.71) ; v1(6698.52,3482.04) 6730.52,3450.04 6837.21,3450.04 6862.88,3424.37 v1@7207.19,3424.37 ; v5(7928.74,4563.74) 7947.74,4544.74 7947.74,4472.26 7955,4465 8035,4465 8040.19,4459.81 8040.19,4288.88 8026.69,4275.37 7984.52,4275.37 v1(7970.52,4261.37) ; 6473.52,2896.65 cw(c6460.25,2896.65) 6469.64,2887.26 ccw(c6460.25,2896.65) 6473.52,2896.65 ; 6473.52,2896.65 ccw(c6486.8,2896.65) 6477.41,2887.26 cw(c6486.8,2896.65) 6473.52,2896.65 ; 6473.52,2906.31 cw(c6450.59,2906.31) 6466.81,2890.09 ccw(c6450.59,2906.31) 6473.52,2906.31 ; 6473.52,2906.31 ccw(c6496.46,2906.31) 6480.24,2890.09 cw(c6496.46,2906.31) 6473.52,2906.31 ; 6707.91,3472.65 cw(c6717.3,3482.04) 6704.02,3482.04 ccw(c6717.3,3482.04) 6707.91,3472.65 ; 6707.91,3472.65 ccw(c6698.52,3463.26) 6698.52,3476.54 cw(c6698.52,3463.26) 6707.91,3472.65 ; 6714.74,3465.82 cw(c6730.96,3482.04) 6708.02,3482.04 ccw(c6730.96,3482.04) 6714.74,3465.82 ; 6714.74,3465.82 ccw(c6698.52,3449.61) 6698.52,3472.54 cw(c6698.52,3449.61) 6714.74,3465.82 ; 7940.69,4551.79 cw(c7952.64,4563.74) 7935.74,4563.74 ccw(c7952.64,4563.74) 7940.69,4551.79 ; 7940.69,4551.79 ccw(c7928.74,4539.84) 7928.74,4556.74 cw(c7928.74,4539.84) 7940.69,4551.79 ; 7947.52,4544.96 cw(c7966.3,4563.74) 7939.74,4563.74 ccw(c7966.3,4563.74) 7947.52,4544.96 ; 7947.52,4544.96 ccw(c7928.74,4526.18) 7928.74,4552.74 cw(c7928.74,4526.18) 7947.52,4544.96 ; 7179.07,3424.37 ccw(c7179.07,3459.83) 7204.14,3434.76 cw(c7179.07,3459.83) 7179.07,3424.37 ; 7188.73,3424.37 ccw(c7188.73,3450.17) 7206.97,3431.93 cw(c7188.73,3450.17) 7188.73,3424.37 ; 7196.77,3424.37 cw(c7196.77,3413.96) 7204.14,3421.32 ccw(c7196.77,3413.96) 7196.77,3424.37 ; 7198.39,3424.37 ccw(c7198.39,3440.51) 7209.8,3429.1 cw(c7198.39,3440.51) 7198.39,3424.37
DB_MEM.BUS_A8: U7.A3 U8.H26 U12.31 U13.31 U16.19 U17.19 U61.93 | length 7778.9
  Top Layer w4: U61.93@5744.34,2853.36 ccw(c5740.32,2857.37) 5746,2857.37 ; 5746,2863 ccw(c5759.63,2863) U61.93@5749.99,2853.36 ; U61.93@5747.17,2837.34 5746,2838.5 5746,2868.21 5752.51,2874.72 5752.51,2883.57 5784.44,2915.5 5831.75,2915.5 5834.75,2912.5 5859.25,2912.5 5913.75,2967 6007.82,2967 6029.5,2988.68 6029.5,3075.35 6048.52,3094.37 6048.52,3152.52 6065.19,3169.19 6065.19,3210 ; U8.H26@5842.76,4453.25 ccw(c5842.76,4470.97) 5855.29,4458.44 ; U8.H26@5850.1,4445.91 cw(c5867.82,4445.91) 5855.29,4458.44 ; v1@6062.37,3239.19 cw(c6047.1,3223.5) 6069,3223.5 ; v1@6065.16,3242.06 cw(c6056.32,3232.97) 6069,3232.97 cw(c6081.68,3232.97) v1@6072.84,3242.06 ; v1(6069,3246) 6069,3223.5 ; v1@6075.63,3239.19 ccw(c6090.9,3223.5) 6069,3223.5 ; 6133.19,4404 cw(c6133.19,4383.93) U17.19@6147.37,4398.12 ; 6134.25,4404 ccw(c6134.25,4422.56) U17.19@6147.37,4409.44 ; 6142.84,4404 cw(c6142.84,4393.59) U17.19@6150.2,4400.95 ; U17.19@6190.98,4400.95 cw(c6198.34,4393.59) 6198.34,4404 ; U17.19@6193.81,4398.12 cw(c6207.99,4383.93) 6207.99,4404 ; U17.19@6193.81,4409.44 ccw(c6206.93,4422.56) 6206.93,4404 ; v1(6302,4413) 6293,4404 6170.59,4404 6115.25,4404 6074.75,4444.5 6063.75,4444.5 6062.62,4445.63 6038.31,4445.63 6030.18,4437.5 6006.81,4437.5 5974.55,4469.77 5949.18,4469.77 5941.18,4469.77 5882.64,4469.77 ccw(c5882.64,4431.09) 5855.29,4458.44 ; v1@6466.81,3315.09 ccw(c6450.59,3331.31) 6473.52,3331.31 ccw(c6496.46,3331.31) v1@6480.24,3315.09 ; v1@6469.64,3312.26 ccw(c6460.25,3321.65) 6473.52,3321.65 ccw(c6486.8,3321.65) v1@6477.41,3312.26 ; v1(6473.52,3308.37) 6473.52,3358.37 6565.19,3450.04 U13.31@6619.41,3450.04 ; U13.31@6596.19,3444.38 ccw(c6582.53,3430.72) 6582.53,3450.04 ccw(c6582.54,3469.35) U13.31@6596.19,3455.7 ; v1@6656.14,3443.32 ccw(c6639.92,3427.11) 6639.92,3450.04 ccw(c6639.92,3472.98) v1@6656.14,3456.76 ; v1@6658.97,3446.15 ccw(c6649.58,3436.76) 6649.58,3450.04 ccw(c6649.58,3463.32) v1@6658.97,3453.93 ; v1(6662.86,3450.04) U13.31@6623.52,3450.04 ; U16.19@6845.59,4403.78 6938.78,4403.78 6954.52,4419.52 6954.52,4475.33 6954.52,4480.04 6952.5,4478.02 v1(6952.5,4475.33) ; U16.19@6868.81,4398.12 cw(c6882.46,4384.47) 6882.46,4403.78 cw(c6882.46,4423.09) U16.19@6868.81,4409.44 ; v1@6945.78,4468.61 cw(c6924.68,4447.5) 6954.52,4447.5 ; v1@6948.61,4471.44 cw(c6934.33,4457.16) 6954.52,4457.16 ; 6954.52,4457.28 cw(c6970.55,4457.28) v1@6959.22,4468.61 ; v1@7166.81,3398.43 ccw(c7150.59,3414.64) 7173.52,3414.64 ccw(c7196.46,3414.64) v1@7180.24,3398.43 ; v1@7169.64,3395.6 ccw(c7160.25,3404.99) 7173.52,3404.99 ccw(c7186.8,3404.99) v1@7177.41,3395.6 ; v1(7173.52,3391.71) 7173.52,3415 7183.52,3425 v1(7183.52,3450.04) U12.31@7276.86,3450.04 ; v1@7176.81,3443.32 cw(c7160.59,3427.11) 7183.52,3427.11 cw(c7206.46,3427.11) 7190.24,3443.32 cw(c7206.46,3427.11) 7206.46,3450.04 cw(c7206.46,3472.98) v1@7190.24,3456.76 ; v1@7179.64,3446.15 cw(c7170.25,3436.76) 7183.52,3436.76 cw(c7196.8,3436.76) 7187.41,3446.15 cw(c7196.8,3436.76) 7196.8,3450.04 cw(c7196.8,3463.32) v1@7187.41,3453.93 ; U12.31@7271.19,3444.38 ccw(c7257.53,3430.72) 7257.53,3450.04 ccw(c7257.54,3469.35) U12.31@7271.19,3455.7 ; 6065.19,3210 6065.19,3219.69 ; 6065.19,3210 6065.19,3219.69 ; 6065.19,3219.69 6069,3223.5 ; U13.31@6619.41,3450.04 U13.31@6623.52,3450.04 ; U13.31@6619.41,3450.04 U13.31@6623.52,3450.04
  Top Layer w8: U7.A3@7987.8,4544.06 v5(8007.48,4563.74) ; v5@7998.48,4563.74 cw(c7976.75,4563.74) 7992.12,4548.38 cw(c8007.48,4533.01) v5@8007.48,4554.74
  MidLayer1 w4: v1(6302,4413) 6306.5,4417.5 6395,4417.5 6417.25,4417.5 6460.72,4417.5 6468.04,4424.81 6485,4424.81 6505.32,4424.81 6530.63,4399.5 6539.71,4399.5 6580,4399.5 6685,4399.5 6693.04,4399.5 6765.29,4399.5 6780,4414.21 6900,4414.21 ; v1@6303.06,4411.94 cw(c6316.49,4398.51) 6316.49,4417.5 ; v1@6305.89,4409.11 cw(c6326.14,4388.86) 6326.14,4417.5 ; v1@6308.72,4406.28 cw(c6335.8,4379.2) 6335.8,4417.5 ; v1@6308.72,4419.72 ccw(c6314.07,4425.07) 6314.07,4417.5 ; v1@6943,4475.33 cw(c6920.06,4475.33) 6936.28,4459.11 cw(c6952.5,4442.89) v1@6952.5,4465.83 ; v1@6947,4475.33 cw(c6933.72,4475.33) 6943.11,4465.94 cw(c6952.5,4456.55) v1@6952.5,4469.83 ; v1@6954.52,4475.33 6954.52,4480.04 6952.5,4478.02 v1(6952.5,4475.33) 6930,4452.83 6930,4434.21 6910,4414.21 6907.5,4414.21 ; 6900,4414.21 6907.5,4414.21 ; 6900,4414.21 6907.5,4414.21
  MidLayer2 w4: v1@6945.78,4482.04 ccw(c6924.68,4503.15) 6954.52,4503.15 ; v1@6948.61,4479.22 ccw(c6934.33,4493.49) 6954.52,4493.49 ; v1(6952.5,4475.33) 6954.52,4477.35 6954.52,4514.37 6981.86,4541.71 7097.15,4541.71 7107.94,4552.5 7122.44,4552.5 7133.23,4541.71 7156.86,4541.71 7215.52,4483.04 7265.88,4483.04 7274.88,4492.04 7340.52,4492.04 7448.19,4492.04 7455,4492.04 8014.86,4492.04 8023.65,4483.25 ; 6954.52,4493.37 ccw(c6970.55,4493.37) v1@6959.22,4482.04 ; v1@7176.81,3443.32 cw(c7164.61,3431.13) 7181.86,3431.13 ; 7181.86,3423.08 cw(c7210.48,3423.08) v1@7190.24,3443.32 ; 7181.86,3432.74 cw(c7200.83,3432.74) v1@7187.41,3446.15 ; v1@7181.86,3448.37 7181.86,3416.71 7198.52,3400.04 7248.52,3400.04 7289.52,3441.04 7289.52,3868.41 7421.82,4000.71 7717.02,4000.71 7880.73,4164.42 7992.94,4164.42 8023.52,4195 8023.52,4258.37 8081.44,4316.29 ; v5@8007.48,4552.74 cw(c8007.48,4519.02) 8031.32,4542.86 ; v5@8007.48,4556.74 cw(c8007.48,4532.68) 8024.5,4549.69 ; v5@8007.48,4566.71 8008.96,4565.22 8031.86,4542.33 8031.86,4525 8031.86,4516.71 8023.65,4508.5 8023.65,4483.25 ; v5@8018.48,4563.74 ccw(c8037.87,4563.74) 8024.16,4550.03 ; 8081.44,4316.44 8082.69,4317.69 8082.69,4342.31 8077.29,4347.71 7999.19,4347.71 7988.19,4358.71 7988.19,4375.71 7998.52,4386.04 8014.19,4386.04 8031.86,4403.71 8031.86,4475.04 8023.65,4483.25
  Bottom Layer w4: v1@6070.5,3244.5 6111.25,3244.5 6115.75,3249 ; v1@6072.89,3249.89 ccw(c6085.9,3262.9) 6085.9,3244.5 ; v1@6075.72,3239.28 cw(c6088.31,3226.69) 6088.31,3244.5 ; v1@6075.72,3252.72 ccw(c6095.56,3272.56) 6095.56,3244.5 ; 6115.75,3249 6150,3249 6194.5,3249 6199.24,3253.74 6203.88,3258.37 6301.13,3258.37 6302.63,3256.87 6327.38,3256.87 6341.5,3271 6436.15,3271 v1(6473.52,3308.37) ; v1@6464.02,3308.37 cw(c6441.09,3308.37) 6457.31,3292.16 cw(c6473.52,3275.94) v1@6473.52,3298.87 ; v1@6468.02,3308.37 cw(c6454.75,3308.37) 6464.14,3298.99 cw(c6473.52,3289.6) v1@6473.52,3302.87 ; v1@6662.86,3440.54 cw(c6662.86,3417.61) 6679.08,3433.82 cw(c6695.29,3450.04) v1@6672.36,3450.04 ; v1@6662.86,3444.54 cw(c6662.86,3431.26) 6672.25,3440.65 cw(c6681.64,3450.04) v1@6668.36,3450.04 ; v1(6662.86,3450.04) 6679.52,3433.37 6831.25,3433.37 6856.25,3408.37 7156.86,3408.37 v1(7173.52,3391.71) ; v1@7164.02,3391.71 ccw(c7141.09,3391.71) 7157.31,3407.93 ccw(c7173.52,3424.14) v1@7173.52,3401.21 ; v1@7168.02,3391.71 ccw(c7154.75,3391.71) 7164.14,3401.1 ccw(c7173.52,3410.49) v1@7173.52,3397.21
DB_MEM.BUS_A9: U7.B6 U8.K26 U12.32 U13.32 U16.20 U17.20 U61.95 | length 8503.8
  Top Layer w4: v1@5695.23,2876.16 cw(c5664.9,2845.83) U61.95@5707.79,2845.83 ; v1@5698.06,2878.99 cw(c5674.56,2855.49) U61.95@5707.79,2855.49 ; v1@5700.89,2881.81 cw(c5684.22,2865.14) 5707.79,2865.14 ; v1(5701.95,2882.88) 5707.79,2877.03 U61.95@5707.79,2837.34 ; U61.95@5704.97,2853.36 ccw(c5698.14,2860.19) 5707.8,2860.19 ccw(c5717.45,2860.19) U61.95@5710.62,2853.36 ; U17.20@6145.83,4368.81 ccw(c6140.28,4366.13) 6140.28,4372.28 ; U17.20@6145.83,4375.76 cw(c6140.28,4378.44) 6140.28,4372.28 ; U17.20@6193.81,4366.63 cw(c6207.46,4352.97) 6207.46,4372.28 cw(c6207.46,4391.6) U17.20@6193.81,4377.94 ; 6214.89,4372.28 cw(c6214.89,4327.89) v1@6246.28,4359.28 ; 6224.55,4372.28 cw(c6224.55,4337.55) v1@6249.11,4362.11 ; 6234.21,4372.28 cw(c6234.21,4347.21) v1@6251.94,4364.94 ; v1(6253,4366) 6246.72,4372.28 U17.20@6170.59,4372.28 6140.28,4372.28 ; v1@6566.81,3509.99 cw(c6550.59,3493.77) 6573.52,3493.77 cw(c6596.46,3493.77) v1@6580.24,3509.99 ; v1@6569.64,3512.82 cw(c6560.25,3503.43) 6573.52,3503.43 cw(c6586.8,3503.43) v1@6577.41,3512.82 ; v1(6573.52,3516.71) 6573.52,3491.71 6583.7,3481.53 ; U13.32@6595.95,3476.14 ccw(c6583.7,3464.94) 6583.7,3481.53 ; U13.32@6595.95,3486.93 cw(c6583.7,3498.13) 6583.7,3481.53 ; U13.32@6619.41,3481.54 6583.7,3481.53 ; v1(6798.52,4357.37) 6798.52,4358.04 6812.77,4372.28 ; U16.20@6821.45,4367.73 ccw(c6812.77,4361.72) 6812.77,4372.28 ; U16.20@6821.45,4376.84 cw(c6812.77,4382.85) 6812.77,4372.28 ; U16.20@6868.81,4366.63 cw(c6882.46,4352.97) 6882.46,4372.28 cw(c6882.46,4391.6) U16.20@6868.81,4377.94 ; v1@7000.14,4368.32 ccw(c6983.92,4352.11) 6983.92,4375.04 ccw(c6983.92,4397.98) v1@7000.14,4381.76 ; v1@7002.97,4371.15 ccw(c6993.58,4361.76) 6993.58,4375.04 ccw(c6993.58,4388.32) v1@7002.97,4378.93 ; v1(7006.86,4375.04) 6935.52,4375.04 6932.77,4372.28 U16.20@6845.59,4372.28 6812.77,4372.28 ; v1@7031.86,3965.54 cw(c7031.86,3942.61) 7048.07,3958.82 cw(c7064.29,3975.04) v1@7041.36,3975.04 ; v1@7031.86,3969.54 cw(c7031.86,3956.26) 7041.25,3965.65 cw(c7050.64,3975.04) v1@7037.36,3975.04 ; v1(7031.86,3975.04) 7090.19,3916.71 7090.19,3575.04 7183.7,3481.53 U12.32@7294.41,3481.54 ; U12.32@7271.19,3475.88 ccw(c7257.54,3462.22) 7257.54,3481.53 ccw(c7257.54,3500.85) U12.32@7271.19,3487.19 ; 5855.29,4379.7 cw(c5842.76,4392.23) 5842.76,4374.51 ccw(c5842.76,4392.23) 5855.29,4379.7 ; 5855.29,4379.7 ccw(c5867.82,4367.16) 5850.1,4367.16 cw(c5867.82,4367.16) 5855.29,4379.7 ; 5855.29,4379.7 cw(c5882.64,4352.35) 5882.64,4391.03 ; 5855.29,4379.7 cw(c5882.64,4352.35) 5882.64,4391.03 ; 5882.64,4391.03 5941.18,4391.03 ; 5882.64,4391.03 5941.18,4391.03 ; 5941.18,4391.03 5982.4,4391.03 5988.43,4385 6018.06,4385 6038.5,4364.56 6038.5,4359.31 6057.81,4340 6073.12,4340 6108,4340 6140.28,4372.28
  Top Layer w8: U7.B6@7948.43,4425.94 v5(7968.11,4406.26) ; v5@7959.11,4406.26 ccw(c7937.38,4406.26) 7952.75,4421.62 ccw(c7968.11,4436.99) v5@7968.11,4415.26
  MidLayer1 w4: v1(6253,4366) 6274.68,4366 ; v1@6257.04,4362.27 cw(c6265.55,4354.43) 6265.55,4366 cw(c6265.55,4377.57) v1@6257.04,4369.73 ; v1@6259.99,4359.56 cw(c6274.68,4346.02) 6274.68,4366 ; v1@6259.99,4372.44 ccw(c6274.68,4385.98) 6274.68,4366 ; v1@6525.14,3222.43 ccw(c6508.92,3238.64) 6531.86,3238.64 ccw(c6554.79,3238.64) v1@6538.57,3222.43 ; v1@6527.97,3219.6 ccw(c6518.58,3228.99) 6531.86,3228.99 ccw(c6545.14,3228.99) v1@6535.75,3219.6 ; v1(6531.86,3215.71) 6531.86,3475.04 v1(6573.52,3516.71) ; v1@6564.02,3516.71 cw(c6541.09,3516.71) 6557.31,3500.49 cw(c6573.52,3484.27) v1@6573.52,3507.21 ; v1@6568.02,3516.71 cw(c6554.75,3516.71) 6564.14,3507.32 cw(c6573.52,3497.93) v1@6573.52,3511.21 ; v1@6791.81,4350.66 cw(c6775.59,4334.44) 6798.52,4334.44 cw(c6821.46,4334.44) v1@6805.24,4350.66 ; v1@6794.64,4353.49 cw(c6785.25,4344.1) 6798.52,4344.1 cw(c6811.8,4344.1) v1@6802.41,4353.49 ; v1(6798.52,4357.37) 6798.52,4328.52 6787.37,4317.37 6758.52,4317.37 6735,4317.37 6730,4317.37 6691.44,4317.37 6679.43,4317.37 6637.77,4359.04 6610,4359.04 6525.84,4359.04 6523.33,4361.55 6370.04,4361.55 6362.08,4369.5 6278.18,4369.5 6274.68,4366 ; 6986.53,4348.9 ccw(c6960.39,4375.04) v1@6997.36,4375.04 ; 6993.36,4355.73 ccw(c6974.05,4375.04) v1@7001.36,4375.04 ; 7000.19,4362.56 ccw(c6987.71,4375.04) v1@7005.36,4375.04 ; 7000.56,4362.93 cw(c7006.86,4356.63) v1@7006.86,4365.54 ; v1(7006.86,4375.04) 7006.86,4369.23 6981.86,4344.23 6981.86,4258.04 7023.52,4216.37 7023.52,4124.37 6948.52,4049.37 6948.52,3991.71 6965.19,3975.04 v1(7031.86,3975.04) 6948.52,3891.71 6931.86,3891.71 6881.86,3841.71 6881.86,3831.37 6848.86,3798.37 6848.86,3745 6848.86,3698.86 6848.86,3695.02 6794.52,3640.69 ; v1@7022.36,3975.04 cw(c6999.42,3975.04) 7015.64,3958.82 cw(c7031.86,3942.61) v1@7031.86,3965.54 ; v1@7025.14,3968.32 ccw(c7008.92,3952.11) 7008.92,3975.04 ccw(c7008.92,3997.98) v1@7025.14,3981.76 ; v1@7026.36,3975.04 cw(c7013.08,3975.04) 7022.47,3965.65 cw(c7031.86,3956.26) v1@7031.86,3969.54 ; v1@7027.97,3971.15 ccw(c7018.58,3961.76) 7018.58,3975.04 ccw(c7018.58,3988.32) v1@7027.97,3978.93 ; 6794.52,3640.69 cw(c6784.69,3640.69) 6789.69,3632.22 ccw(c6784.69,3640.69) 6794.52,3640.69 ; 6794.52,3640.69 ccw(c6804.36,3640.69) 6799.36,3632.22 cw(c6804.36,3640.69) 6794.52,3640.69 ; 6794.52,3640.69 v1(6794.52,3624.04) 6794.52,3640.69
  MidLayer2 w4: v1@5695.23,2889.59 ccw(c5679.01,2905.81) 5701.95,2905.81 ccw(c5724.88,2905.81) v1@5708.67,2889.59 ; v1@5698.06,2886.76 ccw(c5688.67,2896.15) 5701.95,2896.15 ccw(c5715.23,2896.15) v1@5705.84,2886.76 ; v1(5701.95,2882.88) 5701.95,2994.14 5706.86,2999.04 ; v1@6317.81,2893.32 cw(c6301.59,2877.11) 6324.52,2877.11 cw(c6347.46,2877.11) v1@6331.24,2893.32 ; v1@6320.64,2896.15 cw(c6311.25,2886.76) 6324.52,2886.76 cw(c6337.8,2886.76) v1@6328.41,2896.15 ; v1(6324.52,2900.04) 6324.52,2867.34 ; v1(6448.52,3183.37) 6480.86,3215.71 v1(6531.86,3215.71) ; v1@6448.52,3188.87 ccw(c6448.52,3202.15) 6457.91,3192.76 ccw(c6467.3,3183.37) v1@6454.02,3183.37 ; v1@6448.52,3192.87 ccw(c6448.52,3215.81) 6464.74,3199.59 ccw(c6480.96,3183.37) v1@6458.02,3183.37 ; v1@6525.14,3208.99 ccw(c6508.92,3192.77) 6508.92,3215.71 ccw(c6508.92,3238.64) v1@6525.14,3222.43 ; v1@6527.97,3211.82 ccw(c6518.58,3202.43) 6518.58,3215.71 ccw(c6518.58,3228.99) v1@6527.97,3219.6 ; v1(6573.52,3516.71) 6640.19,3583.37 6753.86,3583.37 v1(6794.52,3624.04) ; v1@6573.52,3522.21 ccw(c6573.52,3535.49) 6582.91,3526.1 ccw(c6592.3,3516.71) v1@6579.02,3516.71 ; v1@6573.52,3526.21 ccw(c6573.52,3549.14) 6589.74,3532.93 ccw(c6605.96,3516.71) v1@6583.02,3516.71 ; v1@6785.02,3624.04 cw(c6762.09,3624.04) 6778.31,3607.82 cw(c6794.52,3591.61) v1@6794.52,3614.54 ; v1@6789.02,3624.04 cw(c6775.75,3624.04) 6785.13,3614.65 cw(c6794.52,3605.26) v1@6794.52,3618.54 ; v1@7025.14,3981.76 ccw(c7008.92,3997.98) 7031.86,3997.98 ccw(c7054.79,3997.98) v1@7038.57,3981.76 ; v1@7027.97,3978.93 ccw(c7018.58,3988.32) 7031.86,3988.32 ccw(c7045.14,3988.32) v1@7035.75,3978.93 ; v1(7031.86,3975.04) 7031.86,4096.86 7045,4110 7177.25,4110 7195.21,4092.04 7443.5,4092.04 7470.46,4119 7789.5,4119 7811.71,4141.2 ; 7795.88,4125.37 7811.71,4141.2 ; v5(7968.11,4406.26) 7948.52,4386.67 7948.52,4356.04 7957.86,4346.71 7980,4346.71 7987.86,4338.85 ; 5706.86,2999.04 5728.31,3020.5 ; 5706.86,2999.04 5728.31,3020.5 ; 5728.31,3020.5 5793.74,3020.5 5869.5,2944.74 5869.5,2922.75 5869.5,2878.65 5898.77,2849.37 5905.94,2842.21 6299.4,2842.21 6306.56,2849.37 ; 6306.56,2849.37 6324.52,2867.34 ; 6306.56,2849.37 6324.52,2867.34 ; 7811.71,4141.2 7978.88,4308.37 7984.58,4314.08 7987.86,4317.35 7987.86,4325 ; 7987.86,4325 7987.86,4338.85 ; 7987.86,4325 7987.86,4338.85 ; 7987.86,4325 7987.86,4338.85
  Bottom Layer w4: v1@6315.02,2900.04 ccw(c6292.09,2900.04) 6308.31,2916.26 ccw(c6324.52,2932.48) v1@6324.52,2909.54 ; v1@6319.02,2900.04 ccw(c6305.75,2900.04) 6315.14,2909.43 ccw(c6324.52,2918.82) v1@6324.52,2905.54 ; v1(6324.52,2900.04) 6306.86,2917.71 6165.19,2917.71 6164.19,2916.71 6140.19,2916.71 6120.44,2916.71 6112.11,2925.04 6065.19,2971.96 6065.19,3011.04 6170.86,3116.71 6381.86,3116.71 v1(6448.52,3183.37) ; v1@6439.02,3183.37 cw(c6416.09,3183.37) 6432.31,3167.16 cw(c6448.52,3150.94) v1@6448.52,3173.87 ; v1@6443.02,3183.37 cw(c6429.75,3183.37) 6439.14,3173.99 cw(c6448.52,3164.6) v1@6448.52,3177.87
DB_MEM.BUS_A10: U7.A6 U8.P2 U12.33 U13.33 U16.21 U17.21 U61.96 | length 12799.7
  Top Layer w4: v1@4646.28,4355.28 cw(c4630.06,4339.06) 4653,4339.06 cw(c4675.93,4339.06) v1@4659.72,4355.28 ; v1@4649.11,4358.11 cw(c4639.72,4348.72) 4653,4348.72 cw(c4666.28,4348.72) v1@4656.89,4358.11 ; 4649.75,4269.5 4636.66,4282.59 ; v1(4653,4362) 4653,4322.75 4641.5,4311.25 4641.5,4296.25 4636.66,4291.41 ; 4813,4224 4784.94,4224 ; U8.P2@4890.53,4209.68 ccw(c4872.81,4209.68) 4885.34,4222.22 ; U8.P2@4897.87,4217.03 cw(c4897.87,4234.75) 4885.34,4222.22 ; v1@5661.56,2875.04 5673.52,2875.04 5688.11,2860.45 U61.96@5688.11,2837.34 ; U61.96@5685.28,2853.36 ccw(c5678.45,2860.19) 5688.11,2860.19 ccw(c5697.77,2860.19) U61.96@5690.94,2853.36 ; U17.21@6170.59,4340.79 6249.44,4340.79 6278,4312.23 6278,4264.9 6298.5,4244.4 6298.5,4203.35 6280,4184.85 v1(6280,4185) ; U17.21@6193.81,4335.13 cw(c6207.46,4321.47) 6207.46,4340.79 cw(c6207.46,4360.1) U17.21@6193.81,4346.44 ; v1@6280,4190.5 ccw(c6280,4204.14) 6289.64,4194.49 ; v1@6280,4194.5 ccw(c6280,4217.8) 6296.47,4201.32 ; v1@6285.5,4185 cw(c6298.42,4185) 6289.28,4194.13 ; v1@6289.5,4185 cw(c6312.07,4185) 6296.11,4200.96 ; U13.33@6619.41,3513.03 6695.2,3513.03 6716.52,3491.71 6716.52,3443.04 6709.02,3435.54 6709.02,3270.98 6721.63,3258.37 v1(6748.52,3258.37) ; U13.33@6642.63,3507.37 cw(c6656.28,3493.72) 6656.28,3513.03 cw(c6656.28,3532.35) U13.33@6642.63,3518.69 ; v1(6685,5095) 6698.86,5081.14 6698.86,4968.86 6680,4950 6680,4850 6773.19,4756.81 6773.19,4720.76 6788.52,4705.43 6788.52,4694.82 ; v1(6731.86,4206.71) 6731.86,4220.79 6783.5,4272.44 6783.5,4290.32 ; v1@6741.81,3251.66 ccw(c6725.59,3235.44) 6725.59,3258.37 ccw(c6725.59,3281.31) v1@6741.81,3265.09 ; v1@6744.64,3254.49 ccw(c6735.25,3245.1) 6735.25,3258.37 ccw(c6735.25,3271.65) v1@6744.64,3262.26 ; 6788.52,4698.64 6788.52,4694.82 ; 6810.17,4316.99 ccw(c6786.38,4340.79) U16.21@6820.03,4340.79 ; 6817,4323.82 ccw(c6800.04,4340.79) U16.21@6824.03,4340.79 ; 6823.83,4330.65 ccw(c6813.69,4340.79) U16.21@6828.03,4340.79 ; U16.21@6824.51,4331.33 cw(c6828.03,4327.81) U16.21@6828.03,4332.79 ; U16.21@6845.59,4340.79 6838.18,4333.37 6826.56,4333.37 6783.5,4290.32 ; v1@7159.81,3668.32 cw(c7143.59,3652.11) 7166.52,3652.11 cw(c7189.46,3652.11) v1@7173.24,3668.32 ; v1@7162.64,3671.15 cw(c7153.25,3661.76) 7166.52,3661.76 cw(c7179.8,3661.76) v1@7170.41,3671.15 ; v1(7166.52,3675.04) 7166.52,3538.48 7191.97,3513.03 U12.33@7294.41,3513.03 ; U12.33@7271.19,3507.37 ccw(c7257.54,3493.72) 7257.54,3513.03 ccw(c7257.54,3532.35) U12.33@7271.19,3518.69 ; 4636.66,4282.59 4636.66,4291.41 ; 4636.66,4282.59 4677.25,4242 4719.06,4242 4722.06,4239 4750.5,4239 4769.94,4239 4779.49,4229.45 4784.94,4224 ; 4636.66,4282.59 4636.66,4284.59 4636.66,4291.41 ; 4784.94,4224 4814.38,4224 4815.57,4225.19 4829.19,4225.19 4838.82,4225.19 4878.16,4225.19 cw(c4878.16,4215.04) 4885.34,4222.22 ; 6783.5,4290.32 6783.5,4336.5 6773,4347 6773,4402 6763,4412 6763,4511.69 6795,4543.69 6795,4635 6788.52,4641.48 6788.52,4694.82
  Top Layer w8: U7.A6@7987.8,4425.94 v5(8007.48,4406.26) ; v5@7998.48,4406.26 ccw(c7976.75,4406.26) 7992.12,4421.62 ccw(c8007.48,4436.99) v5@8007.48,4415.26
  MidLayer1 w4: v1(6748.52,3258.37) 6840.19,3258.37 ; v1@6752.41,3254.49 cw(c6761.8,3245.1) 6761.8,3258.37 cw(c6761.8,3271.65) v1@6752.41,3262.26 ; v1@6755.24,3251.66 cw(c6771.46,3235.44) 6771.46,3258.37 cw(c6771.46,3281.31) v1@6755.24,3265.09 ; v1@6833.47,3231.76 ccw(c6817.26,3247.98) 6840.19,3247.98 ccw(c6863.13,3247.98) v1@6846.91,3231.76 ; v1@6836.3,3228.93 ccw(c6826.91,3238.32) 6840.19,3238.32 ccw(c6853.47,3238.32) v1@6844.08,3228.93 ; v1(6840.19,3225.04) 6840.19,3258.37 ; v1@7159.81,3668.32 cw(c7143.59,3652.11) 7166.52,3652.11 cw(c7189.46,3652.11) v1@7173.24,3668.32 ; v1@7159.81,3681.76 ccw(c7143.59,3697.98) 7166.52,3697.98 ccw(c7189.46,3697.98) v1@7173.24,3681.76 ; v1@7162.64,3671.15 cw(c7153.25,3661.76) 7166.52,3661.76 cw(c7179.8,3661.76) v1@7170.41,3671.15 ; v1@7162.64,3678.93 ccw(c7153.25,3688.32) 7166.52,3688.32 ccw(c7179.8,3688.32) v1@7170.41,3678.93 ; v1@7169.07,4142.49 cw(c7152.86,4126.27) 7175.79,4126.27 cw(c7198.73,4126.27) v1@7182.51,4142.49 ; v1@7171.9,4145.32 cw(c7162.51,4135.93) 7175.79,4135.93 cw(c7189.07,4135.93) v1@7179.68,4145.32 ; v1@7181.86,4147.86 7177.14,4147.86 v1(7175.79,4149.21) 7175.79,3980.79 7125,3930 7125,3815 7166.52,3773.48 v1(7166.52,3675.04) 7166.52,3629.36 7107.52,3570.36 7107.52,3370.35 6995.54,3258.37 6840.19,3258.37 ; v5@8007.48,4395.26 cw(c8007.48,4368.7) 8026.26,4387.48 cw(c8045.04,4406.26) v5@8018.48,4406.26 ; v5@8007.48,4399.26 cw(c8007.48,4382.36) 8019.43,4394.31 cw(c8031.38,4406.26) v5@8014.48,4406.26 ; v5(8007.48,4406.26) 8043.86,4369.88 8043.86,4270.96 v1(8066.82,4248) ; v1@8057.32,4248 ccw(c8034.38,4248) 8050.6,4264.22 ccw(c8066.82,4280.43) v1@8066.82,4257.5 ; v1@8061.32,4248 ccw(c8048.04,4248) 8057.43,4257.39 ccw(c8066.82,4266.78) v1@8066.82,4253.5
  MidLayer2 w4: v1@4646.5,4361.82 cw(c4662.59,4362.26) 4651.21,4373.65 ; v1@4650.5,4361.93 cw(c4675.39,4362.61) 4657.78,4380.22 ; v1(4653,4362) 4653,4375.43 4677.5,4399.93 4677.5,4492.75 4712.5,4527.75 4712.5,4554.82 4664.69,4602.63 ; v1@4654.5,4362.04 cw(c4688.18,4362.97) 4664.35,4386.79 ; v1@4658.5,4362.15 cw(c4700.97,4363.32) 4670.93,4393.36 ; v1@4662.5,4362.26 cw(c4713.76,4363.67) 4677.5,4399.93 ; 4664.69,4618.88 4664.69,4602.63 ; 4668.97,4745.49 4664.69,4741.21 ; 4685.26,4761.78 4748.52,4825.04 ; 5075.67,5208.54 5196.27,5208.54 ; v1@5228.28,5151.72 ccw(c5212.06,5167.93) 5235,5167.93 ccw(c5257.93,5167.93) v1@5241.72,5151.72 ; v1@5231.11,5148.89 ccw(c5221.72,5158.28) 5235,5158.28 ccw(c5248.28,5158.28) v1@5238.89,5148.89 ; v1(5235,5145) 5235,5169.81 ; 5235,5165 5235,5169.81 ; v1@5652.49,2884.11 ccw(c5636.28,2900.33) 5659.21,2900.33 ccw(c5682.15,2900.33) v1@5665.93,2884.11 ; v1@5655.32,2881.28 ccw(c5645.93,2890.67) 5659.21,2890.67 ccw(c5672.49,2890.67) v1@5663.1,2881.28 ; v1(5659.21,2877.39) 5659.21,2969.06 5718.65,3028.5 5842.25,3028.5 5907.5,2963.25 5907.5,2874.4 5924.52,2857.37 5989.19,2857.37 6006.86,2875.04 6006.86,2961.86 6010,2965 v1(6010,2996) v1@6009.04,2995.04 ; v1@6003.28,2989.28 cw(c5987.06,2973.06) 6010,2973.06 cw(c6032.93,2973.06) v1@6016.72,2989.28 ; v1@6006.11,2992.11 cw(c5996.72,2982.72) 6010,2982.72 cw(c6023.28,2982.72) v1@6013.89,2992.11 ; v1@6678.28,5101.72 ccw(c6662.06,5117.93) 6685,5117.93 ccw(c6707.93,5117.93) v1@6691.72,5101.72 ; v1@6678.28,5298.28 cw(c6662.06,5282.06) 6685,5282.06 cw(c6707.93,5282.06) v1@6691.72,5298.28 ; v1@6681.11,5098.89 ccw(c6671.72,5108.28) 6685,5108.28 ccw(c6698.28,5108.28) v1@6688.89,5098.89 ; v1@6681.11,5301.11 cw(c6671.72,5291.72) 6685,5291.72 cw(c6698.28,5291.72) v1@6688.89,5301.11 ; v1(6685,5095) v1(6685,5305) ; v1(6731.86,4206.71) 6800.19,4206.71 6861.9,4145 7037.82,4145 7048.82,4134 7160.58,4134 v1(7175.79,4149.21) 7184.96,4158.37 7276.5,4158.37 7318.84,4116.04 7431.04,4116.04 7458,4143 7779.56,4143 7860,4223.44 7860,4364.85 7881.19,4386.04 7935.86,4386.04 7948.52,4398.71 7948.52,4414.04 7960.52,4426.04 7987.7,4426.04 v5(8007.48,4406.26) ; v1@6735.75,4202.82 cw(c6745.14,4193.43) 6745.14,4206.71 cw(c6745.14,4219.99) v1@6735.75,4210.6 ; v1@6738.57,4199.99 cw(c6754.79,4183.77) 6754.79,4206.71 cw(c6754.79,4229.64) v1@6738.57,4213.43 ; v5@7996.48,4406.26 ccw(c7969.92,4406.26) 7988.7,4425.04 ccw(c8007.48,4443.82) v5@8007.48,4417.26 ; v5@8000.48,4406.26 ccw(c7983.58,4406.26) 7995.53,4418.21 ccw(c8007.48,4430.16) v5@8007.48,4413.26 ; v1@8066.61,4243.58 8066.61,4247.8 v1(8066.82,4248) ; 4664.69,4602.63 4664.69,4741.21 ; 4664.69,4741.21 4748.52,4825.04 ; 4748.52,4825.04 4748.52,4960 4732.19,4976.34 4732.19,5114.56 4826.17,5208.54 5196.27,5208.54 ; 5196.27,5208.54 5235,5169.81
  Bottom Layer w4: v1(5235,5145) 5280,5145 5493.37,5358.37 5887.82,5358.37 5904.82,5341.37 6673.63,5341.37 6685,5330 v1(6685,5305) ; v1@5238.89,5141.11 cw(c5248.28,5131.72) 5248.28,5145 cw(c5248.28,5158.28) v1@5238.89,5148.89 ; v1@5241.72,5138.28 cw(c5257.93,5122.06) 5257.93,5145 cw(c5257.93,5167.93) v1@5241.72,5151.72 ; v1@6006.52,2995.04 v1@6007.48,2996 ; v1(6010,2996) v1@6007.48,2996 ; v1@6010,3005.5 ccw(c6010,3022.36) 6021.92,3010.44 ; v1@6015.5,2996 cw(c6034.85,2996) 6021.17,3009.69 ; v1@6019.5,2996 cw(c6048.51,2996) 6028,3016.51 ; v1(6280,4185) 6281.63,4183.37 6422.06,4183.37 6436.66,4197.97 6486.66,4197.97 6490.63,4194 6719.15,4194 v1(6731.86,4206.71) ; v1@6283.89,4188.89 ccw(c6297.2,4202.2) 6297.2,4183.37 ; v1@6286.72,4178.28 cw(c6299.01,4165.99) 6299.01,4183.37 ; v1@6286.72,4191.72 ccw(c6306.86,4211.86) 6306.86,4183.37 ; v1@6678.28,5311.72 ccw(c6662.06,5327.93) 6685,5327.93 ccw(c6707.93,5327.93) v1@6691.72,5311.72 ; v1@6681.11,5308.89 ccw(c6671.72,5318.28) 6685,5318.28 ccw(c6698.28,5318.28) v1@6688.89,5308.89 ; v1@6830.69,3225.04 cw(c6807.76,3225.04) 6823.97,3208.82 cw(c6840.19,3192.61) v1@6840.19,3215.54 ; v1@6834.69,3225.04 cw(c6821.41,3225.04) 6830.8,3215.65 cw(c6840.19,3206.26) v1@6840.19,3219.54 ; v1(6840.19,3225.04) 6787.94,3172.79 6590.52,3172.79 6579.94,3183.37 6481.86,3183.37 6456.86,3208.37 6440.19,3208.37 6431.86,3200.04 6276.5,3200.04 6243.17,3166.71 6178.19,3166.71 6008.74,2997.26 v1@6007.48,2996