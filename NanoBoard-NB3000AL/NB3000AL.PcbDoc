# Altium PCB NB3000AL.PcbDoc (part 42 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DIPSW.D5: R238.1 SW8.11 U8.AE8 | length 5871.3
  Top Layer w4: v3(5114.41,3756.93) U8.AE8@5134.09,3776.61 ; U8.AE8@5126.75,3776.61 cw(c5109.03,3776.61) 5121.56,3764.08 cw(c5134.09,3751.55) U8.AE8@5134.09,3769.27 ; v1(6759.19,608.37) 7141.63,608.37 7258,492 7278,492 7290,480 SW8.11@7290,414.29 ; v1@6763.08,604.49 cw(c6772.47,595.1) 6772.47,608.37 cw(c6772.47,621.65) v1@6763.08,612.26 ; v1@6765.91,601.66 cw(c6782.13,585.44) 6782.13,608.37 cw(c6782.13,631.31) v1@6765.91,615.09 ; SW8.11@7278.04,456.41 ccw(c7260.76,480) 7290,480 ccw(c7319.24,480) SW8.11@7301.96,456.41 ; SW8.11@7280.4,453.18 ccw(c7266.54,472.11) 7290,472.11 ccw(c7313.46,472.11) SW8.11@7299.6,453.18 ; SW8.11@7282.77,449.96 ccw(c7272.32,464.22) 7290,464.22 ccw(c7307.68,464.22) SW8.11@7297.23,449.96 ; 5127.21,3769.73 cw(c5114.41,3782.54) 5114.41,3764.43 ccw(c5114.41,3782.54) 5127.21,3769.73 ; 5127.21,3769.73 ccw(c5140.02,3756.93) 5121.91,3756.93 cw(c5140.02,3756.93) 5127.21,3769.73
  MidLayer1 w4: v1@5098.28,2636.72 ccw(c5070.44,2664.56) 5109.82,2664.56 ; v1@5101.11,2633.89 ccw(c5080.09,2654.91) 5109.82,2654.91 ; v1@5103.94,2631.06 ccw(c5089.75,2645.25) 5109.82,2645.25 ; v1(5105,2630) 5109.82,2630 5109.82,2752.43 5087.38,2774.87 5081,2774.87 5022.5,2833.38 5022.5,2974.37 5031.86,2983.73 5031.86,3110.67 5082.5,3161.31 5082.5,3210 5082.5,3212.25 5082.5,3235.35 5106.5,3259.35 5106.5,3349.68 5106.86,3350.04 5140.19,3383.37 5148.86,3392.04 5148.86,3457.42 5103,3503.28 5103,3566.69 5120,3583.69 5120,3606.31 5114.41,3611.9 5114.41,3630.82 5114.41,3638.82 5114.41,3679.25 v3(5114.41,3756.93) ; v3@5109.11,3751.63 cw(c5096.3,3738.82) 5114.41,3738.82 cw(c5132.52,3738.82) v3@5119.71,3751.63 ; v3@5109.22,3751.74 cw(c5096.68,3739.2) 5114.41,3739.2 cw(c5132.14,3739.2) v3@5119.6,3751.74 ; 5109.82,2641.31 ccw(c5116.31,2641.31) v1@5111.72,2636.72 ; v1@5383.52,2480.54 cw(c5383.52,2457.61) 5399.74,2473.82 cw(c5415.96,2490.04) v1@5393.02,2490.04 ; v1@5383.52,2484.54 cw(c5383.52,2471.26) 5392.91,2480.65 cw(c5402.3,2490.04) v1@5389.02,2490.04 ; v1(5383.52,2490.04) 5407.19,2466.37 5407.19,1665.69 5394.19,1652.69 5394.19,1339.19 5500,1233.37 5787.21,1233.37 5873.52,1233.37 6498.52,608.37 v1(6759.19,608.37) ; v1@6752.47,601.66 ccw(c6736.26,585.44) 6736.26,608.37 ccw(c6736.26,631.31) v1@6752.47,615.09 ; v1@6755.3,604.49 ccw(c6745.91,595.1) 6745.91,608.37 ccw(c6745.91,621.65) v1@6755.3,612.26
  Bottom Layer w4: R238.1@5061.18,2607.27 5061.18,2608.37 5100.37,2608.37 5105,2613 ; R238.1@5064.94,2604 cw(c5075.5,2593.45) 5075.5,2608.37 ; R238.1@5064.94,2611.53 ccw(c5072.55,2619.13) 5072.55,2608.37 ; R238.1@5067.77,2601.17 cw(c5085.15,2583.79) 5085.15,2608.37 ; R238.1@5067.77,2614.35 ccw(c5082.2,2628.79) 5082.2,2608.37 ; v1@5100.02,2621.91 cw(c5094.54,2613) 5105,2613 ; v1@5108.89,2626.11 cw(c5118.28,2616.72) 5118.28,2630 cw(c5118.28,2643.28) v1@5108.89,2633.89 ; v1@5109.98,2621.91 ccw(c5115.46,2613) 5105,2613 ; v1@5111.72,2623.28 cw(c5127.93,2607.06) 5127.93,2630 cw(c5127.93,2652.93) v1@5111.72,2636.72 ; 5361.65,2508.6 ccw(c5383.52,2530.48) v1@5383.52,2499.54 ; 5368.48,2501.77 ccw(c5383.52,2516.82) v1@5383.52,2495.54 ; 5369.65,2500.6 cw(c5359.09,2490.04) v1@5374.02,2490.04 ; v1(5383.52,2490.04) 5380.21,2490.04 5317.5,2552.75 5317.5,2556.06 5256.86,2616.71 5155,2616.71 5141.71,2630 5106,2630 v1(5105,2630) 5105,2613
DIPSW.D6: R237.1 SW8.10 U8.AC8 | length 6341.8
  Top Layer w4: v3(5114.41,3835.67) U8.AC8@5134.09,3855.35 ; U8.AC8@5126.75,3855.35 cw(c5109.03,3855.35) 5121.56,3842.82 cw(c5134.09,3830.29) U8.AC8@5134.09,3848.01 ; v1@6731.86,690.54 cw(c6731.86,667.61) 6748.07,683.82 cw(c6764.29,700.04) v1@6741.36,700.04 ; v1@6731.86,694.54 cw(c6731.86,681.26) 6741.25,690.65 cw(c6750.64,700.04) v1@6737.36,700.04 ; v1(6731.86,700.04) 6811.9,620 7142,620 7262,500 7370,500 7390,480 ; SW8.10@7378.04,456.41 ccw(c7360.78,479.99) 7390,479.99 ; SW8.10@7380.41,453.19 ccw(c7366.55,472.11) 7390,472.11 ccw(c7413.46,472.11) SW8.10@7399.6,453.18 ; SW8.10@7382.77,449.96 ccw(c7372.33,464.22) 7390,464.22 ccw(c7407.68,464.22) SW8.10@7397.24,449.96 ; SW8.10@7390,414.29 7390,416.71 7390,480 ; SW8.10@7401.96,456.41 cw(c7419.24,479.99) 7390,479.99 ; 5127.21,3848.47 cw(c5114.41,3861.28) 5114.41,3843.17 ccw(c5114.41,3861.28) 5127.21,3848.47 ; 5127.21,3848.47 ccw(c5140.02,3835.67) 5121.91,3835.67 cw(c5140.02,3835.67) 5127.21,3848.47
  MidLayer1 w4: v1@5075.5,2695 ccw(c5052.56,2695) 5068.78,2711.22 ccw(c5085,2727.43) v1@5085,2704.5 ; v1@5079.5,2695 ccw(c5066.22,2695) 5075.61,2704.39 ccw(c5085,2713.78) v1@5085,2700.5 ; v1(5085,2695) 5060,2720 5060,2724.88 4979.5,2805.38 4979.5,3147 4989.19,3156.69 4989.19,3335 4989.19,3351.77 4989.19,3371.68 5046,3428.5 5065.92,3428.5 5082.98,3428.5 5096.19,3441.71 5096.19,3487.46 5067.53,3516.12 5067.53,3602.53 5085.04,3620.04 5089.96,3620.04 5090.55,3620.63 5090.55,3630.82 5090.55,3638.82 5090.55,3679.25 5090.55,3698.67 5090.55,3772.79 ; 5090.55,3758.86 5090.55,3772.79 ; v3@5106.94,3835.02 cw(c5088.9,3833.44) 5102.77,3821.8 ; v3@5115.06,3828.2 ccw(c5116.64,3810.16) 5102.77,3821.8 ; v1@5475.69,2221.71 cw(c5452.76,2221.71) 5468.97,2205.49 cw(c5485.19,2189.27) v1@5485.19,2212.21 ; v1@5479.69,2221.71 cw(c5466.41,2221.71) 5475.8,2212.32 cw(c5485.19,2202.93) v1@5485.19,2216.21 ; v1(5485.19,2221.71) 5467,2203.52 5467,1968.65 5467.02,1954.13 5466.5,1953.6 5466.5,1743.73 5473.52,1736.71 6085.19,1125.04 6510.19,700.04 v1(6731.86,700.04) ; v1@6725.14,693.32 ccw(c6708.92,677.11) 6708.92,700.04 ccw(c6708.92,722.98) v1@6725.14,706.76 ; v1@6727.97,696.15 ccw(c6718.58,686.76) 6718.58,700.04 ccw(c6718.58,713.32) v1@6727.97,703.93 ; 5090.55,3772.79 5090.55,3792.29 cw(c5132.28,3792.29) 5102.77,3821.8
  Bottom Layer w4: 5044.43,2646.43 cw(c5061.18,2629.68) R237.1@5061.18,2653.37 ; 5045.62,2647.62 ccw(c5030.55,2662.69) R237.1@5051.86,2662.69 ; R237.1@5051.26,2653.26 cw(c5061.18,2643.34) R237.1@5061.18,2657.37 ; R237.1@5052.45,2654.45 ccw(c5044.21,2662.69) R237.1@5055.86,2662.69 ; R237.1@5065,2659.48 cw(c5073.74,2651.02) 5073.74,2663.18 cw(c5073.74,2675.34) R237.1@5065,2666.88 ; R237.1@5067.88,2656.7 cw(c5083.18,2641.87) 5083.18,2663.18 ; R237.1@5067.88,2669.66 ccw(c5083.18,2684.49) 5083.18,2663.18 ; v1@5078.28,2688.28 cw(c5062.06,2672.06) 5085,2672.06 cw(c5107.93,2672.06) v1@5091.72,2688.28 ; v1@5081.11,2691.11 cw(c5071.72,2681.72) 5085,2681.72 cw(c5098.28,2681.72) v1@5088.89,2691.11 ; v1(5085,2695) 5085,2665 5083.18,2663.18 ; v1@5485.19,2212.21 cw(c5485.19,2189.27) 5501.41,2205.49 cw(c5517.63,2221.71) v1@5494.69,2221.71 ; v1@5485.19,2216.21 cw(c5485.19,2202.93) 5494.58,2212.32 cw(c5503.97,2221.71) v1@5490.69,2221.71 ; v1(5485.19,2221.71) 5515.19,2191.71 5548.52,2191.71 5565.19,2175.04 5565.19,2091.71 5556.86,2083.37 5231.86,2083.37 5206.86,2108.37 5206.86,2441.71 5223.52,2458.37 5223.52,2525.04 5148.52,2600.04 5139.19,2600.04 5122.52,2583.37 5048.52,2583.37 5040.19,2591.71 5040.19,2642.19 R237.1@5061.18,2663.18 5083.18,2663.18
DIPSW.D7: R236.1 SW8.9 U8.AC7 | length 7447.3
  Top Layer w4: v3(5075.04,3835.67) U8.AC7@5094.72,3855.35 ; U8.AC7@5087.38,3855.35 cw(c5069.66,3855.35) 5082.19,3842.82 cw(c5094.72,3830.29) U8.AC7@5094.72,3848.01 ; v1@7415,210.5 cw(c7415,187.56) 7431.22,203.78 cw(c7447.44,220) v1@7424.5,220 ; v1@7415,214.5 cw(c7415,201.22) 7424.39,210.61 cw(c7433.78,220) v1@7420.5,220 ; v1(7415,220) 7440,195 7470,195 7490,215 SW8.9@7490,414.29 ; SW8.9@7475.69,374.19 cw(c7441.13,339.63) 7490,339.63 cw(c7538.87,339.63) SW8.9@7504.31,374.19 ; SW8.9@7478.51,377.02 cw(c7450.78,349.29) 7490,349.29 cw(c7529.22,349.29) SW8.9@7501.49,377.02 ; SW8.9@7481.34,379.85 cw(c7460.44,358.94) 7490,358.94 cw(c7519.56,358.94) SW8.9@7498.66,379.85 ; 5087.84,3848.47 cw(c5075.04,3861.28) 5075.04,3843.17 ccw(c5075.04,3861.28) 5087.84,3848.47 ; 5087.84,3848.47 ccw(c5100.65,3835.67) 5082.54,3835.67 cw(c5100.65,3835.67) 5087.84,3848.47
  MidLayer1 w4: v1@4945.5,2715 ccw(c4922.56,2715) 4938.78,2731.22 ccw(c4955,2747.43) v1@4955,2724.5 ; v1@4949.5,2715 ccw(c4936.22,2715) 4945.61,2724.39 ccw(c4955,2733.78) v1@4955,2720.5 ; v1@4958.89,2711.11 cw(c4968.28,2701.72) 4968.28,2715 cw(c4968.28,2728.28) v1@4958.89,2718.89 ; v1@4961.72,2708.28 cw(c4977.93,2692.06) 4977.93,2715 cw(c4977.93,2737.93) v1@4961.72,2721.72 ; v3@5067.65,3834.37 cw(c5049.82,3831.22) 5064.65,3820.84 ; v3@5076.34,3828.28 ccw(c5079.49,3810.45) 5064.65,3820.84 ; v1@5233.47,1209.99 ccw(c5217.26,1193.77) 5217.26,1216.71 ccw(c5217.26,1239.64) v1@5233.47,1223.43 ; v1@5236.3,1212.82 ccw(c5226.91,1203.43) 5226.91,1216.71 ccw(c5226.91,1229.99) v1@5236.3,1220.6 ; v1(5240.19,1216.71) 4981.86,1216.71 4773.52,1425.04 4773.52,1666.71 4815.19,1708.37 4815.19,2204.71 5025.52,2415.04 5025.52,2691.71 5002.23,2715 v1(4955,2715) 4931.52,2738.48 4931.52,3191.37 4964.86,3224.71 4964.86,3381.29 5032.19,3448.63 5032.19,3530.75 5011.81,3551.13 5011.81,3580.76 5051.18,3620.12 5051.18,3630.82 5051.18,3638.82 5051.18,3679.25 5051.18,3698.67 5051.18,3772.79 5051.18,3796.04 cw(c5074.95,3796.04) 5057.57,3812.26 5064.65,3820.84
  MidLayer2 w4: v1(5240.19,1216.71) 5270.54,1216.71 5280.04,1207.21 5560.64,1207.21 5590.72,1237.29 5680.32,1237.29 5717.39,1200.21 5901.32,1200.21 5926.31,1225.21 6032.42,1225.21 6113.36,1144.27 6113.36,1007.23 6187.7,932.88 6455.81,932.88 6683.77,704.91 6683.77,651.77 6682.95,650.94 6682.95,628.62 7016.37,295.2 7140.2,295.2 7170,325 7170,385 7180,395 7235,395 7245,385 7245,190 7265,170 7410,170 7415,175 v1(7415,220) ; v1@5244.08,1212.82 cw(c5253.47,1203.43) 5253.47,1216.71 cw(c5253.47,1229.99) v1@5244.08,1220.6 ; v1@5246.91,1209.99 cw(c5263.13,1193.77) 5263.13,1216.71 cw(c5263.13,1239.64) v1@5246.91,1223.43 ; v1@7408.28,213.28 cw(c7392.06,197.06) 7415,197.06 cw(c7437.94,197.06) v1@7421.72,213.28 ; v1@7411.11,216.11 cw(c7401.72,206.72) 7415,206.72 cw(c7428.28,206.72) v1@7418.89,216.11
  Bottom Layer w4: v1(4955,2715) 4980,2740 5040.27,2740 R236.1@5061.18,2719.09 ; v1@4955,2720.5 ccw(c4955,2733.78) 4964.39,2724.39 ccw(c4973.78,2715) v1@4960.5,2715 ; v1@4955,2724.5 ccw(c4955,2747.43) 4971.22,2731.22 ccw(c4987.43,2715) v1@4964.5,2715 ; 5044.43,2735.84 ccw(c5061.18,2752.59) R236.1@5061.18,2728.9 ; 5045.62,2734.65 cw(c5030.55,2719.58) R236.1@5051.86,2719.58 ; R236.1@5051.26,2729.01 ccw(c5061.18,2738.93) R236.1@5061.18,2724.9 ; R236.1@5052.45,2727.82 cw(c5044.21,2719.58) R236.1@5055.86,2719.58
ETH#.ACT_A: J8.9 LED6.1 R66.2 | length 2397
  Top Layer w4: J8.9@2052.85,6676.36 cw(c2001.82,6625.33) 2073.98,6625.33 cw(c2146.14,6625.33) J8.9@2095.12,6676.36 ; J8.9@2055.68,6679.18 cw(c2011.48,6634.99) 2073.98,6634.99 cw(c2136.49,6634.99) J8.9@2092.29,6679.18 ; J8.9@2058.51,6682.01 cw(c2021.14,6644.64) 2073.98,6644.64 cw(c2126.83,6644.64) J8.9@2089.46,6682.01 ; J8.9@2061.33,6684.84 cw(c2030.79,6654.3) 2073.98,6654.3 cw(c2117.17,6654.3) J8.9@2086.63,6684.84 ; J8.9@2064.16,6687.67 cw(c2040.45,6663.96) 2073.98,6663.96 cw(c2107.52,6663.96) J8.9@2083.81,6687.67 ; J8.9@2073.98,6697.49 2073.98,6616.02 2110,6580 2256.9,6580 2756.86,6080.04 v1(2756.86,5775.04) 2756.86,5623.14 2805,5575 2890,5575 2909.01,5555.99 LED6.1@2909.01,5482 ; v1@2750.14,5768.32 cw(c2733.92,5752.11) 2756.86,5752.11 cw(c2779.79,5752.11) v1@2763.57,5768.32 ; v1@2750.14,5781.76 ccw(c2733.92,5797.98) 2756.86,5797.98 ccw(c2779.79,5797.98) v1@2763.57,5781.76 ; v1@2752.97,5771.15 cw(c2743.58,5761.76) 2756.86,5761.76 cw(c2770.14,5761.76) v1@2760.75,5771.15 ; v1@2752.97,5778.93 ccw(c2743.58,5788.32) 2756.86,5788.32 ccw(c2770.14,5788.32) v1@2760.75,5778.93
  Bottom Layer w4: v1(2756.86,5775.04) 2779.86,5775.04 2783.82,5779 R66.2@2813.82,5779 ; v1@2760.75,5771.15 cw(c2770.14,5761.76) 2770.14,5775.04 cw(c2770.14,5788.32) v1@2760.75,5778.93 ; v1@2763.57,5768.32 cw(c2779.79,5752.11) 2779.79,5775.04 cw(c2779.79,5797.98) v1@2763.57,5781.76 ; R66.2@2807.23,5772.41 ccw(c2791.32,5756.5) 2791.32,5779 ccw(c2791.32,5801.5) R66.2@2807.23,5785.59 ; R66.2@2810.06,5775.24 ccw(c2800.98,5766.16) 2800.98,5779 ccw(c2800.98,5791.84) R66.2@2810.06,5782.76
ETH#.LINK_K: J8.11 LED3.2 R58.2 | length 1895
  Top Layer w4: LED3.2@2826.71,5792.47 ccw(c2799.29,5819.89) 2838.07,5819.89 ; LED3.2@2829.54,5789.64 ccw(c2808.95,5810.23) 2838.07,5810.23 ; LED3.2@2832.37,5786.81 ccw(c2818.61,5800.58) 2838.07,5800.58 ; LED3.2@2838.07,5780 2838.07,5830.03 2843.04,5835 2896.57,5835 2898.86,5837.29 v1(2898.86,5876.71) ; 2838.07,5806.12 ccw(c2865.37,5806.12) LED3.2@2846.07,5786.81 ; 2838.07,5815.77 ccw(c2875.03,5815.77) LED3.2@2848.89,5789.64 ; 2838.07,5825.43 ccw(c2884.68,5825.43) LED3.2@2851.72,5792.47 ; v1@2892.14,5869.99 cw(c2875.92,5853.77) 2898.86,5853.77 cw(c2921.79,5853.77) v1@2905.57,5869.99 ; v1@2894.97,5872.82 cw(c2885.58,5863.43) 2898.86,5863.43 cw(c2912.14,5863.43) v1@2902.75,5872.82
  MidLayer1 w4: J8.11@2442.18,6695.71 cw(c2383.28,6692.2) 2425,6650.48 ; J8.11@2446.17,6695.95 cw(c2395.16,6692.91) 2431.29,6656.77 cw(c2467.43,6620.63) J8.11@2470.47,6671.65 ; J8.11@2450.16,6696.19 cw(c2407.03,6693.62) 2437.59,6663.06 cw(c2468.14,6632.51) J8.11@2470.71,6675.64 ; J8.11@2454.16,6696.43 cw(c2418.91,6694.32) 2443.88,6669.35 cw(c2468.85,6644.38) J8.11@2470.95,6679.63 ; J8.11@2470.24,6667.65 ccw(c2466.72,6608.76) 2425,6650.48 ; J8.11@2472.02,6697.49 2425,6650.48 ; v1@2892.14,5883.43 ccw(c2875.92,5899.64) 2898.86,5899.64 ccw(c2921.79,5899.64) v1@2905.57,5883.43 ; v1@2894.97,5880.6 ccw(c2885.58,5889.99) 2898.86,5889.99 ccw(c2912.14,5889.99) v1@2902.75,5880.6 ; v1(2898.86,5876.71) 2898.86,5931.14 2425,6405 2425,6650.48
  Bottom Layer w4: R58.2@2856.18,5877 2882.57,5877 2882.86,5876.71 ; R58.2@2859.94,5873.24 cw(c2869.02,5864.16) 2869.02,5877 cw(c2869.02,5889.84) R58.2@2859.94,5880.76 ; R58.2@2862.77,5870.41 cw(c2878.68,5854.5) 2878.68,5877 cw(c2878.68,5899.5) R58.2@2862.77,5883.59 ; v1@2890.52,5872.16 ccw(c2882.86,5867.98) 2882.86,5876.71 ; v1@2890.52,5881.26 cw(c2882.86,5885.43) 2882.86,5876.71 ; v1(2898.86,5876.71) 2882.86,5876.71
ETH#.RX_CT: C40.1 C41.2 C44.1 C47.2 J8.4 J8.5 L1.1 U5.32 | length 2592.3
  Top Layer w12: J8.4@2298,6147.49 2348,6197.49 ; J8.4@2298,6171.02 ccw(c2298,6227.82) 2338.16,6187.66 ccw(c2378.33,6147.49) J8.4@2321.53,6147.49 ; J8.5@2333,6229.36 cw(c2306.64,6197.49) 2348,6197.49 ; J8.5@2348,6247.49 2348,6197.49 ; J8.5@2363,6229.36 ccw(c2389.36,6197.49) 2348,6197.49 ; v1@3036.3,5270.6 ccw(c3026.91,5279.99) 3040.19,5279.99 ccw(c3053.47,5279.99) v1@3044.08,5270.6 ; v1(3040.19,5266.71) 3040.19,5315.19 3045,5320 v2(3045,5600) ; v2@3040.89,5595.89 cw(c3030.97,5585.97) 3045,5585.97 cw(c3059.03,5585.97) v2@3049.11,5595.89
  MidLayer1 w12: J8.4@2281.36,6130.85 cw(c2241.2,6090.69) 2298,6090.69 cw(c2354.8,6090.69) J8.4@2314.64,6130.85 ; J8.4@2298,6147.49 2298,6051.28 2375,5974.28 v2(2375,5910) ; v2@2370.89,5914.11 ccw(c2360.97,5924.03) 2375,5924.03 ccw(c2389.03,5924.03) v2@2379.11,5914.11
  MidLayer2 w12: v1(2390.19,5603.37) 2422.97,5603.37 2436.09,5616.5 2436.5,5616.5 2440,5620 2520,5620 2541.81,5598.19 2603.19,5598.19 2605,5600 v2(3045,5600) ; v1@2394.08,5599.49 cw(c2403.47,5590.1) 2403.47,5603.37 cw(c2403.47,5616.65) v1@2394.08,5607.26 ; v2@3040.89,5595.89 ccw(c3030.97,5585.97) 3030.97,5600 ccw(c3030.97,5614.03) v2@3040.89,5604.11
  Bottom Layer w12: v2@2370.89,5905.89 cw(c2360.97,5895.97) 2375,5895.97 cw(c2389.03,5895.97) v2@2379.11,5905.89 ; v2(2375,5910) 2375,5875 2394.33,5855.67 C47.2@2394.33,5780 C44.1@2394.33,5730 ; v1@2386.3,5607.26 ccw(c2376.42,5617.14) 2390.39,5617.14 ; v1(2390.19,5603.37) 2390.39,5603.58 U5.32@2390.39,5657.32 2390.39,5701.06 2394.33,5705 C44.1@2394.33,5730 ; C44.1@2390.22,5725.89 cw(c2380.3,5715.97) 2394.33,5715.97 cw(c2408.36,5715.97) C44.1@2398.44,5725.89 ; C44.1@2390.22,5734.11 ccw(c2380.3,5744.03) 2394.33,5744.03 ccw(c2408.36,5744.03) C44.1@2398.44,5734.11 ; C47.2@2390.22,5775.89 cw(c2380.3,5765.97) 2394.33,5765.97 cw(c2408.36,5765.97) C47.2@2398.44,5775.89 ; C47.2@2390.22,5784.11 ccw(c2380.3,5794.03) 2394.33,5794.03 ccw(c2408.36,5794.03) C47.2@2398.44,5784.11 ; 2390.39,5616.16 ccw(c2402.98,5616.16) v1@2394.08,5607.26 ; C40.1@2975,5267.99 3038.91,5267.99 v1(3040.19,5266.71) 3067.54,5294.05 ; 3023.81,5267.99 cw(c3023.81,5250.33) v1@3036.3,5262.82 ; v1@3040.19,5272.21 ccw(c3040.19,5285.49) 3049.58,5276.1 ccw(c3058.97,5266.71) v1@3045.69,5266.71 ; L1.1@3084.66,5285.67 ccw(c3067.54,5272.39) 3067.54,5294.06 ; L1.1@3084.66,5302.44 cw(c3067.54,5315.72) 3067.54,5294.06 ; L1.1@3086.6,5304.47 ccw(c3052.64,5344.33) C41.2@3105,5344.33 ; L1.1@3094.38,5295.34 ccw(c3074.78,5318.34) 3105,5318.34 ; C41.2@3100.22,5340.89 cw(c3088.69,5329.36) 3105,5329.36 ; C41.2@3104.33,5345 C41.2@3105,5344.33 ; 3105,5332.59 cw(c3116.74,5332.59) C41.2@3108.44,5340.89 ; 3067.54,5294.06 L1.1@3125,5294.06 3105,5314.06 C41.2@3105,5344.33
ETH#.RX_N: J8.6 R49.1 U5.30 | length 1788
  Bottom Layer w4: 2148.79,5960 ccw(c2148.79,6021.92) R49.1@2192.57,5978.14 ; 2158.45,5960 ccw(c2158.45,6012.26) R49.1@2195.4,5975.31 ; 2168.11,5960 ccw(c2168.11,6002.6) R49.1@2198.23,5972.48 ; 2175.98,5960 cw(c2175.98,5936.53) R49.1@2192.57,5953.12 ; 2177.76,5960 ccw(c2177.76,5992.95) R49.1@2201.06,5969.65 ; R49.1@2185.63,5960 cw(c2185.63,5946.18) R49.1@2195.4,5955.95 ; R49.1@2206.12,5960 2097,5960 2077,5980 2077,6257 2111.02,6291.02 2254.72,6291.02 2283.53,6262.21 2283.53,6261.72 2397.76,6147.49 J8.6@2398,6147.49 ; R49.1@2211.75,5963.88 2243.11,5963.88 ; R49.1@2226.65,5958.57 cw(c2236.04,5952.93) 2236.04,5963.88 ; R49.1@2227.71,5970.5 ccw(c2237.31,5974.15) 2237.31,5963.88 ; R49.1@2230.07,5956.51 cw(c2243.11,5948.67) 2243.11,5963.88 ; R49.1@2231.45,5971.92 ccw(c2243.11,5976.36) 2243.11,5963.88 ; 2350.59,6194.66 ccw(c2398,6242.06) J8.6@2398,6175.02 ; U5.30@2351.02,5657.32 2351.02,5686.02 2362.71,5697.71 2362.71,5844.28 2243.11,5963.88 ; U5.30@2351.02,5680.85 cw(c2363.51,5680.85) 2354.68,5689.68 ; 2351.18,6194.07 cw(c2304.6,6147.49) J8.6@2370.47,6147.49 ; U5.30@2355.02,5680.85 cw(c2377.17,5680.85) 2361.51,5696.51 ; 2357.42,6187.83 ccw(c2398,6228.41) J8.6@2398,6171.02 ; 2358.01,6187.24 cw(c2318.26,6147.49) J8.6@2374.47,6147.49 ; 2364.25,6181 ccw(c2398,6214.75) J8.6@2398,6167.02 ; 2364.84,6180.41 cw(c2331.92,6147.49) J8.6@2378.47,6147.49 ; 2371.08,6174.17 ccw(c2398,6201.09) J8.6@2398,6163.02 ; 2371.67,6173.58 cw(c2345.57,6147.49) J8.6@2382.47,6147.49
ETH#.RX_P: J8.3 R48.1 U5.31 | length 1321.8
  Bottom Layer w4: J8.3@2221.12,6253.42 ccw(c2189.79,6260.33) 2212.47,6283.02 ; J8.3@2225.02,6252.56 ccw(c2198.25,6258.46) 2217.64,6277.85 ccw(c2237.03,6297.25) J8.3@2242.93,6270.47 ; J8.3@2228.93,6251.7 ccw(c2206.7,6256.6) 2222.8,6272.69 ccw(c2238.89,6288.79) J8.3@2243.79,6266.56 ; J8.3@2242.07,6274.37 cw(c2235.16,6305.7) 2212.47,6283.02 ; J8.3@2248,6247.49 2212.47,6283.02 ; R48.1@2283.75,5955.7 ccw(c2265,5942.96) 2265,5965.63 ; R48.1@2283.75,5975.56 cw(c2265,5988.3) 2265,5965.63 ; R48.1@2287.06,5957.94 ccw(c2272.55,5948.09) 2272.55,5965.63 ccw(c2272.55,5983.17) R48.1@2287.06,5973.32 ; U5.31@2367.88,5683.68 ccw(c2361.05,5690.51) 2370.71,5690.51 ccw(c2380.37,5690.51) U5.31@2373.54,5683.68 ; U5.31@2370.71,5657.32 2370.71,5847.6 2280,5938.31 2280,5950 2287.68,5950 R48.1@2303.31,5965.63 2265,5965.63 ; 2212.47,6283.02 2114.33,6283.02 2085,6253.69 2085,5985 2100,5970 2157.79,5970 2180,5992.21 2238.42,5992.21 2265,5965.63
ETH#.TX_N: J8.2 R54.2 U5.33 | length 1158.1
  Bottom Layer w4: J8.2@2198,6147.49 2198,6117 2210,6105 2335,6105 2353,6087 2353,5963.31 2366.31,5950 2385.94,5950 2399.13,5963.19 2427.25,5991.31 ; R54.2@2402.77,5975.25 ccw(c2404.64,5990.67) R54.2@2415.62,5979.68 ; R54.2@2403.25,5979.22 ccw(c2405.89,6001.05) 2421.44,5985.5 ; R54.2@2403.73,5983.19 ccw(c2407.14,6011.43) 2427.25,5991.31 ; U5.33@2410.08,5629.8 cw(c2410.08,5625.09) U5.33@2413.41,5628.42 ; U5.33@2410.08,5657.32 2410.08,5631.74 2428.94,5612.88 2478.26,5612.88 2540,5674.62 2540,5968.41 2517.09,5991.31 2427.25,5991.31 ; R54.2@2411.23,5966.82 cw(c2426.67,5968.72) R54.2@2415.67,5979.73 ; U5.33@2414.08,5633.8 ccw(c2428.69,5633.8) 2418.36,5623.47 ; R54.2@2415.2,5967.31 cw(c2436.98,5970) 2421.46,5985.52 ; R54.2@2419.17,5967.8 cw(c2447.3,5971.27) 2427.25,5991.31
ETH#.TX_P: J8.1 R55.2 U5.34 | length 1691.1
  Bottom Layer w4: J8.1@2128.54,6228.03 cw(c2081.54,6181.03) 2148,6181.03 cw(c2214.46,6181.03) J8.1@2167.46,6228.03 ; J8.1@2131.36,6230.85 cw(c2091.2,6190.69) 2148,6190.69 cw(c2204.8,6190.69) J8.1@2164.64,6230.85 ; J8.1@2134.19,6233.68 cw(c2100.86,6200.35) 2148,6200.35 cw(c2195.14,6200.35) J8.1@2161.81,6233.68 ; J8.1@2137.02,6236.51 cw(c2110.51,6210) 2148,6210 cw(c2185.49,6210) J8.1@2158.98,6236.51 ; J8.1@2148.24,6247.49 J8.1@2148,6247.49 2148,6142 2193,6097 2331.69,6097 2345,6083.69 2345,5960 2370,5935 2420,5935 2450.63,5965.63 ; U5.34@2426.94,5630.97 cw(c2420.11,5624.14) 2429.76,5624.14 cw(c2439.42,5624.14) U5.34@2432.59,5630.97 ; U5.34@2429.76,5657.32 2429.76,5623.37 2431.43,5621.71 2432.26,5620.88 2474.95,5620.88 2531.86,5677.79 2531.86,5950.04 2516.27,5965.63 ; R55.2@2470.71,5955.32 ccw(c2450.63,5940.92) 2450.63,5965.63 ; R55.2@2470.71,5975.94 cw(c2450.63,5990.33) 2450.63,5965.63 ; R55.2@2473.96,5957.65 ccw(c2458.42,5946.51) 2458.42,5965.63 ccw(c2458.42,5984.75) R55.2@2473.96,5973.61 ; R55.2@2488.13,5967.5 R55.2@2490,5965.63 ; R55.2@2492.84,5971.59 cw(c2500.04,5950.96) 2515.49,5966.41 ; R55.2@2494.16,5967.82 cw(c2502.37,5944.27) 2520,5961.9 ; R55.2@2495.48,5964.04 cw(c2504.7,5937.59) 2524.5,5957.4 ; R55.2@2496.79,5960.26 cw(c2507.03,5930.91) 2529.01,5952.89 ; R55.2@2498.11,5956.48 cw(c2509.36,5924.22) 2530.22,5951.28 ; R55.2@2512.3,5962.34 cw(c2516.27,5961.59) 2516.27,5965.63 ; R55.2@2512.3,5968.92 ccw(c2516.27,5969.67) 2516.27,5965.63 ; 2450.63,5965.63 R55.2@2490,5965.63 ; R55.2@2490,5965.63 2516.27,5965.63
ETH.E_COL: R50.1 U5.1 U8.J3 | length 3882.3
  Top Layer w4: v1(4604,4466) 4607.41,4462.59 4740.55,4462.59 4757.37,4445.77 4820.59,4445.77 4835.97,4430.4 4874.27,4430.4 4874.57,4430.7 4883.53,4430.7 4883.84,4430.4 4897.36,4430.4 cw(c4897.36,4391.72) 4924.71,4419.07 ; U8.J3@4929.9,4406.54 ccw(c4912.18,4406.54) 4924.71,4419.07 ; U8.J3@4937.24,4413.88 cw(c4937.24,4431.6) 4924.71,4419.07
  MidLayer2 w4: v1(2473.52,5368.37) 2643.88,5368.37 2920.54,5091.71 3659.84,5091.71 3960.17,4791.37 4200,4791.37 ; v1@2477.41,5364.49 cw(c2486.8,5355.1) 2486.8,5368.37 cw(c2486.8,5381.65) v1@2477.41,5372.26 ; v1@2480.24,5361.66 cw(c2496.46,5345.44) 2496.46,5368.37 cw(c2496.46,5391.31) v1@2480.24,5375.09 ; 4285.17,4791.37 4200,4791.37 ; 4579,4633.29 4579,4590.19 4573.36,4584.55 ; 4579.02,4633.31 4579.02,4642.71 ; v1@4597.28,4459.28 ccw(c4581.06,4443.06) 4581.06,4466 ccw(c4581.06,4488.93) v1@4597.28,4472.72 ; v1@4600.11,4462.11 ccw(c4590.72,4452.72) 4590.72,4466 ccw(c4590.72,4479.28) v1@4600.11,4469.89 ; v1(4604,4466) 4569.94,4466 4555.94,4480 ; 4200,4791.37 4361.44,4791.37 4362.27,4792.2 ; 4362.27,4792.2 4424.5,4854.44 ; 4362.27,4792.2 4365.06,4795 4424.5,4854.44 ; 4424.5,4854.44 4424.5,4875.56 4439.44,4890.5 4460.56,4890.5 ; 4460.56,4890.5 4475.5,4875.56 ; 4460.56,4890.5 4475.5,4875.56 ; 4475.5,4875.56 4575,4776.06 4581.36,4769.7 4581.36,4727.11 4581.36,4666.57 4579.02,4664.23 4579.02,4655 ; 4540.5,4495.44 4555.94,4480 ; 4540.5,4495.44 4540.5,4551.69 4566.6,4577.79 ; 4540.5,4495.44 4555.94,4480 ; 4566.6,4577.79 4573.36,4584.55 ; 4566.6,4577.79 4573.36,4584.55 ; 4579.02,4642.71 4579.02,4655 ; 4579.02,4642.71 4579.02,4655
  Bottom Layer w4: U5.1@2466.31,5296.32 cw(c2459.48,5289.49) 2469.13,5289.49 cw(c2478.79,5289.49) U5.1@2471.96,5296.32 ; v1@2466.81,5361.66 cw(c2450.59,5345.44) 2473.52,5345.44 cw(c2496.46,5345.44) v1@2480.24,5361.66 ; v1@2469.64,5364.49 cw(c2460.25,5355.1) 2473.52,5355.1 cw(c2486.8,5355.1) v1@2477.41,5364.49 ; v1(2473.52,5368.37) 2473.52,5345 2469.13,5340.61 U5.1@2469.13,5322.68 2469.13,5194.69 R50.1@2500,5163.82 ; 2483.25,5180.57 cw(c2466.5,5163.82) R50.1@2490.19,5163.82 ; 2484.44,5179.38 ccw(c2499.51,5194.45) R50.1@2499.51,5173.14 ; R50.1@2490.08,5173.74 cw(c2480.16,5163.82) R50.1@2494.19,5163.82 ; R50.1@2491.27,5172.55 ccw(c2499.51,5180.79) R50.1@2499.51,5169.14
ETH.E_CRS: U6.12 U8.A6 | length 3164.8
  Top Layer w4: v1@4997.14,4918.32 cw(c4980.92,4902.11) 5003.86,4902.11 cw(c5026.79,4902.11) v1@5010.57,4918.32 ; v1@4999.97,4921.15 cw(c4990.58,4911.76) 5003.86,4911.76 cw(c5017.14,4911.76) v1@5007.75,4921.15 ; v1(5003.86,4925.04) 5003.86,4893.67 5030.15,4867.37 5055.35,4842.17 5055.35,4751.18 5055.35,4741.18 U8.A6@5055.35,4721.5 ; U8.A6@5050.16,4726.69 ccw(c5037.63,4739.22) 5055.35,4739.22 ccw(c5073.08,4739.22) U8.A6@5060.55,4726.69
  MidLayer1 w4: v1@4775.14,5268.32 cw(c4758.92,5252.11) 4781.86,5252.11 cw(c4804.79,5252.11) v1@4788.57,5268.32 ; v1@4777.97,5271.15 cw(c4768.58,5261.76) 4781.86,5261.76 cw(c4795.14,5261.76) v1@4785.75,5271.15 ; v1(4781.86,5275.04) 4781.86,5250 4781.86,5205.39 4823.86,5163.39 4823.86,5149.71 4823.86,5115 4823.86,5080.04 4862.78,5041.12 4978.86,4925.04 v1(5003.86,4925.04) ; v1@4997.14,4918.32 ccw(c4980.92,4902.11) 4980.92,4925.04 ccw(c4980.92,4947.98) v1@4997.14,4931.76 ; v1@4999.97,4921.15 ccw(c4990.58,4911.76) 4990.58,4925.04 ccw(c4990.58,4938.32) v1@4999.97,4928.93
  Bottom Layer w4: U6.12@3302.75,5490.58 ccw(c3291.04,5478.88) 3291.04,5495.43 ccw(c3291.04,5511.99) U6.12@3302.75,5500.28 ; U6.12@3341.06,5495.43 3239.86,5495.43 3231.86,5487.43 3231.86,5203.14 3292.81,5142.19 4689.02,5142.19 ; 4689.04,5142.2 4714.7,5142.2 4748.52,5108.37 4806.86,5108.37 4823.52,5125.04 4823.52,5233.37 v1(4781.86,5275.04) ; v1@4781.86,5265.54 cw(c4781.86,5242.61) 4798.07,5258.82 cw(c4814.29,5275.04) v1@4791.36,5275.04 ; v1@4781.86,5269.54 cw(c4781.86,5256.26) 4791.25,5265.65 cw(c4800.64,5275.04) v1@4787.36,5275.04
ETH.E_MDC: R47.1 U5.25 U8.C2 | length 4349.7
  Top Layer w4: v1@4625.14,5076.66 cw(c4608.92,5060.44) 4631.86,5060.44 cw(c4654.79,5060.44) v1@4638.57,5076.66 ; v1@4627.97,5079.49 cw(c4618.58,5070.1) 4631.86,5070.1 cw(c4645.14,5070.1) v1@4635.75,5079.49 ; v1(4631.86,5083.37) 4631.86,4935.04 4733.52,4833.37 4733.52,4827.66 4786,4775.19 4786,4672.69 4800.42,4658.26 4830.82,4658.26 4838.82,4658.26 ; 4838.82,4658.26 4878.16,4658.26 ; 4838.82,4658.26 4878.16,4658.26 ; 4878.16,4658.26 cw(c4878.16,4648.11) 4885.34,4655.29 ; 4878.16,4658.26 cw(c4878.16,4648.11) 4885.34,4655.29 ; 4885.34,4655.29 cw(c4872.81,4642.76) 4890.53,4642.76 ccw(c4872.81,4642.76) 4885.34,4655.29 ; 4885.34,4655.29 ccw(c4897.87,4667.82) 4897.87,4650.1 cw(c4897.87,4667.82) 4885.34,4655.29
  MidLayer1 w4: v1@4043.14,5768.32 cw(c4026.92,5752.11) 4049.86,5752.11 cw(c4072.79,5752.11) v1@4056.57,5768.32 ; v1@4045.97,5771.15 cw(c4036.58,5761.76) 4049.86,5761.76 cw(c4063.14,5761.76) v1@4053.75,5771.15 ; v1(4049.86,5775.04) 4049.86,5751.69 4236.55,5565 4485,5565 4495,5575 4578.69,5575 4615.19,5538.5 4615.19,5100.04 v1(4631.86,5083.37) ; v1@4622.36,5083.37 ccw(c4599.42,5083.37) 4615.64,5099.59 ccw(c4631.86,5115.81) v1@4631.86,5092.87 ; v1@4626.36,5083.37 ccw(c4613.08,5083.37) 4622.47,5092.76 ccw(c4631.86,5102.15) v1@4631.86,5088.87
  MidLayer2 w4: v1(2215.19,5651.67) 2216.82,5650.04 3924.86,5650.04 v1(4049.86,5775.04) ; v1@2219.08,5655.56 ccw(c2232.39,5668.87) 2232.39,5650.04 ; v1@2221.91,5644.95 cw(c2234.2,5632.66) 2234.2,5650.04 ; v1@2221.91,5658.38 ccw(c2242.05,5678.53) 2242.05,5650.04 ; v1@4040.36,5775.04 cw(c4017.42,5775.04) 4033.64,5758.82 cw(c4049.86,5742.61) v1@4049.86,5765.54 ; v1@4044.36,5775.04 cw(c4031.08,5775.04) 4040.47,5765.65 cw(c4049.86,5756.26) v1@4049.86,5769.54
  Bottom Layer w4: R47.1@2106.18,5651.67 v1(2215.19,5651.67) 2215.19,5651.99 2220.52,5657.32 U5.25@2252.6,5657.32 ; R47.1@2109.94,5647.91 cw(c2119.02,5638.83) 2119.02,5651.67 cw(c2119.02,5664.51) R47.1@2109.94,5655.43 ; R47.1@2112.77,5645.08 cw(c2128.68,5629.17) 2128.68,5651.67 cw(c2128.68,5674.16) R47.1@2112.77,5658.26 ; v1@2208.47,5644.95 ccw(c2192.26,5628.73) 2192.26,5651.67 ccw(c2192.26,5674.6) v1@2208.47,5658.38 ; v1@2211.3,5647.78 ccw(c2201.91,5638.39) 2201.91,5651.67 ccw(c2201.91,5664.94) v1@2211.3,5655.56 ; v1@2216.25,5650.61 cw(c2232.47,5634.39) 2232.47,5657.32 ; v1@2219.08,5647.78 cw(c2242.12,5624.73) 2242.12,5657.32 ; v1@2221.91,5644.95 cw(c2251.78,5615.08) U5.25@2251.78,5657.32 ; U5.25@2249.77,5654.49 ccw(c2242.94,5647.67) 2242.94,5657.32 ccw(c2242.94,5666.98) U5.25@2249.77,5660.15
ETH.E_MDIO: R46.1 U5.26 U8.G6 | length 4292.9
  Top Layer w4: v3(5035.67,4504.96) U8.G6@5055.35,4485.28 ; U8.G6@5048.01,4485.28 ccw(c5030.29,4485.28) 5042.82,4497.81 ccw(c5055.35,4510.34) U8.G6@5055.35,4492.62 ; 5048.47,4492.16 cw(c5061.28,4504.96) 5043.17,4504.96 ccw(c5061.28,4504.96) 5048.47,4492.16 ; 5048.47,4492.16 ccw(c5035.67,4479.35) 5035.67,4497.46 cw(c5035.67,4479.35) 5048.47,4492.16
  MidLayer1 w4: v1@2233.47,5709.99 cw(c2217.26,5693.77) 2240.19,5693.77 cw(c2263.13,5693.77) v1@2246.91,5709.99 ; v1@2236.3,5712.82 cw(c2226.91,5703.43) 2240.19,5703.43 cw(c2253.47,5703.43) v1@2244.08,5712.82 ; v1(2240.19,5716.71) 2240.19,5641.71 2248.52,5633.37 ; 3666.31,5630 4037.94,5258.37 4325,5258.37 4340.19,5258.37 4345.54,5258.37 4631.19,4972.73 4631.19,4967.37 ; 3679.28,5617.03 3664.31,5632 2624.37,5632 2517.08,5524.71 2308.17,5524.71 2290.19,5542.69 2290.19,5591.71 ; 4958.86,4528.82 4972.79,4528.82 ; v3@5028.28,4503.66 ccw(c5010.45,4500.51) 5020.84,4515.35 ; v3@5034.37,4512.35 cw(c5031.22,4530.18) 5020.84,4515.35 ; 2248.52,5633.37 2286.02,5595.87 ; 2248.52,5633.37 2286.02,5595.87 ; 2286.02,5595.87 2290.19,5591.71 ; 2286.02,5595.87 2290.19,5591.71 ; 4631.19,4950 4631.19,4967.37 ; 4631.19,4950 4631.19,4967.37 ; 4631.19,4950 4631.19,4936 4631.19,4858.37 4610.86,4838.04 4610.86,4800.58 4610.86,4753.34 4619.24,4744.95 4637,4727.19 4637,4716.5 4722.03,4631.47 4722.03,4613.5 4806.7,4528.82 4830.82,4528.82 4838.82,4528.82 4879.25,4528.82 4898.67,4528.82 4972.79,4528.82 ; 4972.79,4528.82 4996.04,4528.82 ; 4996.04,4528.82 cw(c4996.04,4505.05) 4996.21,4528.82 ; 4996.04,4528.82 4996.21,4528.82 ; 4996.21,4528.82 cw(c4996.04,4505.05) 5012.26,4522.43 5020.84,4515.35
  Bottom Layer w4: R46.1@2106.18,5705 2165,5705 2176.71,5716.71 v1(2240.19,5716.71) 2258.29,5716.71 ; R46.1@2109.94,5701.24 cw(c2119.02,5692.16) 2119.02,5705 cw(c2119.02,5717.84) R46.1@2109.94,5708.76 ; R46.1@2112.77,5698.41 cw(c2128.68,5682.5) 2128.68,5705 cw(c2128.68,5727.5) R46.1@2112.77,5711.59 ; v1@2233.47,5709.99 ccw(c2217.26,5693.77) 2217.26,5716.71 ccw(c2217.26,5739.64) v1@2233.47,5723.43 ; v1@2236.3,5712.82 ccw(c2226.91,5703.43) 2226.91,5716.71 ccw(c2226.91,5729.99) v1@2236.3,5720.6 ; v1@2248.01,5711.31 cw(c2258.29,5704.21) 2258.29,5716.71 ; v1@2248.01,5722.1 ccw(c2258.29,5729.2) 2258.29,5716.71 ; U5.26@2269.45,5683.68 ccw(c2262.63,5690.51) 2272.28,5690.51 ccw(c2281.94,5690.51) U5.26@2275.11,5683.68 ; U5.26@2272.28,5657.32 2272.28,5702.72 2258.29,5716.71
ETH.E_RESETB_E: R59.1 U5.42 U8.F5 | length 4740.9
  Top Layer w4: v3(4996.3,4544.33) U8.F5@5015.98,4524.65 ; U8.F5@5008.64,4524.65 ccw(c4990.92,4524.65) 5003.45,4537.18 ccw(c5015.98,4549.71) U8.F5@5015.98,4531.99 ; 5009.1,4531.53 cw(c5021.91,4544.33) 5003.8,4544.33 ccw(c5021.91,4544.33) 5009.1,4531.53 ; 5009.1,4531.53 ccw(c4996.3,4518.72) 4996.3,4536.83 cw(c4996.3,4518.72) 5009.1,4531.53
  MidLayer1 w4: v2(2640,5540) 2740,5540 2745,5545 v2(2800,5545) ; v2@2644.11,5535.89 cw(c2654.03,5525.97) 2654.03,5540 cw(c2654.03,5554.03) v2@2644.11,5544.11 ; v2@2646.94,5533.06 cw(c2663.69,5516.31) 2663.69,5540 cw(c2663.69,5563.69) v2@2646.94,5546.94 ; v2@2793.06,5538.06 ccw(c2776.31,5521.31) 2776.31,5545 ccw(c2776.31,5568.69) v2@2793.06,5551.94 ; v2@2795.89,5540.89 ccw(c2785.97,5530.97) 2785.97,5545 ccw(c2785.97,5559.03) v2@2795.89,5549.11 ; v1(3965.19,5750.04) 4040.19,5750.04 4199.18,5591.05 4233.23,5557 4488.31,5557 4498.31,5567 4575.37,5567 4606.86,5535.52 4606.86,5025.33 4647.19,4985 4647.19,4862.81 4685,4825 4685,4800 4645,4760 4645,4719.81 4730.03,4634.78 4730.03,4616.81 4787,4559.84 4830.16,4559.84 4838.82,4559.84 4879.25,4559.84 4963.62,4559.84 cw(c4963.79,4526.71) 4981.44,4554.75 ; v1@3969.08,5746.15 cw(c3978.47,5736.76) 3978.47,5750.04 cw(c3978.47,5763.32) v1@3969.08,5753.93 ; v1@3971.91,5743.32 cw(c3988.13,5727.11) 3988.13,5750.04 cw(c3988.13,5772.98) v1@3971.91,5756.76 ; v3@4988.91,4543.03 ccw(c4971.08,4539.88) 4981.47,4554.72 ccw(c4991.85,4569.55) v3@4995,4551.72
  Bottom Layer w4: U5.42@2540.19,5500.04 2542.15,5502 2577,5502 2615,5540 v2(2640,5540) ; U5.42@2554.54,5497.01 cw(c2566.58,5484.98) 2566.58,5502 ; R59.1@2613.82,5322.5 2632.14,5340.82 2632.14,5391.99 2647.96,5407.81 2732.38,5407.81 2733.81,5406.37 2796.52,5406.37 2815.19,5425.04 2815.19,5508.12 2800,5523.31 ; R59.1@2613.82,5328.31 ccw(c2613.82,5342.34) R59.1@2623.74,5332.42 ; R59.1@2613.82,5332.31 ccw(c2613.82,5356) 2630.57,5339.25 ; R59.1@2619.14,5322.99 cw(c2630.79,5322.99) R59.1@2622.55,5331.23 ; R59.1@2623.14,5322.99 cw(c2644.45,5322.99) 2629.38,5338.06 ; v2@2633.06,5533.06 ccw(c2616.31,5516.31) 2616.31,5540 ccw(c2616.31,5563.69) v2@2633.06,5546.94 ; v2@2635.89,5535.89 ccw(c2625.97,5525.97) 2625.97,5540 ccw(c2625.97,5554.03) v2@2635.89,5544.11 ; v2@2793.06,5551.94 ccw(c2776.31,5568.69) 2800,5568.69 ccw(c2823.69,5568.69) v2@2806.94,5551.94 ; v2@2793.52,5537.63 cw(c2780.94,5523.31) 2800,5523.31 ; v2@2795.89,5549.11 ccw(c2785.97,5559.03) 2800,5559.03 ccw(c2814.03,5559.03) v2@2804.11,5549.11 ; v2@2796.16,5540.64 cw(c2788.71,5532.16) 2800,5532.16 cw(c2811.29,5532.16) v2@2803.84,5540.64 ; v2@2806.48,5537.63 ccw(c2819.06,5523.31) 2800,5523.31 ; 3149,5935 3141.82,5935 3117.24,5910.43 2851,5644.19 2800,5593.18 v2(2800,5545) 2800,5523.31 ; 3149.34,5935.34 3563.22,5935.34 3572.47,5935.34 3757.77,5750.04 v1(3965.19,5750.04) ; v1@3958.47,5743.32 ccw(c3942.26,5727.11) 3942.26,5750.04 ccw(c3942.26,5772.98) v1@3958.47,5756.76 ; v1@3961.3,5746.15 ccw(c3951.91,5736.76) 3951.91,5750.04 ccw(c3951.91,5763.32) v1@3961.3,5753.93
ETH.E_RXC: U5.16 U8.G15 | length 4984.8
  Top Layer w4: v1(4102.86,5020.71) 4227.86,5020.71 v1(4265.19,4983.37) ; v1@4106.75,5016.82 cw(c4116.14,5007.43) 4116.14,5020.71 cw(c4116.14,5033.99) v1@4106.75,5024.6 ; v1@4109.57,5013.99 cw(c4125.79,4997.77) 4125.79,5020.71 cw(c4125.79,5043.64) v1@4109.57,5027.43 ; v1@4255.69,4983.37 ccw(c4232.76,4983.37) 4248.97,4999.59 ccw(c4265.19,5015.81) v1@4265.19,4992.87 ; v1@4259.69,4983.37 ccw(c4246.41,4983.37) 4255.8,4992.76 ccw(c4265.19,5002.15) v1@4265.19,4988.87 ; U8.G15@5409.68,4485.28 v3(5429.37,4504.96) ; U8.G15@5409.69,4492.62 ccw(c5409.69,4510.34) 5422.22,4497.81 ccw(c5434.75,4485.28) U8.G15@5417.03,4485.28 ; 5416.57,4492.16 cw(c5429.37,4479.35) 5429.37,4497.46 ccw(c5429.37,4479.35) 5416.57,4492.16 ; 5416.57,4492.16 ccw(c5403.76,4504.96) 5421.87,4504.96 cw(c5403.76,4504.96) 5416.57,4492.16
  MidLayer2 w4: v1@5408.69,4842.62 cw(c5408.69,4819.69) 5424.91,4835.91 cw(c5441.12,4852.12) v1@5418.19,4852.12 ; v1@5408.69,4846.62 cw(c5408.69,4833.35) 5418.08,4842.73 cw(c5427.47,4852.12) v1@5414.19,4852.12 ; v1(5408.69,4852.12) 5426.19,4834.62 5426.19,4780.62 5444.88,4761.93 5444.88,4749.18 5444.88,4741.18 5444.88,4680.27 5444.88,4622.01 5444.88,4528.47 cw(c5430.83,4528.47) 5440.76,4518.54 ; v3@5428.72,4512.43 ccw(c5427.14,4530.47) 5441.01,4518.83 ccw(c5454.88,4507.19) v3@5436.84,4505.61
  Bottom Layer w4: U5.16@2193.54,5440.79 2232.19,5440.79 2240.19,5432.79 2240.19,5340.19 2230.81,5330.81 2055.81,5330.81 2040.19,5315.19 2040.19,5061.36 2093.51,5008.04 3685,5008.04 3755,5008.04 3800.5,5008.04 3810,5017.54 3853.61,5017.54 3857.28,5013.87 3884.93,5013.87 3885.06,5014 4060,5014 4066.71,5020.71 v1(4102.86,5020.71) ; U5.16@2219.9,5437.96 cw(c2226.73,5431.13) 2226.73,5440.79 cw(c2226.73,5450.45) U5.16@2219.9,5443.62 ; v1@4096.14,5013.99 ccw(c4079.92,4997.77) 4079.92,5020.71 ccw(c4079.92,5043.64) v1@4096.14,5027.43 ; v1@4098.97,5016.82 ccw(c4089.58,5007.43) 4089.58,5020.71 ccw(c4089.58,5033.99) v1@4098.97,5024.6 ; v1(4265.19,4983.37) 4311.67,4983.37 4320,4991.71 4731.79,4991.71 4739.31,4984.19 4760.69,4984.19 4768.21,4991.71 4840.66,4991.71 4925.66,4991.71 4958.83,4958.54 5017.73,4958.54 5051.4,4924.87 5097.07,4924.87 5116.69,4944.5 5116.69,4950.38 5161.13,4994.82 5280,4994.82 5311.24,4994.82 5369.63,4936.44 5369.63,4929.81 5369.63,4900 5369.63,4880 5369.63,4875.37 5369.63,4860.37 5377.88,4852.12 5392.88,4852.12 v1(5408.69,4852.12) ; v1@4269.08,4979.49 cw(c4278.47,4970.1) 4278.47,4983.37 cw(c4278.47,4996.65) v1@4269.08,4987.26 ; v1@4271.91,4976.66 cw(c4288.13,4960.44) 4288.13,4983.37 cw(c4288.13,5006.31) v1@4271.91,4990.09
ETH.E_RXD0: U5.21 U8.D2 | length 4468.6
  Top Layer w4: v1@4738.93,4712.69 cw(c4728.17,4699.75) 4745,4699.75 cw(c4761.83,4699.75) v1@4751.07,4712.69 ; v1@4741.48,4715.77 cw(c4735.25,4708.28) 4745,4708.28 cw(c4754.75,4708.28) v1@4748.52,4715.77 ; v1@4745,4711.9 4740.19,4716.71 4743.48,4720 v1(4745,4720) v1@4745,4711.9 ; v1@4745,4711.9 4745,4699.75 4757.5,4687.25 4757.5,4632.5 4771.11,4618.89 4781.11,4618.89 4790,4618.89 4830.82,4618.89 4838.82,4618.89 4878.16,4618.89 ; 4878.16,4618.89 cw(c4878.16,4608.74) 4885.34,4615.92 ; 4878.16,4618.89 cw(c4878.16,4608.74) 4885.34,4615.92 ; 4885.34,4615.92 cw(c4872.81,4603.39) 4890.53,4603.39 ccw(c4872.81,4603.39) 4885.34,4615.92 ; 4885.34,4615.92 ccw(c4897.87,4628.45) 4897.87,4610.73 cw(c4897.87,4628.45) 4885.34,4615.92
  MidLayer1 w4: v1(4415.52,5741.37) 4462.54,5741.37 4631.86,5572.06 4631.86,5123.92 4657.78,5097.99 4675.58,5097.99 4687.2,5097.99 4767.81,5017.38 ; v1@4419.41,5737.49 cw(c4428.8,5728.1) 4428.8,5741.37 cw(c4428.8,5754.65) v1@4419.41,5745.26 ; v1@4422.24,5734.66 cw(c4438.46,5718.44) 4438.46,5741.37 cw(c4438.46,5764.31) v1@4422.24,5748.09 ; v1(4745,4720) 4743.48,4720 4766.13,4742.65 4766.13,4903.32 4766.13,4920 4766.13,4931.33 4767.81,4933.01 4767.81,5002.62 4767.81,5017.38 ; v1@4745,4729.5 ccw(c4745,4748.77) 4758.63,4735.14 ; v1@4750.5,4720 cw(c4767.44,4720) 4755.46,4731.98 ; v1@4754.5,4720 cw(c4781.1,4720) 4762.29,4738.81 ; 4757.38,5027.81 4767.81,5017.38
  MidLayer2 w4: v1@2133.47,5574.76 ccw(c2117.26,5590.98) 2140.19,5590.98 ccw(c2163.13,5590.98) v1@2146.91,5574.76 ; v1@2136.3,5571.93 ccw(c2126.91,5581.32) 2140.19,5581.32 ccw(c2153.47,5581.32) v1@2144.08,5571.93 ; v1(2140.19,5568.04) 2140.19,5759.19 2179,5798 2687,5798 2700,5785 2740,5785 2755,5800 4356.9,5800 4398.24,5758.66 v1(4415.52,5741.37) ; v1@4406.02,5741.37 ccw(c4383.09,5741.37) 4399.31,5757.59 ccw(c4415.52,5773.81) v1@4415.52,5750.87 ; v1@4410.02,5741.37 ccw(c4396.75,5741.37) 4406.14,5750.76 ccw(c4415.52,5760.15) v1@4415.52,5746.87
  Bottom Layer w4: v1@2133.96,5560.87 cw(c2122.11,5547.21) 2140.19,5547.21 ; v1@2136.58,5563.89 cw(c2129.72,5555.98) 2140.19,5555.98 cw(c2150.66,5555.98) v1@2143.8,5563.89 ; v1(2140.19,5568.04) 2140.19,5547.21 ; v1@2146.42,5560.87 ccw(c2158.27,5547.21) 2140.19,5547.21 ; U5.21@2167.19,5536.38 ccw(c2160.36,5529.56) 2160.36,5539.21 ccw(c2160.36,5548.87) U5.21@2167.19,5542.04 ; U5.21@2193.54,5539.21 2148.19,5539.21 2140.19,5547.21
ETH.E_RXD1: U5.20 U8.D1 | length 3870
  Top Layer w4: v1@4371.52,5584.21 cw(c4371.52,5561.27) 4387.74,5577.49 cw(c4403.96,5593.71) v1@4381.02,5593.71 ; v1@4371.52,5588.21 cw(c4371.52,5574.93) 4380.91,5584.32 cw(c4390.3,5593.71) v1@4377.02,5593.71 ; v1(4371.52,5593.71) 4443.93,5521.3 4455.23,5510 4599.27,5510 4623.52,5485.75 4623.52,5103.52 4610,5090 4610,4941.23 4623.84,4927.39 4685.31,4865.92 4698.19,4853.04 4698.19,4812.62 4722,4788.81 4722,4651.39 4770,4603.39 4830.82,4603.39 4838.82,4603.39 U8.D1@4858.5,4603.39 ; U8.D1@4853.31,4598.19 ccw(c4840.78,4585.66) 4840.78,4603.39 ccw(c4840.78,4621.11) U8.D1@4853.31,4608.58
  MidLayer2 w4: v1(2147.86,5516.71) 2307.52,5516.71 2357.52,5566.71 2444.81,5566.71 2462.62,5548.9 2477.38,5548.9 2495.19,5566.71 3463.29,5566.71 3470,5560 3495,5560 3543.37,5608.37 4356.86,5608.37 v1(4371.52,5593.71) ; v1@2151.75,5512.82 cw(c2161.14,5503.43) 2161.14,5516.71 cw(c2161.14,5529.99) v1@2151.75,5520.6 ; v1@2154.57,5509.99 cw(c2170.79,5493.77) 2170.79,5516.71 cw(c2170.79,5539.64) v1@2154.57,5523.43
  Bottom Layer w4: v1(2147.86,5516.71) 2150.68,5519.53 U5.20@2193.54,5519.53 ; v1@2151.75,5512.82 cw(c2167.94,5496.62) U5.20@2167.94,5519.53 ; v1@2154.57,5509.99 cw(c2177.6,5486.96) U5.20@2177.6,5519.53 ; v1@2154.57,5523.43 ccw(c2163.98,5532.83) 2163.98,5519.53
ETH.E_RXD2: U5.19 U8.E3 | length 3799.7
  Top Layer w4: v1@4665.19,4800.54 cw(c4665.19,4777.61) 4681.41,4793.82 cw(c4697.63,4810.04) v1@4674.69,4810.04 ; v1@4665.19,4804.54 cw(c4665.19,4791.26) 4674.58,4800.65 cw(c4683.97,4810.04) v1@4670.69,4810.04 ; v1(4665.19,4810.04) 4714,4761.23 4714,4646 4772.12,4587.88 4830.82,4587.88 4838.82,4587.88 ; 4838.82,4587.88 4897.36,4587.88 ; 4838.82,4587.88 4897.36,4587.88 ; 4897.36,4587.88 cw(c4897.36,4549.2) 4924.71,4576.55 ; 4897.36,4587.88 cw(c4897.36,4549.2) 4924.71,4576.55 ; 4924.71,4576.55 ccw(c4937.24,4589.08) 4937.24,4571.36 cw(c4937.24,4589.08) 4924.71,4576.55 ; 4924.71,4576.55 cw(c4912.18,4564.02) 4929.9,4564.02 ccw(c4912.18,4564.02) 4924.71,4576.55
  MidLayer1 w4: v1@2315.19,5548.87 cw(c2315.19,5525.94) 2331.41,5542.16 cw(c2347.63,5558.37) v1@2324.69,5558.37 ; v1@2315.19,5552.87 cw(c2315.19,5539.6) 2324.58,5548.99 cw(c2333.97,5558.37) v1@2320.69,5558.37 ; v1(2315.19,5558.37) 2340.86,5532.71 2513.77,5532.71 2621.06,5640 3667.63,5640 4040.92,5266.71 4348.52,5266.71 4639.19,4976.04 4639.19,4836.04 v1(4665.19,4810.04) ; v1@4655.69,4810.04 ccw(c4632.76,4810.04) 4648.97,4826.26 ccw(c4665.19,4842.48) v1@4665.19,4819.54 ; v1@4659.69,4810.04 ccw(c4646.41,4810.04) 4655.8,4819.43 ccw(c4665.19,4828.82) v1@4665.19,4815.54
  Bottom Layer w4: U5.19@2193.54,5499.84 2279.84,5499.84 2315.19,5535.19 v1(2315.19,5558.37) ; U5.19@2219.9,5497.01 cw(c2226.73,5490.19) 2226.73,5499.84 cw(c2226.73,5509.5) U5.19@2219.9,5502.67 ; v1@2308.47,5551.66 cw(c2292.26,5535.44) 2315.19,5535.44 cw(c2338.13,5535.44) v1@2321.91,5551.66 ; v1@2311.3,5554.49 cw(c2301.91,5545.1) 2315.19,5545.1 cw(c2328.47,5545.1) v1@2319.08,5554.49
ETH.E_RXD3: U5.18 U8.H5 | length 3752.3
  Top Layer w4: v3(4996.3,4465.59) U8.H5@5015.98,4445.91 ; U8.H5@5008.64,4445.91 ccw(c4990.92,4445.91) 5003.45,4458.44 ccw(c5015.98,4470.97) U8.H5@5015.98,4453.25 ; 5009.1,4452.79 cw(c5021.91,4465.59) 5003.8,4465.59 ccw(c5021.91,4465.59) 5009.1,4452.79 ; 5009.1,4452.79 ccw(c4996.3,4439.98) 4996.3,4458.09 cw(c4996.3,4439.98) 5009.1,4452.79
  MidLayer1 w4: v1@2383.28,5443.28 cw(c2367.06,5427.06) 2390,5427.06 cw(c2412.93,5427.06) v1@2396.72,5443.28 ; v1@2386.11,5446.11 cw(c2376.72,5436.72) 2390,5436.72 cw(c2403.28,5436.72) v1@2393.89,5446.11 ; v1(2390,5450) 2390,5325 2398.29,5316.71 3595.52,5316.71 3795.02,5117.21 4390,5117.21 4424.11,5117.21 4441.45,5117.21 4557,5001.66 4557,4983 4557,4940 4557,4920 4557,4861.69 4570,4848.69 4570.86,4847.83 4570.86,4732.83 4590,4713.69 4592,4711.69 4592,4633 4608.29,4616.71 4625,4616.71 4644.74,4616.71 4663.03,4598.42 4686.41,4575.04 4711.19,4575.04 4799.38,4486.85 4805.13,4481.1 4828.82,4481.1 4838.82,4481.1 4879.25,4481.1 4898.67,4481.1 4958.86,4481.1 4972.79,4481.1 cw(c4972.79,4467.05) 4982.72,4476.98 ; v3@4988.83,4464.94 ccw(c4970.79,4463.36) 4982.43,4477.23 ccw(c4994.07,4491.1) v3@4995.65,4473.06
  Bottom Layer w4: U5.18@2193.54,5480.16 2248.03,5480.16 2259.58,5491.71 2348.29,5491.71 v1(2390,5450) ; U5.18@2219.9,5477.33 cw(c2226.73,5470.5) 2226.73,5480.16 cw(c2226.73,5489.81) U5.18@2219.9,5482.99 ; v1@2380.5,5450 ccw(c2357.56,5450) 2373.78,5466.22 ccw(c2390,5482.43) v1@2390,5459.5 ; v1@2384.5,5450 ccw(c2371.22,5450) 2380.61,5459.39 ccw(c2390,5468.78) v1@2390,5455.5
ETH.E_RXDV: U5.22 U8.E4 | length 4278.1
  Top Layer w4: v3(4956.93,4583.7) U8.E4@4976.61,4564.02 ; U8.E4@4969.27,4564.02 ccw(c4951.55,4564.02) 4964.08,4576.55 ccw(c4976.61,4589.08) U8.E4@4976.61,4571.36 ; 4969.73,4570.9 cw(c4982.54,4583.7) 4964.43,4583.7 ccw(c4982.54,4583.7) 4969.73,4570.9 ; 4969.73,4570.9 ccw(c4956.93,4558.09) 4956.93,4576.2 cw(c4956.93,4558.09) 4969.73,4570.9
  MidLayer1 w4: v1@2445,5598.9 v1(2445,5595) 2498,5648 3829.82,5648 3981.86,5800.04 4415.19,5800.04 4640.19,5575.04 4640.19,5165.96 4682.35,5123.8 4725.85,5123.8 4799.36,5050.29 4799.36,5035.79 4783.81,5020.25 4783.81,4926.39 4782.13,4924.7 4782.13,4920 4782.13,4909.95 4782.13,4717.13 4782.13,4710.82 4775.81,4704.5 4775.81,4604.19 ; v1@2445,5600.5 ccw(c2445,5613.78) 2454.39,5604.39 ccw(c2463.78,5595) v1@2450.5,5595 ; v1@2445,5604.5 ccw(c2445,5627.43) 2461.22,5611.22 ccw(c2477.43,5595) v1@2454.5,5595 ; 4775,4605 4775.81,4604.19 ; v3@4951.74,4578.51 ccw(c4939.2,4565.97) 4939.2,4583.7 ccw(c4939.2,4601.43) v3@4951.74,4588.89 ; v3(4956.93,4583.7) 4898.67,4583.7 4879.25,4583.7 4838.82,4583.7 4830.82,4583.7 4796.3,4583.7 ; 4775.81,4604.19 4796.3,4583.7 ; 4775.81,4604.19 4796.3,4583.7 ; 4938.82,4583.7 cw(c4938.82,4565.59) 4951.63,4578.4 ccw(c4938.82,4565.59) 4938.82,4583.7 ; 4938.82,4583.7 ccw(c4938.82,4601.81) 4951.63,4589 cw(c4938.82,4601.81) 4938.82,4583.7
  Bottom Layer w4: U5.22@2193.54,5558.37 2290.19,5558.37 2313.52,5581.71 2360.79,5581.71 2375.79,5566.71 2416.71,5566.71 v1(2445,5595) v1@2445,5598.9 ; U5.22@2219.9,5556.07 cw(c2225.47,5550.5) 2225.47,5558.37 ; U5.22@2219.9,5561.73 ccw(c2227.99,5569.82) 2227.99,5558.37 ; v1@2435.5,5595 cw(c2412.56,5595) 2428.78,5578.78 cw(c2445,5562.56) v1@2445,5585.5 ; v1@2439.5,5595 cw(c2426.22,5595) 2435.61,5585.61 cw(c2445,5576.22) v1@2445,5589.5
ETH.E_RXER: U6.14 U8.B8 | length 2722.2
  Top Layer w4: v1@5076.47,4951.66 cw(c5060.26,4935.44) 5083.19,4935.44 cw(c5106.13,4935.44) v1@5089.91,4951.66 ; v1@5079.3,4954.49 cw(c5069.91,4945.1) 5083.19,4945.1 cw(c5096.47,4945.1) v1@5087.08,4954.49 ; v1(5083.19,4958.37) 5083.19,4911.5 5123.52,4871.16 5123.52,4803.52 5118.59,4798.59 5118.59,4701.84 ccw(c5128.74,4701.84) 5121.56,4694.66 ; U8.B8@5126.75,4682.13 ccw(c5109.03,4682.13) 5121.56,4694.66 ; U8.B8@5134.09,4689.47 cw(c5134.09,4707.19) 5121.56,4694.66
  Bottom Layer w4: U6.14@3341.06,5546.61 3483.39,5546.61 3550.61,5479.39 3550.61,5461.09 3556.72,5454.98 3728.47,5454.98 3740.19,5466.71 3931.86,5466.71 3956.86,5441.71 4006.86,5441.71 4023.86,5458.71 4322.85,5458.71 4331.52,5450.04 4581.86,5450.04 4673.52,5541.71 4723.52,5541.71 4976.73,5288.5 4976.73,4989.59 4983.77,4982.54 5026.79,4982.54 5026.83,4982.5 5059.06,4982.5 v1(5083.19,4958.37) ; U6.14@3379.38,5541.76 cw(c3391.08,5530.06) 3391.08,5546.61 cw(c3391.09,5563.17) U6.14@3379.38,5551.46 ; v1@5073.69,4958.37 ccw(c5050.76,4958.37) 5066.97,4974.59 ccw(c5083.19,4990.81) v1@5083.19,4967.87 ; v1@5077.69,4958.37 ccw(c5064.41,4958.37) 5073.8,4967.76 ccw(c5083.19,4977.15) v1@5083.19,4963.87
ETH.E_TXC: U5.7 U8.J5 | length 4573.2
  Top Layer w4: v3(4996.3,4426.22) U8.J5@5015.98,4406.54 ; U8.J5@5008.64,4406.54 ccw(c4990.92,4406.54) 5003.45,4419.07 ccw(c5015.98,4431.6) U8.J5@5015.98,4413.88 ; 5009.1,4413.42 cw(c5021.91,4426.22) 5003.8,4426.22 ccw(c5021.91,4426.22) 5009.1,4413.42 ; 5009.1,4413.42 ccw(c4996.3,4400.61) 4996.3,4418.72 cw(c4996.3,4400.61) 5009.1,4413.42
  MidLayer1 w4: v1(1815.19,5066.71) 1840.19,5091.71 1873.52,5091.71 1890.19,5075.04 1890.69,5074.54 3453.19,5074.54 3488.65,5110 3549.88,5110 3576.5,5083.37 4013.13,5083.37 4173.69,4922.81 4173.69,4908.46 4257.61,4824.54 4259.73,4824.54 4329.43,4754.84 4339.86,4744.42 4339.86,4716.69 4524.36,4532.19 4612.81,4532.19 4697,4448 4726.38,4448 4732.66,4441.73 4830.82,4441.73 4838.82,4441.73 4879.25,4441.73 4898.67,4441.73 4958.86,4441.73 4972.79,4441.73 cw(c4972.79,4427.68) 4982.72,4437.61 ; v1@1815.19,5072.21 ccw(c1815.19,5085.49) 1824.58,5076.1 ccw(c1833.97,5066.71) v1@1820.69,5066.71 ; v1@1815.19,5076.21 ccw(c1815.19,5099.14) 1831.41,5082.93 ccw(c1847.63,5066.71) v1@1824.69,5066.71 ; v3@4988.83,4425.57 ccw(c4970.79,4423.99) 4982.43,4437.86 ccw(c4994.07,4451.73) v3@4995.65,4433.69
  MidLayer2 w4: v1@1808.47,5073.43 ccw(c1792.26,5089.64) 1815.19,5089.64 ccw(c1838.13,5089.64) v1@1821.91,5073.43 ; v1@1811.3,5070.6 ccw(c1801.91,5079.99) 1815.19,5079.99 ccw(c1828.47,5079.99) v1@1819.08,5070.6 ; v1(1815.19,5066.71) 1815.19,5200.04 1831.86,5216.71 1915.19,5216.71 1973.52,5275.04 1976.29,5277.81 2348.75,5277.81 v1(2351.52,5275.04) ; 2321.9,5277.81 cw(c2321.9,5245.42) v1@2344.81,5268.32 ; 2331.56,5277.81 cw(c2331.56,5255.07) v1@2347.64,5271.15 ; 2335.28,5277.81 ccw(c2335.28,5291.29) v1@2344.81,5281.76
  Bottom Layer w4: U5.7@2348.59,5295.98 cw(c2344.81,5291.04) 2351.02,5291.04 ; U5.7@2351.02,5322.68 2351.02,5291.04 ; v1(2351.52,5275.04) 2351.52,5290.54 2351.02,5291.04 ; U5.7@2353.46,5295.98 ccw(c2357.24,5291.04) 2351.02,5291.04