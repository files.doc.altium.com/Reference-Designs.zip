# Altium PCB NB3000AL.PcbDoc (part 9 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
3V3: (continued)
  Top Layer w12: v2(-395,2660) -393.62,2658.62 U1.8@-320,2658.62 ; v2@-390.89,2664.11 ccw(c-377.64,2677.36) -377.64,2658.62 ; v1@-389.6,2740.4 ccw(c-374.65,2755.35) -374.65,2734.21 ; v1(-385,2745) -385,2736.23 -382.98,2734.21 U1.5@-320,2734.21 ; v1@-381.11,2748.89 ccw(c-345.68,2784.32) -345.68,2734.21 ; R99.2@-231.27,2409.28 ccw(c-225.51,2423.88) -214.41,2412.78 ; R99.2@-225.06,2411.24 cw(c-215.98,2402.16) -215.98,2415 cw(c-215.98,2427.84) R99.2@-225.06,2418.76 ; -208.57,2415 ccw(c-208.57,2429.59) v1@-195.77,2422.59 ; v1@-206.3,2428.35 cw(c-228.82,2440.67) R99.2@-228.82,2415 -212.18,2415 v1(-201.48,2425.71) ; v1@772.94,3139.15 cw(c763.18,3129.38) 776.99,3129.38 ; EXTHDR1.87@776.99,3071.85 v1@776.99,3142.88 ; 776.99,3130.14 cw(c789.73,3130.14) v1@780.72,3139.15 ; v1@804.44,3139.15 cw(c794.67,3129.38) 808.49,3129.38 ; EXTHDR1.85@808.49,3071.85 v1@808.49,3142.88 ; 808.49,3130.14 cw(c821.23,3130.14) v1@812.22,3139.15 ; R283.1@1097.74,3160 R234.2@1143.82,3160 1145,3161.18 v1(1145,3220) ; R283.1@1101.51,3156.24 cw(c1110.59,3147.15) 1110.59,3160 cw(c1110.58,3172.83) R283.1@1101.51,3163.76 ; R234.2@1140.06,3156.24 ccw(c1130.98,3147.16) 1130.98,3160 ccw(c1130.98,3172.84) R234.2@1140.06,3163.76 ; R234.2@1140.06,3164.25 ccw(c1128.13,3176.18) 1145,3176.18 ; v1@1141.11,3216.11 cw(c1131.72,3206.72) 1145,3206.72 cw(c1158.28,3206.72) v1@1148.89,3216.11 ; R277.1@1801.61,3165.24 cw(c1825.18,3141.67) 1825.18,3175 ; R277.1@1806.34,3160.02 1821.32,3175 1855.06,3175 v1(1880.02,3150.04) 1915.04,3150.04 1925.03,3160.03 R278.2@1964.34,3160.03 ; R277.1@1806.34,3165.83 ccw(c1806.34,3179.86) R277.1@1816.26,3169.94 ; R277.1@1810.1,3156.75 cw(c1854.15,3112.7) 1854.15,3175 ; R277.1@1811.66,3160.51 cw(c1823.31,3160.51) R277.1@1815.07,3168.75 ; v1@1874.52,3150.04 ccw(c1861.24,3150.04) 1870.63,3159.43 ccw(c1880.02,3168.82) v1@1880.02,3155.54 ; v1@1883.91,3146.15 cw(c1893.3,3136.76) 1893.3,3150.04 cw(c1893.3,3163.32) v1@1883.91,3153.93 ; R278.2@1960.58,3156.27 ccw(c1951.5,3147.19) 1951.5,3160.03 ccw(c1951.5,3172.87) R278.2@1960.58,3163.79 ; LED3.1@2905,5780 2960,5780 2975.19,5764.81 v1(2975.19,5717.71) ; LED3.1@2915.82,5770.29 cw(c2939.27,5746.84) 2939.27,5780 ; LED3.1@2915.82,5789.64 ccw(c2939.1,5812.92) 2939.1,5780 ; v1@2971.3,5721.6 ccw(c2961.91,5730.99) 2975.19,5730.99 ccw(c2988.47,5730.99) v1@2979.08,5721.6 ; v1@4411.3,4195.6 ccw(c4401.91,4204.99) 4415.19,4204.99 ccw(c4428.47,4204.99) v1@4419.08,4195.6 ; v1@4412.02,4194.87 v1(4415.19,4191.71) 4415.19,4216.83 4412.02,4220 4412.02,4245 4418.82,4251.79 R147.1@4418.82,4275 ; R147.1@4415.06,4270.75 cw(c4405.98,4261.67) 4418.82,4261.67 cw(c4431.66,4261.67) R147.1@4422.58,4270.75 ; v1(4947.19,5075.04) 4947.19,5068.37 4948.86,5066.71 4955.52,5066.71 4962.99,5059.24 ; C276.1@4950.02,5039.68 ccw(c4941.77,5059.24) 4962.99,5059.24 ; C278.1@4951.56,3339.71 cw(c4945.6,3323.38) 4962.99,3323.38 ; C278.1@4962.99,3375 4962.99,3323.37 ; C276.1@4962.99,4982.01 C276.1@4962.99,5005 4962.99,5059.24 ; C278.1@4974.42,3339.71 ccw(c4980.38,3323.38) 4962.99,3323.38 ; C276.1@4975.97,5039.68 cw(c4984.22,5059.24) 4962.99,5059.24 ; v1@5029.64,3317.82 ccw(c5020.25,3308.43) 5020.25,3321.71 ccw(c5020.25,3334.99) v1@5029.64,3325.6 ; v1(5033.52,3321.71) 4964.66,3321.71 4962.99,3323.37 ; v1@5266.75,229.49 cw(c5276.14,220.1) 5276.14,233.37 cw(c5276.14,246.65) v1@5266.75,237.26 ; v1@5267.41,228.82 v1(5262.86,233.37) 5305.44,233.37 R107.1@5310,228.82 ; 5285.67,233.37 cw(c5285.67,204.98) R107.1@5305.75,225.06 ; R102.1@5310,1006.18 5338.19,1006.18 5340.19,1008.18 v1(5340.19,1008.37) ; R102.1@5321.62,1006.18 ccw(c5321.62,1026.95) v1@5336.3,1012.26 ; v1@5360.19,2641.85 5392.19,2641.85 5397.86,2636.18 R273.2@5445,2636.18 ; v1@5364.08,2637.82 cw(c5373.8,2628.09) 5373.8,2641.85 ; v1@5364.08,2645.6 ccw(c5373.13,2654.65) 5373.13,2641.85 ; v2@5365,2574.19 cw(c5365,2560.16) 5374.92,2570.08 cw(c5384.84,2580) v2@5370.81,2580 ; v2(5365,2580) 5389.88,2555.12 5425.12,2555.12 5445,2535.23 ; R273.2@5440.75,2632.42 ccw(c5431.67,2623.34) 5431.67,2636.18 ccw(c5431.67,2649.02) R273.2@5440.75,2639.94 ; R272.2@5441.24,2507.45 ccw(c5432.16,2516.53) 5445,2516.53 ccw(c5457.84,2516.53) R272.2@5448.76,2507.45 ; R272.2@5445,2503.69 5445,2535.23 ; U61.126@5516.83,2331.35 5554.88,2331.35 v1@5560,2336.47 ; U61.115@5516.83,2547.88 5463.03,2547.88 5447.69,2532.54 5445,2535.23 ; U61.104@5516.83,2764.42 5550,2764.42 5551.86,2766.27 v1(5551.86,2782.04) 5551.86,2859.86 5596.38,2904.38 5710.86,2904.38 5715.19,2900.04 5733.6,2881.63 5734.12,2881.12 5738.02,2877.21 ; 5537.9,2331.35 ccw(c5537.9,2357.1) v1@5556.11,2338.89 ; v1@5547.97,2785.93 ccw(c5538.58,2795.32) 5551.86,2795.32 ccw(c5565.14,2795.32) v1@5555.75,2785.93 ; U53.3@5655,1480 5715.19,1480 5731.86,1463.33 v1(5731.86,1440.19) 5731.86,1398.62 5775.48,1355 C165.2@5824.33,1355 ; U50.3@5655,1820 5698.52,1820 ; v1(5655.79,3252.04) 5671.52,3252.04 5715.19,3208.37 ; v1(5677,1168) v1@5677.23,1168 ; U50.3@5684.53,1824.22 cw(c5684.53,1800.62) 5701.22,1817.31 ; U50.3@5689.37,1813.91 cw(c5696.94,1804.42) 5705.52,1813 ; U53.3@5690.03,1474.5 cw(c5703.31,1461.22) 5703.31,1480 cw(c5703.31,1498.78) U53.3@5690.03,1485.5 ; U50.3@5691.13,1815.89 cw(c5698.52,1811.3) 5698.52,1820 ; U50.3@5691.13,1824.11 ccw(c5698.52,1828.7) 5698.52,1820 ; NT36.2@5710,3180 5710,3203.52 5714.86,3208.37 5715.19,3208.37 ; v1@5711.11,1766.89 ccw(c5701.26,1776.74) 5715.19,1776.74 ; v1(5715,1763) 5715.19,1763.19 5715.19,1803.33 5698.52,1820 ; 5715.19,1775.82 ccw(c5727.82,1775.82) v1@5718.89,1766.89 ; U61.94@5727.48,2837.34 5727.48,2866.71 ; 5727.52,2866.71 5738.02,2877.21 ; v1@5727.97,1436.3 cw(c5718.58,1426.92) 5731.86,1426.92 cw(c5745.14,1426.92) v1@5735.75,1436.3 ; v1@5727.97,1444.08 ccw(c5718.58,1453.47) 5731.86,1453.47 ccw(c5745.14,1453.47) v1@5735.75,1444.08 ; v1@5746.3,3287.82 cw(c5720.82,3262.33) 5756.86,3262.33 ; U61.10@5747.17,2240 5747.17,2271.33 5743.5,2275 5743.5,2293.91 5764.97,2315.37 5779.52,2315.37 5779.15,2315 5775,2315 v1(5770,2320) ; NT35.2@5750,3180 5750,3207.18 ; v1(5750.19,3291.71) 5756.86,3285.04 5756.86,3214.04 5750,3207.18 ; v1@5756.5,1031.16 cw(c5756.5,1017.88) 5765.89,1027.27 cw(c5775.28,1036.66) v1@5762,1036.66 ; v1(5756.5,1036.66) 5785,1008.16 R103.1@5785,1006.18 ; 5759.92,2310.32 cw(c5770,2300.24) v1@5770,2314.5 ; 5760.9,2311.3 ccw(c5752.2,2320) v1@5764.5,2320 ; 5773.68,1019.48 cw(c5760.38,1006.18) R103.1@5779.19,1006.18 ; C277.1@5801.08,5038.26 ccw(c5786.53,5065.04) 5817.01,5065.04 ; U61.13@5806.22,2240 5806.22,2278.74 5819.19,2291.71 5817.48,2290 v1(5810,2290) ; 5806.22,2267.6 cw(c5832.4,2267.6) v1@5813.89,2286.11 ; C279.1@5811.3,3338.18 cw(c5810.12,3331.4) 5817.01,3331.4 ; C279.1@5817.01,3375 5817.01,3331.4 ; C277.1@5817.01,5005 5817.01,5065.04 ; C165.2@5820.22,1350.89 ccw(c5810.3,1340.97) 5810.3,1355 ccw(c5810.3,1369.03) C165.2@5820.22,1359.11 ; C159.2@5820.22,2005.89 cw(c5810.3,1995.97) 5824.33,1995.97 cw(c5838.36,1995.97) C159.2@5828.44,2005.89 ; C279.1@5822.72,3338.19 ccw(c5823.9,3331.4) 5817.01,3331.4 ; C159.2@5824.33,2010 5824.33,1969.86 5874.19,1920 ; 5825.42,3322.98 ccw(c5849.22,3346.78) v1@5855.79,3313.77 ; C277.1@5832.94,5038.26 cw(c5847.48,5065.04) 5817.01,5065.04 ; 5841.3,3307.1 ccw(c5854.49,3320.29) v1@5858.12,3302 ; 5842,2962 5835.5,2955.5 5805.09,2955.5 5738.02,2888.43 5738.02,2877.21 ; 5843.52,2963.52 5845,2965 NT37.2@5845,2980 ; v1@5851.3,5062.82 ccw(c5841.91,5053.43) 5841.91,5066.71 ccw(c5841.91,5079.99) v1@5851.3,5070.6 ; v1@5852.97,3304.49 ccw(c5843.58,3295.1) 5843.58,3308.37 ccw(c5843.58,3321.65) v1@5852.97,3312.26 ; v1(5855.19,5066.71) 5818.67,5066.71 5817.01,5065.04 ; v1(5856.86,3308.37) 5840.03,3308.37 5817.01,3331.4 ; C164.1@5865.67,1670 5905.19,1670 v1(5940,1635.19) v1@5940,1630.04 ; C164.1@5869.78,1665.89 cw(c5879.7,1655.97) 5879.7,1670 cw(c5879.7,1684.03) C164.1@5869.78,1674.11 ; U50.7@5895.56,1864.5 ccw(c5882.28,1851.22) 5882.28,1870 ccw(c5882.28,1888.78) U50.7@5895.56,1875.5 ; U50.8@5895.56,1914.5 ccw(c5882.28,1901.22) 5882.28,1920 ccw(c5882.28,1938.78) U50.8@5895.56,1925.5 ; U53.8@5930,1580 5930.3,1580.3 U53.8@5930.59,1580.59 ; U53.8@5930.59,1577.12 U53.8@5930.59,1580 U53.8@5930.59,1580.59 ; U50.8@5930.59,1920 5874.19,1920 ; U53.8@5933.57,1577.02 ccw(c5918.06,1592.53) U53.8@5940,1592.53 ; v1@5934.5,1635.19 ccw(c5921.22,1635.19) 5930.61,1644.58 ccw(c5940,1653.97) v1@5940,1640.69 ; v1@5936.11,1631.3 cw(c5926.72,1621.92) 5940,1621.92 cw(c5953.28,1621.92) v1@5943.89,1631.3 ; v1@5936.3,2778.93 ccw(c5917.68,2797.55) 5944.02,2797.55 ; v1@5939.92,1630.04 v1@5940,1630.04 ; v1(5940.19,2775.04) 5944.02,2778.87 U61.83@5944.01,2837.34 ; v1(5952.77,5540) v1@5958.3,5540 ; U53.7@5965,1540 U53.8@5965,1568.31 ; U50.7@5965.62,1864.5 cw(c5978.9,1851.22) 5978.9,1870 cw(c5978.9,1888.78) U50.7@5965.62,1875.5 ; 6024.91,1884.76 cw(c6048.52,1861.14) v1@6048.52,1894.54 ; v1(6048.52,1900.04) 6040.19,1900.04 6010.23,1870.08 6010.23,1870 U50.7@5930.59,1870 5878.86,1870 5877.19,1871.67 5877.19,1917 5874.19,1920 ; v1@6097.97,2804.6 ccw(c6089.45,2813.11) 6101.49,2813.11 ; 6101.49,2814.86 ccw(c6116.01,2814.86) v1@6105.75,2804.6 ; U61.75@6101.49,2837.34 6101.49,2801.07 v1(6101.86,2800.71) ; U51.3@6130,1480 6202.48,1480 v1@6206.86,1484.37 ; U52.3@6130,1820 6188.15,1820 6198.52,1830.37 6198.52,1850.48 6198.68,1850.48 v1(6198.68,1850) ; U51.3@6165.03,1474.5 cw(c6178.31,1461.22) 6178.31,1480 cw(c6178.31,1498.78) U51.3@6165.03,1485.5 ; U52.3@6165.03,1814.5 cw(c6178.31,1801.22) 6178.31,1820 cw(c6178.31,1838.78) U52.3@6165.03,1825.5 ; U13.27@6170.59,3355.55 6204.19,3355.55 6223.52,3336.22 v1(6223.52,3301.04) ; U13.14@6170.59,3765 6208.56,3765 6215.19,3758.37 6296.19,3758.37 v1(6315.19,3777.37) ; U13.9@6170.59,3922.48 6251.08,3922.48 ; U13.3@6170.59,4111.46 6173.55,4108.5 6231.73,4108.5 6240.19,4100.04 6240.19,4050.04 6248.52,4041.71 6248.52,3925.04 6251.08,3922.48 ; U17.11@6170.59,4655.75 6204.23,4655.75 v1(6215.19,4666.71) ; U17.11@6175.45,4655.75 ccw(c6175.45,4706.45) v1@6211.3,4670.6 ; 6186.24,1480 ccw(c6186.24,1513.76) v1@6210.11,1489.89 ; U13.3@6190.98,4114.29 ccw(c6204.94,4128.25) 6204.94,4108.5 ; U13.1@6193.32,4168.34 ccw(c6182.12,4181.57) 6199.45,4181.57 ; v1@6194.64,4204.49 cw(c6183.01,4192.86) 6199.45,4192.86 ; v1@6194.79,1846.11 cw(c6185.77,1837.1) 6198.52,1837.1 ; 6198.52,1836.35 cw(c6212.33,1836.35) v1@6202.57,1846.11 ; 6198.52,4175.37 6199.45,4174.45 v1@6199.45,4207.45 ; v1@6202.97,1712.82 cw(c6193.58,1703.43) 6206.86,1703.43 cw(c6220.14,1703.43) v1@6210.75,1712.82 ; 6204.42,4655.75 ccw(c6204.42,4677.48) v1@6219.79,4662.11 ; C160.1@6206.56,1674.11 ccw(c6196.64,1684.03) 6210.67,1684.03 ccw(c6224.7,1684.03) C160.1@6214.78,1674.11 ; v1(6206.86,1716.71) 6206.86,1694.04 6207,1694.04 6210.67,1690.37 C160.1@6210.67,1670 ; v1@6212.56,1486 v1(6214,1486) ; v1@6219.64,3304.93 ccw(c6210.25,3314.32) 6223.52,3314.32 ccw(c6236.8,3314.32) v1@6227.41,3304.93 ; 6257.57,2980 ccw(c6257.57,2994.68) v1@6271.25,2989.34 ; U61.67@6258.97,2837.34 6258.98,2918.83 6273.52,2933.37 6273.52,2983.37 v1(6265.19,2991.71) 6265.19,2983.37 6261.82,2980 NT34.2@6240,2980 ccw(c6240,3001.54) v1@6260.07,2993.71 ; v1@6261.3,2987.82 cw(c6231.79,2958.31) 6273.52,2958.31 ; v1@6262.36,1649.83 ccw(c6251.35,1670) C163.2@6274.33,1670 ; R104.2@6265,1011.18 v1@6331.18,1011.18 ; v1(6265,1645) 6265,1644.18 6274.33,1653.51 C163.2@6274.33,1670 ; R104.2@6269.25,1007.42 cw(c6278.33,998.34) 6278.33,1011.18 cw(c6278.33,1024.02) R104.2@6269.25,1014.94 ; v1@6271.36,3896.71 ccw(c6258.08,3896.71) 6267.47,3906.1 ccw(c6276.86,3915.49) v1@6276.86,3902.21 ; v1(6276.86,3896.71) 6251.08,3922.48 ; 6308.87,1011.18 cw(c6308.87,993.87) v1@6321.11,1006.11 ; v1@6309.69,3777.37 cw(c6296.41,3777.37) 6305.8,3767.99 cw(c6315.19,3758.6) v1@6315.19,3771.87 ; C161.2@6315,1355 6335,1335 6365,1335 6365,1336 6364,1335 v2(6364,1334) ; C161.2@6315.67,1349.19 cw(c6315.67,1336.78) C161.2@6324.45,1345.55 ; C162.1@6315.67,2010 6361.52,2010 6375.07,1996.45 ; C162.1@6319.78,2005.89 cw(c6329.7,1995.97) 6329.7,2010 cw(c6329.7,2024.03) C162.1@6319.78,2014.11 ; C161.2@6321.48,1355 ccw(c6337.13,1355) C161.2@6326.06,1343.94 ; 6347.56,1335 cw(c6347.56,1317.56) v2@6359.89,1329.89 ; U61.48@6351.71,2469.14 6324.96,2469.14 6305.86,2450.04 6281.86,2450.04 6265.19,2433.37 6265.19,2408.37 6248.52,2391.71 6200.52,2391.71 6165.19,2427.04 6165.19,2527.16 6323.71,2685.68 U61.59@6351.93,2685.68 6433.83,2685.68 6449.86,2701.71 6449.86,2713.86 v1(6450,2714) ; U61.40@6351.93,2311.66 v1@6385.86,2311.66 ; U61.40@6367.28,2311.66 ccw(c6367.28,2337.62) v1@6385.64,2319.26 ; U52.7@6373.52,1870 U52.7@6405.59,1870 U52.8@6405.59,1920 6405.59,1951.25 6375.07,1981.77 6375.07,1996.45 ; v2@6385.89,2080.89 cw(c6375.91,2070.91) 6390.02,2070.91 ; v1@6385.86,2311.71 v1(6389.52,2315.37) ; 6390.02,2071.03 cw(c6403.97,2071.03) v2@6394.11,2080.89 ; v2(6390,2085) 6390,2075.64 6390.02,2050.21 6390.19,2050.04 6375.07,2034.93 6375.07,1996.45 ; U52.7@6400.09,1875.5 ccw(c6386.81,1888.78) 6405.59,1888.78 ccw(c6424.37,1888.78) U52.7@6411.09,1875.5 ; U52.8@6400.09,1914.5 cw(c6386.81,1901.22) 6405.59,1901.22 cw(c6424.37,1901.22) U52.8@6411.09,1914.5 ; U52.8@6400.09,1925.5 ccw(c6386.81,1938.78) 6405.59,1938.78 ccw(c6424.37,1938.78) U52.8@6411.09,1925.5 ; U51.7@6405.59,1530 6470,1530 ; U51.8@6405.59,1580 6445,1580 v1@6470,1555 ; 6439.9,2691.75 ccw(c6425.68,2705.97) v1@6444.78,2712.28 ; U51.7@6440.62,1524.5 cw(c6453.9,1511.22) 6453.9,1530 cw(c6453.9,1548.78) U51.7@6440.62,1535.5 ; 6454.08,1570.92 cw(c6436.15,1553) v1@6461.5,1553 ; v1@6463.11,1549.11 cw(c6446.48,1532.48) 6470,1532.48 ; v1(6467,1553) 6469,1555 v1@6470,1555 ; v1@6471.23,1555 v1@6470,1555 ; v1@6473.52,1552.71 v1@6473.52,1555 ; v1@6473.62,1551.38 v1@6470,1555 ; 6475.34,1524.66 ccw(c6495.73,1545.06) C231.1@6499.28,1516.44 ; v2@6481.89,2170.11 ccw(c6471.97,2180.03) 6486,2180.03 ccw(c6500.03,2180.03) v2@6490.11,2170.11 ; v2(6486,2166) 6486,2205.33 C251.1@6500,2219.33 ; C231.1@6494.5,1508.81 ccw(c6482.81,1504.85) 6482.81,1517.19 ; C231.1@6500,1510.67 6493.48,1517.19 6482.81,1517.19 ; v1@6505.1,1337.61 v1@6505.19,1337.52 ; v1@6505.19,1337.37 v1@6505.19,1337.52 ; v1(6506,1338) 6505.48,1338 6505.19,1337.71 v1@6505.19,1337.52 ; C215.1@6610.22,2379.11 ccw(c6600.3,2389.03) 6614.33,2389.03 ccw(c6628.36,2389.03) C215.1@6618.44,2379.11 ; C232.1@6614.33,1355 6638,1331.33 v2(6638,1282) ; C215.1@6614.33,2375 6614.33,2393.9 6623.33,2402.9 6645,2402.9 ; C202.1@6619.4,2527.47 cw(c6562.43,2470.5) 6642.99,2470.5 cw(c6723.55,2470.5) C202.1@6666.59,2527.47 ; U13.43@6619.41,3827.99 6665.19,3827.99 6681.86,3811.32 6681.86,3811.04 6684.52,3808.37 6715.19,3808.37 6715.19,3807.99 6740,3783.18 ; U13.49@6619.41,4016.97 6654.52,4016.97 6666.49,4005 v1(6675,4005) v1@6670.15,4005 ; U17.33@6619.41,4624.25 6652.07,4624.25 6665.19,4637.37 ; C202.1@6627.88,2535.95 cw(c6591.4,2499.47) 6642.99,2499.47 cw(c6694.58,2499.47) C202.1@6658.1,2535.95 ; v2@6633.89,1286.11 ccw(c6623.97,1296.03) 6638,1296.03 ccw(c6652.03,1296.03) v2@6642.11,1286.11 ; U17.33@6635.81,4616.34 ccw(c6637.93,4630.83) 6648.29,4620.47 ; U17.33@6637.55,4628.21 ccw(c6642.24,4660.32) 6665.19,4637.37 ; C202.1@6642.99,2555 6642.99,2404.91 6645,2402.9 ; 6658.78,4012.71 ccw(c6667.75,4021.69) v1@6672.81,4010.05 ; v1@6661.3,4660.15 cw(c6651.91,4650.76) 6665.19,4650.76 cw(c6678.47,4650.76) v1@6669.08,4660.15 ; v1(6665.19,4664.04) 6665.19,4637.37 ; v1(6698.52,2700.04) 6713.56,2685 R215.1@6788.82,2685 ; v1(6703,4865) 6703,4865.23 6702.52,4865.71 6708.19,4871.38 C79.1@6735,4871.38 ; v1@6704.52,1006.18 R105.1@6745,1006.18 ; v1@6706.89,4861.11 cw(c6731.67,4836.33) C79.1@6731.67,4871.38 ; v1@6708.41,1014.6 ccw(c6728.73,1034.92) 6728.73,1006.18 ; v1@6708.49,2399.01 ccw(c6699.1,2389.62) 6699.1,2402.9 ccw(c6699.1,2416.18) v1@6708.49,2406.79 ; v1@6708.69,3741.71 cw(c6733.24,3741.71) 6715.88,3759.06 ; v1@6711.3,3745.6 ccw(c6701.91,3754.99) 6715.19,3754.99 ccw(c6728.47,3754.99) v1@6719.08,3745.6 ; v1(6712.38,2402.9) 6645,2402.9 ; v1@6715.19,3736.21 cw(c6715.19,3722.93) 6724.58,3732.32 cw(c6733.97,3741.71) 6720.69,3741.71 cw(c6774.21,3741.71) 6736.37,3779.55 ; v1@6726.07,3404.09 cw(c6736.99,3409.65) 6728.32,3418.32 ; C84.1@6730.89,4453.36 ccw(c6720.97,4463.29) 6735,4463.29 ccw(c6749.03,4463.28) C84.1@6739.11,4453.36 ; C83.1@6730.89,4544.51 cw(c6720.97,4534.59) 6735,4534.59 cw(c6749.03,4534.6) C83.1@6739.11,4544.51 ; C80.1@6730.89,4685.22 cw(c6720.97,4675.3) 6735,4675.3 cw(c6749.03,4675.3) C80.1@6739.11,4685.22 ; C79.1@6730.89,4867.27 ccw(c6720.97,4857.35) 6720.97,4871.38 ccw(c6720.97,4885.41) C79.1@6730.89,4875.49 ; v1@6731.11,4491.11 cw(c6721.72,4481.72) 6735,4481.72 cw(c6748.28,4481.72) v1@6738.89,4491.11 ; v1@6731.11,4498.89 ccw(c6721.72,4508.28) 6735,4508.28 ccw(c6748.28,4508.28) v1@6738.89,4498.89 ; v1(6731.86,3407.04) 6731.86,3421.86 6740,3430 ; C84.1@6735,4449.26 C83.1@6735,4548.62 ; C68.1@6735.89,3450.07 cw(c6725.97,3440.15) 6740,3440.15 cw(c6754.03,3440.15) C68.1@6744.11,3450.07 ; C66.1@6735.89,3814.71 cw(c6725.97,3804.79) 6740,3804.79 cw(c6754.03,3804.79) C66.1@6744.11,3814.71 ; v1@6736.76,3409.54 cw(c6752.46,3417.54) 6740,3430 ; C68.1@6740,3454.18 6740,3430 ; C67.1@6740,3719.45 6737.45,3719.45 v1(6715.19,3741.71) 6715.19,3758.37 6740,3783.18 ; C66.1@6740,3818.82 6740,3783.18 ; C65.1@6740,4070.01 cw(c6740,4055.98) 6749.92,4065.9 cw(c6759.84,4075.82) C65.1@6745.81,4075.82 ; C65.1@6740,4075.82 6763.45,4052.37 v1(6780.52,4052.37) ; R105.1@6740.75,1002.42 ccw(c6731.67,993.34) 6731.67,1006.18 ccw(c6731.67,1019.02) R105.1@6740.75,1009.94 ; v1(6743.19,4658.37) 6735,4666.56 C80.1@6735,4689.33 ccw(c6771.34,4689.33) v1@6746.89,4662.44 ; C65.1@6748.54,4067.29 ccw(c6772.99,4091.73) v1@6779.49,4057.78 ; 6764.55,4051.27 ccw(c6778.13,4064.86) v1@6781.75,4045.99 ; v2(6775,4110) 6776.46,4111.46 U12.3@6845.59,4111.46 ; v1@6776.64,4048.49 ccw(c6767.25,4039.1) 6767.25,4052.37 ccw(c6767.25,4065.65) v1@6776.64,4056.26 ; v2@6779.11,4105.89 cw(c6792.55,4092.45) 6792.55,4111.46 ; R215.1@6785.06,2681.24 ccw(c6775.98,2672.16) 6775.98,2685 ccw(c6775.98,2697.84) R215.1@6785.06,2688.76 ; v1(6795.88,4722.82) 6806.86,4711.84 6806.86,4664.08 6815.19,4655.75 U16.11@6845.59,4655.75 ; R264.2@6831.18,2475 6860,2475 6861.19,2476.19 v1(6861.19,2500.04) v1@6866.19,2500.04 ; R264.2@6834.94,2471.24 cw(c6844.02,2462.16) 6844.02,2475 cw(c6844.02,2487.84) R264.2@6834.94,2478.76 ; U12.27@6845.59,3355.55 6886.86,3355.55 6892.37,3350.04 6892.52,3350.04 6906.86,3335.71 v1(6906.86,3316.71) ; U12.14@6845.59,3765 6909.9,3765 6915.19,3759.71 v1(6915.19,3711.37) ; U12.9@6845.59,3922.48 6899.42,3922.48 v1(6905.19,3916.71) ; U12.1@6845.59,4174.45 6894.45,4174.45 6895,4175 v2(6895,4180) ; v1@6857.3,2496.15 cw(c6847.91,2486.76) 6861.19,2486.76 cw(c6874.47,2486.76) v1@6865.08,2496.15 ; U12.1@6867.57,4174.45 ccw(c6867.57,4207.43) v2@6890.89,4184.11 ; 6877.98,3922.48 cw(c6877.98,3889.49) v1@6901.3,3912.82 ; v1@6902.97,3320.6 ccw(c6893.58,3329.99) 6906.86,3329.99 ccw(c6920.14,3329.99) v1@6910.75,3320.6 ; v1@6911.3,3715.26 ccw(c6901.91,3724.65) 6915.19,3724.65 ccw(c6928.47,3724.65) v1@6919.08,3715.26 ; v1@6966.11,2521.11 cw(c6948.21,2503.21) 6973.52,2503.21 ; R265.2@6967.42,2479.25 ccw(c6952.68,2493.99) 6973.52,2493.99 ; v1(6970,2525) 6973.52,2521.48 6973.52,2477.34 R265.2@6971.18,2475 ; v1@7148.52,1017.21 cw(c7148.52,1003.93) 7157.91,1013.32 cw(c7167.3,1022.71) v1@7154.02,1022.71 ; v1(7148.52,1022.71) 7165.05,1006.18 R106.2@7220,1006.18 7258.82,1006.18 7273.52,991.48 v1(7273.52,940.71) v1@7278.52,935.71 ; v1@7154.52,3827.87 cw(c7154.52,3814.6) 7163.91,3823.99 cw(c7173.3,3833.37) v1@7160.02,3833.37 ; v1(7154.52,3833.37) 7171.19,3816.71 7252.19,3816.71 7259.86,3824.37 7259.86,3824.66 7263.19,3827.99 U12.43@7294.41,3827.99 7349.52,3827.99 7358.52,3818.99 7358.52,3818.82 C64.1@7385,3818.82 7433.19,3818.82 7438.52,3813.48 ; R106.2@7215.75,1002.42 ccw(c7206.67,993.34) 7206.67,1006.18 ccw(c7206.67,1019.02) R106.2@7215.75,1009.94 ; R106.2@7224.25,1002.42 cw(c7233.33,993.34) 7233.33,1006.18 cw(c7233.33,1019.02) R106.2@7224.25,1009.94 ; v4(7234.34,858.27) 7270.19,858.27 7278.52,866.6 v1@7278.52,935.71 ; v1(7246.19,4655.71) 7246.19,4641.58 7263.52,4624.25 U16.33@7294.41,4624.25 ; v1@7251.37,4653.87 ccw(c7271.76,4646.62) 7256.46,4631.31 ; 7252.85,4634.92 ccw(c7270.6,4652.66) U16.33@7275.99,4628.16 ; 7256.36,3821.16 cw(c7268.02,3809.5) U12.43@7275.13,3824.38 ; C201.1@7264.03,2534.09 cw(c7243.93,2507.81) 7277.01,2507.81 cw(c7310.09,2507.81) C201.1@7289.99,2534.09 ; v1@7269.64,936.82 cw(c7248.17,915.36) 7278.52,915.36 ; v1@7269.64,944.6 ccw(c7260.25,953.99) 7273.52,953.99 ccw(c7286.8,953.99) v1@7277.41,944.6 ; v1@7271.11,2485.89 ccw(c7256.87,2500.13) 7277.01,2500.13 ; v1@7277.01,2483.52 C201.1@7277.01,2555 ; v1@7278.52,940.71 v1@7278.52,935.71 ; U12.49@7294.41,4016.97 7333.37,4016.97 7350.37,3999.97 7350.37,3999.86 7385,3999.86 ; v1@7340.19,2355 7340.19,2366.67 7348.52,2375 C233.1@7364.33,2375 ; v1@7345.06,2357.15 cw(c7360.01,2363.51) 7348.52,2375 ; 7349.34,2375.82 cw(c7362.6,2362.55) C233.1@7365.18,2381.13 ; 7351.79,2378.26 cw(c7360.98,2369.07) C233.1@7367.38,2380.39 ; C233.1@7360.22,2370.89 ccw(c7350.3,2360.97) 7350.3,2375 ccw(c7350.3,2389.03) C233.1@7360.22,2379.11 ; C64.1@7380.89,3814.71 ccw(c7370.97,3804.79) 7370.97,3818.82 ccw(c7370.97,3832.85) C64.1@7380.89,3822.93 ; C69.1@7380.89,4030.38 cw(c7370.97,4020.46) 7385,4020.46 cw(c7399.03,4020.46) C69.1@7389.11,4030.38 ; C81.1@7380.89,4453.36 ccw(c7370.97,4463.29) 7385,4463.29 ccw(c7399.03,4463.28) C81.1@7389.11,4453.36 ; C86.1@7380.89,4544.51 cw(c7370.97,4534.59) 7385,4534.59 cw(c7399.03,4534.6) C86.1@7389.11,4544.51 ; C85.1@7380.89,4685.22 cw(c7370.97,4675.3) 7385,4675.3 cw(c7399.03,4675.3) C85.1@7389.11,4685.22 ; C70.1@7385,3454.18 7406.86,3454.18 7406.86,3454.37 v1(7412.52,3454.37) ; C63.1@7385,3678.11 7398.52,3678.11 ; C69.1@7385,4034.48 7385,3999.86 ; C81.1@7385,4449.26 7385,4495.18 7390,4500.18 v1(7390,4515) ; C86.1@7385,4540.35 ccw(c7415.35,4540.35) v1@7393.89,4518.89 ; C86.1@7385,4548.62 7385,4520 v1(7390,4515) ; 7385,4674.18 ccw(c7416,4674.18) v1@7394.08,4652.26 ; C85.1@7385,4689.33 7385,4661.71 7385.19,4661.71 7390.19,4656.71 v1(7390.19,4648.37) ; C82.1@7385,4830.04 7428.19,4830.04 7433.86,4835.71 v1(7442.52,4835.71) ; C63.1@7387.6,3683.31 ccw(c7395.05,3698.25) 7406.86,3686.44 ; C64.1@7389.11,3814.71 cw(c7399.03,3804.79) 7399.03,3818.82 cw(c7399.03,3832.85) C64.1@7389.11,3822.93 ; C82.1@7389.11,4825.93 cw(c7399.03,4816.01) 7399.03,4830.04 cw(c7399.03,4844.07) C82.1@7389.11,4834.15 ; C63.1@7389.22,3674.11 cw(c7398.52,3665.28) 7398.52,3678.11 ; C63.1@7389.22,3682.11 ccw(c7398.52,3690.94) 7398.52,3678.11 ; 7398.77,3454.18 ccw(c7398.77,3468.13) v1@7408.64,3458.26 ; 7399.73,3454.18 cw(c7399.73,3441.58) v1@7408.64,3450.49 ; 7415.55,4830.04 ccw(c7415.55,4862.68) v1@7438.64,4839.6 ; v1@7443.92,3062.78 ccw(c7461.07,3079.9) 7461.07,3055.67 ; v1(7448.52,3067.37) 7448.52,3057.71 7446.48,3055.67 7448.52,3055.67 C156.1@7490,3055.67 ; v1@7452.42,3071.26 ccw(c7490,3108.76) C156.1@7490,3055.67 ; 7456.75,3841.71 7456.86,3841.71 ; C155.1@7485.89,2915.22 cw(c7475.97,2905.3) 7490,2905.3 cw(c7504.03,2905.3) C155.1@7494.11,2915.22 ; C156.1@7485.89,3051.56 ccw(c7475.97,3041.64) 7475.97,3055.67 ccw(c7475.97,3069.7) C156.1@7485.89,3059.78 ; 7490,2889.4 ccw(c7525.55,2889.4) v1@7500.41,2864.26 ; C155.1@7490,2919.33 7490,2866.9 v1(7496.52,2860.37) ; C252.1@7515.89,2215.22 cw(c7505.97,2205.3) 7520,2205.3 cw(c7534.03,2205.3) C252.1@7524.11,2215.22 ; v1@7515.97,2174.26 ccw(c7506.23,2184) 7520,2184 ; v1(7519.86,2170.37) 7520,2170.52 C252.1@7520,2219.33 ; 7520,2183.31 ccw(c7532.79,2183.31) v1@7523.75,2174.26 ; R156.2@7526.24,3814.55 cw(c7517.16,3805.46) 7530,3805.46 cw(c7542.84,3805.47) R156.2@7533.76,3814.55 ; R235.2@7530,3453.66 7568.9,3453.66 7571.57,3456.33 7571.57,3456.42 v1(7576.86,3461.71) ; R156.2@7530,3818.31 7530,3769.9 7530.19,3769.71 7550,3769.71 7555.19,3769.71 7554.9,3770 v1(7550,3770) ; C60.1@7530.89,4285.22 cw(c7520.97,4275.3) 7535,4275.3 cw(c7549.03,4275.3) C60.1@7539.11,4285.22 ; R235.2@7534.25,3449.9 cw(c7543.33,3440.82) 7543.33,3453.66 cw(c7543.33,3466.51) R235.2@7534.25,3457.43 ; C60.1@7535,4289.33 7535,4265.04 7539.33,4260.71 7539.52,4260.71 v1(7576.52,4223.71) ; C59.1@7535,4444.33 7564.19,4473.52 v1(7564.19,4601.71) 7558.52,4601.71 7556.86,4600.04 7556.86,4592.66 7548.52,4584.33 ; C59.1@7535,4450.14 ccw(c7535,4464.17) 7544.92,4454.25 ccw(c7554.84,4444.33) C59.1@7540.81,4444.33 ; C58.1@7535,4584.33 7548.52,4584.33 ; 7536.02,3769.71 ccw(c7536.02,3783.98) v1@7546.11,3773.89 ; 7537.43,3769.71 cw(c7537.43,3757.43) v1@7546.11,3766.11 ; C58.1@7539.22,4580.33 cw(c7548.52,4571.5) 7548.52,4584.33 ; C58.1@7539.22,4588.33 ccw(c7548.52,4597.16) 7548.52,4584.33 ; 7544.16,3453.66 ccw(c7544.16,3494.4) v1@7572.97,3465.6 ; 7553.59,4589.4 ccw(c7541.28,4601.71) v1@7558.69,4601.71 ; U47.11@7555.59,3050.75 7618.56,3050.75 7619.86,3049.45 7619.86,3049.37 v1(7631.86,3037.37) ; v1@7560.3,4597.82 cw(c7550.91,4588.43) 7564.19,4588.43 cw(c7577.47,4588.43) v1@7568.08,4597.82 ; v1@7571.02,4223.71 ccw(c7557.75,4223.71) 7567.14,4233.1 ccw(c7576.52,4242.49) v1@7576.52,4229.21 ; v1@7641.17,4860.24 ccw(c7658.5,4869.79) 7658.5,4850 ; v1(7646.86,4863.37) 7646.86,4853.37 7650.23,4850 R159.2@7678.82,4850 cw(c7678.82,4881) v1@7651.67,4866.03 ; C203.1@7652.75,1455.89 cw(c7642.1,1433.38) 7667.01,1433.38 ; C203.1@7667.01,1490 7667.01,1433.37 ; C200.1@7667.01,1655 7721.52,1655 v1@7721.86,1655.33 ; v1@7669.64,1407.26 ccw(c7660.25,1416.65) 7673.52,1416.65 ccw(c7686.8,1416.65) v1@7677.41,1407.26 ; v2@7669.71,5917.89 cw(c7659.79,5907.97) 7673.82,5907.97 cw(c7687.85,5907.97) v2@7677.93,5917.89 ; v2@7669.71,5926.11 ccw(c7659.79,5936.03) 7673.82,5936.03 ccw(c7687.85,5936.03) v2@7677.93,5926.11 ; v1(7673.52,1403.37) 7673.52,1426.86 7667.01,1433.37 ; R282.1@7673.82,5896.33 v2(7673.82,5922) R280.1@7673.82,5946.67 ; R159.2@7675.06,4846.24 ccw(c7665.98,4837.16) 7665.98,4850 ccw(c7665.98,4862.84) R159.2@7675.06,4853.76 ; C203.1@7681.27,1455.89 ccw(c7691.91,1433.38) 7667.01,1433.38 ; C200.1@7705.79,1655 ccw(c7705.79,1674.11) v1@7719.3,1660.6 ; v1@7721.86,1655.37 v1(7723.19,1656.71) ; v5@7763.52,4366.71 v5@7764.86,4368.04 ; v5@7764.52,4368.37 v5@7764.86,4368.04 ; v5(7771.26,4366.89) 7769.78,4368.37 7765.19,4368.37 v5@7764.86,4368.04 ; LED2.1@7826.24,2164.43 cw(c7855.89,2166.07) 7834.89,2187.07 ; LED2.1@7829.69,2176.85 ccw(c7822.82,2188.72) 7836.54,2188.72 ; LED2.1@7836.54,2165 7836.54,2188.72 ; LED2.1@7838.22,2165.09 cw(c7891.86,2168.06) 7853.87,2206.06 ; LED2.1@7843.38,2176.85 cw(c7850.25,2188.72) 7836.54,2188.72 ; v1@7867.36,2225.04 cw(c7854.08,2225.04) 7863.47,2215.65 cw(c7872.86,2206.26) v1@7872.86,2219.54 ; v1(7872.86,2225.04) 7836.54,2188.72 ; U2.3@7874.17,3831.34 7927.19,3831.34 7932.19,3826.34 7932.19,3758.71 v1(7931.86,3758.37) ; U2.3@7901.33,3825.84 cw(c7914.61,3812.56) 7914.61,3831.34 cw(c7914.61,3850.12) U2.3@7901.33,3836.84 ; v2@7901.7,5917.89 cw(c7891.78,5907.97) 7905.81,5907.97 cw(c7919.84,5907.97) v2@7909.92,5917.89 ; v2@7901.7,5926.11 ccw(c7891.78,5936.03) 7905.81,5936.03 ccw(c7919.84,5936.03) v2@7909.92,5926.11 ; R281.1@7905.81,5896.33 v2(7905.81,5922) R279.1@7905.81,5946.67 ; v1(7906.86,3416.71) 7947.52,3457.37 7947.52,3479.5 7947.32,3479.5 C35.1@7947.32,3525 ; v1@7906.86,3422.21 ccw(c7906.86,3435.49) 7916.25,3426.1 ccw(c7925.64,3416.71) v1@7912.36,3416.71 ; v1@7927.97,3762.26 ccw(c7917.78,3772.46) 7932.19,3772.46 ; 7932.19,3770.85 ccw(c7944.33,3770.85) v1@7935.75,3762.26 ; v1@7936.3,3002.93 ccw(c7926.91,3012.32) 7940.19,3012.32 ccw(c7953.47,3012.32) v1@7944.08,3002.93 ; v1(7940.19,2999.04) 7940.19,3015.37 7944.07,3019.25 U47.33@8004.41,3019.25 8075.08,3019.25 C153.1@8080,3014.33 8096.9,3014.33 v1(8111.19,3000.04) ; C35.1@7943.21,3520.89 cw(c7933.29,3510.97) 7947.32,3510.97 cw(c7961.35,3510.97) C35.1@7951.43,3520.89 ; v1@8023.64,3878.35 cw(c8014.25,3868.96) 8027.52,3868.96 cw(c8040.8,3868.96) v1@8031.41,3878.35 ; v1@8027.52,3882.04 8027.52,3796.3 8042.49,3781.34 U2.13@8098.58,3781.34 ; U23.4@8044.19,2450.65 ccw(c8032.59,2462.25) 8049,2462.25 ccw(c8065.41,2462.25) U23.4@8053.81,2450.65 ; v1@8046.3,2481.15 cw(c8036.91,2471.76) 8050.19,2471.76 cw(c8063.47,2471.76) v1@8054.08,2481.15 ; U23.4@8049,2423.2 8049,2464 8050.19,2465.19 v1(8050.19,2485.04) ; 8054.09,3019.25 cw(c8054.09,2988.42) C153.1@8075.89,3010.22 ; v1(8065,3255) 8120,3255 8125,3250 C36.1@8125,3192.01 ; v1@8068.89,3251.11 cw(c8078.28,3241.72) 8078.28,3255 cw(c8078.28,3268.28) v1@8068.89,3258.89 ; U2.13@8071.43,3775.84 ccw(c8058.15,3762.56) 8058.15,3781.34 ccw(c8058.15,3800.12) U2.13@8071.43,3786.84 ; C153.1@8077.07,3019.78 cw(c8083.83,3007.2) 8093.93,3017.3 ; C154.1@8080,2919.33 8125.67,2919.33 8139.9,2905.1 v1@8140,2905 ; C153.1@8080,3020.52 cw(c8080,2994.66) 8098.29,3012.95 ; C154.1@8084.11,2915.22 cw(c8094.03,2905.3) 8094.03,2919.33 cw(c8094.03,2933.36) C154.1@8084.11,2923.44 ; C153.1@8084.11,3010.22 cw(c8094.03,3000.3) 8094.03,3014.33 cw(c8094.03,3028.36) C153.1@8084.11,3018.44 ; C36.1@8108.23,3220.86 ccw(c8091.3,3250) 8125,3250 ccw(c8158.7,3250) C36.1@8141.77,3220.86 ; v2@8160.89,4259.11 ccw(c8150.97,4269.03) 8165,4269.03 ccw(c8179.03,4269.03) v2@8169.11,4259.11 ; C56.1@8160.89,4499.78 ccw(c8150.97,4509.7) 8165,4509.7 ccw(c8179.03,4509.7) C56.1@8169.11,4499.78 ; v2@8160.89,4530.89 cw(c8150.97,4520.97) 8165,4520.97 cw(c8179.03,4520.97) v2@8169.11,4530.89 ; v2@8160.89,4655.89 cw(c8150.97,4645.97) 8165,4645.97 cw(c8179.03,4645.97) v2@8169.11,4655.89 ; v2(8165,4255) C57.1@8165,4284.33 ; C56.1@8165,4495.67 v2(8165,4535) ; C55.1@8165,4630.67 v2(8165,4660) ; 5715.19,3208.37 5751.19,3208.37 5750,3207.18 ; U53.8@5930.59,1580.59 5940,1590 v1@5940,1630.04 ; 6470,1530 v1@6470,1555 ; 6470,1530 6482.81,1517.19 ; 7385,3999.86 7385,3936.37 7385.67,3935.71 7385.86,3935.71 7385.86,3928.71 7456.86,3857.71 7456.86,3841.71 ; v1(7390,4515) 7390.19,4514.81 v1(7390,4515) ; 7398.52,3678.11 7406.86,3686.44 ; 7406.86,3686.44 7406.86,3728.71 7438.52,3760.37 7438.52,3813.48 ; 7438.52,3813.48 7456.86,3831.82 7456.86,3841.71
  MidLayer1 w4: 4838.82,3977.64 4879.25,3977.64 4898.67,3977.64 4958.86,3977.64 4972.79,3977.64 ccw(c4972.79,3991.69) 4982.72,3981.76 ; 4838.82,4095.75 4879.25,4095.75 4898.67,4095.75 4958.86,4095.75 4972.79,4095.75 ccw(c4972.79,4109.8) 4982.72,4099.87 ; 4838.82,4284.25 4879.25,4284.25 4898.67,4284.25 4958.86,4284.25 4972.79,4284.25 cw(c4972.79,4270.2) 4982.72,4280.13 ; 4838.82,4402.36 4879.25,4402.36 4898.67,4402.36 4958.86,4402.36 4972.79,4402.36 cw(c4972.79,4388.31) 4982.72,4398.24 ; v3@4988.83,3993.8 cw(c4970.79,3995.38) 4982.43,3981.51 cw(c4994.07,3967.64) v3@4995.65,3985.68 ; v3@4988.83,4111.91 cw(c4970.79,4113.49) 4982.43,4099.62 cw(c4994.07,4085.75) v3@4995.65,4103.79 ; v3@4988.83,4268.09 ccw(c4970.79,4266.51) 4982.43,4280.38 ccw(c4994.07,4294.25) v3@4995.65,4276.21 ; v3@4988.83,4386.2 ccw(c4970.79,4384.62) 4982.43,4398.49 ccw(c4994.07,4412.36) v3@4995.65,4394.32 ; 5020.16,3638.82 5020.16,3679.25 5020.16,3763.62 cw(c5053.29,3763.79) 5025.25,3781.44 ; 5020.16,4741.18 5020.16,4700.75 5020.16,4616.38 ccw(c5053.29,4616.21) 5025.25,4598.56 ; v3@5028.28,3795 cw(c5010.45,3791.85) 5025.28,3781.47 cw(c5040.12,3771.08) v3@5036.97,3788.91 ; v3@5028.28,4585 ccw(c5010.45,4588.15) 5025.28,4598.53 ccw(c5040.12,4608.92) v3@5036.97,4591.09 ; 5138.27,3638.82 5138.27,3679.25 5138.27,3772.79 cw(c5152.32,3772.79) 5142.39,3782.72 ; 5142.39,4597.28 cw(c5152.32,4607.21) 5138.27,4607.21 5138.27,4700.75 5138.27,4741.18 5138.27,4751.18 5138.27,4835 5138.27,4868.27 5144.86,4874.86 v1(5158,4888) v1@5158,4885.91 ; v3@5146.31,3795.65 cw(c5128.27,3794.07) 5142.14,3782.43 cw(c5156.01,3770.79) v3@5154.43,3788.83 ; v3@5146.31,4584.35 ccw(c5128.27,4585.93) 5142.14,4597.57 ccw(c5156.01,4609.21) v3@5154.43,4591.17 ; 5295.75,3638.82 5295.75,3772.79 ; 5295.75,3758.86 5295.75,3772.79 ; 5295.75,4621.14 5295.75,4607.21 ; 5295.75,4741.18 5295.75,4607.21 ; 5299.87,3782.72 ccw(c5309.8,3772.79) 5295.75,3772.79 ; 5299.87,4597.28 cw(c5309.8,4607.21) 5295.75,4607.21 ; v3@5303.79,3795.65 cw(c5285.75,3794.07) 5299.62,3782.43 cw(c5313.49,3770.79) v3@5311.91,3788.83 ; v3@5303.79,4584.35 ccw(c5285.75,4585.93) 5299.62,4597.57 ccw(c5313.49,4609.21) v3@5311.91,4591.17 ; v3@5468.09,3788.83 cw(c5466.51,3770.79) 5480.38,3782.43 cw(c5494.25,3794.07) v3@5476.21,3795.65 ; v3@5468.09,4591.17 ccw(c5466.51,4609.21) 5480.38,4597.57 ccw(c5494.25,4585.93) v3@5476.21,4584.35 ; 5480.13,3782.72 cw(c5470.2,3772.79) 5484.25,3772.79 ; 5480.13,4597.28 ccw(c5470.2,4607.21) 5484.25,4607.21 ; 5484.25,3638.82 5484.25,3772.79 ; 5484.25,3758.86 5484.25,3772.79 ; 5484.25,4621.14 5484.25,4607.21 ; 5484.25,4741.18 5484.25,4607.21 ; v3@5625.57,3788.83 cw(c5623.99,3770.79) 5637.86,3782.43 cw(c5651.73,3794.07) v3@5633.69,3795.65 ; v3@5625.57,4591.17 ccw(c5623.99,4609.21) 5637.86,4597.57 ccw(c5651.73,4585.93) v3@5633.69,4584.35 ; 5637.61,3782.72 cw(c5627.68,3772.79) 5641.73,3772.79 5641.73,3679.25 5641.73,3638.82 ; 5637.61,4597.28 ccw(c5627.68,4607.21) 5641.73,4607.21 5641.73,4700.75 5641.73,4741.18 ; v1@5650.02,3527.98 v1(5654,3524) ; v3@5743.03,3788.91 cw(c5739.88,3771.08) 5754.72,3781.47 cw(c5769.55,3791.85) v3@5751.72,3795 ; v3@5743.03,4591.09 ccw(c5739.88,4608.92) 5754.72,4598.53 ccw(c5769.55,4588.15) v3@5751.72,4585 ; 5754.75,3781.44 cw(c5726.71,3763.79) 5759.84,3763.62 5759.84,3679.25 5759.84,3638.82 ; 5754.75,4598.56 ccw(c5726.71,4616.21) 5759.84,4616.38 5759.84,4700.75 5759.84,4741.18 ; v3@5784.35,3985.68 cw(c5785.93,3967.64) 5797.57,3981.51 cw(c5809.21,3995.38) v3@5791.17,3993.8 ; v3@5784.35,4103.79 cw(c5785.93,4085.75) 5797.57,4099.62 cw(c5809.21,4113.49) v3@5791.17,4111.91 ; v3@5784.35,4276.21 ccw(c5785.93,4294.25) 5797.57,4280.38 ccw(c5809.21,4266.51) v3@5791.17,4268.09 ; v3@5784.35,4394.32 ccw(c5785.93,4412.36) 5797.57,4398.49 ccw(c5809.21,4384.62) v3@5791.17,4386.2 ; 5797.28,3981.76 ccw(c5807.21,3991.69) 5807.21,3977.64 5821.14,3977.64 5881.33,3977.64 5900.75,3977.64 5941.18,3977.64 ; 5797.28,4099.87 ccw(c5807.21,4109.8) 5807.21,4095.75 5821.14,4095.75 5881.33,4095.75 5900.75,4095.75 5941.18,4095.75 ; 5797.28,4280.13 cw(c5807.21,4270.2) 5807.21,4284.25 5821.14,4284.25 5881.33,4284.25 5900.75,4284.25 5941.18,4284.25 ; 5797.28,4398.24 cw(c5807.21,4388.31) 5807.21,4402.36 5821.14,4402.36 5881.33,4402.36 5900.75,4402.36 5941.18,4402.36 ; 6665.67,1692.01 6741.1,1692.01 ccw(c6741.27,1725.14) 6758.92,1697.1 ; 6665.67,1770.75 6741.1,1770.75 ccw(c6741.27,1803.88) 6758.92,1775.84 ; 6665.67,1959.25 6741.1,1959.25 cw(c6741.27,1926.12) 6758.92,1954.16 ; 6665.67,2037.99 6741.1,2037.99 cw(c6741.27,2004.86) 6758.92,2032.9 ; v3@6766.39,1708.82 cw(c6748.56,1711.97) 6758.95,1697.13 ; v3@6766.39,1787.56 cw(c6748.56,1790.71) 6758.95,1775.87 cw(c6769.33,1761.04) v3@6772.48,1778.87 ; v3@6766.39,1942.44 ccw(c6748.56,1939.29) 6758.95,1954.13 ccw(c6769.33,1968.96) v3@6772.48,1951.13 ; v3@6766.39,2021.18 ccw(c6748.56,2018.03) 6758.95,2032.87 ; v3@6772.48,1700.13 ccw(c6769.33,1682.3) 6758.95,1697.13 ; v3@6772.48,2029.87 cw(c6769.33,2047.7) 6758.95,2032.87 ; 6797.64,1510.67 6797.64,1511.73 6797.64,1596.1 cw(c6830.77,1596.27) 6802.73,1613.92 ; 6797.64,2219.33 6797.64,2218.27 6797.64,2133.9 ccw(c6830.77,2133.73) 6802.73,2116.08 ; v3@6805.76,1627.48 cw(c6787.93,1624.33) 6802.76,1613.95 cw(c6817.6,1603.56) v3@6814.45,1621.39 ; v3@6805.76,2102.52 ccw(c6787.93,2105.67) 6802.76,2116.05 ccw(c6817.6,2126.44) v3@6814.45,2108.61 ; 6915.75,1510.67 6915.75,1511.73 6915.75,1596.1 cw(c6948.88,1596.27) 6920.84,1613.92 ; 6915.75,2219.33 6915.75,2218.27 6915.75,2133.9 ccw(c6948.88,2133.73) 6920.84,2116.08 ; v3@6923.87,1627.48 cw(c6906.04,1624.33) 6920.87,1613.95 cw(c6935.71,1603.56) v3@6932.56,1621.39 ; v3@6923.87,2102.52 ccw(c6906.04,2105.67) 6920.87,2116.05 ccw(c6935.71,2126.44) v3@6932.56,2108.61 ; v3@7087.44,1621.39 cw(c7084.29,1603.56) 7099.13,1613.95 cw(c7113.96,1624.33) v3@7096.13,1627.48 ; v3@7087.44,2108.61 ccw(c7084.29,2126.44) 7099.13,2116.05 ccw(c7113.96,2105.67) v3@7096.13,2102.52 ; 7099.16,1613.92 cw(c7071.12,1596.27) 7104.25,1596.1 7104.25,1511.73 7104.25,1510.67 ; 7099.16,2116.08 ccw(c7071.12,2133.73) 7104.25,2133.9 7104.25,2218.27 7104.25,2219.33 ; v3@7205.55,1621.39 cw(c7202.4,1603.56) 7217.24,1613.95 cw(c7232.07,1624.33) v3@7214.24,1627.48 ; v3@7205.55,2108.61 ccw(c7202.4,2126.44) 7217.24,2116.05 ccw(c7232.07,2105.67) v3@7214.24,2102.52 ; 7217.27,1613.92 cw(c7189.23,1596.27) 7222.36,1596.1 7222.36,1511.73 7222.36,1510.67 ; 7217.27,2116.08 ccw(c7189.23,2133.73) 7222.36,2133.9 7222.36,2218.27 7222.36,2219.33 ; v3@7247.52,1700.13 cw(c7250.67,1682.3) 7261.05,1697.13 ; v3@7247.52,1778.87 cw(c7250.67,1761.04) 7261.05,1775.87 cw(c7271.44,1790.71) v3@7253.61,1787.56 ; v3@7247.52,1951.13 ccw(c7250.67,1968.96) 7261.05,1954.13 ccw(c7271.44,1939.29) v3@7253.61,1942.44 ; v3@7247.52,2029.87 ccw(c7250.67,2047.7) 7261.05,2032.87 ; v3@7253.61,1708.82 ccw(c7271.44,1711.97) 7261.05,1697.13 ; v3@7253.61,2021.18 cw(c7271.44,2018.03) 7261.05,2032.87 ; 7261.08,1775.84 ccw(c7278.73,1803.88) 7278.9,1770.75 7354.33,1770.75 ; 7261.08,1954.16 cw(c7278.73,1926.12) 7278.9,1959.25 7360.75,1959.25 ; 7354.33,1692.01 7278.9,1692.01 cw(c7278.73,1725.14) 7261.08,1697.1 ; 7354.33,2037.99 7278.9,2037.99 ccw(c7278.73,2004.86) 7261.08,2032.9
  MidLayer1 w12: J8.12@2553.71,6612.26 ccw(c2509.51,6568.06) 2509.51,6630.56 ccw(c2509.51,6693.07) J8.12@2553.71,6648.87 ; J8.12@2562.19,6620.74 ccw(c2538.48,6597.03) 2538.48,6630.56 ccw(c2538.48,6664.09) J8.12@2562.19,6640.38 ; J8.12@2572.02,6630.56 2500.56,6630.56 2455,6585 2455,6410 2760,6105 2840,6105 2940,6005 2940,5840 2928,5828 v1(2789.7,5828) ; v1@2793.59,5824.11 cw(c2802.98,5814.72) 2802.98,5828 cw(c2802.98,5841.28) v1@2793.59,5831.89 ; v1(7550,3770) 7554.9,3770 7555.19,3769.71 v1@7555.19,3770
  MidLayer2 w4: 4838.82,3977.64 4841.47,3977.64 4899.73,3977.64 4957.99,3977.64 4977.41,3977.64 5037.6,3977.64 5051.53,3977.64 ccw(c5051.53,3991.69) 5061.46,3981.76 ; 4838.82,4410.71 4841.47,4410.71 4899.73,4410.71 4957.99,4410.71 4977.41,4410.71 5051.53,4410.71 5071.03,4410.71 cw(c5071.03,4368.98) 5100.54,4398.49 ; v3@5067.57,3993.8 cw(c5049.53,3995.38) 5061.17,3981.51 cw(c5072.81,3967.64) v3@5074.39,3985.68 ; v3@5106.94,4386.2 ccw(c5088.9,4384.62) 5100.54,4398.49 ; v3@5113.76,4394.32 cw(c5112.18,4412.36) 5100.54,4398.49 ; 5177.64,3638.82 5177.64,3699.73 ; 5177.64,3641.47 5177.64,3699.73 ; 5177.64,3837.6 5177.64,3851.53 ; 5181.76,3861.46 ccw(c5191.69,3851.53) 5177.64,3851.53 ; v3@5185.68,3874.39 cw(c5167.64,3872.81) 5181.51,3861.17 cw(c5195.38,3849.53) v3@5193.8,3867.57 ; 5208.66,3638.82 5208.66,3641.47 5208.66,3699.73 5208.66,3757.99 5208.66,3777.41 5208.66,3851.53 5208.66,3871.03 cw(c5250.39,3871.03) 5220.88,3900.54 ; 5208.66,4741.18 5208.66,4738.53 5208.66,4680.27 5208.66,4622.01 5208.66,4602.59 5208.66,4528.47 5208.66,4508.97 ccw(c5250.39,4508.97) 5220.88,4479.46 ; v3@5225.05,3913.76 cw(c5207.01,3912.18) 5220.88,3900.54 ; v3@5225.05,4466.24 ccw(c5207.01,4467.82) 5220.88,4479.46 ; v3@5233.17,3906.94 ccw(c5234.75,3888.9) 5220.88,3900.54 ; v3@5233.17,4473.06 cw(c5234.75,4491.1) 5220.88,4479.46 ; v3@5546.83,3906.94 cw(c5545.25,3888.9) 5559.12,3900.54 ; v3@5546.83,4473.06 ccw(c5545.25,4491.1) 5559.12,4479.46 ; v3@5554.95,3913.76 ccw(c5572.99,3912.18) 5559.12,3900.54 ; v3@5554.95,4466.24 cw(c5572.99,4467.82) 5559.12,4479.46 ; 5571.34,3638.82 5571.34,3641.47 5571.34,3699.73 5571.34,3757.99 5571.34,3777.41 5571.34,3851.53 5571.34,3871.03 ccw(c5529.61,3871.03) 5559.12,3900.54 ; 5571.34,4741.18 5571.34,4738.53 5571.34,4680.27 5571.34,4622.01 5571.34,4602.59 5571.34,4528.47 5571.34,4508.97 cw(c5529.61,4508.97) 5559.12,4479.46 ; v3@5666.24,4064.42 cw(c5667.82,4046.38) 5679.46,4060.25 ; v3@5666.24,4354.95 ccw(c5667.82,4372.99) 5679.46,4359.12 ; v3@5673.06,4072.54 ccw(c5691.1,4074.12) 5679.46,4060.25 ; v3@5673.06,4346.83 cw(c5691.1,4345.25) 5679.46,4359.12 ; 5941.18,4048.03 5938.53,4048.03 5880.27,4048.03 5822.01,4048.03 5802.59,4048.03 5728.47,4048.03 5708.97,4048.03 cw(c5708.97,4089.76) 5679.46,4060.25 ; 5941.18,4371.34 5938.53,4371.34 5880.27,4371.34 5822.01,4371.34 5802.59,4371.34 5728.47,4371.34 5708.97,4371.34 ccw(c5708.97,4329.61) 5679.46,4359.12 ; v3@7168.13,1911.84 ccw(c7169.71,1929.88) 7181.35,1916.01 ccw(c7192.99,1902.14) v3@7174.95,1903.72 ; 7181.06,1915.76 cw(c7190.99,1905.83) 7190.99,1919.88 7284.53,1919.88 7354.33,1919.88 ; 5177.64,3699.73 5177.64,3757.99 5177.64,3851.53
  MidLayer2 w12: v2@4930.89,460.89 cw(c4920.97,450.97) 4935,450.97 cw(c4949.03,450.97) v2@4939.11,460.89 ; v2(4935,465) 4935,446.97 4954.16,427.81 4963.33,427.81 5041.14,350 5090,350 5203.97,350 5262.86,291.11 v1(5262.86,233.37) ; v1@5258.97,237.26 ccw(c5249.58,246.65) 5262.86,246.65 ccw(c5276.14,246.65) v1@5266.75,237.26 ; v1@7176.11,6066.11 cw(c7166.72,6056.72) 7180,6056.72 cw(c7193.28,6056.72) v1@7183.89,6066.11 ; v1(7180,6070) 7180,5985 7263,5902 7454,5902 7480,5876 7509,5876 7520,5887 7638.82,5887 v2(7673.82,5922) ; v2@7668.01,5922 cw(c7653.98,5922) 7663.9,5912.08 cw(c7673.82,5902.16) v2@7673.82,5916.19 ; v2@7677.93,5917.89 cw(c7687.85,5907.97) 7687.85,5922 cw(c7687.85,5936.03) v2@7677.93,5926.11 ; v2@7678.32,5917.5 v2(7673.82,5922) ; v2@7900,5922 cw(c7885.97,5922) 7895.89,5912.08 cw(c7905.81,5902.16) v2@7905.81,5916.19 ; v2@7901.31,5917.5 v2(7905.81,5922) ; v2@7907,5922 v2(7905.81,5922) ; v2(7673.82,5922) 7710.5,5922 7764,5868.5 7808.91,5868.5 7852.31,5868.5 v2(7905.81,5922)
  Bottom Layer w4: v1@4775.43,3935.89 ccw(c4782.26,3937.01) C323.1@4782.26,3930.08 ; v1@4776.72,3928.28 cw(c4781.06,3923.94) C323.1@4781.06,3930.08 ; C323.1@4779.19,3930.08 4786.97,3930.08 cw(c4786.97,3937.78) C323.1@4779.38,3936.53 ; C331.1@5013.7,3584.34 cw(c5010.86,3572) 5023.52,3572 ; C331.1@5014.59,3588.24 cw(c5012.02,3577.02) 5023.52,3577.02 ; C331.1@5015,3590 C331.1@5023.52,3581.48 ; 5023.52,3568.61 C331.1@5023.52,3581.48 ; 5023.52,3569.39 ccw(c5033.99,3569.39) v1@5029.9,3559.76 ; 5023.52,3575.43 ccw(c5036.55,3575.43) v1@5031.46,3563.44 ; v1@5033.03,3567.12 cw(c5039.12,3581.47) C331.1@5023.52,3581.47 ; v1(5130,3510) 5131.23,3511.23 v1@5131.23,3514 ; 5295.75,4741.18 5295.75,4718.05 5295.75,4659.79 5295.75,4601.53 5295.75,4543.27 5295.75,4523.85 5295.75,4463.66 5295.75,4449.73 ccw(c5309.8,4449.73) 5299.87,4439.8 ; v3@5303.79,4426.87 ccw(c5285.75,4428.45) 5299.62,4440.09 ccw(c5313.49,4451.73) v3@5311.91,4433.69 ; v1@5329.95,4825.78 cw(c5313.73,4809.56) 5336.67,4809.56 cw(c5359.6,4809.56) v1@5343.39,4825.78 ; v1@5332.78,4828.61 cw(c5323.39,4819.22) 5336.67,4819.22 cw(c5349.95,4819.22) v1@5340.56,4828.61 ; v1@5336.67,4830.52 5336.67,4798.33 5345,4790 C332.1@5369.33,4790 C332.1@5369.33,4784.33 ; C332.1@5362.39,4783.06 ccw(c5345.65,4766.31) 5345.65,4790 ccw(c5345.65,4813.69) C332.1@5362.39,4796.94 ; C332.1@5365.22,4785.89 ccw(c5355.3,4775.97) 5355.3,4790 ccw(c5355.3,4804.03) C332.1@5365.22,4794.11 ; v3@5428.72,4433.69 ccw(c5427.14,4451.73) 5441.01,4440.09 ccw(c5454.88,4428.45) v3@5436.84,4426.87 ; 5440.76,4439.8 ccw(c5430.83,4449.73) 5444.88,4449.73 5444.88,4463.66 5444.88,4523.85 5444.88,4543.27 5444.88,4601.53 5444.88,4659.79 5444.88,4718.05 5444.88,4741.18 ; v3@5468.09,3946.31 cw(c5466.51,3928.27) 5480.38,3939.91 cw(c5494.25,3951.55) v3@5476.21,3953.13 ; 5480.13,3940.2 cw(c5470.2,3930.27) 5484.25,3930.27 5484.25,3916.34 5484.25,3856.15 5484.25,3836.73 5484.25,3778.47 5484.25,3720.21 5484.25,3661.95 5484.25,3638.82 ; C307.1@5765,4790 5783.98,4808.98 5786.82,4808.98 5790,4805.8 v1(5790,4805) ; C307.1@5765,4795.81 ccw(c5765,4809.84) 5774.92,4799.92 ccw(c5784.84,4790) C307.1@5770.81,4790 ; C307.1@5766.04,4791.04 cw(c5786.82,4770.25) v1@5789.5,4799.52 ; C307.1@5772.07,4797.07 cw(c5787.83,4781.31) v1@5789.86,4803.51 ; 5778.11,4803.1 cw(c5788.84,4792.37) v1@5790.23,4807.49 ; C319.1@5990,4395.74 cw(c5990,4384.9) 5997.67,4392.56 ; C319.1@5990,4405.55 5990,4400.23 6013,4377.23 v1@6013,4355 ; C303.1@5990,4523.66 6020.14,4523.66 6030.52,4534.04 v1(6030.52,4573.71) ; C319.1@5991.81,4405.54 ccw(c6008.79,4405.45) 5996.78,4393.45 ; C303.1@5994.11,4519.55 cw(c6004.03,4509.63) 6004.03,4523.66 cw(c6004.03,4537.69) C303.1@5994.11,4527.77 ; C319.1@5995.81,4405.52 ccw(c6022.27,4405.38) 6003.56,4386.67 ; C303.1@5996.94,4516.72 cw(c6013.68,4499.98) 6013.68,4523.66 cw(c6013.69,4547.35) C303.1@5996.94,4530.6 ; C319.1@5999.81,4405.5 ccw(c6035.76,4405.31) 6010.34,4379.89 ; v1@6006.28,4360.72 ccw(c5990.06,4376.93) 6013,4376.93 ccw(c6035.93,4376.93) v1@6019.72,4360.72 ; v1@6009.11,4357.89 ccw(c5999.72,4367.28) 6013,4367.28 ccw(c6026.28,4367.28) v1@6016.89,4357.89 ; v1@6023.81,4566.99 cw(c6007.59,4550.77) 6030.52,4550.77 cw(c6053.46,4550.77) v1@6037.24,4566.99 ; v1@6026.64,4569.82 cw(c6017.25,4560.43) 6030.52,4560.43 cw(c6043.8,4560.43) v1@6034.41,4569.82 ; v1(6215.19,4666.71) 6223.52,4658.37
  Bottom Layer w8: 5383.71,2731.61 ccw(c5405.04,2752.94) C234.1@5406.38,2722.8 ; C234.1@5401.2,2720.52 ccw(c5387.87,2733.86) 5406.72,2733.86 ccw(c5425.58,2733.86) C234.1@5412.25,2720.52 ; C218.1@5401.2,2829.48 cw(c5387.87,2816.14) 5406.72,2816.14 cw(c5425.58,2816.14) C218.1@5412.25,2829.48 ; C234.1@5406.72,2713.79 cw(c5445.82,2713.79) v2@5420.97,2743.97 ; 5406.72,2730.75 cw(c5431.86,2730.75) v2@5415.88,2750.15 ; C218.1@5406.72,2835 5406.72,2809.72 5371.81,2774.81 5370.79,2774.81 5359.19,2763.21 5359.19,2746.79 5371.17,2734.81 5380.51,2734.81 5400.32,2715 C234.1@5406.72,2715 5406.72,2742.28 v2@5414.45,2750 ; v2(5416,2750) v2@5414.45,2750 ; v2@5421.52,2744.48 cw(c5439.69,2726.31) 5439.69,2752 ; v2@5421.52,2755.52 ccw(c5430.03,2764.03) 5430.03,2752 ; v2(5429,2738) 5443,2752 ; 5449,2744 5449,2728 ; v2@5471.48,2746.48 ccw(c5458.14,2733.14) 5458.14,2752 ccw(c5458.14,2770.86) v2@5471.48,2757.52 ; v2(5477,2752) 5443,2752 ; v2@5477,2752.71 5522.52,2752.71 v1(5551.86,2782.04) ; v2@5482.52,2746.48 cw(c5497.57,2731.43) 5497.57,2752.71 ; v2@5482.52,2757.52 ccw(c5494.15,2769.15) 5494.15,2752.71 ; C258.1@5499.86,2709.48 ccw(c5486.53,2696.14) 5486.53,2715 ccw(c5486.53,2733.86) C258.1@5499.86,2720.52 ; C258.1@5505.39,2715 5449,2715 5449,2728 ; v1@5544.36,2782.04 cw(c5526.25,2782.04) 5539.05,2769.24 cw(c5551.86,2756.43) v1@5551.86,2774.54 ; v4(6424.34,6243.27) U56.55@6455.67,6243.27 ; v4@6428.58,6239.03 cw(c6438.82,6228.78) 6438.82,6243.27 cw(c6438.82,6257.75) v4@6428.58,6247.51 ; v4@6595.91,6316.42 cw(c6585.67,6306.18) 6600.16,6306.18 cw(c6614.64,6306.18) v4@6604.4,6316.42 ; U56.7@6600.16,6289.33 v4(6600.16,6320.66) ; v4@6674.65,6007.76 cw(c6664.41,5997.52) 6678.9,5997.52 cw(c6693.38,5997.52) v4@6683.14,6007.76 ; v4@6674.66,6316.42 cw(c6664.41,6306.18) 6678.9,6306.18 cw(c6693.38,6306.18) v4@6683.14,6316.42 ; U56.32@6678.9,5980.67 v4(6678.9,6012) ; U56.11@6678.9,6289.33 v4(6678.9,6320.66) ; U56.27@6764.33,6026.73 v4(6795.66,6026.73) ; U56.17@6764.33,6223.58 v4(6795.66,6223.58) ; v4@6791.42,6022.49 ccw(c6781.18,6012.25) 6781.18,6026.73 ccw(c6781.18,6041.22) v4@6791.42,6030.97 ; v4@6791.42,6219.34 ccw(c6781.18,6209.1) 6781.18,6223.58 ccw(c6781.18,6238.07) v4@6791.42,6227.83 ; v4(7234.34,858.27) U19.27@7265.67,858.27 ; v4@7238.58,854.03 cw(c7248.82,843.78) 7248.82,858.27 cw(c7248.82,872.75) v4@7238.58,862.51 ; v4@7346.86,568.58 ccw(c7336.62,578.82) 7351.1,578.82 ccw(c7365.59,578.82) v4@7355.34,568.58 ; v4@7346.86,877.24 ccw(c7336.62,887.48) 7351.1,887.48 ccw(c7365.59,887.48) v4@7355.35,877.24 ; v4(7351.1,564.34) U19.11@7351.1,595.67 ; v4(7351.1,873) U19.32@7351.1,904.33 ; v4@7425.6,568.58 ccw(c7415.36,578.82) 7429.84,578.82 ccw(c7444.33,578.82) v4@7434.09,568.58 ; v4(7429.84,564.34) U19.7@7429.84,595.67 ; U19.55@7574.33,641.73 v4(7605.66,641.73) ; v4@7601.42,637.49 ccw(c7591.18,627.25) 7591.18,641.73 ccw(c7591.18,656.22) v4@7601.42,645.97 ; v2@5414.45,2750 5416.45,2752 5443,2752 ; 5443,2752 5449,2746 5449,2728
  Bottom Layer w10: U67.5@5547.59,1457.51 cw(c5535.96,1445.88) 5552.4,1445.88 cw(c5568.84,1445.88) U67.5@5557.22,1457.51 ; v1@5547.81,1432 ccw(c5536.71,1443.09) 5552.4,1443.09 ccw(c5568.09,1443.09) v1@5557,1432 ; v1(5552.4,1427.4) U67.5@5552.4,1475.12 ; v1(5876,2970) 5870.82,2970 R76.2@5885.82,2955 ; v1@8065.4,4855.4 cw(c8047.1,4837.1) U69.5@8072.99,4837.1 ; v1(8070,4860) 8072.99,4857.01 U69.5@8072.99,4828.53