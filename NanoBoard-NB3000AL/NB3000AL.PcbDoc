# Altium PCB NB3000AL.PcbDoc (part 11 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
5V0: C1.1 C2.1 C3.1 C4.1 C61.1 C62.1 C111.1 C112.2 C113.2 C114.2 C121.2 C122.2 C123.2 C124.2 C125.2 C130.1 C131.1 C134.1 C135.1 C145.2 C149.1 C152.2 D3.2 D4.2 D5.2 D6.2 EXTHDR1.89 EXTHDR1.91 EXTHDR1.93 F1.1 F2.2 J13.1 J15.1 J31.4 J32.4 J33.A47 J33.A48 J33.A49 JP1.2 JP2.2 L3.1 LED16.2 LED17.2 LED18.2 LED19.2 LED20.2 LED21.2 LED22.2 LED23.2 LED24.2 LED25.2 NT18.2 NT26.2 NT27.2 NT33.2 NT43.2 PROTOTYPE1.30 R82.1 R83.1 R86.1 R87.1 R141.2 R197.1 R199.1 R274.2 R275.2 R276.2 RLY1.1 RLY2.1 RLY3.1 RLY4.1 SW7.1 SW7.2 TP2.1 U26.2 U26.10 U26.15 U31.14 U32.14 U33.14 U34.14 U35.14 U40.3 U41.3 U44.1 U44.3 U46.14 U59.16 U61.2 U61.6 U61.7 U71.5 U72.5 VR1.3 | length 11658.2
  Top Layer w12: J33.A49@-785.98,2298.53 -686.47,2298.53 v1(-660,2325) -672.9,2337.9 J33.A48@-785.98,2337.9 ; J33.A47@-785.98,2377.27 -696.87,2377.27 -686.37,2366.77 -686.37,2339.27 ; J33.A48@-715.29,2337.9 cw(c-715.29,2287.41) v1@-679.59,2323.11 ; J33.A49@-711.58,2293.03 cw(c-698.3,2279.75) -698.3,2298.53 cw(c-698.3,2317.31) J33.A49@-711.58,2304.03 ; J33.A48@-711.58,2332.4 cw(c-698.3,2319.12) -698.3,2337.9 cw(c-698.3,2356.68) J33.A48@-711.58,2343.4 ; J33.A47@-711.58,2371.77 cw(c-698.3,2358.49) -698.3,2377.27 cw(c-698.3,2396.05) J33.A47@-711.58,2382.77 ; -686.37,2337.06 ccw(c-665.64,2337.06) v1@-680.3,2322.4 ; -686.37,2366.03 ccw(c-636.67,2366.03) v1@-671.81,2330.89 ; -686.32,2337.9 cw(c-686.32,2316.38) v1@-671.1,2331.6 ; v1@-665.5,2325 cw(c-678.78,2325) -669.39,2315.61 cw(c-660,2306.22) v1@-660,2319.5 ; U26.2@-389.13,5150 -325,5150 -316.62,5158.37 v1(-291.48,5158.37) ; U26.2@-351.56,5145.89 cw(c-341.64,5135.97) -341.64,5150 cw(c-341.64,5164.03) U26.2@-351.56,5154.11 ; v1@-295.36,5154.49 ccw(c-304.75,5145.1) -304.75,5158.37 ccw(c-304.75,5171.65) v1@-295.36,5162.26 ; C3.1@-292.01,4080 -242.38,4129.63 ; C3.1@-287.78,4104.88 ccw(c-281.31,4136.91) C3.1@-258.2,4113.81 ; C3.1@-285.4,4116.65 ccw(c-275.99,4163.23) -242.38,4129.63 ; C3.1@-270.69,4085.36 cw(c-237.71,4087.56) C3.1@-261.08,4110.93 ; C3.1@-258.71,4086.16 cw(c-202.66,4089.9) -242.38,4129.63 ; C2.1@-177.43,2207.25 ccw(c-190.75,2235.27) -159.72,2235.27 ; C1.1@-161.48,5711.04 C1.1@-159.72,5711.06 v1(-75.48,5711.04) ; C1.1@-161.48,5711.06 C1.1@-159.72,5711.06 ; C2.1@-159.72,2166.06 -159.72,2235.28 ; C2.1@-142.02,2207.25 cw(c-128.7,2235.27) -159.72,2235.27 ; C1.1@-136.63,5693.12 cw(c-100,5664.65) -100,5711.04 ; C1.1@-136.62,5728.99 ccw(c-99.98,5757.42) -99.98,5711.04 ; v1@-133.14,4919.54 cw(c-133.14,4903.85) -122.05,4914.94 ; v1(-133.14,4925.04) -132.14,4925.04 -107.1,4900 U26.10@-30.87,4900 ; -128.32,4170 cw(c-128.32,4121.31) v1@-93.89,4155.74 ; v1@-127.64,4925.04 ccw(c-116.78,4925.04) -124.46,4917.36 ; v2@-119.11,2240.89 ccw(c-129.03,2230.97) -129.03,2245 ccw(c-129.03,2259.03) v2@-119.11,2249.11 ; v2(-115,2245) -150,2245 -159.72,2235.28 ; v1@-101.11,5146.11 cw(c-91.72,5136.72) -91.72,5150 cw(c-91.72,5163.28) v1@-101.11,5153.89 ; v1@-100,5150 U26.15@-30.87,5150 ; -99.35,4170 cw(c-99.35,4150.28) v1@-85.4,4164.22 ; v1(-90,4159.63) -100.37,4170 -169.63,4170 -210,4129.63 -242.38,4129.63 ; v1@-79.36,5707.15 ccw(c-88.75,5697.76) -88.75,5711.04 ccw(c-88.75,5724.32) v1@-79.36,5714.93 ; U26.10@-68.44,4895.89 ccw(c-78.36,4885.97) -78.36,4900 ccw(c-78.36,4914.03) U26.10@-68.44,4904.11 ; U26.15@-68.44,5145.89 ccw(c-78.36,5135.97) -78.36,5150 ccw(c-78.36,5164.03) U26.15@-68.44,5154.11 ; C4.1@1.27,1616.81 ccw(c-19.04,1647.78) 18,1647.78 ; C4.1@12.99,1595 18,1600.01 v1(18,1670) ; v1@14.11,1666.11 cw(c4.72,1656.72) 18,1656.72 cw(c31.28,1656.72) v1@21.89,1666.11 ; 18,1638.44 ccw(c52.49,1638.44) C4.1@28.1,1614.05 ; LED17.2@339.13,4563.78 387.52,4563.78 390.19,4566.44 390.19,4848.71 385.12,4853.78 ; LED16.2@342.97,4861.8 377.1,4861.8 385.12,4853.78 ; v1@534.3,4821.15 ccw(c524.91,4811.76) 524.91,4825.04 ccw(c524.91,4838.32) v1@534.3,4828.93 ; v1(538.19,4825.04) 413.86,4825.04 385.12,4853.78 ; v1@678.46,3139.15 cw(c668.69,3129.38) 682.5,3129.38 ; EXTHDR1.93@682.5,3071.85 v1@682.5,3142.88 ; 682.5,3130.14 cw(c695.24,3130.14) v1@686.23,3139.15 ; v1@709.95,3139.15 cw(c700.18,3129.38) 714,3129.38 ; EXTHDR1.91@714,3071.85 v1@714,3142.88 ; 714,3130.14 cw(c726.74,3130.14) v1@717.73,3139.15 ; v1@741.45,3139.15 cw(c731.68,3129.38) 745.49,3129.38 ; EXTHDR1.89@745.49,3071.85 v1@745.49,3142.88 ; 745.49,3130.14 cw(c758.24,3130.14) v1@749.23,3139.15 ; v1@1656.22,5705.43 1657.65,5704 v1(1658,5704) ; C121.2@4010.67,4085 v1@4053.52,4085 ; C121.2@4014.78,4080.89 cw(c4024.7,4070.97) 4024.7,4085 ; C121.2@4014.78,4089.11 ccw(c4024.7,4099.03) 4024.7,4085 ; C124.2@4015.67,3270 4036.86,3291.19 4036.86,3300.71 v1(4034.19,3303.37) ; C124.2@4015.67,3275.81 ccw(c4015.67,3289.84) 4025.59,3279.92 ccw(c4035.51,3270) C124.2@4021.48,3270 ; C124.2@4023.1,3277.43 ccw(c4006.17,3294.35) v1@4028.96,3301.69 ; 4027.47,4085 cw(c4027.47,4053.65) 4049.64,4075.82 cw(c4040.25,4066.43) 4053.52,4066.43 cw(c4066.8,4066.43) v1@4057.41,4075.82 ; 4036.98,3291.31 ccw(c4027.18,3301.12) v1@4040.38,3305.37 ; v1(4053.52,4079.71) 4053.52,4046.48 4080,4020 U32.14@4138.5,4020 ; v1@4106.86,3525.87 cw(c4106.86,3505.32) 4121.39,3519.85 ; v1(4106.86,3531.37) 4115.19,3523.04 4118.2,3523.04 4138.5,3502.74 U31.14@4138.5,3475 ; v1@4165.19,3552.87 cw(c4165.19,3536.13) 4177.03,3547.97 ; v1@4170.69,3558.37 cw(c4200.42,3558.37) NT26.2@4179.4,3579.4 ; 4177.32,3577.32 ccw(c4169.64,3585) NT26.2@4180.5,3585 ; NT27.2@4185,3540 4166.63,3558.37 v1(4165.19,3558.37) 4165.19,3565.19 NT26.2@4185,3585 ; v1@4369.02,3699.59 cw(c4365.38,3679.54) NT33.2@4385.76,3679.54 ; v1@4371.16,3711.4 cw(c4367.99,3693.91) 4385.76,3693.91 ; v1@4376.86,3708.37 4385.76,3699.47 NT33.2@4385.76,3685 ; D3.2@4838.64,5457.4 cw(c4823.27,5442.03) 4845,5442.03 cw(c4866.73,5442.03) D3.2@4851.36,5457.4 ; D3.2@4845,5471.26 4845,5435 4850,5430 v1(4895,5430) 4895,5361.59 4955,5301.59 RLY1.1@4955,5245 ; v1@4891.11,5433.89 cw(c4881.72,5443.28) 4881.72,5430 cw(c4881.72,5416.72) 4891.11,5426.11 cw(c4881.72,5416.72) 4895,5416.72 cw(c4908.28,5416.72) v1@4898.89,5426.11 ; RLY1.1@4945.32,5274.36 ccw(c4921.96,5297.72) 4955,5297.72 ccw(c4988.04,5297.72) RLY1.1@4964.68,5274.36 ; v2(5240,2925) 5244.29,2925 5260.67,2941.37 C122.2@5260.67,2960 ; v2@5240,2930.81 ccw(c5240,2955.21) 5257.25,2937.96 ; C122.2@5256.56,2955.89 cw(c5246.64,2945.97) 5260.67,2945.97 cw(c5274.7,2945.97) C122.2@5264.78,2955.89 ; U33.14@5343.5,3165 5383.52,3165 5386.52,3162 5386.52,3128.71 v1(5390.19,3125.04) ; 5386.52,3147.17 ccw(c5412.32,3147.17) v1@5394.08,3128.93 ; D4.2@5423.64,5485.12 ccw(c5408.27,5500.49) 5430,5500.49 ccw(c5451.73,5500.49) D4.2@5436.36,5485.12 ; D4.2@5430,5471.26 5430,5561.48 5446.9,5578.37 v1(5482.52,5578.37) ; v1@5478.64,5574.49 ccw(c5469.25,5565.1) 5469.25,5578.37 ccw(c5469.25,5591.65) v1@5478.64,5582.26 ; RLY2.1@5520.32,5274.36 ccw(c5496.96,5297.72) 5530,5297.72 ccw(c5563.04,5297.72) RLY2.1@5539.68,5274.36 ; RLY2.1@5530,5245 5530,5365 5547.86,5382.86 v1(5547.86,5425.04) ; v1@5543.97,5421.15 cw(c5534.58,5411.76) 5547.86,5411.76 cw(c5561.14,5411.76) v1@5551.75,5421.15 ; 5570,2300 ccw(c5588.83,2300) v2@5575.97,2286.24 ; v2@5572,2276.19 cw(c5572,2247.67) 5592.16,2267.84 ; v2(5572,2282) v2@5570,2280 ; U61.2@5590.19,2228.37 5589.69,2228.37 U61.2@5589.68,2240 5589.68,2270.31 5580,2280 v2@5570,2280 ; U61.6@5668.19,2240 5668.19,2259.71 5680,2259.71 ; U61.6@5668.42,2253.19 cw(c5680,2246.17) 5680,2259.71 ; 5672.38,2259.71 cw(c5672.38,2237.46) U61.7@5688.11,2253.19 ; 5680,2272.77 ccw(c5707.69,2272.77) U61.7@5688.11,2253.19 ; U61.7@5688.11,2240 5688.11,2259.71 5680,2259.71 ; v1@5800.85,173.05 ccw(c5791.46,182.44) 5804.73,182.44 ccw(c5818.01,182.44) v1@5808.62,173.05 ; LED18.2@5804.73,223.69 v1(5804.73,169.16) ; v1@5912.3,176.26 ccw(c5903.42,185.15) 5915.98,185.15 ; 5915.98,186.16 ccw(c5929.97,186.16) v1@5920.08,176.26 ; LED19.2@5915.98,223.69 5915.98,172.58 v1(5916.19,172.37) ; v1(5972.86,5475.04) v1@5973.19,5475.04 ; v1@5976.75,5471.15 cw(c5986.14,5461.76) 5986.14,5475.04 cw(c5986.14,5488.32) v1@5976.75,5478.93 ; v1@5976.86,5471.26 5976.86,5471.37 v1@5973.19,5475.04 ; 5994.29,5475.04 ccw(c5994.29,5509.47) D5.2@6018.64,5485.12 ; D5.2@6025,5475.04 v1@5973.19,5475.04 ; LED20.2@6035.25,219.85 6035.25,260.73 v1(6049.52,275) ; v1@6044.02,275 cw(c6030.74,275) 6040.13,265.61 cw(c6049.52,256.22) v1@6049.52,269.5 ; RLY3.1@6120.32,5274.36 ccw(c6096.96,5297.72) 6130,5297.72 ccw(c6163.04,5297.72) RLY3.1@6139.68,5274.36 ; RLY3.1@6130,5245 6130,5369 6182,5421 v1(6182,5484) ; v1@6136.3,263.82 cw(c6126.91,254.43) 6140.19,254.43 cw(c6153.47,254.43) v1@6144.08,263.82 ; LED21.2@6138.48,223.69 6138.48,247.33 6140.19,249.04 v1(6140.19,267.71) ; v1@6178.11,5480.11 cw(c6168.72,5470.72) 6182,5470.72 cw(c6195.28,5470.72) v1@6185.89,5480.11 ; LED22.2@6257.75,219.85 6257.75,195.63 6265,188.37 6349.3,188.37 6360.97,200.04 6360.97,270.19 6361.19,270.19 6361.3,270.08 v1(6361.3,267.8) ; v1@6357.41,263.91 cw(c6348.82,255.32) 6360.97,255.32 ; 6360.97,253.73 cw(c6375.37,253.73) v1@6365.19,263.91 ; v1@6469.64,145.6 ccw(c6460.25,154.99) 6473.52,154.99 ccw(c6486.8,154.99) v1@6477.41,145.6 ; LED24.2@6472.22,223.69 6472.22,185 ; v1(6473.52,141.71) 6473.52,165.37 6472.22,166.68 6472.22,185 ; LED25.2@6591.49,219.85 6591.49,196.49 6580,185 6472.22,185 ; D6.2@6610,5471.26 6661.41,5471.26 v1(6673.52,5483.37) ; D6.2@6616.36,5464.9 cw(c6631.73,5449.53) 6631.73,5471.26 cw(c6631.73,5492.99) D6.2@6616.36,5477.62 ; 6631,5471.26 ccw(c6631,5525.9) v1@6669.64,5487.26 ; 6659.97,5471.26 ccw(c6659.97,5496.93) v1@6678.12,5478.78 ; RLY4.1@6700.32,5274.36 ccw(c6676.96,5297.72) 6710,5297.72 ccw(c6743.04,5297.72) RLY4.1@6719.68,5274.36 ; RLY4.1@6710,5245 6710,5369 6762,5421 v1(6762,5484) ; v1@6758.11,5480.11 cw(c6748.72,5470.72) 6762,5470.72 cw(c6775.28,5470.72) v1@6765.89,5480.11 ; C123.2@6900.22,2960.89 cw(c6890.3,2950.97) 6904.33,2950.97 cw(c6918.36,2950.97) C123.2@6908.44,2960.89 ; C123.2@6904.33,2965 6904.33,2939.71 6931.66,2912.37 6998.52,2912.37 7000,2910.9 v1(7000,2910) ; 6980.99,2912.37 cw(c6980.99,2890.99) v1@6996.11,2906.11 ; v1(7035,3200) 7073.11,3170 U34.14@7038.5,3170 ; v1@7035.65,3194.54 cw(c7037.22,3181.35) 7045.43,3191.79 cw(c7053.65,3202.22) v1@7040.46,3200.65 ; C125.2@7266.56,2964.11 ccw(c7256.64,2974.03) 7270.67,2974.03 ccw(c7284.7,2974.03) C125.2@7274.78,2964.11 ; C125.2@7270.67,2960 7270.67,3008.85 7278.52,3016.71 ; v1@7293.38,3006.43 ccw(c7278.52,3000.83) 7278.52,3016.71 ; v1(7298.52,3008.37) 7290.19,3016.71 7278.52,3016.71 ; U35.14@7348.5,3170 v1@7390,3170 ; U35.14@7364.65,3170 cw(c7364.65,3139.65) v1@7386.11,3161.11 ; v2@5570,2280 5570,2300 5600,2330 5670,2330 5680,2320 5680,2259.71 ; 5680,2259.71 cw(c5680,2251.4) U61.7@5688.11,2253.19 ; 5680,2259.71 cw(c5680,2251.4) U61.7@5688.11,2253.19 ; v1(5804.73,169.16) 5807.19,166.71 v1(5804.73,169.16)
  Top Layer w20: v1(4635,5730) v1@4680.19,5730
  MidLayer2 w12: v1@533.59,4820.44 ccw(c551.38,4838.23) 551.38,4813.08 ; v1(538.19,4825.04) 550.16,4813.08 JP1.2@675.1,4813.08 ; v1@542.08,4828.93 ccw(c580.35,4867.2) 580.35,4813.08 ; JP1.2@658.46,4796.44 ccw(c618.3,4756.28) 618.3,4813.08 ccw(c618.3,4869.88) JP1.2@658.46,4829.71 ; v1@1426.19,5100.04 v1(1426.52,5100.37)
  Bottom Layer w12: C113.2@-206.81,5504.19 ccw(c-216.73,5514.11) -202.7,5514.11 ccw(c-188.67,5514.11) C113.2@-198.59,5504.19 ; v1@-206.36,5545.15 cw(c-215.22,5536.3) -202.7,5536.3 ; C113.2@-202.7,5500.08 -202.7,5548.82 v1(-202.48,5549.04) ; -202.7,5535.22 cw(c-188.66,5535.22) v1@-198.59,5545.15 ; C111.1@-93.1,5620.95 cw(c-129.58,5584.47) -77.99,5584.47 cw(c-26.4,5584.47) C111.1@-62.88,5620.95 ; C111.1@-90.36,5661.37 ccw(c-107.33,5685.3) -77.99,5685.3 ccw(c-48.65,5685.3) C111.1@-65.63,5661.37 ; v1@-81.88,5542.08 ccw(c-91.27,5551.46) -77.99,5551.46 ccw(c-64.71,5551.46) v1@-74.1,5542.08 ; v1@-77.99,5537.99 v1(-77.99,5538.19) C111.1@-77.99,5640 -77.99,5708.52 v1(-75.48,5711.04) ; -77.99,5691.69 cw(c-56.12,5691.69) v1@-71.59,5707.15 ; v1@10.08,5500.08 C112.2@67.3,5500.08 ; v1@13.97,5496.39 cw(c22.89,5487.47) 22.89,5500.08 ; v1@13.97,5504.16 ccw(c23.83,5514.02) 23.83,5500.08 ; C112.2@63.19,5495.97 ccw(c53.27,5486.05) 53.27,5500.08 ccw(c53.27,5514.11) C112.2@63.19,5504.19 ; R141.2@109.15,5182.22 141.15,5182.22 165,5158.37 v1(200.19,5158.37) ; R141.2@112.91,5178.46 cw(c121.99,5169.38) 121.99,5182.22 cw(c121.99,5195.07) R141.2@112.91,5185.99 ; v1@131,5448.5 cw(c108.13,5464.31) C114.2@108.13,5436.51 120.52,5436.51 123.52,5433.51 123.52,5433.37 v1(135.52,5445.37) ; v1@196.3,5154.49 ccw(c186.91,5145.1) 186.91,5158.37 ccw(c186.91,5171.65) v1@196.3,5162.26 ; C145.2@445,2547.71 468.86,2547.7 470.52,2546.04 470.52,2545.71 v1(502.52,2513.71) 502.52,2543.16 534.41,2575.04 534.41,2583.37 ; C145.2@449.11,2543.6 cw(c459.03,2533.68) 459.03,2547.7 cw(c459.03,2561.74) C145.2@449.11,2551.81 ; v2@485.89,5654.11 ccw(c475.97,5664.03) 490,5664.03 ccw(c504.03,5664.03) v2@494.11,5654.11 ; v2(490,5650) 490,5675 496.44,5681.44 C149.1@496.44,5710.08 ; C149.1@492.33,5705.97 cw(c482.41,5696.05) 496.44,5696.05 cw(c510.47,5696.05) C149.1@500.55,5705.97 ; v1@497.02,2513.71 ccw(c483.75,2513.71) 493.14,2523.1 ccw(c502.52,2532.49) v1@502.52,2519.21 ; v1@498.64,2517.6 ccw(c489.25,2526.99) 502.52,2526.99 ccw(c515.8,2526.99) v1@506.41,2517.6 ; U44.1@534.41,2605.78 534.41,2583.37 ; 585,2575 550.04,2575 542.74,2575.04 538.58,2579.21 534.41,2583.37 ; 585.59,2575.59 U44.3@585.59,2605.78 ; v2(639.92,5720.08) U59.16@704.59,5720.08 ; v2@644.03,5715.97 cw(c653.95,5706.05) 653.95,5720.08 cw(c653.95,5734.11) v2@644.03,5724.19 ; U59.16@677.44,5714.58 ccw(c664.16,5701.3) 664.16,5720.08 ccw(c664.16,5738.86) U59.16@677.44,5725.58 ; NT18.2@1371.1,5099.76 1425.91,5099.76 v1(1426.52,5100.37) ; NT18.2@1388.25,5092.87 cw(c1404.89,5076.23) 1404.89,5099.76 cw(c1404.89,5123.3) NT18.2@1388.25,5106.66 ; 1411.77,5099.76 ccw(c1411.77,5115.13) v1@1422.64,5104.26 ; 1414.72,5099.76 cw(c1414.72,5088.57) v1@1422.64,5096.49 ; U46.14@1542.57,5720.08 1622.82,5720.08 1638.9,5704 v1(1658,5704) ; U46.14@1578.17,5715.97 cw(c1588.09,5706.05) 1588.09,5720.08 cw(c1588.09,5734.11) U46.14@1578.17,5724.19 ; v1@1654.11,5700.11 ccw(c1644.72,5690.72) 1644.72,5704 ccw(c1644.72,5717.28) v1@1654.11,5707.89 ; C152.2@1860.67,5470 1877,5486.33 v1(1877,5507) ; C152.2@1860.67,5475.81 ccw(c1860.67,5489.84) 1870.59,5479.92 ccw(c1880.51,5470) C152.2@1866.48,5470 ; v1@1873.11,5503.11 cw(c1863.72,5493.72) 1877,5493.72 cw(c1890.28,5493.72) v1@1880.89,5503.11 ; v1(2124.25,1123.58) F2.2@2200.75,1123.58 F2.2@2209.25,1123.58 ; v1(2125,1077.15) 2200.75,1077.15 F2.2@2210,1077.15 ; v1(2125,1170) 2200.75,1170 F2.2@2210,1170 ; v1@2128.14,1119.69 cw(c2137.53,1110.3) 2137.53,1123.58 cw(c2137.53,1136.86) v1@2128.14,1127.47 ; v1@2128.89,1073.27 cw(c2138.28,1063.88) 2138.28,1077.16 cw(c2138.28,1090.43) v1@2128.89,1081.04 ; v1@2128.89,1166.11 cw(c2138.28,1156.72) 2138.28,1170 cw(c2138.28,1183.28) v1@2128.89,1173.89 ; 2147.49,1077.15 ccw(c2147.49,1113.99) F2.2@2178.09,1093.49 ; 2147.49,1170 cw(c2147.49,1133.17) F2.2@2178.09,1153.67 ; 2148.84,1077.15 cw(c2148.84,1039.81) F2.2@2178.84,1062.05 ; 2148.84,1170 ccw(c2148.84,1207.35) F2.2@2178.84,1185.1 ; F2.2@2178.58,1107.68 ccw(c2147.63,1085.49) 2147.63,1123.58 ccw(c2147.63,1161.67) F2.2@2178.58,1139.47 ; R82.1@2843.23,950 v1(2870,950) v1@2872.23,950 ; v1@2866.11,946.11 ccw(c2856.72,936.72) 2856.72,950 ccw(c2856.72,963.28) v1@2866.11,953.89 ; v1@3014.1,1063.89 ccw(c3004.71,1073.28) 3017.99,1073.28 ccw(c3031.27,1073.28) v1@3021.88,1063.89 ; v1(3017.99,1060) C62.1@3017.99,1125 v1(3085,1125) 3087.19,1125 v1@3087.19,1124.71 ; C62.1@3035.05,1112.12 cw(c3060.9,1092.61) 3060.9,1125 cw(c3060.9,1157.39) C62.1@3035.05,1137.88 ; v1@3081.11,1121.11 ccw(c3071.72,1111.72) 3071.72,1125 ccw(c3071.72,1138.28) v1@3081.11,1128.89 ; R83.1@3099.13,950 3123.52,950 v1(3126.86,953.37) ; R83.1@3105.43,950 ccw(c3105.43,974.8) v1@3122.97,957.26 ; R86.1@3433.23,950 3458.23,950 3461.61,953.37 v1(3468.19,953.37) ; R86.1@3436.99,946.24 cw(c3446.07,937.16) 3446.07,950 cw(c3446.07,962.84) R86.1@3436.99,953.76 ; 3446.76,950 ccw(c3446.76,974.8) v1@3464.3,957.26 ; v1@3607.99,1075.04 C61.1@3607.99,1125 ; C61.1@3607.99,1088.13 ccw(c3628.13,1088.13) v1@3613.89,1073.89 ; R87.1@3689.13,950 3692.51,953.37 v1(3720.86,953.37) ; v1@3716.97,949.49 ccw(c3707.58,940.1) 3707.58,953.37 ccw(c3707.58,966.65) v1@3716.97,957.26 ; R197.1@3855.06,6159.25 ccw(c3845.98,6168.33) 3858.82,6168.33 ccw(c3871.66,6168.33) R197.1@3862.58,6159.25 ; R197.1@3858.82,6155 3858.82,6197.67 v1(3886.19,6225.04) ; v1@3880.69,6225.04 cw(c3867.41,6225.04) 3876.8,6215.65 cw(c3886.19,6206.26) v1@3886.19,6219.54 ; U72.5@4039.33,6027.98 cw(c4029.41,6018.06) 4043.44,6018.06 cw(c4057.47,6018.06) U72.5@4047.55,6027.98 ; v1@4039.47,5986.95 ccw(c4029.88,5996.53) 4043.44,5996.53 ; v1(4043.36,5983.06) 4043.44,5983.14 U72.5@4043.44,6044.88 ; 4043.44,5996.13 ccw(c4056.44,5996.13) v1@4047.25,5986.94 ; U71.5@4449.33,6027.98 cw(c4439.41,6018.06) 4453.44,6018.06 cw(c4467.47,6018.06) U71.5@4457.55,6027.98 ; v1@4449.47,5986.95 ccw(c4439.88,5996.53) 4453.44,5996.53 ; v1(4453.36,5983.06) 4453.44,5983.14 U71.5@4453.44,6044.88 ; 4453.44,5996.13 ccw(c4466.44,5996.13) v1@4457.25,5986.94 ; NT43.2@4513.34,2723.25 ccw(c4496.7,2739.89) 4520.24,2739.89 ccw(c4543.77,2739.89) NT43.2@4527.13,2723.25 ; NT43.2@4520.24,2706.1 4520.24,2745 4524.24,2749 v1(4560,2749) ; v1@4556.11,2745.11 ccw(c4546.72,2735.72) 4546.72,2749 ccw(c4546.72,2762.28) v1@4556.11,2752.89 ; v1@4854.93,6124.97 ccw(c4845.54,6134.36) 4858.82,6134.36 ccw(c4872.1,6134.36) v1@4862.71,6124.97 ; R199.1@4855.06,6155.75 cw(c4845.98,6146.67) 4858.82,6146.67 cw(c4871.66,6146.67) R199.1@4862.58,6155.75 ; v1(4858.82,6121.08) R199.1@4858.82,6160 ; v2@5180.89,964.11 ccw(c5170.97,974.03) 5185,974.03 ccw(c5199.03,974.03) v2@5189.11,964.11 ; v2(5185,960) 5185,1035 5200,1050 5450,1050 5475,1025 R275.2@5475,956.18 ; R274.2@5225,913.82 5252.75,913.82 5252.86,913.71 v1(5252.86,888.71) ; R274.2@5229.25,910.06 cw(c5238.33,900.98) 5238.33,913.82 cw(c5238.33,926.66) R274.2@5229.25,917.58 ; v1@5248.97,892.6 ccw(c5239.58,901.99) 5252.86,901.99 ccw(c5266.14,901.99) v1@5256.75,892.6 ; R275.2@5471.24,959.94 ccw(c5462.16,969.02) 5475,969.02 ccw(c5487.84,969.02) R275.2@5478.76,959.94 ; v1(5482.52,5578.37) 5513.37,5578.37 5519.06,5584.06 L3.1@5519.06,5650 ; v1@5486.41,5574.49 cw(c5495.8,5565.1) 5495.8,5578.37 cw(c5495.8,5591.65) v1@5486.41,5582.26 ; L3.1@5509.38,5610.8 cw(c5486.02,5587.43) 5519.06,5587.43 cw(c5552.09,5587.43) L3.1@5528.73,5610.8 ; R276.2@5725,913.82 v1(5752.75,913.82) ; v1@5748.86,909.93 ccw(c5739.47,900.54) 5739.47,913.82 ccw(c5739.47,927.1) v1@5748.86,917.71
  other v1: 3610,1070 310,1450 1395,1450 665,1462.5 720.83,1462.5 1750,1462.5 1805.83,1462.5 21.14,1465 125,1465 1106.14,1465 1210,1465 665,1485 720.83,1485 1750,1485 1805.83,1485 21.14,1487.5 125,1487.5 1106.14,1487.5 1210,1487.5 275,1490 345,1490 1360,1490 1430,1490 665,1507.5 720.83,1507.5 1750,1507.5 1805.83,1507.5 21.14,1510 125,1510 1106.14,1510 1210,1510 275,1516.67 345,1516.67 1360,1516.67 1430,1516.67 275,1543.33 345,1543.33 1360,1543.33 1430,1543.33 275,1570 345,1570 1360,1570 1430,1570 -675.7,2327 682.35,3143.04 713.84,3143.04 745.34,3143.04 7390,3165 4370,3705 -105,5150 10.08,5500.28 4655,5730 4675,5730 4695,5730
+5V_VIDOUT: C97.1 C98.1 C99.2 L3.2 U21.40 U21.44 | length 1467.3
  MidLayer1 w12: v2(5215,5675) 5305.15,5675 v1(5355.19,5725.04) 5390.19,5690.04 5390.19,5650 5335,5594.81 5335,5575.83 5361.33,5549.5 5369.91,5549.5 5385,5534.41 5385,5478.11 5348.6,5441.71 v1(5348.52,5441.71) ; v2@5219.11,5670.89 cw(c5229.03,5660.97) 5229.03,5675 cw(c5229.03,5689.03) v2@5219.11,5679.11 ; v1@5348.52,5447.21 ccw(c5348.52,5460.66) 5358.04,5451.15 ; v1@5349.69,5725.04 cw(c5336.41,5725.04) 5345.8,5715.65 cw(c5355.19,5706.26) 5355.19,5719.54 cw(c5355.19,5706.26) 5364.58,5715.65 cw(c5373.97,5725.04) v1@5360.69,5725.04 ; v1@5354.02,5441.71 cw(c5367.13,5441.71) 5357.86,5450.97
  Bottom Layer w12: C97.1@5091.56,5800.89 cw(c5081.64,5790.97) 5095.67,5790.97 cw(c5109.7,5790.97) C97.1@5099.78,5800.89 ; C97.1@5095.67,5805 5095.67,5737.32 5095.67,5704.33 5102.2,5697.8 5135,5697.8 ; U21.40@5095.79,5713.8 ccw(c5104.11,5709.28) 5097.41,5702.59 ; 5174.16,5703.01 ccw(c5168.57,5708.6) U21.44@5174.53,5713.8 ; U21.44@5174.53,5737.32 5174.53,5703.37 5168.95,5697.8 5135,5697.8 ; v2@5210.89,5670.89 ccw(c5200.97,5660.97) 5200.97,5675 ccw(c5200.97,5689.03) v2@5210.89,5679.11 ; v2(5215,5675) 5140,5675 5135,5680 5135,5697.8 ; v1@5343.93,5437.11 ccw(c5361.1,5454.28) 5361.1,5430 ; v1(5348.52,5441.71) 5360.23,5430 C98.1@5399.33,5430 5399.33,5466.71 5405.63,5473.01 C99.2@5405.63,5515 ; v1@5352.41,5445.6 ccw(c5390.07,5483.25) C98.1@5390.07,5430 ; v1(5355.19,5725.04) 5384.28,5725.04 5400.94,5708.37 ; v1@5359.08,5721.15 cw(c5368.47,5711.76) 5368.47,5725.04 cw(c5368.47,5738.32) v1@5359.08,5728.93 ; L3.2@5392.29,5690.13 ccw(c5377.39,5708.37) 5400.94,5708.37 ; C98.1@5395.22,5425.89 ccw(c5385.3,5415.97) 5385.3,5430 ccw(c5385.3,5444.03) 5395.22,5434.11 ccw(c5385.3,5444.03) 5399.33,5444.03 ccw(c5413.36,5444.03) C98.1@5403.44,5434.11 ; C99.2@5395.95,5500.4 cw(c5372.59,5477.04) 5405.63,5477.04 cw(c5438.67,5477.04) C99.2@5415.31,5500.4 ; L3.2@5400.94,5650 5400.94,5708.37 ; L3.2@5409.6,5690.13 cw(c5424.5,5708.37) 5400.94,5708.37
+B: D10.2 J19.1 PROTOTYPE1.32 SW7.3 TP3.1 | length 7267.4
  Top Layer w12: v1@3494.64,4511.26 ccw(c3485.25,4520.65) 3498.52,4520.65 ccw(c3511.8,4520.65) v1@3502.41,4511.26 ; v1(3498.52,4507.37) 3498.52,4650.04 3473.52,4675.04 3473.52,5153.52 3495,5175 3600.96,5175 3602.96,5173 3605,5175.04 v1(3606.86,5175.04) ; 3593.48,5175 ccw(c3593.48,5188.42) v1@3602.97,5178.93 ; 3593.68,5175 cw(c3593.68,5161.86) v1@3602.97,5171.15
  MidLayer1 w12: PROTOTYPE1.32@3376.12,3408.23 3424.62,3456.74 3424.62,3863.9 3468.96,3908.23 TP3.1@3576.12,3908.23 3673.23,3908.23 3693.35,3928.35 3693.35,4067.27 ; PROTOTYPE1.32@3376.12,3421.23 ccw(c3376.12,3452.62) 3398.31,3430.43 ccw(c3420.51,3408.23) PROTOTYPE1.32@3389.12,3408.23 ; PROTOTYPE1.32@3376.12,3433.23 ccw(c3376.12,3493.59) 3418.8,3450.91 ccw(c3461.48,3408.23) PROTOTYPE1.32@3401.12,3408.23 ; v1(3498.52,4507.37) 3652.63,4507.37 3707.17,4452.83 3707.17,4285.54 3677.02,4255.4 3677.02,4166.14 3693.35,4149.81 3693.35,4067.27 ; v1@3502.41,4503.49 cw(c3511.8,4494.1) 3511.8,4507.37 cw(c3511.8,4520.65) v1@3502.41,4511.26 ; TP3.1@3559.15,3891.26 ccw(c3518.18,3850.29) 3518.18,3908.23 ccw(c3518.18,3966.18) TP3.1@3559.15,3925.21 ; TP3.1@3593.09,3891.26 cw(c3634.06,3850.29) 3634.06,3908.23 cw(c3634.06,3966.18) TP3.1@3593.09,3925.21 ; 3693.35,4071.88 3693.35,4067.27
  MidLayer2 w12: v1(3606.86,5175.04) 4410.04,5175.04 4445,5210 4445,5534.45 4495,5584.45 4495,5750 4506.5,5761.5 4788.91,5761.5 4805.2,5745.21 5341.21,5745.21 5359.19,5763.19 5414.6,5763.19 5442.22,5790.81 5825.66,5790.81 6106,6071.15 6106,6226 6205,6325 6335,6325 6381.99,6371.99 6711.65,6371.99 6712.08,6372.41 7033.78,6372.41 J19.1@7040,6378.63 ; v1@3610.75,5171.15 cw(c3620.14,5161.76) 3620.14,5175.04 cw(c3620.14,5188.32) v1@3610.75,5178.93 ; 6895.22,6372.41 ccw(c6895.22,6474.2) J19.1@6967.19,6402.23 ; 6924.19,6372.41 ccw(c6924.19,6445.23) J19.1@6975.68,6393.74 ; 6925.23,6372.41 cw(c6925.23,6313.07) J19.1@6967.19,6355.03
  other v2: 7765,5280 7790,5280.1 7815.1,5280.1 7840.2,5280.1 7865.3,5280.1 7765,5300 7790,5300.1 7815.1,5300.1 7840.2,5300.1 7865.3,5300.1
A3V3_CODEC: C19.1 C22.1 C146.1 C147.2 U1.19 U44.5 | length 2226.5
  Top Layer w12: U1.19@-78.48,2710.37 U1.19@-79.84,2709.02 13.64,2709.02 15,2710.37 v1(89.19,2710.37) ; v1@85.3,2706.49 ccw(c75.91,2697.1) 75.91,2710.37 ccw(c75.91,2723.65) v1@85.3,2714.26
  MidLayer1 w12: v1@89.19,2704.87 cw(c89.19,2691.6) 98.58,2700.99 cw(c107.97,2710.37) v1@94.69,2710.37 ; v1(89.19,2710.37) 332.86,2466.71 v1(543.19,2466.71) ; v1@539.3,2462.82 ccw(c529.91,2453.43) 529.91,2466.71 ccw(c529.91,2479.99) v1@539.3,2470.6
  MidLayer2 w12: v1(543.19,2466.71) 611.71,2466.71 628.37,2483.37 v1(775.19,2483.37) ; v1@547.08,2462.82 cw(c556.47,2453.43) 556.47,2466.71 cw(c556.47,2479.99) v1@547.08,2470.6 ; v1@771.3,2479.49 ccw(c761.91,2470.1) 761.91,2483.37 ccw(c761.91,2496.65) v1@771.3,2487.26
  Bottom Layer w4: v1(89.19,2710.37) 89.33,2710.51 v1(89.19,2710.37)
  Bottom Layer w12: C19.1@64.64,2682.22 ccw(c59.96,2691.81) 70.63,2691.81 ; C19.1@70.63,2665 70.63,2691.81 ; C19.1@76.63,2682.22 cw(c81.3,2691.81) 70.63,2691.81 ; v1@83.69,2710.37 cw(c70.41,2710.37) 79.8,2700.99 cw(c89.19,2691.6) v1@89.19,2704.87 ; C22.1@85.22,2740.89 cw(c75.64,2731.31) 89.19,2731.31 ; v1@85.3,2714.26 ccw(c75.91,2723.65) 89.19,2723.65 ccw(c102.47,2723.65) v1@93.08,2714.26 ; 89.19,2730.63 cw(c103.7,2730.63) C22.1@93.44,2740.89 ; C22.1@89.33,2745 89.19,2744.86 v1(89.19,2710.37) 70.63,2691.81 ; U44.5@534.41,2530.97 534.41,2491.49 543.19,2482.71 v1(543.19,2466.71) ; v1@539.3,2470.6 ccw(c529.91,2479.99) 543.19,2479.99 ccw(c556.47,2479.99) v1@547.08,2470.6 ; 544.1,2481.8 cw(c530.4,2468.11) v1@549.65,2466 ; v1(775.19,2483.37) 818.48,2483.37 828.48,2493.37 ; v1@779.08,2479.49 cw(c788.47,2470.1) 788.47,2483.37 cw(c788.47,2496.65) v1@779.08,2487.26 ; C146.1@807.17,2538.76 cw(c769.51,2493.38) 828.48,2493.38 ; C146.1@814.84,2547.99 cw(c790.72,2518.93) 828.48,2518.93 cw(c866.25,2518.93) C146.1@842.13,2547.99 ; C146.1@821.75,2577.43 cw(c841.68,2538.98) 872.3,2569.6 ; C146.1@826.66,2574.21 cw(c847.17,2552.86) 868.11,2573.79 ; C146.1@827.27,2566.77 cw(c849.59,2523.7) 883.9,2558 ; C146.1@832.8,2556.12 cw(c857.51,2508.43) 895.49,2546.41 ; C146.1@834.98,2565.55 cw(c855.66,2544.03) 876.76,2565.14 ; C146.1@843.29,2556.9 cw(c864.14,2535.2) 885.42,2556.48 ; C146.1@849.8,2538.76 ccw(c887.46,2493.38) 828.48,2493.38 ; C146.1@851.6,2548.25 cw(c872.62,2526.37) 894.07,2547.82 ; C146.1@860.41,2558.66 cw(c873.52,2554.67) 873.52,2568.37 ; C146.1@860.41,2578.09 ccw(c873.52,2582.08) 873.52,2568.37 ; C147.2@940.89,2543.6 ccw(c930.97,2533.68) 930.97,2547.71 ccw(c930.97,2561.73) C147.2@940.89,2551.81 ; C147.2@945,2547.71 894.19,2547.71 873.52,2568.37 ; 828.48,2493.38 C146.1@828.48,2568.37 873.52,2568.37
A3V3_USBA: C88.2 C89.1 NT10.2 U19.3 | length 1730
  MidLayer1 w12: v4(7508.58,564.34) 7585,640.76 7585,960 7618.86,993.86 v1(7618.86,1169.71) ; v1@7614.97,1165.82 cw(c7605.58,1156.43) 7618.86,1156.43 cw(c7632.14,1156.43) v1@7622.75,1165.82
  Bottom Layer w8: v4@7504.34,568.58 ccw(c7494.1,578.82) 7508.58,578.82 ccw(c7523.07,578.82) v4@7512.83,568.58 ; v4(7508.58,564.34) U19.3@7508.58,595.67
  Bottom Layer w12: C89.1@7312.55,1180.99 cw(c7301.49,1157.99) 7327.01,1157.99 ; C89.1@7327.01,1240.31 ccw(c7327.01,1301.4) 7370.21,1258.2 ; C89.1@7327.01,1252.31 ccw(c7327.01,1342.37) 7390.7,1278.69 ; C89.1@7341.47,1180.99 ccw(c7352.52,1157.99) 7327.01,1157.99 ; C89.1@7348.38,1218.94 cw(c7390.47,1218.94) C89.1@7360.71,1248.7 ; C89.1@7360.38,1218.94 cw(c7431.44,1218.94) 7381.19,1269.18 ; C88.2@7443.52,1115 ccw(c7429.49,1115) 7439.41,1124.92 ccw(c7449.33,1134.84) C88.2@7449.33,1120.81 ; C88.2@7449.33,1115 7414.33,1150 7335,1150 7327.01,1157.99 ; 7542.3,1247.7 ccw(c7599.76,1305.16) NT10.2@7599.76,1223.9 ; 7562.79,1227.21 ccw(c7599.76,1264.19) NT10.2@7599.76,1211.9 ; 7583.27,1206.73 ccw(c7599.76,1223.22) NT10.2@7599.76,1199.9 ; NT10.2@7595.32,1184.97 cw(c7591.61,1177.71) 7599.76,1177.71 ; NT10.2@7604.2,1184.97 ccw(c7607.92,1177.71) 7599.76,1177.71 ; v1(7618.86,1169.71) 7607.76,1169.71 7599.76,1177.71 ; 7327.01,1157.99 C89.1@7327.01,1215 7390.88,1278.87 7511.13,1278.87 7586.1,1203.9 NT10.2@7599.76,1203.9 7599.76,1177.71
A3V3_USBB: C170.2 C171.1 NT45.2 U56.3 | length 1973.9
  MidLayer1 w12: v4(6521.42,6320.66) 6521.42,6510.42 6538,6527 6608,6527 6636.5,6498.5 6636.5,6477.84 6676.13,6438.21 6872.76,6438.21 6935,6375.97 6935,6339.59 7130.89,6143.71 v1(7148.19,6143.71) ; 7109.26,6165.33 ccw(c7148.19,6204.26) v1@7148.19,6149.21 ; 7129.75,6144.85 ccw(c7148.19,6163.29) v1@7148.19,6137.21 ; v1@7144.3,6139.82 ccw(c7134.91,6130.43) 7134.91,6143.71 ccw(c7134.91,6156.99) v1@7144.3,6147.6
  Bottom Layer w8: v4@6517.17,6316.42 cw(c6506.93,6306.18) 6521.42,6306.18 cw(c6535.9,6306.18) v4@6525.66,6316.42 ; U56.3@6521.42,6289.33 v4(6521.42,6320.66)
  Bottom Layer w12: C171.1@7009.98,5975.99 cw(c6967.23,5927.33) 7032.01,5927.33 ; C171.1@7011.57,6035.32 ccw(c6979.27,6077) 7032.01,6077 ; C171.1@7017.9,5985.01 cw(c6990.52,5953.84) 7032.01,5953.84 cw(c7073.49,5953.84) C171.1@7046.11,5985.01 ; C171.1@7018.92,6025.83 ccw(c6998.24,6052.53) 7032.01,6052.53 ccw(c7065.78,6052.53) C171.1@7045.1,6025.83 ; C171.1@7052.45,6035.32 cw(c7084.74,6077) 7032.01,6077 ; C170.2@7053.52,5900 ccw(c7039.49,5900) 7049.41,5909.92 ccw(c7059.33,5919.84) C170.2@7059.33,5905.81 ; C171.1@7054.03,5975.99 ccw(c7096.79,5927.33) 7032.01,5927.33 ; C170.2@7059.33,5900 7032.01,5927.32 ; NT45.2@7111.75,6098.34 ccw(c7095.11,6081.7) 7095.11,6105.24 ccw(c7095.11,6128.77) NT45.2@7111.75,6112.13 ; NT45.2@7123.15,6113.11 ccw(c7114.91,6124.41) 7128.9,6124.41 ; NT45.2@7128.17,6096.16 cw(c7144.73,6109.85) 7129.53,6125.05 ; NT45.2@7134.64,6113.11 cw(c7142.89,6124.41) 7128.9,6124.41 ; v1@7142.69,6143.71 cw(c7129.41,6143.71) 7138.8,6134.32 cw(c7148.19,6124.93) v1@7148.19,6138.21 ; v1(7148.19,6143.71) 7128.9,6124.42 ; 7032.01,5927.32 C171.1@7032.01,6005 7032.01,6077.01 ; 7032.01,6077.01 7060.24,6105.24 NT45.2@7128.9,6105.24 7128.9,6124.42
ADC#.ADC0: J13.2 J33.A9 R133.1 | length 6920
  Top Layer w4: J33.A9@-785.98,3952.07 -694.48,3952.07 ; J33.A9@-710.71,3947.62 cw(c-702.15,3941.64) -702.15,3952.07 cw(c-702.15,3962.51) J33.A9@-710.71,3956.53 ; J33.A9@-707.43,3945.32 cw(c-694.48,3936.27) -694.48,3952.07 ; J33.A9@-707.43,3958.82 ccw(c-694.48,3967.88) -694.48,3952.07 ; v1@-692.72,3987.28 cw(c-707.79,3972.21) -686.48,3972.21 ; v1@-689.89,3990.11 cw(c-698.13,3981.87) -686.48,3981.87 ; v1@-687.8,3993.52 -686.48,3992.19 -686.48,3960.07 -694.48,3952.07 ; -686.48,3969.92 cw(c-661.92,3969.92) v1@-679.28,3987.28 ; -686.48,3979.57 cw(c-671.57,3979.57) v1@-682.11,3990.11 ; 1667.94,5276.75 ccw(c1684.68,5293.5) R133.1@1684.68,5269.81 ; 1669.12,5275.56 cw(c1654.06,5260.49) R133.1@1675.37,5260.49 ; R133.1@1674.76,5269.92 ccw(c1684.68,5279.84) R133.1@1684.68,5265.81 ; R133.1@1675.95,5268.73 cw(c1667.71,5260.49) R133.1@1679.37,5260.49 ; R133.1@1684.68,5260 1650,5294.68 1650,5525 1853.07,5728.07 J13.2@1853.07,5880 ; J13.2@1825.25,5852.18 cw(c1758.1,5785.03) 1853.07,5785.03 cw(c1948.04,5785.03) J13.2@1880.89,5852.18 ; J13.2@1828.08,5855.01 cw(c1767.75,5794.68) 1853.07,5794.68 cw(c1938.38,5794.69) J13.2@1878.06,5855.01 ; J13.2@1830.91,5857.84 cw(c1777.41,5804.34) 1853.07,5804.34 cw(c1928.73,5804.34) J13.2@1875.23,5857.84 ; J13.2@1833.74,5860.67 cw(c1787.07,5814) 1853.07,5814 ; J13.2@1836.57,5863.5 cw(c1796.73,5823.65) 1853.07,5823.65 cw(c1909.41,5823.66) J13.2@1869.57,5863.5 ; J13.2@1839.4,5866.33 cw(c1806.38,5833.31) 1853.07,5833.31 cw(c1899.76,5833.31) J13.2@1866.75,5866.33 ; 1853.07,5814 cw(c1919.07,5814) J13.2@1872.4,5860.67
  MidLayer1 w4: v2@1193.06,5031.94 ccw(c1176.31,5048.69) 1200,5048.69 ccw(c1223.69,5048.69) v2@1206.94,5031.94 ; v2@1195.89,5029.11 ccw(c1185.97,5039.03) 1200,5039.03 ccw(c1214.03,5039.03) v2@1204.11,5029.11 ; v2(1200,5025) 1200,5310 1239.84,5349.84 v2(1239.84,5420.16) ; v2@1232.9,5413.22 cw(c1216.16,5396.47) 1239.84,5396.47 cw(c1263.53,5396.47) v2@1246.78,5413.22 ; v2@1235.73,5416.05 cw(c1225.81,5406.13) 1239.84,5406.13 cw(c1253.87,5406.13) v2@1243.95,5416.05
  Bottom Layer w4: v1@-687.8,3993.52 -573.27,3993.52 -567.25,3987.5 -522.35,3987.5 -451,4058.85 -451,4375.52 -250.48,4576.04 361.04,4576.04 375,4590 375,4980 410.19,5015.19 1155.19,5015.19 1165,5025 v2(1200,5025) ; v1@-682.11,3990.11 cw(c-673.87,3981.87) -673.87,3993.52 ; v1@-682.11,3997.89 ccw(c-671.57,4008.43) -671.57,3993.52 ; v1@-679.28,3987.28 cw(c-664.22,3972.22) -664.22,3993.52 ; v1@-679.28,4000.72 ccw(c-661.91,4018.09) -661.91,3993.52 ; v2@1193.06,5018.06 ccw(c1176.31,5001.31) 1176.31,5025 ccw(c1176.31,5048.69) v2@1193.06,5031.94 ; v2@1195.89,5020.89 ccw(c1185.97,5010.97) 1185.97,5025 ccw(c1185.97,5039.03) v2@1195.89,5029.11 ; v2@1232.9,5427.1 ccw(c1216.16,5443.84) 1239.84,5443.84 ccw(c1263.53,5443.84) v2@1246.78,5427.1 ; v2@1235.73,5424.27 ccw(c1225.81,5434.19) 1239.84,5434.19 ccw(c1253.87,5434.19) v2@1243.95,5424.27 ; v2(1239.84,5420.16) 1239.84,5640 ; 1239.84,5574.69 1239.84,5640 ; J13.2@1813.74,5880.92 ccw(c1726.05,5882.97) 1788.07,5945 ccw(c1850.1,6007.02) J13.2@1852.15,5919.33 ; J13.2@1817.74,5880.83 ccw(c1738.96,5882.67) 1794.68,5938.39 ccw(c1850.4,5994.11) J13.2@1852.24,5915.33 ; J13.2@1821.74,5880.73 ccw(c1751.88,5882.37) 1801.29,5931.78 ccw(c1850.71,5981.19) J13.2@1852.34,5911.33 ; J13.2@1825.74,5880.64 ccw(c1764.79,5882.06) 1807.9,5925.17 ccw(c1851.01,5968.28) J13.2@1852.43,5907.33 ; J13.2@1829.74,5880.55 ccw(c1777.71,5881.76) 1814.51,5918.56 ccw(c1851.31,5955.36) J13.2@1852.53,5903.33 ; J13.2@1833.74,5880.45 ccw(c1790.63,5881.46) 1821.12,5911.95 ccw(c1851.61,5942.44) J13.2@1852.62,5899.33 ; J13.2@1853.07,5880 1788.07,5945 1360,5945 1239.84,5824.84 1239.84,5640
  other v1: -686,3994
ADC#.ADC1: J13.3 J33.A8 R134.1 | length 5361.8
  Top Layer w4: J33.A8@-785.98,3991.44 -714.63,3991.44 -691.08,4015 -648.1,4015 v1(-608.14,3975.04) ; J33.A8@-717.08,3999.22 ccw(c-717.08,4023.92) -699.62,4006.46 ; J33.A8@-717.08,4003.22 ccw(c-717.08,4037.58) -692.79,4013.29 ; J33.A8@-709.3,3991.44 cw(c-696.44,3991.44) J33.A8@-705.54,4000.54 ; J33.A8@-705.3,3991.44 cw(c-682.79,3991.44) -698.71,4007.37 ; v1@-617.64,3975.04 ccw(c-640.58,3975.04) -624.36,3991.26 ccw(c-608.14,4007.48) v1@-608.14,3984.54 ; v1@-613.64,3975.04 ccw(c-626.92,3975.04) -617.53,3984.43 ccw(c-608.14,3993.82) v1@-608.14,3980.54 ; v1@1608.47,4790.09 ccw(c1592.26,4806.31) 1615.19,4806.31 ccw(c1638.13,4806.31) v1@1621.91,4790.09 ; v1@1611.3,4787.26 ccw(c1601.91,4796.65) 1615.19,4796.65 ccw(c1628.47,4796.65) v1@1619.08,4787.26 ; v1(1615.19,4783.37) 1615.19,5100.04 1706.86,5191.71 1706.86,5285 1684.68,5307.17 R134.1@1684.68,5415 1684.68,5514.76 J13.3@2049.92,5880 ; R134.1@1678.1,5407.92 cw(c1662.19,5392.01) 1684.68,5392.01 cw(c1707.18,5392.01) R134.1@1691.27,5407.92 ; R134.1@1678.1,5422.08 ccw(c1662.19,5437.99) 1684.68,5437.99 ccw(c1707.18,5437.99) R134.1@1691.27,5422.08 ; R134.1@1680.92,5410.75 cw(c1671.84,5401.67) 1684.68,5401.67 cw(c1697.53,5401.67) R134.1@1688.45,5410.75 ; R134.1@1680.92,5419.25 ccw(c1671.84,5428.33) 1684.68,5428.33 ccw(c1697.53,5428.33) R134.1@1688.45,5419.25 ; J13.3@2010.58,5880 cw(c1915.61,5880) 1982.77,5812.84 cw(c2049.92,5745.69) J13.3@2049.92,5840.66 ; J13.3@2014.58,5880 cw(c1929.27,5880) 1989.59,5819.67 cw(c2049.92,5759.35) J13.3@2049.92,5844.66 ; J13.3@2018.58,5880 cw(c1942.92,5880) 1996.42,5826.5 cw(c2049.92,5773) J13.3@2049.92,5848.66 ; J13.3@2022.58,5880 cw(c1956.58,5880) 2003.25,5833.33 cw(c2049.92,5786.66) J13.3@2049.92,5852.66 ; J13.3@2026.58,5880 cw(c1970.24,5880) 2010.08,5840.16 cw(c2049.92,5800.32) J13.3@2049.92,5856.66 ; J13.3@2030.58,5880 cw(c1983.9,5880) 2016.91,5846.99 cw(c2049.92,5813.97) J13.3@2049.92,5860.66
  MidLayer2 w4: v1(-608.14,3975.04) -593.14,3990.04 -593.14,4006.61 -575.75,4024 -557.96,4024 -318.14,4263.82 v1(-318.14,4391.71) ; v1@-324.86,4384.99 cw(c-341.08,4368.77) -318.14,4368.77 cw(c-295.21,4368.77) v1@-311.43,4384.99 ; v1@-322.03,4387.82 cw(c-331.42,4378.43) -318.14,4378.43 cw(c-304.86,4378.43) v1@-314.25,4387.82
  Bottom Layer w4: v1@-324.86,4398.43 ccw(c-341.08,4414.64) -318.14,4414.64 ccw(c-295.21,4414.64) v1@-311.43,4398.43 ; v1@-322.03,4395.6 ccw(c-331.42,4404.99) -318.14,4404.99 ccw(c-304.86,4404.99) v1@-314.25,4395.6 ; v1(-318.14,4391.71) -318.14,4474.43 -240.53,4552.04 300.08,4552.04 300.12,4552 468.46,4552 591.5,4675.04 1006.86,4675.04 1015.19,4683.37 1015.19,4741.71 1031.86,4758.37 1590.19,4758.37 v1(1615.19,4783.37) ; v1@1605.69,4783.37 cw(c1582.76,4783.37) 1598.97,4767.16 cw(c1615.19,4750.94) v1@1615.19,4773.87 ; v1@1609.69,4783.37 cw(c1596.41,4783.37) 1605.8,4773.99 cw(c1615.19,4764.6) v1@1615.19,4777.87
ADC#.ADC2: J13.4 J33.A12 R135.1 | length 6213.5
  Top Layer w4: J33.A12@-785.98,3755.22 -557.61,3755.22 -542.5,3770.33 -542.5,4082.5 -555,4095 v1(-600,4095) ; J33.A12@-711.58,3749.72 cw(c-698.3,3736.44) -698.3,3755.22 cw(c-698.3,3774) J33.A12@-711.58,3760.72 ; J33.A12@-708.76,3746.89 cw(c-688.65,3726.79) -688.65,3755.22 ; v1@-596.11,4091.11 cw(c-586.72,4081.72) -586.72,4095 cw(c-586.72,4108.28) v1@-596.11,4098.89 ; v1@-593.28,4088.28 cw(c-577.07,4072.06) -577.07,4095 cw(c-577.07,4117.93) v1@-593.28,4101.72 ; v2@2103.06,5468.06 cw(c2074.23,5439.23) 2115,5439.23 ; v2@2105.89,5470.89 cw(c2083.89,5448.89) 2115,5448.89 ; v2@2108.72,5473.72 cw(c2093.55,5458.55) 2115,5458.55 ; v2(2110,5475) 2115,5470 2115,5432.04 R135.1@2132.05,5415 ; 2115,5463.39 cw(c2121.61,5463.39) v2@2116.94,5468.06 ; 2115.3,5431.75 ccw(c2132.05,5448.5) R135.1@2132.05,5424.81 ; 2116.49,5430.56 cw(c2101.42,5415.49) R135.1@2122.73,5415.49 ; R135.1@2122.13,5424.92 ccw(c2132.05,5434.84) R135.1@2132.05,5420.81 ; R135.1@2123.32,5423.73 cw(c2115.08,5415.49) R135.1@2126.73,5415.49
  MidLayer1 w4: v2@2103.06,5481.94 ccw(c2086.31,5498.69) 2110,5498.69 ccw(c2133.69,5498.69) v2@2116.94,5481.94 ; v2@2105.89,5479.11 ccw(c2095.97,5489.03) 2110,5489.03 ccw(c2124.03,5489.03) v2@2114.11,5479.11 ; v2(2110,5475) 2110,5743.23 J13.4@2246.77,5880 ; J13.4@2207.43,5880 cw(c2112.46,5880) 2179.62,5812.84 cw(c2246.77,5745.69) J13.4@2246.77,5840.66 ; J13.4@2211.43,5880 cw(c2126.12,5880) 2186.44,5819.67 cw(c2246.77,5759.35) J13.4@2246.77,5844.66 ; J13.4@2215.43,5880 cw(c2139.77,5880) 2193.27,5826.5 cw(c2246.77,5773) J13.4@2246.77,5848.66 ; J13.4@2219.43,5880 cw(c2153.43,5880) 2200.1,5833.33 cw(c2246.77,5786.66) J13.4@2246.77,5852.66 ; J13.4@2223.43,5880 cw(c2167.09,5880) 2206.93,5840.16 cw(c2246.77,5800.32) J13.4@2246.77,5856.66 ; J13.4@2227.43,5880 cw(c2180.75,5880) 2213.76,5846.99 cw(c2246.77,5813.97) J13.4@2246.77,5860.66
  MidLayer2 w4: v1(-600,4095) -550,4145 -550,4175.2 -507.98,4217.22 -507.98,4576.77 -462.25,4622.5 -328.91,4622.5 -285.28,4578.87 -222.75,4578.87 -192.25,4609.37 83.31,4609.37 163.75,4689.82 193.94,4720 430,4720 469.5,4759.5 469.5,4950.5 460,4960 460,5298.69 463.31,5302 796.69,5302 836.69,5262 1033,5262 1103.29,5191.71 1361.71,5191.71 1391.02,5221.02 1391.02,5342.53 1490.19,5441.71 1798.52,5441.71 1815.19,5458.37 2031.86,5458.37 2035.23,5455 2092.05,5455 v2@2110,5472.95 ; 2093.07,5456.02 ccw(c2075.79,5473.31) v2@2100.2,5474.52 ; 2096.75,5459.7 cw(c2110,5446.45) v2@2110,5465.19 ; 2099.45,5462.4 ccw(c2087.94,5473.91) v2@2104.2,5474.71
ADC#.ADC3: J13.5 J33.A10 R136.1 | length 8071.2
  Top Layer w4: J33.A10@-785.98,3912.7 -719,3912.7 -705,3926.71 ; J33.A10@-722.9,3918.52 cw(c-703.12,3898.74) -703.12,3926.71 ; J33.A10@-720.07,3915.69 cw(c-693.46,3889.08) -693.46,3926.71 ; J33.A10@-717.24,3912.86 cw(c-683.81,3879.43) -683.81,3926.71 ; J33.A10@-714.41,3910.03 cw(c-674.15,3869.77) -674.15,3926.71 ; J33.A10@-714.25,3924.14 ccw(c-711.9,3933.61) -705,3926.71 ; J33.A10@-711.58,3907.2 cw(c-664.49,3860.11) -664.49,3926.71 ; J33.A10@-706.49,3917.85 cw(c-699.53,3921.23) -705,3926.71 ; v1@88.28,5893.28 ccw(c72.06,5877.06) 72.06,5900 ccw(c72.06,5922.93) v1@88.28,5906.72 ; v1@91.11,5896.11 ccw(c81.72,5886.72) 81.72,5900 ccw(c81.72,5913.28) v1@91.11,5903.89 ; v1(95,5900) -446.48,5900 -551.48,5795 -551.48,4700.04 -609.81,4641.71 -609.81,4618.63 -592.06,4600.87 -591.93,4600.87 -536,4544.94 -536,4196.69 -549,4183.69 -549,4124.5 -561,4112.5 -635.68,4112.5 -642.5,4105.68 -642.5,4067.69 -632.62,4057.81 -592.81,4057.81 -584.81,4049.81 -584.81,3943.37 -601.48,3926.71 -705,3926.71 ; v2(2105,5305) 2120,5305 2132.05,5292.95 R136.1@2132.05,5260 ; R136.1@2125.46,5267.08 ccw(c2109.55,5282.99) 2132.05,5282.99 ccw(c2154.54,5282.99) R136.1@2138.64,5267.08 ; R136.1@2128.29,5264.25 ccw(c2119.21,5273.33) 2132.05,5273.33 ccw(c2144.89,5273.33) R136.1@2135.81,5264.25 ; v2@2141.06,5457.56 ccw(c2124.31,5474.31) 2148,5474.31 ccw(c2171.69,5474.31) v2@2154.94,5457.56 ; v2@2143.89,5454.73 ccw(c2133.97,5464.65) 2148,5464.65 ccw(c2162.03,5464.65) v2@2152.11,5454.73 ; v2(2148,5450.62) 2148,5478.9 2122.69,5504.21 2122.69,5737.88 2214.81,5830 2393.62,5830 ; J13.5@2405.32,5871.03 cw(c2362.6,5861.03) 2393.62,5830 ; J13.5@2409.21,5871.94 cw(c2370.84,5862.96) 2398.71,5835.09 cw(c2426.58,5807.21) J13.5@2435.56,5845.59 ; J13.5@2413.11,5872.85 cw(c2379.08,5864.89) 2403.79,5840.17 cw(c2428.51,5815.45) J13.5@2436.48,5849.49 ; J13.5@2417,5873.77 cw(c2387.31,5866.81) 2408.88,5845.25 cw(c2430.44,5823.69) J13.5@2437.39,5853.38 ; J13.5@2420.9,5874.68 cw(c2395.55,5868.74) 2413.96,5850.34 cw(c2432.37,5831.93) J13.5@2438.3,5857.28 ; J13.5@2434.65,5841.7 ccw(c2424.65,5798.98) 2393.62,5830 ; J13.5@2443.62,5880 2393.62,5830
  MidLayer1 w4: v1@88.28,5893.28 cw(c72.06,5877.06) 95,5877.06 cw(c117.93,5877.06) v1@101.72,5893.28 ; v1@91.11,5896.11 cw(c81.72,5886.72) 95,5886.72 cw(c108.28,5886.72) v1@98.89,5896.11 ; v1(95,5900) 95,5830 120,5805 v2(205,5805) ; v2@198.06,5798.06 ccw(c181.31,5781.31) 181.31,5805 ccw(c181.31,5828.69) v2@198.06,5811.94 ; v2@200.89,5800.89 ccw(c190.97,5790.97) 190.97,5805 ccw(c190.97,5819.03) v2@200.89,5809.11 ; v2@2098.06,5311.94 ccw(c2081.31,5328.69) 2105,5328.69 ccw(c2128.69,5328.69) v2@2111.94,5311.94 ; v2@2100.89,5309.11 ccw(c2090.97,5319.03) 2105,5319.03 ccw(c2119.03,5319.03) v2@2109.11,5309.11 ; v2(2105,5305) 2105,5407.62 v2(2148,5450.62) ; v2@2138.19,5450.62 cw(c2114.5,5450.62) 2131.25,5433.87 cw(c2148,5417.13) v2@2148,5440.81 ; v2@2142.19,5450.62 cw(c2128.16,5450.62) 2138.08,5440.7 cw(c2148,5430.78) v2@2148,5444.81
  MidLayer2 w4: v2@205,5795.19 cw(c205,5771.5) 221.75,5788.25 cw(c238.5,5805) v2@214.81,5805 ; v2@205,5799.19 cw(c205,5785.16) 214.92,5795.08 cw(c224.84,5805) v2@210.81,5805 ; v2(205,5805) 230,5780 1240,5780 1337.73,5877.73 1395.32,5935.32 2258.4,5935.32 2313.72,5880 J13.5@2443.62,5880 ; J13.5@2415.81,5852.18 ccw(c2348.65,5785.03) 2348.65,5880 ccw(c2348.65,5974.97) J13.5@2415.81,5907.82 ; J13.5@2418.63,5855.01 ccw(c2358.31,5794.69) 2358.31,5880 ccw(c2358.31,5965.31) J13.5@2418.63,5904.99 ; J13.5@2421.46,5857.84 ccw(c2367.96,5804.34) 2367.96,5880 ccw(c2367.96,5955.66) J13.5@2421.46,5902.16 ; J13.5@2424.29,5860.67 ccw(c2377.62,5814) 2377.62,5880 ccw(c2377.62,5946) J13.5@2424.29,5899.33 ; J13.5@2427.12,5863.5 ccw(c2387.28,5823.66) 2387.28,5880 ccw(c2387.28,5936.34) J13.5@2427.12,5896.5 ; J13.5@2429.95,5866.33 ccw(c2396.93,5833.31) 2396.93,5880 ccw(c2396.93,5926.69) J13.5@2429.95,5893.67
ADC.CLK: U8.F14 U24.10 | length 8170.2
  Top Layer w4: U24.10@1824.29,5305.63 1862.45,5305.63 1881.86,5325.04 1881.86,5471.86 1899.36,5489.36 1899.36,5630 2056.67,5787.32 2107.32,5787.32 2115,5795 2115,5930 1945,6100 1945,6345 1856.86,6433.14 v1(1856.86,6521.04) ; v1@1850.14,6514.32 cw(c1833.92,6498.11) 1856.86,6498.11 cw(c1879.79,6498.11) v1@1863.57,6514.32 ; v1@1852.97,6517.15 cw(c1843.58,6507.76) 1856.86,6507.76 cw(c1870.14,6507.76) v1@1860.75,6517.15 ; U24.10@1854.58,5302.8 cw(c1861.41,5295.97) 1861.41,5305.63 cw(c1861.41,5315.29) U24.10@1854.58,5308.46 ; v3(5350.63,4544.33) U8.F14@5370.31,4524.65 ; U8.F14@5362.97,4524.65 ccw(c5345.25,4524.65) 5357.78,4537.18 ccw(c5370.31,4549.71) U8.F14@5370.31,4531.99 ; 5363.43,4531.53 cw(c5376.24,4544.33) 5358.13,4544.33 ccw(c5376.24,4544.33) 5363.43,4531.53 ; 5363.43,4531.53 ccw(c5350.63,4518.72) 5350.63,4536.83 cw(c5350.63,4518.72) 5363.43,4531.53
  MidLayer1 w4: v1@1847.36,6521.04 ccw(c1824.42,6521.04) 1840.64,6537.26 ccw(c1856.86,6553.48) v1@1856.86,6530.54 ; v1@1851.36,6521.04 ccw(c1838.08,6521.04) 1847.47,6530.43 ccw(c1856.86,6539.82) v1@1856.86,6526.54 ; v1(1856.86,6521.04) 1813,6564.9 1813,6726.69 1833.31,6747 4716.69,6747 4810,6653.69 4810,6261.71 4830,6241.71 5617.98,6241.71 5702,6157.69 5702,5564.63 5682.19,5544.82 5682.19,5447.39 5480,5245.2 5480,5213.63 5486.5,5207.13 5486.5,5136.65 5503.86,5119.29 5503.86,5116.02 5524.8,5095.07 5530.1,5095.07 5539.48,5085.7 5539.48,5040.99 5445.64,4947.16 5445.64,4938.39 5441,4933.75 5415.19,4907.94 5415.19,4883.37 5373.52,4841.71 5373.52,4822.06 5326.77,4775.3 5326.77,4749.18 5326.77,4741.18 5326.77,4700.75 5326.77,4681.33 5326.77,4607.21 5326.77,4587.71 ccw(c5368.5,4587.71) 5338.99,4558.2 ; v3@5343.16,4544.98 ccw(c5325.12,4546.56) 5338.99,4558.2 ; v3@5351.28,4551.8 cw(c5352.86,4569.84) 5338.99,4558.2
ADC.CS: U8.G1 U24.1 | length 3783.6
  Top Layer w4: 1981.86,5286.67 cw(c2004.66,5286.67) U24.1@1988.54,5302.8 ; 1981.86,5296.33 cw(c1995.01,5296.33) U24.1@1985.71,5305.63 1981.86,5301.78 1981.86,4950.04 v1(2015.19,4916.71) ; v1@2005.69,4916.71 ccw(c1982.76,4916.71) 1998.97,4932.93 ccw(c2015.19,4949.14) v1@2015.19,4926.21 ; v1@2009.69,4916.71 ccw(c1996.41,4916.71) 2005.8,4926.1 ccw(c2015.19,4935.49) v1@2015.19,4922.21 ; v1(4413.86,4516.71) 4415.19,4516.71 4440.35,4541.87 4530.68,4541.87 4556.62,4567.81 4573.77,4567.81 4651.04,4490.55 4688.08,4490.55 4711.12,4513.59 4738.88,4513.59 4767.19,4485.28 4838.82,4485.28 U8.G1@4858.5,4485.28 ; v1@4413.86,4522.21 ccw(c4413.86,4538.7) 4425.52,4527.04 ; v1@4413.86,4526.21 ccw(c4413.86,4552.35) 4432.35,4533.87 ; v1@4423.36,4516.71 cw(c4443.09,4516.71) 4429.14,4530.66 ; 4840.78,4485.28 ccw(c4840.78,4503) 4853.31,4490.47 cw(c4840.78,4503) 4840.78,4485.28 ; 4840.78,4485.28 cw(c4840.78,4467.55) 4853.31,4480.08 ccw(c4840.78,4467.55) 4840.78,4485.28
  MidLayer2 w4: v1(2015.19,4916.71) 3700.9,4916.71 4092.74,4524.87 4351.13,4524.87 4358.29,4517.71 4412.86,4517.71 v1(4413.86,4516.71) ; v1@2019.08,4912.82 cw(c2028.47,4903.43) 2028.47,4916.71 cw(c2028.47,4929.99) v1@2019.08,4920.6 ; v1@2021.91,4909.99 cw(c2038.13,4893.77) 2038.13,4916.71 cw(c2038.13,4939.64) v1@2021.91,4923.43 ; 4388.51,4517.71 cw(c4388.51,4491.36) v1@4407.14,4509.99 ; 4393.34,4517.71 ccw(c4393.34,4537.23) v1@4407.14,4523.43 ; 4398.17,4517.71 cw(c4398.17,4501.02) v1@4409.97,4512.82
ADC.DIN: U8.G2 U24.8 | length 4392.3
  Top Layer w4: U24.8@1794,5342.17 ccw(c1787.17,5335.34) 1787.17,5345 ccw(c1787.17,5354.66) U24.8@1794,5347.83 ; v1@1858.47,5184.99 ccw(c1842.26,5168.77) 1842.26,5191.71 ccw(c1842.26,5214.64) v1@1858.47,5198.43 ; v1@1861.3,5187.82 ccw(c1851.91,5178.43) 1851.91,5191.71 ccw(c1851.91,5204.99) v1@1861.3,5195.6 ; v1(1865.19,5191.71) 1808.29,5191.71 1775,5225 1775,5340 1780,5345 U24.8@1818.8,5345 ; v1@4621.28,4551.28 cw(c4611.85,4541.85) 4625.19,4541.85 ; 4625.19,4528.28 cw(c4657.72,4528.28) v1@4634.72,4551.28 ; 4625.19,4537.94 cw(c4648.06,4537.94) v1@4631.89,4554.11 ; v1(4628,4558) 4625.19,4555.19 4625.19,4527.71 4653.52,4499.37 4654.35,4498.55 4684.76,4498.55 4707.81,4521.59 4742.19,4521.59 4763,4500.78 4828.82,4500.78 4838.82,4500.78 ; U24.8@1818.8,5345 1796.83,5345 U24.8@1818.8,5345 ; U24.8@1818.8,5345 U24.8@1824.29,5345 U24.8@1818.8,5345 ; 4838.82,4500.78 4878.16,4500.78 ; 4838.82,4500.78 4878.16,4500.78 ; 4878.16,4500.78 cw(c4878.16,4490.63) 4885.34,4497.81 ; 4878.16,4500.78 cw(c4878.16,4490.63) 4885.34,4497.81 ; 4885.34,4497.81 cw(c4872.81,4485.28) 4890.53,4485.28 ccw(c4872.81,4485.28) 4885.34,4497.81 ; 4885.34,4497.81 ccw(c4897.87,4510.34) 4897.87,4492.62 cw(c4897.87,4510.34) 4885.34,4497.81
  MidLayer2 w4: v1(1865.19,5191.71) 1931.86,5191.71 1998.52,5258.37 2115.19,5258.37 2131.38,5242.19 2420,5242.19 2448.52,5270.71 2448.52,5366.71 2448.52,5375.04 2465.19,5391.71 2631.86,5391.71 2923.52,5100.04 4262.34,5100.04 4483.5,4878.88 4581.86,4780.52 4583,4779.38 4583.06,4779.31 4583.31,4779.31 4588,4774.63 4588,4774.38 4589.36,4773.01 4589.36,4730.42 4589.36,4663.25 4587.02,4660.92 4587.02,4630 4587.02,4617.58 ; v1@1869.08,5187.82 cw(c1878.47,5178.43) 1878.47,5191.71 cw(c1878.47,5204.99) v1@1869.08,5195.6 ; v1@1871.91,5184.99 cw(c1888.13,5168.77) 1888.13,5191.71 cw(c1888.13,5214.64) v1@1871.91,5198.43 ; 4587,4629.98 4587,4617.56 ; v1@4621.28,4551.28 ccw(c4605.06,4535.06) 4605.06,4558 ccw(c4605.06,4580.93) v1@4621.28,4564.72 ; v1@4624.11,4554.11 ccw(c4614.72,4544.72) 4614.72,4558 ccw(c4614.72,4571.28) v1@4624.11,4561.89 ; 4587,4617.56 4587,4590.5 4587,4573 4602,4558 v1@4619.5,4558 ; v1@4619.5,4558 v1(4628,4558) v1@4619.5,4558