# Altium PCB NB3000AL.PcbDoc (part 58 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
LEDS#.LED5.RED: J28.23 R185.2 U34.8 | length 5537.6
  Top Layer w4: v1@4198.27,3700.79 J28.23@4246.61,3700.79 J28.23@4248.52,3700.79 ; v1@4201.41,3696.15 cw(c4212.6,3684.96) 4212.6,3700.79 ; v1@4204.24,3693.32 cw(c4222.26,3675.3) J28.23@4222.26,3700.79 ; v1@4204.24,3706.76 ccw(c4218.66,3721.17) J28.23@4218.66,3700.79 ; v1@4668.02,3175.04 cw(c4645.09,3175.04) 4661.31,3158.82 cw(c4677.52,3142.61) v1@4677.52,3165.54 ; v1@4672.02,3175.04 cw(c4658.75,3175.04) 4668.14,3165.65 cw(c4677.52,3156.26) v1@4677.52,3169.54 ; v1@4676.24,3173.76 v1(4677.52,3175.04) 4632.02,3129.54 4632.02,3027.57 4632.02,3009.3 4648.19,2993.12 4648.19,2900.37 4706.86,2841.71 v1@4780.19,2841.71 ; 4754.9,2841.71 cw(c4754.9,2813.08) v1@4775.14,2833.32 ; 4762.95,2841.71 ccw(c4762.95,2858.95) v1@4775.14,2846.76 ; 4764.55,2841.71 cw(c4764.55,2822.74) v1@4777.97,2836.15 ; U34.8@7035.68,3013.63 cw(c7028.85,3006.8) 7038.5,3006.8 cw(c7048.16,3006.8) U34.8@7041.33,3013.63 ; U34.8@7038.5,3016.46 7038.5,2881.5 7110,2810 7110,2726.87 7068,2684.87 7068,2618.23 7068,2616 v1(7102,2582) ; v1@7092.5,2582 ccw(c7069.56,2582) 7085.78,2598.22 ccw(c7102,2614.43) v1@7102,2591.5 ; v1@7096.5,2582 ccw(c7083.22,2582) 7092.61,2591.39 ccw(c7102,2600.78) v1@7102,2587.5
  MidLayer2 w4: v1(4115.19,3641.71) 4173.52,3700.04 v1(4197.52,3700.04) ; v1@4115.19,3647.21 ccw(c4115.19,3660.49) 4124.58,3651.1 ccw(c4133.97,3641.71) v1@4120.69,3641.71 ; v1@4115.19,3651.21 ccw(c4115.19,3674.14) 4131.41,3657.93 ccw(c4147.63,3641.71) v1@4124.69,3641.71 ; v1@4190.81,3693.32 ccw(c4174.59,3677.11) 4174.59,3700.04 ccw(c4174.59,3722.98) v1@4190.81,3706.76 ; v1@4193.64,3696.15 ccw(c4184.25,3686.76) 4184.25,3700.04 ccw(c4184.25,3713.32) v1@4193.64,3703.93 ; v1@4529.19,3182.21 cw(c4529.19,3159.27) 4545.41,3175.49 cw(c4561.63,3191.71) v1@4538.69,3191.71 ; v1@4529.19,3186.21 cw(c4529.19,3172.93) 4538.58,3182.32 cw(c4547.97,3191.71) v1@4534.69,3191.71 ; v1(4529.19,3191.71) 4565.9,3155 4657.48,3155 v1(4677.52,3175.04) ; v1@4668.02,3175.04 cw(c4645.09,3175.04) 4661.31,3158.82 cw(c4677.52,3142.61) v1@4677.52,3165.54 ; v1@4672.02,3175.04 cw(c4658.75,3175.04) 4668.14,3165.65 cw(c4677.52,3156.26) v1@4677.52,3169.54
  Bottom Layer w4: v1@4108.47,3634.99 cw(c4092.26,3618.77) 4115.19,3618.77 cw(c4138.13,3618.77) v1@4121.91,3634.99 ; v1@4111.3,3637.82 cw(c4101.91,3628.43) 4115.19,3628.43 cw(c4128.47,3628.43) v1@4119.08,3637.82 ; v1(4115.19,3641.71) 4115.19,3593.77 4140.19,3568.77 4140.19,3491.71 4148.52,3483.37 4148.52,3203.02 4188.5,3163.04 4441.88,3163.04 4466.21,3187.37 4490,3187.37 4494.33,3191.71 v1(4529.19,3191.71) ; v1@4522.47,3184.99 ccw(c4506.26,3168.77) 4506.26,3191.71 ccw(c4506.26,3214.64) v1@4522.47,3198.43 ; v1@4525.3,3187.82 ccw(c4515.91,3178.43) 4515.91,3191.71 ccw(c4515.91,3204.99) v1@4525.3,3195.6 ; R185.2@4656.28,3196.94 cw(c4657.48,3181.46) 4668.46,3192.44 ; R185.2@4665.19,3195.71 4677.52,3183.37 v1(4677.52,3175.04) ; R185.2@4665.5,3198.26 ccw(c4672.4,3198.26) 4667.52,3193.38 ; R185.2@4666.39,3194.5 cw(c4651.73,3179.84) v1@4672.12,3176.05 ; 4671.76,3189.13 cw(c4660.79,3178.16) v1@4676.05,3175.32 ; v1(4781.86,2840.04) 4787.86,2834.04 4989.29,2834.04 4997.75,2842.5 5012.25,2842.5 5020.37,2834.37 5086.82,2834.37 5092.48,2840.04 5099.52,2840.04 5114.52,2825.04 5219.52,2825.04 5272.5,2772.06 5272.5,2767.75 5381.88,2658.37 5440.19,2658.37 5465.19,2683.37 5573.52,2683.37 5581.86,2691.71 5600,2691.71 5614.19,2691.71 5686.11,2691.71 5697.82,2680 5697.82,2645 5697.82,2611.69 5697.82,2605.06 5720,2582.88 5760,2582.88 5774.39,2582.88 5781.18,2582.88 5810.85,2553.21 5855,2553.21 6200.71,2553.21 6242.19,2511.73 6248.68,2505.24 6410.76,2505.24 6419.81,2496.19 6442.69,2496.19 6445.54,2499.04 6455.6,2499.04 6488.82,2499.04 6525,2499.04 6558.84,2499.04 6616.34,2556.54 6776.72,2556.54 6782,2561.81 6856,2561.81 6875,2580.81 6897.37,2580.81 6899.06,2582.5 6946.18,2582.5 6960.94,2582.5 6964.81,2586.37 6989.31,2610.87 7017.07,2610.87 7025.07,2602.87 7060,2602.87 7081.13,2602.87 v1(7102,2582) ; v1@4782.92,2841.1 ccw(c4799.96,2858.15) 4799.96,2834.04 ; v1@4785.75,2843.93 ccw(c4809.62,2867.8) 4809.62,2834.04 ; v1@4788.57,2846.76 ccw(c4819.28,2877.46) 4819.28,2834.04 ; v1@7092.5,2582 ccw(c7069.56,2582) 7085.78,2598.22 ccw(c7102,2614.43) v1@7102,2591.5 ; v1@7096.5,2582 ccw(c7083.22,2582) 7092.61,2591.39 ccw(c7102,2600.78) v1@7102,2587.5
LEDS#.LED6.BLUE: J28.32 R189.2 U35.4 | length 4957.1
  Top Layer w4: J28.32@4323.39,3523.62 4358.19,3523.62 ; J28.32@4349.99,3519.82 cw(c4358.19,3512.88) 4358.19,3523.62 ; J28.32@4349.99,3527.42 ccw(c4358.19,3534.37) 4358.19,3523.62 ; 4461.08,3477.82 ccw(c4474.69,3491.43) v1@4482.26,3473.73 ; 4465.26,3473.64 ccw(c4477.19,3485.57) v1@4483.84,3470.06 ; 4469.44,3469.46 ccw(c4479.7,3479.72) v1@4485.41,3466.38 ; 4473.62,3465.28 ccw(c4482.21,3473.86) v1@4486.98,3462.7 ; v1(4486,3465) 4484.85,3463.85 4475.05,3463.85 4455.03,3483.87 4412.7,3483.87 4412.21,3483.37 4402.52,3483.37 4398.52,3487.37 4398.52,3516.71 4381.86,3533.37 4367.94,3533.37 4358.19,3523.62 ; v1@4643.14,3233.43 ccw(c4626.92,3249.64) 4649.86,3249.64 ccw(c4672.79,3249.64) 4656.57,3233.43 ccw(c4672.79,3249.64) 4672.79,3226.71 ccw(c4672.79,3203.77) v1@4656.57,3219.99 ; v1@4645.97,3230.6 ccw(c4636.58,3239.99) 4649.86,3239.99 ccw(c4663.14,3239.99) 4653.75,3230.6 ccw(c4663.14,3239.99) 4663.14,3226.71 ccw(c4663.14,3213.43) v1@4653.75,3222.82 ; v1@4676.36,3357.37 cw(c4653.42,3357.37) 4669.64,3341.16 cw(c4685.86,3324.94) v1@4685.86,3347.87 ; v1@4680.36,3357.37 cw(c4667.08,3357.37) 4676.47,3347.99 cw(c4685.86,3338.6) v1@4685.86,3351.87 ; v1(4685.86,3357.37) 4649.86,3321.37 v1(4649.86,3226.71) 4693.29,3226.71 4706.86,3213.14 4706.86,3017.71 v1(4740.19,2984.37) ; v1@4730.69,2984.37 ccw(c4707.76,2984.37) 4723.97,3000.59 ccw(c4740.19,3016.81) v1@4740.19,2993.87 ; v1@4734.69,2984.37 ccw(c4721.41,2984.37) 4730.8,2993.76 ccw(c4740.19,3003.15) v1@4740.19,2989.87 ; U35.4@7130,3093.23 7175.04,3093.23 v1(7190.19,3108.37) ; U35.4@7159.31,3090.4 cw(c7166.14,3083.57) 7166.14,3093.23 cw(c7166.14,3102.88) U35.4@7159.31,3096.06
  MidLayer2 w4: v1(5364.86,2975.04) 5452.73,2975.04 5463.5,2985.81 5492.69,2985.81 5499.31,2979.19 5527.46,2979.19 5633.71,2872.94 5633.71,2860.29 5644,2850 5767.13,2850 5798.92,2818.21 6136.79,2818.21 6142.86,2812.14 v1(6142.86,2780.37) ; v1@5368.75,2971.15 cw(c5378.14,2961.76) 5378.14,2975.04 cw(c5378.14,2988.32) v1@5368.75,2978.93 ; v1@5371.57,2968.32 cw(c5387.79,2952.11) 5387.79,2975.04 cw(c5387.79,2997.98) v1@5371.57,2981.76 ; v1@6136.14,2787.09 ccw(c6119.92,2803.31) 6142.86,2803.31 ccw(c6165.79,2803.31) v1@6149.57,2787.09 ; v1@6138.97,2784.26 ccw(c6129.58,2793.65) 6142.86,2793.65 ccw(c6156.14,2793.65) v1@6146.75,2784.26
  Bottom Layer w4: v1(4486,3465) 4519.56,3465 4556.86,3427.71 4556.86,3412.71 4578.2,3391.37 4592.88,3391.37 4596.7,3395.19 4679.81,3395.19 4685.86,3389.14 v1(4685.86,3357.37) ; v1@4489.89,3461.11 cw(c4499.28,3451.72) 4499.28,3465 cw(c4499.28,3478.28) v1@4489.89,3468.89 ; v1@4492.72,3458.28 cw(c4508.93,3442.06) 4508.93,3465 cw(c4508.93,3487.93) v1@4492.72,3471.72 ; v1@4644.74,3234.71 ccw(c4631.35,3255.62) 4656.18,3255.62 4656.18,3228.72 4658.19,3226.71 v1(4649.86,3226.71) ; v1@4646.89,3231.34 ccw(c4636.03,3248.31) R189.2@4656.18,3248.31 ; v1@4649.05,3227.97 ccw(c4640.71,3241) 4656.18,3241 ; R189.2@4652.42,3251.37 cw(c4643.34,3242.29) 4656.18,3242.29 cw(c4669.02,3242.29) R189.2@4659.94,3251.37 ; v1@4679.14,3364.09 ccw(c4662.92,3380.31) 4685.86,3380.31 ccw(c4708.79,3380.31) v1@4692.57,3364.09 ; v1@4681.97,3361.26 ccw(c4672.58,3370.65) 4685.86,3370.65 ccw(c4699.14,3370.65) v1@4689.75,3361.26 ; v1@4738.42,2982.61 ccw(c4756.69,3000.87) 4756.69,2975.04 ; v1(4740.19,2984.37) 4749.52,2975.04 4920.48,2975.04 4995.48,3050.04 5065.19,3050.04 5131.86,2983.37 5151.88,2963.35 5164.86,2950.37 5206.25,2950.37 5214.68,2958.81 5254,2958.81 5271.11,2941.71 5305,2941.71 5338.33,2975.04 v1(5364.86,2975.04) ; v1@4741.25,2985.44 ccw(c4766.35,3010.53) 4766.35,2975.04 ; v1@4744.08,2988.26 ccw(c4776,3020.19) 4776,2975.04 ; v1@4746.91,2991.09 ccw(c4785.66,3029.84) 4785.66,2975.04 ; v1@5358.14,2968.32 ccw(c5341.92,2952.11) 5341.92,2975.04 ccw(c5341.92,2997.98) v1@5358.14,2981.76 ; v1@5360.97,2971.15 ccw(c5351.58,2961.76) 5351.58,2975.04 ccw(c5351.58,2988.32) v1@5360.97,2978.93 ; v1(6142.86,2780.37) 6190.52,2828.04 6309.21,2828.04 6333.71,2803.54 6417.29,2803.54 6455.46,2841.71 6601.51,2841.71 6627.17,2816.04 6828.21,2816.04 6903.21,2891.04 6982.9,2891.04 6989.44,2884.5 7140.15,2884.5 7164.36,2908.71 7164.36,3073.96 7190.19,3099.79 v1(7190.19,3108.37) ; v1@6142.86,2785.87 ccw(c6142.86,2799.15) 6152.25,2789.76 ccw(c6161.64,2780.37) v1@6148.36,2780.37 ; v1@6142.86,2789.87 ccw(c6142.86,2812.81) 6159.07,2796.59 ccw(c6175.29,2780.37) v1@6152.36,2780.37 ; 7168.65,3078.25 ccw(c7139.56,3107.34) v1@7180.69,3108.18 ; 7175.29,3084.89 ccw(c7152.57,3107.61) v1@7184.69,3108.26 ; 7181.92,3091.52 ccw(c7165.57,3107.87) v1@7188.69,3108.34
LEDS#.LED6.GREEN: J28.35 R190.2 U35.6 | length 4365.1
  Top Layer w4: v1@4191.02,3411.37 ccw(c4168.09,3411.37) 4184.31,3427.59 ccw(c4200.52,3443.81) v1@4200.52,3420.87 ; v1@4195.02,3411.37 ccw(c4181.75,3411.37) 4191.13,3420.76 ccw(c4200.52,3430.15) v1@4200.52,3416.87 ; v1(4200.52,3411.37) 4181.86,3430.04 4181.86,3447.9 4198.52,3464.57 J28.35@4246.61,3464.57 ; J28.35@4220.33,3460.41 ccw(c4210.31,3450.39) 4210.31,3464.57 ccw(c4210.31,3478.75) J28.35@4220.33,3468.72 ; U35.6@7130,3042.05 7190,3042.05 7198.52,3033.52 v1(7198.52,2982.37) ; U35.6@7159.31,3039.22 cw(c7166.14,3032.39) 7166.14,3042.05 cw(c7166.14,3051.71) U35.6@7159.31,3044.88 ; v1@7191.81,2989.09 ccw(c7175.59,3005.31) 7198.52,3005.31 ccw(c7221.46,3005.31) v1@7205.24,2989.09 ; v1@7194.64,2986.26 ccw(c7185.25,2995.65) 7198.52,2995.65 ccw(c7211.8,2995.65) v1@7202.41,2986.26
  Bottom Layer w4: v1@4200.52,3401.87 cw(c4200.52,3378.94) 4216.74,3395.16 cw(c4232.96,3411.37) v1@4210.02,3411.37 ; v1@4200.52,3405.87 cw(c4200.52,3392.6) 4209.91,3401.99 cw(c4219.3,3411.37) v1@4206.02,3411.37 ; v1(4200.52,3411.37) 4261.86,3350.04 4396.86,3350.04 4398.52,3351.71 4398.52,3384.37 4405.86,3391.71 4438.86,3391.71 4488.86,3341.71 4626.97,3341.71 R190.2@4656.18,3312.5 4686.05,3312.5 4693.66,3304.89 4693.66,3299.55 4723.19,3270.02 4723.19,3194.1 4723.02,3193.94 4723.02,3126.15 4742.3,3106.87 5029.69,3106.87 5056.69,3133.87 5129.98,3133.87 5154.39,3109.47 5220.28,3109.47 5282.25,3047.5 5567.48,3047.5 5620,2994.98 5620,2966.55 5673.36,2913.19 5764.75,2913.19 5796.59,2881.34 5796.59,2835.45 5765.19,2804.05 5765.19,2789.55 5775.44,2779.3 5789.94,2779.3 5802.66,2792.02 5839.87,2792.02 5842.52,2789.37 5890.19,2741.71 5973.52,2741.71 5990.19,2758.37 6065.19,2758.37 6090.19,2733.37 6274.86,2733.37 6288.55,2747.07 6293.52,2752.04 6407.52,2752.04 6438.86,2783.37 6674.19,2783.37 6682.52,2791.71 6682.69,2791.87 6837.98,2791.87 6912.82,2866.71 6973.29,2866.71 6979.5,2860.5 7200.5,2860.5 7235,2895 7235,2970 7222.63,2982.37 v1(7198.52,2982.37) ; 4639.43,3329.25 ccw(c4656.18,3346) R190.2@4656.18,3322.31 ; 4640.62,3328.06 cw(c4625.55,3312.99) R190.2@4646.86,3312.99 ; R190.2@4646.26,3322.42 ccw(c4656.18,3332.34) R190.2@4656.18,3318.31 ; R190.2@4647.45,3321.23 cw(c4639.21,3312.99) R190.2@4650.86,3312.99 ; R190.2@4659.94,3308.74 cw(c4669.02,3299.66) 4669.02,3312.5 cw(c4669.02,3325.34) R190.2@4659.94,3316.26 ; R190.2@4662.77,3305.91 cw(c4678.68,3290) 4678.68,3312.5 cw(c4678.68,3335) R190.2@4662.77,3319.09
LEDS#.LED6.RED: J28.28 R188.2 U35.2 | length 11633.1
  Top Layer w4: J28.28@4323.39,3602.36 4331.86,3602.36 4331.86,3608.37 4341.52,3608.37 4349.86,3600.04 4414.86,3600.04 4423.52,3591.37 4423.52,3541.37 4473.19,3491.71 4498.52,3491.71 4506.86,3483.37 4506.86,3399.04 v1(4518.86,3387.04) ; J28.28@4346.84,3603.69 ccw(c4355.64,3612.49) 4355.64,3600.04 ; J28.28@4349.67,3598.21 cw(c4354.09,3593.79) 4354.09,3600.04 ; J28.28@4349.67,3606.52 ccw(c4365.3,3622.15) 4365.3,3600.04 ; 7089.68,3134.68 cw(c7103.52,3120.83) U35.2@7103.52,3140.41 ; 7090,3115.19 7090,3135 7099.41,3144.41 U35.2@7130,3144.41 U35.2@7131.86,3144.41 ; 7090.19,3115 7090.19,2925.04 7149.31,2865.92 7170.81,2844.42 7170.81,2826.62 7156.86,2812.67 7156.86,2658.37 7173.52,2641.71 7290.27,2641.71 7296.49,2647.93 7326.79,2647.93 7348.52,2626.2 7348.52,2491.37 7354.95,2484.95 v1(7373.19,2466.71) ; 7096.5,3141.5 cw(c7103.52,3134.49) U35.2@7103.52,3144.41 ; v1@7363.69,2466.71 ccw(c7340.76,2466.71) 7356.97,2482.93 ccw(c7373.19,2499.14) v1@7373.19,2476.21 ; v1@7367.69,2466.71 ccw(c7354.41,2466.71) 7363.8,2476.1 ccw(c7373.19,2485.49) v1@7373.19,2472.21 ; v1@7404.81,2484.99 cw(c7388.59,2468.77) 7411.52,2468.77 cw(c7434.46,2468.77) v1@7418.24,2484.99 ; v1@7407.64,2487.82 cw(c7398.25,2478.43) 7411.52,2478.43 cw(c7424.8,2478.43) v1@7415.41,2487.82 ; v1(7411.52,2491.71) 7411.52,2465.02 7462.24,2414.31 7483.18,2414.31 7535.98,2361.5 7543.25,2361.5 7556.86,2347.89 7556.86,2150.04 7590.19,2116.71 7590.19,2049.32 7566.19,2025.32 7566.19,2005 7554.5,1993.31 7554.5,1964.12 7600.5,1918.12 7600.5,1902.12 7621.12,1881.5 7649.81,1881.5 7685.81,1917.5 7803.56,1917.5 7839.9,1881.16 7839.9,1579.09 7830.19,1569.38 7830.19,1554.62 7840.19,1544.62 7840.19,1446.04 7665.97,1271.81 7662.62,1271.81 7652.19,1261.38 7652.19,512.19 v1(7630,490) ; v1@7630,495.5 ccw(c7630,508.78) 7639.39,499.39 ccw(c7648.78,490) v1@7635.5,490 ; v1@7630,499.5 ccw(c7630,522.43) 7646.22,506.22 ccw(c7662.44,490) v1@7639.5,490
  MidLayer1 w4: 4740.83,3216.01 ccw(c4723.46,3233.37) v1@4748.02,3233.37 ; 4742.45,3217.63 cw(c4757.52,3202.56) v1@4757.52,3223.87 ; 4747.66,3222.84 ccw(c4737.12,3233.37) v1@4752.02,3233.37 ; 4749.28,3224.46 cw(c4757.52,3216.22) v1@4757.52,3227.87 ; v1@4757.85,3233.04 4723.52,3198.71 4723.52,3175.04 4740.19,3158.37 4798.52,3158.37 4807.52,3149.37 4807.52,2775.71 4656.86,2625.04 4656.86,1915 4606.52,1864.67 4606.52,1038.48 4619.96,1025.04 4690,1025.04 4700,1035.04 4700,1064.2 4797.8,1162 4872.27,1162 5032.19,1002.08 5032.19,294.12 5176.31,150 5645,150 5730,235 6263.69,235 6389.98,108.71 7460.02,108.71 7485.34,134.02 7485.34,241.81 7467.5,259.65 7467.5,437.5 7520,490 v1(7630,490) ; v1@7623.28,483.28 ccw(c7607.06,467.06) 7607.06,490 ccw(c7607.06,512.93) v1@7623.28,496.72 ; v1@7626.11,486.11 ccw(c7616.72,476.72) 7616.72,490 ccw(c7616.72,503.28) v1@7626.11,493.89
  MidLayer2 w4: v1@7366.8,2473.74 ccw(c7353.65,2488.19) 7373.19,2488.19 ; v1@7369.49,2470.78 ccw(c7361.88,2479.14) 7373.19,2479.14 ccw(c7384.5,2479.14) v1@7376.89,2470.78 ; v1(7373.19,2466.71) 7373.19,2488.19 ; v1@7379.58,2473.74 cw(c7392.73,2488.19) 7373.19,2488.19 ; v1@7404.81,2484.99 ccw(c7388.59,2468.77) 7388.59,2491.71 ccw(c7388.59,2514.64) v1@7404.81,2498.43 ; v1@7407.64,2487.82 ccw(c7398.25,2478.43) 7398.25,2491.71 ccw(c7398.25,2504.99) v1@7407.64,2495.6 ; v1(7411.52,2491.71) 7376.71,2491.71 7373.19,2488.19
  Bottom Layer w4: v1(4518.86,3387.04) 4523.52,3391.71 4566.54,3391.71 4576.32,3381.93 4594.76,3381.93 4600.01,3387.19 4638.37,3387.19 R188.2@4656.18,3369.38 ; v1@4519.92,3385.98 cw(c4533.75,3372.15) 4533.75,3391.71 ; v1@4522.75,3383.15 cw(c4543.4,3362.5) 4543.4,3391.71 ; v1@4525.57,3380.32 cw(c4553.06,3352.84) 4553.06,3391.71 ; v1@4525.57,3393.76 ccw(c4530.53,3398.71) 4530.53,3391.71 ; 4639.43,3386.12 ccw(c4656.18,3402.87) R188.2@4656.18,3379.19 ; 4640.62,3384.94 cw(c4625.55,3369.87) R188.2@4646.86,3369.87 ; R188.2@4646.26,3379.29 ccw(c4656.18,3389.21) R188.2@4656.18,3375.19 ; R188.2@4647.45,3378.11 cw(c4639.21,3369.87) R188.2@4650.86,3369.87 ; R188.2@4656.86,3358.37 4675.52,3339.71 4715.19,3339.71 4731.19,3323.71 4731.19,3281.71 4757.52,3255.38 ; R188.2@4657.45,3368.51 ccw(c4671.35,3364.39) 4661.1,3354.13 ; R188.2@4661.28,3367.37 ccw(c4678.69,3362.22) 4665.85,3349.38 ; R188.2@4665.12,3366.24 ccw(c4686.03,3360.05) 4670.61,3344.62 ; v1@4751,3240.29 ccw(c4736.79,3255.38) 4757.52,3255.38 ; v1@4753.75,3237.38 ccw(c4745.52,3246.11) 4757.52,3246.11 ccw(c4769.52,3246.11) v1@4761.29,3237.38 ; v1(4757.52,3233.38) 4757.52,3255.38 ; v1@4764.03,3240.29 cw(c4778.25,3255.38) 4757.52,3255.38
LEDS#.LED7.BLUE: J28.36 R192.2 U35.10 | length 7887
  Top Layer w4: J28.36@4323.39,3444.88 4337.7,3444.88 4367.86,3475.04 4415.19,3475.04 v1@4431.86,3458.37 ; J28.36@4343.39,3444.88 cw(c4357.12,3444.88) 4347.41,3454.59 ; J28.36@4347.39,3444.88 cw(c4370.77,3444.88) 4354.24,3461.42 ; J28.36@4351.39,3444.88 cw(c4384.43,3444.88) 4361.06,3468.25 ; 4420.27,3469.96 cw(c4405.58,3455.27) v1@4426.36,3455.09 ; 4421.33,3468.9 ccw(c4431.86,3479.43) v1@4431.86,3464.54 ; v1@4576.86,3446.87 cw(c4576.86,3423.94) 4593.07,3440.16 cw(c4609.29,3456.37) v1@4586.36,3456.37 ; v1@4576.86,3450.87 cw(c4576.86,3437.6) 4586.25,3446.99 cw(c4595.64,3456.37) v1@4582.36,3456.37 ; v1(4576.86,3456.37) 4606.86,3426.37 4606.86,3175.04 4594.07,3162.26 4560.3,3162.26 4532.02,3133.97 4532.02,3081.45 4532.02,3075 4532.02,3049.97 4532.02,2686.19 4537.85,2680.36 4698.52,2519.69 v2(4698.52,1955) ; v1@6722.3,1354.12 ccw(c6706.08,1370.34) 6729.02,1370.34 ccw(c6751.95,1370.34) v1@6735.74,1354.12 ; v1@6725.13,1351.29 ccw(c6715.74,1360.68) 6729.02,1360.68 ccw(c6742.3,1360.68) v1@6732.91,1351.29 ; v1(6729.02,1347.4) 6729.02,1400.21 6750.62,1421.81 6809.35,1421.81 6828.69,1402.47 6841.34,1402.47 6847.86,1408.99 6866.01,1408.99 6890.81,1384.19 6969.19,1384.19 7016.81,1431.81 7063,1431.81 7086.62,1408.19 7111.06,1408.19 7145.13,1374.12 7312.69,1374.12 7396.81,1290 7438.23,1290 7452.12,1303.88 7452.12,1373.88 ; U35.10@7348.5,3066.71 7373.52,3066.71 7390.19,3050.04 7390.19,2941.71 7323.52,2875.04 7322.38,2873.89 7322.38,2676.44 7356.86,2641.96 7356.86,2508.37 7454,2411.23 7454,2340.38 7465.81,2328.57 7465.81,2313.81 7461.81,2309.81 7461.81,2139.63 7446.19,2124 7446.19,2096 7454.18,2088.01 7454.18,1991.99 7448.19,1986 7448.19,1938.68 7470,1916.87 7470,1888.5 7462.19,1880.69 7462.19,1815.63 7488.31,1789.5 7488.31,1761 7479.93,1752.62 7479.93,1675 ; U35.10@7378.98,3067.64 ccw(c7394.41,3067.64) 7383.5,3056.73 ; 7452,1374 7452,1594.18 7479.93,1622.12 7479.93,1680.19
  MidLayer1 w4: v1(4431.86,3455.04) v1(4493.52,3516.71) ; v1@4431.86,3460.54 ccw(c4431.86,3473.82) 4441.25,3464.43 ccw(c4450.64,3455.04) v1@4437.36,3455.04 ; v1@4431.86,3464.54 ccw(c4431.86,3487.48) 4448.07,3471.26 ccw(c4464.29,3455.04) v1@4441.36,3455.04 ; v1@4484.02,3516.71 cw(c4461.09,3516.71) 4477.31,3500.49 cw(c4493.52,3484.27) v1@4493.52,3507.21 ; v1@4488.02,3516.71 cw(c4474.75,3516.71) 4484.14,3507.32 cw(c4493.52,3497.93) v1@4493.52,3511.21
  MidLayer2 w4: v2(4698.52,1955) 4728.94,1955 5008.13,1675.81 5467.32,1675.81 5522.8,1620.33 5621.63,1521.5 5742.88,1521.5 5754.92,1533.54 5873.65,1533.54 5890.15,1517.04 6005.85,1517.04 6022.62,1533.81 6037.38,1533.81 6053.38,1517.81 6166.62,1517.81 6171.62,1522.81 6188.38,1522.81 6193.38,1517.81 6210.88,1517.81 6248.62,1480.06 6307.88,1420.81 6354.69,1420.81 6366.62,1408.88 6393.41,1408.88 6452.41,1349.88 6473.79,1349.88 6499.42,1375.5 6700.92,1375.5 v1(6729.02,1347.4) ; v2@4702.63,1950.89 cw(c4712.55,1940.97) 4712.55,1955 cw(c4712.55,1969.03) v2@4702.63,1959.11 ; v2@4705.46,1948.06 cw(c4722.21,1931.31) 4722.21,1955 cw(c4722.21,1978.69) v2@4705.46,1961.94 ; v1@6719.52,1347.4 ccw(c6696.58,1347.4) 6712.8,1363.62 ccw(c6729.02,1379.84) v1@6729.02,1356.9 ; v1@6723.52,1347.4 ccw(c6710.24,1347.4) 6719.63,1356.79 ccw(c6729.02,1366.18) v1@6729.02,1352.9
  Bottom Layer w4: v1(4493.52,3516.71) 4516.52,3516.71 v1(4576.86,3456.37) ; v1@4497.41,3512.82 cw(c4506.8,3503.43) 4506.8,3516.71 cw(c4506.8,3529.99) v1@4497.41,3520.6 ; v1@4500.24,3509.99 cw(c4516.46,3493.77) 4516.46,3516.71 cw(c4516.46,3539.64) v1@4500.24,3523.43 ; v1@4567.36,3456.37 ccw(c4544.42,3456.37) 4560.64,3472.59 ccw(c4576.86,3488.81) v1@4576.86,3465.87 ; v1@4571.36,3456.37 ccw(c4558.08,3456.37) 4567.47,3465.76 ccw(c4576.86,3475.15) v1@4576.86,3461.87 ; v1@4580.75,3452.49 cw(c4594.96,3438.27) 4594.96,3458.37 cw(c4594.96,3474.48) v1@4583.57,3463.09 ; v1@4581.86,3458.37 4630.86,3458.37 4655.86,3433.37 4656.18,3433.37 R192.2@4656.18,3426.25 ; v1@4583.57,3449.66 cw(c4604.62,3428.61) 4604.62,3458.37 ; 4635.81,3453.42 cw(c4609.13,3426.74) R192.2@4646.86,3426.74 ; 4642.64,3446.59 cw(c4622.79,3426.74) R192.2@4650.86,3426.74 ; 4649.47,3439.76 cw(c4636.45,3426.74) R192.2@4654.86,3426.74 ; 4651.04,3438.19 ccw(c4656.18,3443.33) R192.2@4656.18,3436.06 ; R192.2@4656.18,3426.25 4656.18,3425.76 R192.2@4656.18,3426.25
LEDS#.LED7.GREEN: J28.30 R193.2 U35.12 | length 6213.8
  Top Layer w4: J28.30@4323.39,3562.99 4361.19,3562.99 4367.34,3556.84 4378.66,3556.84 v1(4400.52,3578.71) ; J28.30@4349.67,3558.84 cw(c4359.69,3548.81) 4359.69,3562.99 cw(c4359.69,3577.17) J28.30@4349.67,3567.15 ; v1(4637.52,3511.04) 4657.19,3491.37 4657.19,3396.73 4678.88,3375.04 4700.9,3375.04 4706.86,3369.08 4706.86,3345.37 4681.86,3320.37 4681.86,3296.04 4715.19,3262.71 4715.19,3108.37 v1(4765.19,3058.37) ; v1(5445,2925) 5466.5,2903.5 v1@5537.5,2903.5 ; U35.12@7348.5,3118.82 7463.75,3118.82 v1(7481.86,3100.71) ; U35.12@7377.81,3115.99 cw(c7384.64,3109.16) 7384.64,3118.82 cw(c7384.64,3128.48) U35.12@7377.81,3121.65 ; 4384.31,3562.49 cw(c4400.52,3546.27) 4400.52,3569.21 ccw(c4400.52,3546.27) 4384.31,3562.49 ; 4384.31,3562.49 ccw(c4368.09,3578.71) 4391.02,3578.71 cw(c4368.09,3578.71) 4384.31,3562.49 ; 4391.14,3569.32 cw(c4400.52,3559.93) 4400.52,3573.21 ccw(c4400.52,3559.93) 4391.14,3569.32 ; 4391.14,3569.32 ccw(c4381.75,3578.71) 4395.02,3578.71 cw(c4381.75,3578.71) 4391.14,3569.32 ; 4646.91,3501.65 cw(c4656.3,3511.04) 4643.02,3511.04 ccw(c4656.3,3511.04) 4646.91,3501.65 ; 4646.91,3501.65 ccw(c4637.52,3492.26) 4637.52,3505.54 cw(c4637.52,3492.26) 4646.91,3501.65 ; 4653.74,3494.82 cw(c4669.96,3511.04) 4647.02,3511.04 ccw(c4669.96,3511.04) 4653.74,3494.82 ; 4653.74,3494.82 ccw(c4637.52,3478.61) 4637.52,3501.54 cw(c4637.52,3478.61) 4653.74,3494.82 ; 4748.97,3074.59 cw(c4732.76,3058.37) 4755.69,3058.37 ccw(c4732.76,3058.37) 4748.97,3074.59 ; 4748.97,3074.59 ccw(c4765.19,3090.81) 4765.19,3067.87 cw(c4765.19,3090.81) 4748.97,3074.59 ; 4755.8,3067.76 cw(c4746.41,3058.37) 4759.69,3058.37 ccw(c4746.41,3058.37) 4755.8,3067.76 ; 4755.8,3067.76 ccw(c4765.19,3077.15) 4765.19,3063.87 cw(c4765.19,3077.15) 4755.8,3067.76 ; 7465.64,3116.93 cw(c7449.42,3100.71) 7472.36,3100.71 ccw(c7449.42,3100.71) 7465.64,3116.93 ; 7465.64,3116.93 ccw(c7481.86,3133.14) 7481.86,3110.21 cw(c7481.86,3133.14) 7465.64,3116.93 ; 7472.47,3110.1 cw(c7463.08,3100.71) 7476.36,3100.71 ccw(c7463.08,3100.71) 7472.47,3110.1 ; 7472.47,3110.1 ccw(c7481.86,3119.49) 7481.86,3106.21 cw(c7481.86,3119.49) 7472.47,3110.1 ; 5508.62,2903.5 cw(c5508.62,2868.62) 5533.28,2893.28 ccw(c5508.62,2868.62) 5508.62,2903.5 ; 5518.27,2903.5 cw(c5518.27,2878.27) 5536.11,2896.11 ccw(c5518.27,2878.27) 5518.27,2903.5 ; 5525.51,2903.5 ccw(c5525.51,2914.49) 5533.28,2906.72 cw(c5525.51,2914.49) 5525.51,2903.5 ; 5527.93,2903.5 cw(c5527.93,2887.93) 5538.94,2898.94 ccw(c5527.93,2887.93) 5527.93,2903.5
  MidLayer1 w4: v1@4640.19,3513.71 v1(4640.19,3616.71) ; 4640.19,3593.77 cw(c4663.13,3593.77) 4646.91,3609.99 ccw(c4663.13,3593.77) 4640.19,3593.77 ; 4640.19,3593.77 ccw(c4617.26,3593.77) 4633.47,3609.99 cw(c4617.26,3593.77) 4640.19,3593.77 ; 4640.19,3603.43 cw(c4653.47,3603.43) 4644.08,3612.82 ccw(c4653.47,3603.43) 4640.19,3603.43 ; 4640.19,3603.43 ccw(c4626.91,3603.43) 4636.3,3612.82 cw(c4626.91,3603.43) 4640.19,3603.43 ; v1@4630.81,3517.76 ccw(c4608.15,3540.41) 4640.19,3540.41 cw(c4608.15,3540.41) v1@4630.81,3517.76 ; v1@4633.64,3514.93 ccw(c4617.81,3530.76) 4640.19,3530.76 cw(c4617.81,3530.76) v1@4633.64,3514.93 ; 4640.19,3527.54 ccw(c4654.02,3527.54) 4644.24,3517.76 cw(c4654.02,3527.54) 4640.19,3527.54
  MidLayer2 w4: v1(4400.52,3578.71) 4435.33,3578.71 4440,3583.37 4606.86,3583.37 v1(4640.19,3616.71) ; 4413.8,3578.71 cw(c4413.8,3591.99) 4404.41,3582.6 ccw(c4413.8,3591.99) 4413.8,3578.71 ; 4413.8,3578.71 ccw(c4413.8,3565.43) 4404.41,3574.82 cw(c4413.8,3565.43) 4413.8,3578.71 ; 4423.46,3578.71 cw(c4423.46,3601.64) 4407.24,3585.43 ccw(c4423.46,3601.64) 4423.46,3578.71 ; 4423.46,3578.71 ccw(c4423.46,3555.77) 4407.24,3571.99 cw(c4423.46,3555.77) 4423.46,3578.71 ; 4623.97,3600.49 cw(c4640.19,3584.27) 4640.19,3607.21 ccw(c4640.19,3584.27) 4623.97,3600.49 ; 4623.97,3600.49 ccw(c4607.76,3616.71) 4630.69,3616.71 cw(c4607.76,3616.71) 4623.97,3600.49 ; 4630.8,3607.32 cw(c4640.19,3597.93) 4640.19,3611.21 ccw(c4640.19,3597.93) 4630.8,3607.32 ; 4630.8,3607.32 ccw(c4621.41,3616.71) 4634.69,3616.71 cw(c4621.41,3616.71) 4630.8,3607.32
  Bottom Layer w4: v1(4637.52,3511.04) 4654.19,3511.04 ; R193.2@4649.59,3490.21 ccw(c4633.68,3506.12) 4656.18,3506.12 ccw(c4678.68,3506.11) R193.2@4662.77,3490.21 ; R193.2@4652.42,3487.38 ccw(c4643.34,3496.46) 4656.18,3496.46 ccw(c4669.02,3496.46) R193.2@4659.94,3487.38 ; R193.2@4656.18,3483.12 4656.18,3509.05 4654.19,3511.04 ; v1(4765.19,3058.37) 4781.86,3041.71 4941.9,3041.71 4983.06,3082.87 5077.61,3082.87 5095.24,3065.25 5164.67,3065.25 5191.65,3065.25 5256.86,3000.04 5323.52,3000.04 5341.48,3018 5354.98,3031.5 5401.25,3031.5 5445,2987.75 v1(5445,2925) ; v1@5541,2900 5573.36,2867.64 5573.36,2861.16 5601.52,2833 5642.83,2833 5683.62,2792.21 5692.42,2792.21 5700.11,2784.52 5721.59,2784.52 5773.52,2732.59 5773.52,2662.85 5776.98,2659.39 5776.98,2632.33 5823.61,2585.71 6475.86,2585.71 6506.86,2616.71 6675.5,2616.71 6686.3,2627.5 6812.75,2627.5 6848.75,2663.5 6863.25,2663.5 6878.25,2648.5 6907.19,2648.5 6928.19,2627.5 6949.37,2627.5 6972.75,2650.87 7033.63,2650.87 7041.63,2642.87 7121.71,2642.87 7379.04,2900.2 7391.99,2900.2 7392.15,2900.04 7458.94,2900.04 7483.02,2924.13 7483.02,3099.54 v1(7481.86,3100.71) ; 7483.02,3074.96 ccw(c7456.1,3074.96) 7475.14,3093.99 cw(c7458.92,3077.77) 7481.86,3077.77 cw(c7504.79,3077.77) 7488.57,3093.99 ccw(c7501.97,3080.59) 7483.02,3080.59 ; 7483.02,3084.61 ccw(c7465.76,3084.61) 7477.97,3096.82 cw(c7468.58,3087.43) 7481.86,3087.43 cw(c7495.14,3087.43) v1@7485.75,3096.82 ; 4654.19,3511.04 cw(c4654.19,3520.91) 4645.7,3515.88 ccw(c4654.19,3520.91) 4654.19,3511.04 ; 4654.19,3511.04 ccw(c4654.19,3501.17) 4645.7,3506.2 cw(c4654.19,3501.17) 4654.19,3511.04 ; 4774.58,3048.99 cw(c4783.97,3058.37) 4770.69,3058.37 ccw(c4783.97,3058.37) 4774.58,3048.99 ; 4774.58,3048.99 ccw(c4765.19,3039.6) 4765.19,3052.87 cw(c4765.19,3039.6) 4774.58,3048.99 ; 4781.41,3042.16 cw(c4797.63,3058.37) 4774.69,3058.37 ccw(c4797.63,3058.37) 4781.41,3042.16 ; 4781.41,3042.16 ccw(c4765.19,3025.94) 4765.19,3048.87 cw(c4765.19,3025.94) 4781.41,3042.16 ; 5445,2938.28 cw(c5431.72,2938.28) 5441.11,2928.89 ccw(c5431.72,2938.28) 5445,2938.28 ; 5445,2938.28 ccw(c5458.28,2938.28) 5448.89,2928.89 cw(c5458.28,2938.28) 5445,2938.28 ; 5445,2947.93 cw(c5422.06,2947.93) 5438.28,2931.72 ccw(c5422.06,2947.93) 5445,2947.93 ; 5445,2947.93 ccw(c5467.93,2947.93) 5451.72,2931.72 cw(c5467.93,2947.93) 5445,2947.93 ; v1@5540,2890.5 cw(c5540,2865.15) 5557.92,2883.08 ccw(c5540,2865.15) v1@5540,2890.5 ; v1@5540,2894.5 cw(c5540,2878.81) 5551.1,2889.9 ccw(c5540,2878.81) v1@5540,2894.5 ; v1@5545.5,2900 ccw(c5556.36,2900) 5548.68,2892.32 cw(c5556.36,2900) v1@5545.5,2900 ; v1@5549.5,2900 ccw(c5570.02,2900) 5555.51,2885.49 cw(c5570.02,2900) v1@5549.5,2900
  other v1: 5540,2900
LEDS#.LED7.RED: J28.34 R191.2 U35.8 | length 5224.7
  Top Layer w4: J28.34@4323.39,3484.25 4365.52,3484.25 4373.52,3492.25 ; J28.34@4349.67,3480.1 cw(c4359.69,3470.07) 4359.69,3484.25 cw(c4359.69,3498.43) J28.34@4349.67,3488.41 ; v1@4367.89,3503.39 cw(c4359.7,3492.25) 4373.52,3492.25 ; v1(4373.52,3511.04) 4373.52,3492.25 ; v1@4379.16,3503.39 ccw(c4387.35,3492.25) 4373.52,3492.25 ; v1@4775.14,3493.32 cw(c4758.92,3477.11) 4781.86,3477.11 cw(c4804.79,3477.11) v1@4788.57,3493.32 ; v1@4777.97,3496.15 cw(c4768.58,3486.76) 4781.86,3486.76 cw(c4795.14,3486.76) v1@4785.75,3496.15 ; v1(4781.86,3500.04) 4781.86,3458.33 4790.19,3450 4790.19,3311.12 4813.81,3287.5 4832.56,3287.5 4847.5,3272.56 4847.5,3217.66 4822.86,3193.02 4822.86,2934.04 v1(4873.52,2883.37) ; v1@4864.02,2883.37 ccw(c4841.09,2883.37) 4857.31,2899.59 ccw(c4873.52,2915.81) v1@4873.52,2892.87 ; v1@4868.02,2883.37 ccw(c4854.75,2883.37) 4864.14,2892.76 ccw(c4873.52,2902.15) v1@4873.52,2888.87 ; v1(6665.19,2645.71) 6719.29,2645.71 6731.86,2633.14 v1(6731.86,2600.04) ; v1@6669.08,2641.82 cw(c6678.47,2632.43) 6678.47,2645.71 cw(c6678.47,2658.99) v1@6669.08,2649.6 ; v1@6671.91,2638.99 cw(c6688.13,2622.77) 6688.13,2645.71 cw(c6688.13,2668.64) v1@6671.91,2652.43 ; v1@6725.14,2606.76 ccw(c6708.92,2622.98) 6731.86,2622.98 ccw(c6754.79,2622.98) v1@6738.57,2606.76 ; v1@6727.97,2603.93 ccw(c6718.58,2613.32) 6731.86,2613.32 ccw(c6745.14,2613.32) v1@6735.75,2603.93 ; v1@7228.19,3002.54 cw(c7228.19,2979.61) 7244.41,2995.82 cw(c7260.63,3012.04) v1@7237.69,3012.04 ; v1@7228.19,3006.54 cw(c7228.19,2993.26) 7237.58,3002.65 cw(c7246.97,3012.04) v1@7233.69,3012.04 ; v1(7228.19,3012.04) 7248.52,2991.71 7248.52,2943.37 7250.19,2941.71 7331.86,2941.71 7348.52,2958.37 U35.8@7348.5,3016.46 ; U35.8@7345.68,3013.63 cw(c7338.8,3006.75) 7348.52,3006.75 ; 7348.52,3006.85 cw(c7358.11,3006.85) U35.8@7351.33,3013.63 ; U35.8@7348.5,3016.46 7348.52,3016.71 U35.8@7348.5,3016.46
  MidLayer1 w4: v1(6731.86,2600.04) 6890.19,2758.37 6890.19,2877.06 7025.17,3012.04 v1(7228.19,3012.04) ; v1@6731.86,2605.54 ccw(c6731.86,2618.82) 6741.25,2609.43 ccw(c6750.64,2600.04) v1@6737.36,2600.04 ; v1@6731.86,2609.54 ccw(c6731.86,2632.48) 6748.07,2616.26 ccw(c6764.29,2600.04) v1@6741.36,2600.04 ; v1@7221.47,3005.32 ccw(c7205.26,2989.11) 7205.26,3012.04 ccw(c7205.26,3034.98) v1@7221.47,3018.76 ; v1@7224.3,3008.15 ccw(c7214.91,2998.76) 7214.91,3012.04 ccw(c7214.91,3025.32) v1@7224.3,3015.93
  Bottom Layer w4: v1(4373.52,3511.04) 4384.52,3511.04 4398.52,3525.04 ; v1@4374.02,3512.46 ccw(c4378.92,3526.59) 4389.5,3516.01 ; v1@4375.33,3516.24 ccw(c4381.25,3533.29) 4394.01,3520.53 ; v1@4376.64,3520.02 ccw(c4383.57,3539.99) 4398.52,3525.04 ; 4639.43,3556.75 ccw(c4656.18,3573.5) R191.2@4656.18,3549.81 ; 4640.62,3555.56 cw(c4625.55,3540.49) R191.2@4646.86,3540.49 ; R191.2@4646.26,3549.92 ccw(c4656.18,3559.84) R191.2@4656.18,3545.81 ; R191.2@4647.45,3548.73 cw(c4639.21,3540.49) R191.2@4650.86,3540.49 ; R191.2@4657.76,3530.32 cw(c4660.05,3516.96) 4669.63,3526.55 cw(c4679.96,3536.88) R191.2@4665.44,3538.48 ; v1@4775.14,3493.32 ccw(c4758.92,3477.11) 4758.92,3500.04 ccw(c4758.92,3522.98) v1@4775.14,3506.76 ; v1@4777.97,3496.15 ccw(c4768.58,3486.76) 4768.58,3500.04 ccw(c4768.58,3513.32) v1@4777.97,3503.93 ; v1(4781.86,3500.04) 4753.87,3500.04 4734.4,3519.52 4676.67,3519.52 R191.2@4656.18,3540 4629.47,3566.71 4523.52,3566.71 4515.19,3575.04 4423.52,3575.04 4398.52,3550.04 4398.52,3525.04 ; v1@4873.52,2873.87 cw(c4873.52,2850.94) 4889.74,2867.16 cw(c4905.96,2883.37) v1@4883.02,2883.37 ; v1@4873.52,2877.87 cw(c4873.52,2864.6) 4882.91,2873.99 cw(c4892.3,2883.37) v1@4879.02,2883.37 ; v1(4873.52,2883.37) 4890.52,2866.37 4976.37,2866.37 4984.5,2874.5 5025.5,2874.5 5033.63,2866.37 5073.56,2866.37 5081.56,2874.37 5089.56,2874.37 5110.99,2895.8 5320.04,2895.8 5322.29,2893.54 5343.42,2893.54 5382.68,2893.54 5405,2915.86 5429.39,2915.86 5438.68,2906.57 5479.69,2906.57 5506.62,2933.5 5555.97,2933.5 5596.93,2892.54 5614.11,2892.54 5649.11,2857.54 5691.22,2857.54 5691.39,2857.38 5715.06,2857.38 5729.93,2842.51 5729.93,2790.07 5781.52,2738.48 5781.52,2666.16 5784.98,2662.71 5784.98,2635.65 5826.92,2593.71 6243.19,2593.71 6274.52,2625.04 6348.52,2625.04 6373.52,2600.04 6393.04,2600.04 6404.5,2611.5 6404.5,2616.25 6432.45,2644.2 6484.34,2644.2 6495.5,2633.04 6617.33,2633.04 6630,2645.71 v1(6665.19,2645.71) ; v1@6658.47,2638.99 ccw(c6642.26,2622.77) 6642.26,2645.71 ccw(c6642.26,2668.64) v1@6658.47,2652.43 ; v1@6661.3,2641.82 ccw(c6651.91,2632.43) 6651.91,2645.71 ccw(c6651.91,2658.99) v1@6661.3,2649.6
LINEAOUT_L: R137.2 R144.1 U26.4 | length 757.1
  Top Layer w4: U26.4@-389.13,5050 -332.81,5050 ; U26.4@-351.46,5046 cw(c-342.13,5037.13) -342.13,5050 cw(c-342.13,5062.87) U26.4@-351.46,5054 ; U26.4@-348.56,5043.24 cw(c-332.81,5028.28) -332.81,5050 ; U26.4@-348.56,5056.76 ccw(c-332.81,5071.72) -332.81,5050 ; -332.77,5050.04 v1(-317.14,5050.04)
  Bottom Layer w4: v1@-323.86,5056.76 ccw(c-340.08,5072.98) -317.14,5072.98 ccw(c-294.21,5072.98) v1@-310.43,5056.76 ; v1@-321.03,5053.93 ccw(c-330.42,5063.32) -317.14,5063.32 ccw(c-303.86,5063.32) v1@-313.25,5053.93 ; v1(-317.14,5050.04) -317.14,5075 -270,5122.14 -270,5225 -250,5245 -250,5320 -237.42,5332.58 R144.1@-203.21,5332.58 R137.2@-203.21,5388.42 ; R144.1@-209.8,5325.99 ccw(c-225.71,5310.08) -225.71,5332.58 ccw(c-225.71,5355.08) R144.1@-209.8,5339.17 ; R144.1@-209.8,5339.66 ccw(c-225.71,5355.57) -203.21,5355.57 ccw(c-180.71,5355.57) R144.1@-196.62,5339.66 ; R137.2@-209.8,5381.33 cw(c-225.71,5365.43) -203.21,5365.43 cw(c-180.71,5365.43) R137.2@-196.62,5381.33 ; R144.1@-206.97,5328.82 ccw(c-216.05,5319.74) -216.05,5332.58 ccw(c-216.05,5345.42) R144.1@-206.97,5336.34 ; R144.1@-206.97,5336.84 ccw(c-216.05,5345.91) -203.21,5345.91 ccw(c-190.37,5345.91) R144.1@-199.45,5336.84 ; R137.2@-206.97,5384.16 cw(c-216.05,5375.08) -203.21,5375.08 cw(c-190.37,5375.08) R137.2@-199.45,5384.16
LINEAOUT_R: R138.2 R143.1 U26.7 | length 1606.7
  Top Layer w4: U26.7@-395,4900 U26.7@-389.13,4900 -348,4900 v1(-328,4880) ; U26.7@-355.67,4898.19 cw(c-355.67,4875.3) -339.49,4891.49 ; U26.7@-345.86,4900 ccw(c-340.69,4900) U26.7@-344.34,4896.34 ; v1@-337.5,4880 ccw(c-360.44,4880) -344.22,4896.22 ccw(c-328,4912.43) v1@-328,4889.5 ; v1@-333.5,4880 ccw(c-346.78,4880) -337.39,4889.39 ccw(c-328,4898.78) v1@-328,4885.5
  MidLayer1 w4: v1@-334.72,4873.28 ccw(c-350.94,4857.06) -350.94,4880 ccw(c-350.94,4902.93) v1@-334.72,4886.72 ; v1@-331.89,4876.11 ccw(c-341.28,4866.72) -341.28,4880 ccw(c-341.28,4893.28) v1@-331.89,4883.89 ; v1(-328,4880) -354,4880 -364,4890 -364,5171 v1(-280,5255) ; v1@-289.5,5255 cw(c-312.44,5255) -296.22,5238.78 cw(c-280,5222.56) v1@-280,5245.5 ; v1@-285.5,5255 cw(c-298.78,5255) -289.39,5245.61 cw(c-280,5236.22) v1@-280,5249.5
  MidLayer2 w4: v1(-280,5255) -248.14,5255 -217.81,5285.33 ; v1@-276.11,5251.11 cw(c-266.72,5241.72) -266.72,5255 cw(c-266.72,5268.28) v1@-276.11,5258.89 ; v1@-273.28,5248.28 cw(c-257.07,5232.06) -257.07,5255 cw(c-257.07,5277.93) v1@-273.28,5261.72 ; v1@-223.52,5296.78 cw(c-232.14,5285.33) -217.81,5285.33 ; v1@-213.92,5300.49 cw(c-204.53,5291.1) -204.53,5304.37 cw(c-204.53,5317.65) v1@-213.92,5308.26 ; v1@-212.1,5296.78 ccw(c-203.48,5285.33) -217.81,5285.33 ; v1@-211.09,5297.66 cw(c-194.87,5281.44) -194.87,5304.37 cw(c-194.87,5327.31) v1@-211.09,5311.09 ; v1@16.81,5164.99 ccw(c0.59,5148.77) 0.59,5171.71 ccw(c0.59,5194.64) v1@16.81,5178.43 ; v1@19.64,5167.82 ccw(c10.25,5158.43) 10.25,5171.71 ccw(c10.25,5184.99) v1@19.64,5175.6 ; v1(23.52,5171.71) -76.71,5171.71 -90,5185 -90,5284.37 -110,5304.37 v1(-217.81,5304.37) -217.81,5285.33
  Bottom Layer w4: v1(-217.81,5304.37) -203.21,5289.77 R138.2@-203.21,5276.75 ; -206.17,5292.73 cw(c-219.98,5278.92) R138.2@-200.54,5276.97 ; v1@16.81,5164.99 cw(c0.59,5148.77) 23.52,5148.77 cw(c46.46,5148.77) v1@30.24,5164.99 ; v1@19.64,5167.82 cw(c10.25,5158.43) 23.52,5158.43 cw(c36.8,5158.43) v1@27.41,5167.82 ; v1(23.52,5171.71) 23.52,5128.65 33.52,5118.65 R143.1@66.28,5118.65 ; R143.1@59.69,5112.06 ccw(c43.78,5096.16) 43.78,5118.65 ccw(c43.78,5141.15) R143.1@59.69,5125.24 ; R143.1@62.52,5114.89 ccw(c53.44,5105.81) 53.44,5118.65 ccw(c53.44,5131.5) R143.1@62.52,5122.41
MIDI.MIDI_RX: R195.1 R196.2 U8.C4 U36.4 | length 3059.9
  Top Layer w4: v1(3715.19,6127.37) 3717.52,6125.04 4478.88,6125.04 4548.52,6055.39 4548.52,5583.37 4640.19,5491.71 4640.19,5115.58 4657.78,5097.99 4724.19,5031.58 4724.19,4944.02 4800.5,4867.71 4882.29,4867.71 4952.75,4797.25 4952.75,4749.18 4952.75,4741.18 ; v1@3719.08,6131.26 ccw(c3734.1,6146.29) 3734.1,6125.04 ; v1@3721.91,6120.66 cw(c3732.49,6110.07) 3732.49,6125.04 ; v1@3721.91,6134.09 ccw(c3743.76,6155.94) 3743.76,6125.04 ; 4952.75,4682.64 ccw(c4991.43,4682.64) 4964.08,4655.29 ; 4952.75,4682.64 ccw(c4991.43,4682.64) 4964.08,4655.29 ; 4952.75,4682.64 4952.75,4741.18 ; 4952.75,4682.64 4952.75,4741.18 ; 4964.08,4655.29 cw(c4951.55,4642.76) 4969.27,4642.76 ccw(c4951.55,4642.76) 4964.08,4655.29 ; 4964.08,4655.29 ccw(c4976.61,4667.82) 4976.61,4650.1 cw(c4976.61,4667.82) 4964.08,4655.29
  Bottom Layer w4: U36.4@3487.48,6195 3533.82,6195 R196.2@3573.82,6155 ; R196.2@3569.13,6163.54 ccw(c3564.37,6171.71) 3573.82,6171.71 ; R196.2@3578.51,6163.54 cw(c3583.27,6171.71) 3573.82,6171.71 ; v1@3705.69,6127.37 ccw(c3682.76,6127.37) 3698.97,6143.59 ccw(c3715.19,6159.81) v1@3715.19,6136.87 ; v1@3709.69,6127.37 ccw(c3696.41,6127.37) 3705.8,6136.76 ccw(c3715.19,6146.15) v1@3715.19,6132.87 ; R195.1@3713.04,6145.79 cw(c3711.25,6141.04) 3716.32,6141.04 ; R195.1@3716.32,6155 3716.32,6141.04 ; R195.1@3719.6,6145.79 ccw(c3721.39,6141.04) 3716.32,6141.04 ; 3573.82,6171.71 3575.49,6173.37 3669.19,6173.37 v1(3715.19,6127.37) 3715.19,6139.91 3716.32,6141.04
MIDI.MIDI_TX: U8.D6 U38.2 | length 2522.5
  Top Layer w4: v3(5035.67,4623.07) U8.D6@5055.35,4603.39 ; U8.D6@5048.01,4603.39 ccw(c5030.29,4603.39) 5042.82,4615.92 ccw(c5055.35,4628.45) U8.D6@5055.35,4610.73 ; 5048.47,4610.27 cw(c5061.28,4623.07) 5043.17,4623.07 ccw(c5061.28,4623.07) 5048.47,4610.27 ; 5048.47,4610.27 ccw(c5035.67,4597.46) 5035.67,4615.57 cw(c5035.67,4597.46) 5048.47,4610.27
  MidLayer1 w4: v1(4356.86,6158.37) 4398.37,6158.37 4415.37,6175.37 4750,6175.37 ; v1@4360.75,6154.49 cw(c4370.14,6145.1) 4370.14,6158.37 cw(c4370.14,6171.65) v1@4360.75,6162.26 ; v1@4363.57,6151.66 cw(c4379.79,6135.44) 4379.79,6158.37 cw(c4379.79,6181.31) v1@4363.57,6165.09 ; 4750,6175 4757.69,6167.31 4757.69,5149.21 4806.86,5100.04 4806.86,5083.14 5015.52,4874.48 5015.52,4854.48 5035.67,4834.33 5035.67,4749.18 5035.67,4741.18 5035.67,4700.75 v3(5035.67,4623.07) ; v3@5030.48,4628.26 ccw(c5017.94,4640.8) 5035.67,4640.8 ccw(c5053.4,4640.8) v3@5040.86,4628.26 ; 5035.67,4641.18 cw(c5017.56,4641.18) 5030.37,4628.37 ccw(c5017.56,4641.18) 5035.67,4641.18 ; 5035.67,4641.18 ccw(c5053.78,4641.18) 5040.97,4628.37 cw(c5053.78,4641.18) 5035.67,4641.18
  Bottom Layer w4: U38.2@4285.84,6155.12 U38.2@4285.84,6168.71 ; U38.2@4285.84,6168.89 U38.2@4285.84,6168.71 ; U38.2@4287.51,6169.61 cw(c4298.99,6174.52) 4290.16,6183.34 ; U38.2@4291.19,6171.18 cw(c4304.85,6177.02) 4294.34,6187.53 ; U38.2@4294.86,6172.75 cw(c4310.71,6179.52) 4298.52,6191.71 ; v1@4352.02,6166.55 ccw(c4346.99,6175.04) 4356.86,6175.04 ; v1(4356.86,6158.37) 4356.86,6175.04 ; v1@4361.7,6166.55 cw(c4366.72,6175.04) 4356.86,6175.04 ; U38.2@4285.84,6168.71 4285.52,6168.71 4285.52,6178.71 4298.52,6191.71 ; 4298.52,6191.71 4340.19,6191.71 4356.86,6175.04
MOUSE.CLOCK: R89.1 U8.AE9 | length 4859.5
  Top Layer w4: v3(5153.78,3756.93) U8.AE9@5173.46,3776.61 ; U8.AE9@5166.12,3776.61 cw(c5148.4,3776.61) 5160.93,3764.08 cw(c5173.46,3751.55) U8.AE9@5173.46,3769.27 ; 5166.58,3769.73 cw(c5153.78,3782.54) 5153.78,3764.43 ccw(c5153.78,3782.54) 5166.58,3769.73 ; 5166.58,3769.73 ccw(c5179.39,3756.93) 5161.28,3756.93 cw(c5179.39,3756.93) 5166.58,3769.73
  MidLayer1 w4: v1@4958.47,1348.43 ccw(c4942.26,1364.64) 4965.19,1364.64 ccw(c4988.13,1364.64) v1@4971.91,1348.43 ; v1@4961.3,1345.6 ccw(c4951.91,1354.99) 4965.19,1354.99 ccw(c4978.47,1354.99) v1@4969.08,1345.6 ; v1(4965.19,1341.71) 4965.19,2279.73 5080.46,2395 5093.9,2395 5131.86,2432.96 5131.86,2443.39 5111.5,2463.75 5111.5,2611.75 5122.5,2622.75 5122.5,2637.25 5117.82,2641.93 5117.82,2755.75 5090.69,2782.87 5084.31,2782.87 5030.5,2836.69 5030.5,2971.06 5040.19,2980.75 5040.19,3107.69 5090.5,3158 5090.5,3215.56 5090.5,3232.04 5114.5,3256.04 5114.5,3346.37 5156.86,3388.73 5156.86,3471.86 5185.81,3500.81 5185.81,3555.38 5153.78,3587.41 5153.78,3630.82 5153.78,3638.82 5153.78,3679.25 v3(5153.78,3756.93) ; v3@5148.48,3751.63 cw(c5135.67,3738.82) 5153.78,3738.82 cw(c5171.89,3738.82) v3@5159.08,3751.63 ; v3@5148.59,3751.74 cw(c5136.05,3739.2) 5153.78,3739.2 cw(c5171.51,3739.2) v3@5158.97,3751.74
  MidLayer2 w4: v1@3508.47,1023.43 ccw(c3492.26,1039.64) 3515.19,1039.64 ccw(c3538.13,1039.64) v1@3521.91,1023.43 ; v1@3511.3,1020.6 ccw(c3501.91,1029.99) 3515.19,1029.99 ccw(c3528.47,1029.99) v1@3519.08,1020.6 ; v1(3515.19,1016.71) 3515.19,1207.23 3525,1217.04 4202.04,1217.04 4326.71,1341.71 v1(4965.19,1341.71) ; v1@4958.47,1334.99 ccw(c4942.26,1318.77) 4942.26,1341.71 ccw(c4942.26,1364.64) v1@4958.47,1348.43 ; v1@4961.3,1337.82 ccw(c4951.91,1328.43) 4951.91,1341.71 ccw(c4951.91,1354.99) v1@4961.3,1345.6
  Bottom Layer w4: R89.1@3433.23,1005 3475,1005 3486.71,1016.71 v1(3515.19,1016.71) ; R89.1@3436.99,1001.24 cw(c3446.07,992.16) 3446.07,1005 cw(c3446.07,1017.84) R89.1@3436.99,1008.76 ; R89.1@3439.82,998.41 cw(c3455.73,982.5) 3455.73,1005 cw(c3455.73,1027.5) R89.1@3439.82,1011.59 ; v1@3508.47,1009.99 ccw(c3492.26,993.77) 3492.26,1016.71 ccw(c3492.26,1039.64) v1@3508.47,1023.43 ; v1@3511.3,1012.82 ccw(c3501.91,1003.43) 3501.91,1016.71 ccw(c3501.91,1029.99) v1@3511.3,1020.6
MOUSE.DATA: R88.1 U8.Y10 | length 5385.7
  Top Layer w4: v3(5193.15,3953.78) U8.Y10@5212.83,3973.46 ; U8.Y10@5205.49,3973.46 cw(c5187.77,3973.46) 5200.3,3960.93 cw(c5212.83,3948.4) U8.Y10@5212.83,3966.12 ; 5205.95,3966.58 cw(c5193.15,3979.39) 5193.15,3961.28 ccw(c5193.15,3979.39) 5205.95,3966.58 ; 5205.95,3966.58 ccw(c5218.76,3953.78) 5200.65,3953.78 cw(c5218.76,3953.78) 5205.95,3966.58
  MidLayer1 w4: v1(4139.96,1250.04) 4240.04,1250.04 4254,1264 4254,1321.63 4257.86,1325.48 4264,1331.63 4264,1582.31 4258,1588.31 4240.02,1606.29 4240.02,1743.96 4310.5,1814.44 4310.5,1835.56 4234,1912.06 4234,2093.31 4132.19,2195.12 4132.19,2439.67 4265.19,2572.67 4265.19,2982.41 4390.19,3107.41 4390.19,3345.71 4352.52,3383.37 4352.52,3516.71 4369.19,3533.37 4381.86,3533.37 4422.19,3573.71 v1(4422.19,3633.37) ; v1@4143.85,1246.15 cw(c4153.24,1236.76) 4153.24,1250.04 cw(c4153.24,1263.32) v1@4143.85,1253.93 ; v1@4146.68,1243.32 cw(c4162.89,1227.11) 4162.89,1250.04 cw(c4162.89,1272.98) v1@4146.68,1256.76 ; v1@4415.47,3626.66 cw(c4399.26,3610.44) 4422.19,3610.44 cw(c4445.13,3610.44) v1@4428.91,3626.66 ; v1@4418.3,3629.49 cw(c4408.91,3620.1) 4422.19,3620.1 cw(c4435.47,3620.1) v1@4426.08,3629.49
  Bottom Layer w4: R88.1@3682.54,1012.08 ccw(c3666.64,1027.99) 3689.13,1027.99 ccw(c3711.63,1027.99) R88.1@3695.72,1012.08 ; R88.1@3685.37,1009.25 ccw(c3676.29,1018.33) 3689.13,1018.33 ccw(c3701.97,1018.33) R88.1@3692.89,1009.25 ; R88.1@3689.13,1005 3689.13,1229.13 3710.04,1250.04 v1(4139.96,1250.04) ; v1@4133.24,1243.32 ccw(c4117.02,1227.11) 4117.02,1250.04 ccw(c4117.02,1272.98) v1@4133.24,1256.76 ; v1@4136.07,1246.15 ccw(c4126.68,1236.76) 4126.68,1250.04 ccw(c4126.68,1263.32) v1@4136.07,1253.93 ; v1(4422.19,3633.37) 4439.69,3650.87 4630,3650.87 4634.13,3650.87 4686.27,3650.87 4708.94,3628.21 4736.54,3628.21 4757.25,3607.5 4773.19,3591.56 4773.19,3580.06 4773,3579.87 4773,3556.27 4818.6,3510.67 4833,3496.27 4856.4,3472.88 4892.11,3472.88 4906.48,3458.5 4975.88,3458.5 4978.88,3461.5 5008.5,3461.5 5047,3423 5215,3423 5222.02,3430.02 5222.02,3440 5222.02,3557.98 5207.81,3572.19 5160.15,3572.19 5156.64,3575.7 5155,3577.34 5155,3580 5155,3590 5155,3602.66 5160.15,3607.81 5177.64,3607.81 5177.64,3630.82 5177.64,3638.82 5177.64,3661.95 5177.64,3720.21 5177.64,3778.47 5177.64,3836.73 5177.64,3856.15 5177.64,3916.34 5177.64,3921.1 cw(c5210.77,3921.27) 5182.73,3938.92 ; v1@4422.19,3638.87 ccw(c4422.19,3652.15) 4431.58,3642.76 ccw(c4440.97,3633.37) v1@4427.69,3633.37 ; v1@4422.19,3642.87 ccw(c4422.19,3665.81) 4438.41,3649.59 ccw(c4454.63,3633.37) v1@4431.69,3633.37 ; v3@5185.76,3952.48 cw(c5167.93,3949.33) 5182.76,3938.95 cw(c5197.6,3928.56) v3@5194.45,3946.39
NC1: U8.Y2 | length 75.2
  Top Layer w4: 4838.82,3957.96 4878.16,3957.96 ccw(c4878.16,3968.11) 4885.34,3960.93 ; U8.Y2@4890.53,3973.46 cw(c4872.81,3973.46) 4885.34,3960.93 ; U8.Y2@4897.87,3966.12 ccw(c4897.87,3948.4) 4885.34,3960.93
NC2: U8.Y1 | length 47.5
  Top Layer w4: 4838.82,3973.46 U8.Y1@4858.5,3973.46 ; U8.Y1@4853.31,3968.27 ccw(c4840.78,3955.74) 4840.78,3973.46 ccw(c4840.78,3991.19) U8.Y1@4853.31,3978.66
NC3: U8.Y28 | length 47.5
  Top Layer w4: U8.Y28@5921.5,3973.46 5941.18,3973.46 ; U8.Y28@5926.69,3968.27 cw(c5939.22,3955.74) 5939.22,3973.46 cw(c5939.22,3991.19) U8.Y28@5926.69,3978.66
NC4: U8.AH15 | length 47.5
  Top Layer w4: U8.AH15@5404.49,3653.31 cw(c5391.96,3640.78) 5409.68,3640.78 cw(c5427.41,3640.78) U8.AH15@5414.88,3653.31 ; 5409.68,3638.82 U8.AH15@5409.68,3658.5
NC5: U8.AG14 | length 75.2
  Top Layer w4: 5354.81,3638.82 5354.81,3678.16 cw(c5364.96,3678.16) 5357.78,3685.34 ; U8.AG14@5362.97,3697.87 cw(c5345.25,3697.87) 5357.78,3685.34 ; U8.AG14@5370.32,3690.53 ccw(c5370.32,3672.8) 5357.78,3685.34
NC6: U8.F4 | length 315.4
  Top Layer w4: v3(4956.93,4544.33) U8.F4@4976.61,4524.65 ; U8.F4@4969.27,4524.65 ccw(c4951.55,4524.65) 4964.08,4537.18 ccw(c4976.61,4549.71) U8.F4@4976.61,4531.99 ; 4969.73,4531.53 cw(c4982.54,4544.33) 4964.43,4544.33 ccw(c4982.54,4544.33) 4969.73,4531.53 ; 4969.73,4531.53 ccw(c4956.93,4518.72) 4956.93,4536.83 cw(c4956.93,4518.72) 4969.73,4531.53
  MidLayer1 w4: 4838.82,4544.33 4879.25,4544.33 4898.67,4544.33 v3(4956.93,4544.33) ; v3@4951.74,4539.14 ccw(c4939.2,4526.6) 4939.2,4544.33 ccw(c4939.2,4562.06) v3@4951.74,4549.52 ; 4938.82,4544.33 cw(c4938.82,4526.22) 4951.63,4539.03 ccw(c4938.82,4526.22) 4938.82,4544.33 ; 4938.82,4544.33 ccw(c4938.82,4562.44) 4951.63,4549.63 cw(c4938.82,4562.44) 4938.82,4544.33
NC7: U8.E2 | length 150.3
  Top Layer w4: 4878.16,4579.52 cw(c4878.16,4569.37) 4885.34,4576.55 ; 4878.16,4579.52 cw(c4878.16,4569.37) 4885.34,4576.55 ; 4878.16,4579.52 4838.82,4579.52 4878.16,4579.52 ; 4885.34,4576.55 cw(c4872.81,4564.02) 4890.53,4564.02 ccw(c4872.81,4564.02) 4885.34,4576.55 ; 4885.34,4576.55 ccw(c4897.87,4589.08) 4897.87,4571.36 cw(c4897.87,4589.08) 4885.34,4576.55