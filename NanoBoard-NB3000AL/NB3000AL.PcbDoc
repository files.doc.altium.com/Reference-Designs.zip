# Altium PCB NB3000AL.PcbDoc (part 10 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
3V3: (continued)
  Bottom Layer w11.81: v2@6450.82,5984.18 ccw(c6439.13,5995.87) 6455.67,5995.87 ; C174.2@6455.15,5919.18 ccw(c6445.07,5929.26) 6459.33,5929.26 ccw(c6473.59,5929.26) C174.2@6463.51,5919.18 ; 6455.67,5992.64 ccw(c6467.64,5992.64) v2@6459.18,5984.18 ; U56.43@6455.67,6007.05 6455.67,5982.85 6455.86,5982.85 6455.86,5980 6455.86,5966.04 ; 6455.86,5966.71 6455.86,5966.04 ; 6456.86,5964.85 6456.86,5965.04 6455.86,5966.04 ; C174.2@6459.33,5915 6459.33,5962.51 ; U19.43@7574.33,877.95 7618.28,877.95 v1(7628.52,867.71) ; U19.43@7590.28,877.95 cw(c7590.28,829.47) v1@7624.57,863.75 ; 7618.8,877.95 cw(c7618.8,857.98) v1@7632.92,872.1
  Bottom Layer w12: v1@-385,2739.5 cw(c-385,2726.22) -375.61,2735.61 cw(c-366.22,2745) v1@-379.5,2745 ; v1(-385,2745) -354.99,2714.99 ; C20.1@-369.05,2650.4 cw(c-392.41,2627.04) -359.37,2627.04 cw(c-326.33,2627.04) C20.1@-349.69,2650.4 ; C20.1@-369.05,2679.6 ccw(c-392.41,2702.96) -359.37,2702.96 ccw(c-326.33,2702.96) C20.1@-349.69,2679.6 ; R21.1@-351.1,2604.92 ccw(c-341.18,2614.84) R21.1@-341.18,2600.81 ; R21.1@-349.91,2603.73 cw(c-358.15,2595.49) R21.1@-346.5,2595.49 ; C21.1@-344.78,2740.89 cw(c-354.7,2730.97) -340.67,2730.97 cw(c-326.64,2730.97) C21.1@-336.56,2740.89 ; R21.1@-341.18,2595 -359.37,2613.19 C20.1@-359.37,2665 -359.37,2710.6 -354.99,2714.99 ; C21.1@-340.67,2745 -340.67,2720.71 -340,2720.04 ; v1@-205.36,2429.6 ccw(c-214.75,2438.99) -201.48,2438.99 ccw(c-188.2,2438.99) v1@-197.59,2429.6 ; v1(-201.48,2425.71) -201.48,2705.04 -216.48,2720.04 -340,2720.04 ; R154.2@-187.44,1905.75 cw(c-196.52,1896.67) -183.68,1896.67 cw(c-170.84,1896.67) R154.2@-179.92,1905.75 ; R154.2@-183.68,1910 -183.68,1889.37 -181.68,1887.37 -109.81,1887.37 -4.81,1887.37 14.52,1906.71 14.52,1907.01 21.14,1907.01 C136.1@73.07,1907.01 ; R98.2@-145.08,2200.75 cw(c-154.16,2191.67) -141.32,2191.67 cw(c-128.48,2191.67) R98.2@-137.56,2200.75 ; R98.2@-137.56,2201.24 cw(c-128.48,2192.16) -128.48,2205 cw(c-128.48,2217.84) R98.2@-137.56,2208.76 ; U45.4@-136.34,2080.45 ccw(c-156.34,2100.45) -128.05,2100.45 ccw(c-99.77,2100.45) U45.4@-119.77,2080.45 ; U45.4@-128.05,2063.31 -128.05,2113.05 -141.32,2126.32 R98.2@-141.32,2205 -93.1,2205 -92.81,2204.71 -73.1,2185 v1(70,2185) ; 1.81,1893.99 cw(c21.14,1874.66) v1@21.14,1902 ; v1@25.03,1903.61 cw(c33.23,1895.41) C136.1@33.23,1907.01 ; v1@25.03,1911.39 ccw(c35.61,1921.97) C136.1@35.61,1907.01 ; v1@66.11,2181.11 ccw(c56.72,2171.72) 56.72,2185 ccw(c56.72,2198.28) v1@66.11,2188.89 ; v1@694.64,1595.6 ccw(c684.53,1605.7) 698.82,1605.7 ; R205.2@695.06,1620.75 cw(c685.98,1611.67) 698.82,1611.67 cw(c711.66,1611.67) R205.2@702.58,1620.75 ; R205.2@695.06,1629.25 ccw(c685.98,1638.33) 698.82,1638.33 ccw(c711.66,1638.33) R205.2@702.58,1629.25 ; v1(698.52,1591.71) 698.82,1592 R205.2@698.82,1625 698.82,1654.72 v1(747.01,1702.91) ; 698.82,1604.27 ccw(c711.09,1604.27) v1@702.41,1595.6 ; v1@741.51,1702.91 cw(c728.23,1702.91) 737.62,1693.52 cw(c747.01,1684.14) v1@747.01,1697.41 ; v1@2075.53,5476.54 ccw(c2087.64,5471.49) 2078.36,5462.21 ; v1(2081.52,5474.04) 2081.52,5459.04 2098.52,5442.04 2098.67,5442.04 2100.67,5440.04 C50.2@2100.67,5400 2102.09,5401.42 U5.14@2193.54,5401.42 ; v1@2086.6,5471.92 ccw(c2105.52,5464.03) 2091.02,5449.54 ; C50.2@2096.56,5404.11 ccw(c2086.64,5414.03) 2100.67,5414.03 ccw(c2114.7,5414.03) C50.2@2104.78,5404.11 ; C50.2@2104.78,5395.89 cw(c2118.12,5382.55) 2118.12,5401.42 ; v1@2470.52,5458.37 v1(2472.62,5460.47) U5.44@2528.19,5460.47 ; v1@2476.51,5456.58 cw(c2485.9,5447.19) 2485.9,5460.47 cw(c2485.9,5473.75) v1@2476.51,5464.36 ; U39.3@2479.81,1525.19 U39.3@2480,1525 ; 2498.52,5558.9 2498.52,5578.58 ; 2498.52,5563.77 cw(c2519.48,5563.77) 2504.66,5578.58 cw(c2519.48,5593.4) 2498.52,5593.4 ; 2498.52,5573.71 ccw(c2519.48,5573.71) U5.39@2504.66,5558.9 ; 2498.52,5583.45 cw(c2519.48,5583.45) U5.37@2504.66,5598.27 ; R50.2@2500,5206.18 2605.33,5206.18 v1(2615.19,5216.04) 2615.19,5264.14 C51.2@2614.33,5265 ; R50.2@2504.25,5202.42 cw(c2513.33,5193.34) 2513.33,5206.18 cw(c2513.33,5219.02) R50.2@2504.25,5209.94 ; U5.48@2527.52,5381.73 2527.52,5355 ; U5.41@2528.19,5519.53 2564.53,5519.53 v1(2580,5540.19) 2580,5555 2576.1,5558.9 U5.39@2528.19,5558.9 ; U5.38@2528.19,5578.58 2498.52,5578.58 ; U5.37@2551.71,5598.27 U5.37@2528.19,5598.27 2498.52,5598.27 2498.52,5578.58 ; v1@2556.11,5346.3 ccw(c2546.72,5336.92) 2546.72,5350.19 ccw(c2546.72,5363.47) v1@2556.11,5354.08 ; v1(2560,5350.19) 2532.33,5350.19 2527.52,5355 ; v1@2574.56,5539.41 cw(c2561.41,5537.52) 2572.04,5529.56 cw(c2582.67,5521.61) v1@2580.78,5534.75 ; 2578.11,5206.18 ccw(c2578.11,5253.12) 2611.3,5219.93 ccw(c2601.91,5229.32) 2615.19,5229.32 ccw(c2628.47,5229.32) v1@2619.08,5219.93 ; 2582.75,5552.25 cw(c2572.9,5542.4) v1@2586.21,5538.27 ; 2607.08,5206.18 ccw(c2607.08,5224.15) v1@2619.79,5211.44 ; C51.2@2610.22,5260.89 cw(c2598.23,5248.9) 2615.19,5248.9 ; 2615.19,5253.05 cw(c2626.28,5253.05) C51.2@2618.44,5260.89 ; R59.2@2652.42,5318.25 cw(c2643.34,5309.17) 2656.18,5309.17 cw(c2669.02,5309.17) R59.2@2659.94,5318.25 ; R59.2@2656.18,5322.5 2656.18,5308.37 2647.85,5300.04 2548.52,5300.04 2527.52,5321.04 2527.52,5355 ; v1(2789.7,5828) R57.2@2813.82,5828 ; v1@2793.59,5824.11 cw(c2802.98,5814.72) 2802.98,5828 cw(c2802.98,5841.28) v1@2793.59,5831.89 ; C49.1@2961.63,5664.67 ccw(c2939.31,5692.51) 2975,5692.51 ccw(c3010.69,5692.51) C49.1@2988.37,5664.67 ; v1@2971.3,5713.82 cw(c2962.37,5704.89) 2975,5704.89 ; C49.1@2975,5647.99 v1@2975,5717.52 ; 2975,5703.97 cw(c2988.93,5703.97) v1@2979.08,5713.82 ; v1@3045,5675 3124.06,5675 L2.1@3125,5674.06 ; v1@3048.89,5671.3 cw(c3057.81,5662.38) 3057.81,5675 ; v1@3048.89,5679.08 ccw(c3058.75,5688.94) 3058.75,5675 ; 3064.72,5675 ccw(c3064.72,5704.81) L2.1@3085.8,5683.73 ; v1(3065,5725.19) C52.2@3104.33,5725 ; v1@3068.87,5721.29 cw(c3078.21,5711.85) 3078.28,5725.13 cw(c3078.34,5738.41) v1@3068.91,5729.06 ; C52.2@3100.2,5720.91 ccw(c3090.23,5711.04) 3090.3,5725.07 ccw(c3090.37,5739.1) C52.2@3100.24,5729.13 ; R226.2@3228.82,2522.5 3228.82,2533.86 3245,2550.04 ; R226.2@3234.14,2523.09 cw(c3271.24,2523.8) 3245,2550.04 ; v1(3238,5674.57) U6.19@3341.06,5674.57 3384.19,5674.57 ; v1@3241.89,5670.68 cw(c3251.28,5661.29) 3251.28,5674.57 cw(c3251.28,5687.84) v1@3241.89,5678.46 ; v1@3267.3,2853.49 cw(c3257.93,2844.12) 3271.18,2844.12 ; v1@3267.3,2861.26 ccw(c3257.93,2870.63) 3271.18,2870.63 ; R224.2@3267.42,2816.75 ccw(c3258.34,2825.83) 3271.18,2825.83 ccw(c3284.02,2825.83) R224.2@3274.94,2816.75 ; R232.2@3271.18,2450 v1@3319.48,2450 ; R227.2@3271.18,2595 3313.9,2595 ; R225.2@3271.18,2667.5 3305.92,2667.5 3317.92,2655.5 ; R218.2@3271.18,2740 3330,2740 3336.19,2746.19 v1(3336.19,2779.37) v1@3331.86,2775.04 ; R224.2@3271.18,2812.5 v1(3271.19,2857.37) R219.2@3271.18,2885 ; 3271.18,2844.07 cw(c3284.49,2844.07) v1@3275.08,2853.49 ; 3271.18,2870.67 ccw(c3284.49,2870.67) v1@3275.08,2861.26 ; R217.2@3271.18,2957.5 3302.73,2957.5 v1(3311.19,2949.04) ; R216.2@3271.18,3030 3319.23,3030 v1(3336.19,3013.04) ; R232.2@3274.94,2446.24 cw(c3284.02,2437.16) 3284.02,2450 cw(c3284.02,2462.84) R232.2@3274.94,2453.76 ; R227.2@3274.94,2591.24 cw(c3284.02,2582.16) 3284.02,2595 cw(c3284.02,2607.84) R227.2@3274.94,2598.76 ; R225.2@3274.94,2663.74 cw(c3284.02,2654.66) 3284.02,2667.5 cw(c3284.02,2680.34) R225.2@3274.94,2671.26 ; R218.2@3274.94,2736.24 cw(c3284.02,2727.16) 3284.02,2740 cw(c3284.02,2752.84) R218.2@3274.94,2743.76 ; R217.2@3274.94,2953.74 cw(c3284.02,2944.66) 3284.02,2957.5 cw(c3284.02,2970.34) R217.2@3274.94,2961.26 ; R216.2@3274.94,3026.24 cw(c3284.02,3017.16) 3284.02,3030 cw(c3284.02,3042.84) R216.2@3274.94,3033.76 ; R217.2@3277.49,2957.5 cw(c3277.49,2915.34) v1@3307.3,2945.15 ; 3286.23,2450 cw(c3286.23,2408.41) v1@3315.64,2437.82 ; v1@3315.64,2445.6 ccw(c3296.59,2464.64) 3323.52,2464.64 ; 3317.86,2655.37 3317.86,2598.96 3313.9,2595 ; v1(3319.52,2441.71) 3319.52,2450.04 v1@3319.48,2450 ; v1@3319.64,2487.82 cw(c3310.25,2478.43) 3323.52,2478.43 cw(c3336.8,2478.43) v1@3327.41,2487.82 ; v1@3319.64,2546.15 ccw(c3310.25,2536.76) 3310.25,2550.04 ccw(c3310.25,2563.32) v1@3319.64,2553.93 ; v1(3323.52,2491.71) 3323.52,2454.04 v1@3319.48,2450 ; v1(3323.52,2550.04) 3245,2550.04 ; v1@3330.69,3013.04 ccw(c3317.41,3013.04) 3326.8,3022.43 ccw(c3336.19,3031.82) v1@3336.19,3018.54 ; v1@3332.3,2775.49 cw(c3322.91,2766.1) 3336.19,2766.1 cw(c3349.47,2766.1) v1@3340.08,2775.49 ; U6.20@3341.06,5700.16 3384.52,5700.16 3386.19,5698.49 ; v1@3369.64,2696.15 cw(c3360.25,2686.76) 3373.52,2686.76 cw(c3386.8,2686.76) v1@3377.41,2696.15 ; U6.19@3373.21,5677.1 ccw(c3362.08,5698.49) 3386.19,5698.49 ; v1(3373.52,2700.04) 3373.52,2608.52 3360,2595 3313.9,2595 ; 3386.19,5676.57 3386.19,5698.49 ; v1(3400,5390) 3415,5405 C54.2@3449.33,5405 ; C54.2@3445.22,5400.89 ccw(c3435.3,5390.97) 3435.3,5405 ccw(c3435.3,5419.03) C54.2@3445.22,5409.11 ; U36.6@3487.48,5995 3554.4,5995 3599.4,5950 3720,5950 3725.12,5955.12 U37.5@3725.12,5982.6 3765.52,5982.6 3769.52,5986.6 v1(3769.52,6003.37) ; U37.5@3742.02,5978.49 cw(c3751.94,5968.57) 3751.94,5982.6 cw(c3751.94,5996.63) U37.5@3742.02,5986.71 ; v1@3754.79,6105.21 ccw(c3745.4,6114.6) 3758.68,6114.6 ccw(c3771.96,6114.6) v1@3762.57,6105.21 ; R195.2@3754.92,6150.75 cw(c3745.84,6141.67) 3758.68,6141.67 cw(c3771.52,6141.67) R195.2@3762.44,6150.75 ; v1(3758.68,6101.32) R195.2@3758.68,6155 ; v1@3765.64,5999.49 cw(c3756.25,5990.1) 3769.52,5990.1 cw(c3782.8,5990.1) v1@3773.41,5999.49 ; C244.1@3816.28,5520.29 ccw(c3806.36,5530.21) 3820.39,5530.21 ccw(c3834.42,5530.21) C244.1@3824.5,5520.29 ; C243.1@3816.28,5622.07 cw(c3806.36,5612.15) 3820.39,5612.15 cw(c3834.42,5612.15) C243.1@3824.5,5622.07 ; v1@3816.5,5566.3 cw(c3807.11,5556.92) 3820.39,5556.92 cw(c3833.66,5556.92) v1@3824.28,5566.3 ; v1@3816.5,5574.08 ccw(c3807.11,5583.47) 3820.39,5583.47 ccw(c3833.66,5583.47) v1@3824.28,5574.08 ; C244.1@3820.39,5516.18 v1(3820.39,5570.19) C243.1@3820.39,5626.18 ; v1@3995.4,1189.6 cw(c4020.52,1164.48) 4020.52,1200 ; C229.1@3997.62,5622.07 cw(c3987.7,5612.15) 4001.73,5612.15 cw(c4015.75,5612.15) C229.1@4005.83,5622.07 ; D1.3@3999.21,1155 v1@3999.21,1175.04 ; D1.3@3999.21,1169.82 cw(c4015.18,1169.82) 4003.89,1181.11 cw(c4049.49,1135.51) U3.14@4049.49,1200 ; v1(4000,1185) 4000,1200 U3.14@4076.5,1200 ; C259.1@4001.72,5516.18 v1@4033.82,5516.18 ; 4001.73,5603.41 ccw(c4024.56,5603.41) v1@4008.41,5587.26 ; C229.1@4001.72,5626.18 v1@4001.73,5586.17 ; C259.1@4005.83,5512.07 cw(c4015.75,5502.15) 4015.75,5516.18 cw(c4015.75,5530.21) C259.1@4005.83,5520.29 ; 4020.08,5516.18 ccw(c4020.08,5530.12) v1@4029.93,5520.26 ; 4021.01,5516.18 cw(c4021.01,5503.56) v1@4029.93,5512.48 ; v1@4053.44,973.78 cw(c4044.05,964.39) 4057.33,964.39 cw(c4070.61,964.39) v1@4061.22,973.78 ; C37.2@4057.33,949 v1(4057.33,977.67) ; U38.5@4244.33,6027.98 cw(c4234.41,6018.06) 4248.44,6018.06 cw(c4262.47,6018.06) U38.5@4252.55,6027.98 ; v1@4244.47,5986.95 ccw(c4234.88,5996.53) 4248.44,5996.53 ; v1(4248.36,5983.06) 4248.44,5983.14 U38.5@4248.44,6044.88 ; 4248.44,5996.13 ccw(c4261.44,5996.13) v1@4252.25,5986.95 ; v1@4694.84,4541.5 cw(c4695.25,4524.83) 4707.04,4536.62 ; v1(4695,4535) 4708.66,4535 4720,4523.66 C304.1@4790,4523.66 ; v1(4725,4480.09) 4725,4473.56 4739.19,4459.37 4739.19,4456.22 4748.52,4446.89 C320.1@4790,4446.89 ; v1@4730.44,4479.28 ccw(c4749.69,4476.4) 4735.93,4462.64 ; v1(4765,3810) 4760,3810 4760,3815 4760,3820 C322.1@4785,3820 ; v2@4765.89,4260.89 cw(c4745.86,4240.86) 4774.19,4240.86 ; v2(4770,4265) 4774.19,4260.81 4774.19,4240.41 4790,4224.6 C335.1@4790,4210.67 ; v1@4770.33,3808.63 cw(c4785,3804.85) C322.1@4785,3820 ; C323.1@4779.19,3930.08 4777.69,3931.58 v1@4777.69,3931.69 ; C320.1@4785.89,4442.78 ccw(c4775.97,4432.86) 4775.97,4446.89 ccw(c4775.97,4460.92) C320.1@4785.89,4451 ; C304.1@4785.89,4519.55 ccw(c4775.97,4509.63) 4775.97,4523.66 ccw(c4775.97,4537.69) C304.1@4785.89,4527.77 ; C323.1@4786.97,3930.08 C323.1@4790,3933.11 ; C322.1@4790,3815 C322.1@4785,3820 ; v1@4835.61,3673.89 ccw(c4827.87,3681.63) 4838.82,3681.63 ; 4838.82,3684.92 ccw(c4854.42,3684.92) v1@4843.39,3673.89 ; C327.1@4838.82,3717.56 4838.82,3670.68 v1(4839.5,3670) ; C310.1@4838.82,4662.44 4858.5,4682.13 v2(4858.5,4721.5) 4897.87,4721.5 C294.1@4917.56,4741.18 4927.56,4751.18 4941.18,4751.18 4965,4775 4965,4790 ; C310.1@4838.82,4668.25 ccw(c4838.82,4682.28) 4848.74,4672.36 ccw(c4858.66,4662.44) C310.1@4844.63,4662.44 ; v2@4854.39,4717.39 cw(c4844.47,4707.47) 4858.5,4707.47 cw(c4872.53,4707.47) 4862.61,4717.39 cw(c4872.53,4707.47) 4872.53,4721.5 cw(c4872.53,4735.53) v2@4862.61,4725.61 ; C294.1@4911.75,4741.18 cw(c4897.72,4741.18) 4907.64,4731.26 cw(c4917.56,4721.34) C294.1@4917.56,4735.37 ; C326.1@4917.56,3633.01 cw(c4917.56,3618.98) 4927.48,3628.9 cw(c4937.4,3638.82) C326.1@4923.37,3638.82 ; C326.1@4917.56,3638.82 4947.19,3609.19 v2@4947.19,3566.81 ; v2@4940.89,3569.11 ccw(c4925.69,3584.31) 4947.19,3584.31 ; v1(4950,2503) 5011.27,2503 R240.2@5018.82,2495.45 R241.2@5018.82,2439.55 ; v1@4951.11,4846.11 cw(c4941.72,4836.72) 4955,4836.72 cw(c4968.28,4836.72) v1@4958.89,4846.11 ; v1@4953.89,2499.11 cw(c4963.28,2489.72) 4963.28,2503 cw(c4963.28,2516.28) v1@4953.89,2506.89 ; v1(4955,4850) 4955,4800 4965,4790 ; v1(4965.19,2383.37) 4994.19,2383.37 4994.45,2383.64 R242.2@5018.82,2383.64 R243.2@5018.82,2327.73 R243.2@5018.82,2329.67 ; v1@4969.08,2379.49 cw(c4978.47,2370.1) 4978.47,2383.37 cw(c4978.47,2396.65) v1@4969.08,2387.26 ; 4986.86,2641.71 v1(4948.52,2641.71) 5017.11,2641.71 5018.82,2640 ; 4988.95,2503 cw(c4988.95,2466.08) R240.2@5015.06,2492.19 ; 4989.5,2645.73 4989.5,2686.91 ; C331.1@5008.57,3583.57 5023.52,3568.61 5029.31,3562.82 v1(5029.31,3558.38) ; R236.2@5008.9,2709.17 cw(c5018.82,2699.25) R236.2@5018.82,2713.28 ; R236.2@5010.09,2710.36 ccw(c5001.85,2718.6) R236.2@5013.5,2718.6 ; C308.1@5010.89,4785.89 ccw(c5000.97,4775.97) 5000.97,4790 ccw(c5000.97,4804.03) C308.1@5010.89,4794.11 ; C331.1@5013.56,3588.57 C331.1@5015,3590 ; C308.1@5015,4790 4965,4790 ; R243.2@5015.06,2331.98 ccw(c5005.98,2341.06) 5018.82,2341.06 ccw(c5031.66,2341.06) R243.2@5022.58,2331.98 ; R242.2@5015.06,2379.38 cw(c5005.98,2370.3) 5018.82,2370.3 cw(c5031.66,2370.3) R242.2@5022.58,2379.38 ; R242.2@5015.06,2379.87 ccw(c5005.98,2370.8) 5005.98,2383.64 ccw(c5005.98,2396.48) R242.2@5015.06,2387.4 ; R241.2@5015.06,2443.8 ccw(c5005.98,2452.88) 5018.82,2452.88 ccw(c5031.66,2452.88) R241.2@5022.58,2443.8 ; R240.2@5015.06,2491.2 cw(c5005.98,2482.12) 5018.82,2482.12 cw(c5031.66,2482.12) R240.2@5022.58,2491.2 ; R239.2@5015.06,2555.62 ccw(c5005.98,2564.7) 5018.82,2564.7 ccw(c5031.66,2564.7) R239.2@5022.58,2555.62 ; R238.2@5015.06,2603.02 cw(c5005.98,2593.94) 5018.82,2593.94 cw(c5031.66,2593.94) R238.2@5022.58,2603.02 ; R238.2@5015.06,2611.53 ccw(c5005.98,2620.61) 5018.82,2620.61 ccw(c5031.66,2620.61) R238.2@5022.58,2611.53 ; R237.2@5015.06,2658.93 cw(c5005.98,2649.85) 5018.82,2649.85 cw(c5031.66,2649.85) R237.2@5022.58,2658.93 ; R260.2@5015.06,2771.24 ccw(c5005.98,2762.16) 5005.98,2775 ccw(c5005.98,2787.84) R260.2@5015.06,2778.76 ; R242.2@5018.82,2383.82 R242.2@5020,2385 ; R239.2@5018.82,2551.36 R238.2@5018.82,2607.27 5018.82,2640 ; R237.2@5018.82,2663.18 5018.82,2640 ; R236.2@5018.82,2719.09 4989.5,2689.77 4989.5,2686.91 ; R260.2@5018.82,2775 4940,2775 4933.5,2768.5 4933.5,2706.09 4946.09,2693.5 4982.91,2693.5 4989.5,2686.91 ; v2(5025,5255) 5045,5255 5053.36,5263.36 5053.36,5292.28 5039.33,5306.31 C96.1@5039.33,5330 ; v2@5029.11,5250.89 cw(c5039.03,5240.97) 5039.03,5255 cw(c5039.03,5269.03) v2@5029.11,5259.11 ; C96.1@5035.22,5325.89 cw(c5025.3,5315.97) 5039.33,5315.97 cw(c5053.36,5315.97) C96.1@5043.44,5325.89 ; C96.1@5035.22,5334.11 ccw(c5025.3,5344.03) 5039.33,5344.03 ccw(c5053.36,5344.03) 5043.44,5334.11 cw(c5059.63,5350.3) 5036.73,5350.3 ; U21.24@5036.73,5402.68 5036.73,5332.6 C96.1@5039.33,5330 ; U21.23@5056.42,5402.68 5056.42,5366.42 5039.33,5349.33 C96.1@5039.33,5330 ; v1@5126.11,3513.89 ccw(c5116.72,3523.28) 5130,3523.28 ccw(c5143.28,3523.28) v1@5133.89,3513.89 ; C292.1@5129,4794.11 ccw(c5119.08,4804.03) 5133.11,4804.03 ccw(c5147.14,4804.03) C292.1@5137.22,4794.11 ; v1(5130,3510) 5130,3530.11 5145.36,3545.47 5145.36,3563.28 5133.11,3575.53 C330.1@5133.11,3590 ; C292.1@5133.11,4790 5133.11,4835 5133.11,4863.11 5144,4874 v1(5158,4888) ; v1(5285,1525) 5305,1525 5317.4,1512.6 U65.5@5317.4,1475.12 ; v1(5287.34,1724.1) 5287.34,1724.38 5287.96,1725 5305,1725 5317.4,1737.4 U66.5@5317.4,1745.12 U66.5@5317.28,1745 ; v1@5288.89,1521.11 cw(c5298.28,1511.72) 5298.28,1525 cw(c5298.28,1538.28) v1@5288.89,1528.89 ; v1@5291.23,1720.21 cw(c5302.79,1708.65) 5302.79,1725 ; v1@5302.97,5440.6 ccw(c5293.26,5450.3) 5306.99,5450.3 ; v1(5306.86,5436.71) 5306.99,5436.71 5306.99,5456.4 U21.12@5312.32,5461.73 ; 5306.99,5449.67 ccw(c5319.82,5449.67) v1@5310.75,5440.6 ; U65.5@5313.29,1492.02 ccw(c5303.37,1501.94) 5317.4,1501.94 ccw(c5331.43,1501.94) U65.5@5321.51,1492.02 ; v1@5327.68,3555.54 cw(c5339.73,3552.61) 5339.73,3565 ; v1(5334,3554) 5345,3565 5355,3565 ; v1@5339.34,3552.7 cw(c5355,3548.89) 5355,3565 ; 5360.34,3570.34 ccw(c5348.85,3581.82) C333.1@5363.93,3587.85 ; C333.1@5369.33,3579.33 5355,3565 ; C333.1@5370,3590 5370,3585 v2(5410,3545) ; C333.1@5375.14,3590 ccw(c5399.63,3590) 5382.31,3572.69 ; v2@5404.19,3545 ccw(c5390.16,3545) 5400.08,3554.92 ccw(c5410,3564.84) v2@5410,3550.81 ; v2(5472.31,2924.38) 5502.93,2955 R73.2@5504.87,2955 ; v2@5472.31,2930.19 ccw(c5472.31,2944.22) 5482.23,2934.3 ccw(c5492.15,2924.38) v2@5478.12,2924.38 ; v2(5477,2752) v2@5480.71,2752 ; 5491.64,2943.71 cw(c5504.87,2930.47) R73.2@5504.87,2949.19 ; v1(5515,1740) 5547.28,1740 U68.5@5552.4,1745.12 ; v1@5518.89,1736.11 cw(c5528.28,1726.72) 5528.28,1740 cw(c5528.28,1753.28) v1@5518.89,1743.89 ; v1(5528.86,4798.37) 5568.37,4798.37 5576.75,4790 C291.1@5605.55,4790 5605.55,4815.55 5610,4820 v1(5633,4820) ; v1@5532.75,4794.49 cw(c5542.14,4785.1) 5542.14,4798.37 cw(c5542.14,4811.65) v1@5532.75,4802.26 ; C257.1@5542.62,2830.89 cw(c5532.7,2820.97) 5546.73,2820.97 cw(c5560.75,2820.97) C257.1@5550.83,2830.89 ; 5546.73,2807.71 ccw(c5577.53,2807.71) v1@5555.75,2785.93 ; C257.1@5546.72,2835 5546.73,2787.17 v1(5551.86,2782.04) ; v1(5619.39,5090.5) 5624.89,5085 R70.2@5641.32,5085 cw(c5641.32,5106.86) v1@5623.8,5093.79 ; v1@5629.11,4816.11 ccw(c5619.72,4806.72) 5619.72,4820 ccw(c5619.72,4833.28) v1@5629.11,4823.89 ; v2@5629.22,1350.19 cw(c5629.22,1336.16) 5639.14,1346.08 cw(c5649.06,1356) v2@5635.04,1356 ; v2(5629.22,1356) C367.1@5659.05,1326.18 ; C328.1@5642.78,3585.89 cw(c5632.86,3575.97) 5646.89,3575.97 cw(c5660.92,3575.97) C328.1@5651,3585.89 ; C328.1@5646.89,3590 5646.89,3560 5654,3552.89 v1(5654,3524) ; v1@5650.11,3527.89 ccw(c5640.72,3537.28) 5654,3537.28 ccw(c5667.28,3537.28) v1@5657.89,3527.89 ; C367.1@5653.24,1326.18 ccw(c5639.21,1326.18) 5649.13,1336.1 ccw(c5659.05,1346.02) C367.1@5659.05,1331.99 ; v1(5677,1168) 5677.23,1168 5680.86,1164.37 5680.86,1180.04 5681.86,1181.04 5690.02,1181.04 ; 5690.02,1181.35 5700.39,1191.71 C368.1@5700.39,1216.18 ; C368.1@5696.28,1212.07 cw(c5686.36,1202.15) 5700.39,1202.15 cw(c5714.42,1202.15) C368.1@5704.5,1212.07 ; C185.1@5697.38,2161.33 ccw(c5677.66,2193.04) 5715,2193.04 ; C185.1@5715,2132.99 5715,2193.04 ; C329.1@5723.66,3584.19 cw(c5723.66,3562.47) 5739.02,3577.83 ; C329.1@5723.66,3590 5726.85,3590 5763.9,3552.95 ; C185.1@5732.62,2161.33 cw(c5752.34,2193.04) 5715,2193.04 ; C256.1@5762.62,5512.07 cw(c5752.7,5502.15) 5766.72,5502.15 cw(c5780.75,5502.15) C256.1@5770.83,5512.07 ; C255.1@5762.62,5630.29 ccw(c5752.7,5640.21) 5766.72,5640.21 ccw(c5780.75,5640.21) C255.1@5770.83,5630.29 ; 5763.9,3528.19 ccw(c5785.62,3528.19) v2@5772.17,3511.14 ; 5766.54,5651.54 cw(c5785,5633.09) v2@5785,5659.19 ; C256.1@5766.72,5516.18 5766.72,5445.17 v1(5781.86,5430.04) ; C255.1@5766.72,5626.18 5766.72,5651.72 v2@5780.49,5665.49 ; v1(5770,2320) 5775,2315 5779.15,2315 v1@5779.52,2315.37 ; v2(5776,3516) 5776,3518 5774,3520 5773.42,3519.42 5772,3519.42 5763.9,3527.52 5763.9,3552.95 ; v2@5779.6,3520.56 cw(c5805.15,3552.95) 5763.9,3552.95 ; v1@5790,4805.8 5824.2,4805.8 5862.44,4767.56 C293.1@5862.44,4741.18 5882.13,4721.5 v2(5921.5,4721.5) 5921.5,4682.13 C309.1@5941.18,4662.44 ; v1@5793.89,4801.11 cw(c5805.21,4789.79) 5805.21,4805.8 ; v1(5810,2290) 5818.5,2281.5 5818.5,2224.11 5819.19,2223.42 5819.19,2217.03 5798.52,2196.36 5718.51,2196.36 5715.19,2193.04 5715,2193.04 ; 5850,3621.1 ccw(c5881.1,3621.1) v2@5859.11,3599.11 ; v1@5853.64,1287.82 cw(c5844.25,1278.43) 5857.52,1278.43 cw(c5870.8,1278.43) v1@5861.41,1287.82 ; v2(5855,3595) 5850,3600 5850,3623.82 5855,3628.82 ; v1(5857.52,1291.71) 5857.52,1269.33 5881.72,1245.13 C250.1@5881.72,1216.18 ; C293.1@5858.33,4745.29 ccw(c5848.41,4755.21) 5862.44,4755.21 ccw(c5876.47,4755.21) C293.1@5866.55,4745.29 ; C324.1@5862.44,3638.82 5882.13,3658.5 5921.5,3658.5 5921.5,3697.87 C325.1@5941.18,3717.56 ; C324.1@5862.44,3644.63 ccw(c5862.44,3658.66) 5872.36,3648.74 ccw(c5882.28,3638.82) C324.1@5868.25,3638.82 ; C293.1@5862.44,4735.37 cw(c5862.44,4721.34) 5872.36,4731.26 cw(c5882.28,4741.18) C293.1@5868.25,4741.18 ; C250.1@5877.62,1220.29 ccw(c5867.7,1230.21) 5881.72,1230.21 ccw(c5895.75,1230.21) C250.1@5885.83,1220.29 ; C249.1@5877.62,1322.07 cw(c5867.7,1312.15) 5881.72,1312.15 cw(c5895.75,1312.15) C249.1@5885.83,1322.07 ; C249.1@5881.72,1325.42 ccw(c5923.91,1325.42) v1@5894.08,1295.6 ; C249.1@5881.72,1326.18 5881.72,1300.17 v1(5890.19,1291.71) ; 5903.11,3658.5 ccw(c5903.11,3676.89) 5916.11,3663.89 ccw(c5903.11,3676.89) 5921.5,3676.89 ; R158.2@5906.18,1730 5925,1730 5940.19,1714.81 v1(5940.19,1700.04) ; v2@5917.39,4725.61 cw(c5907.47,4735.53) 5907.47,4721.5 cw(c5907.47,4707.47) 5917.39,4717.39 cw(c5907.47,4707.47) 5921.5,4707.47 cw(c5935.53,4707.47) v2@5925.61,4717.39 ; 5920.36,1734.64 cw(c5885.76,1700.04) v1@5934.69,1700.04 ; C325.1@5935.37,3717.56 cw(c5921.34,3717.56) 5931.26,3707.64 cw(c5941.18,3697.72) C325.1@5941.18,3711.75 ; C309.1@5935.37,4662.44 ccw(c5921.34,4662.44) 5931.26,4672.36 ccw(c5941.18,4682.28) C309.1@5941.18,4668.25 ; v1(5940.19,2775.04) 6056.86,2775.04 6082.52,2800.71 v1(6101.86,2800.71) ; 5940.84,1714.16 cw(c5926.73,1700.04) v1@5946.69,1700.04 ; v1@5944.08,2771.15 cw(c5953.47,2761.76) 5953.47,2775.04 cw(c5953.47,2788.32) v1@5944.08,2778.93 ; v1@5952.77,5534.5 cw(c5952.77,5521.22) 5962.16,5530.61 cw(c5971.55,5540) v1@5958.27,5540 ; v1(5952.77,5540) 5997.77,5495 ; v1@5985.71,3887.99 ccw(c5975.36,3898.34) 5990,3898.34 ; C305.1@5985.89,3929 cw(c5975.97,3919.08) 5990,3919.08 cw(c6004.03,3919.08) C305.1@5994.11,3929 ; v1(5989.6,3884.1) 5990,3884.5 C305.1@5990,3933.11 ; C321.1@5990,3856.34 5990,3865.41 5997.19,3872.6 v1@5997.19,3891.71 ; 5990,3896.41 ccw(c6001.91,3896.41) v1@5993.49,3887.99 ; C334.1@5994.11,4165.22 cw(c6004.03,4155.3) 6004.03,4169.33 cw(c6004.03,4183.36) C334.1@5994.11,4173.44 ; C334.1@5995.71,4175.04 C334.1@5990,4169.33 6019.33,4169.33 6028.5,4178.5 6028.5,4216.98 v1@6030.52,4219 ; v1(6048.52,1900.04) v1@6053.2,1900.04 ; v1@6097.97,2796.82 ccw(c6088.58,2787.43) 6088.58,2800.71 ccw(c6088.58,2813.99) v1@6097.97,2804.6 ; U60.4@6116.16,5670.45 ccw(c6088.8,5697.82) 6127.5,5697.82 ; U54.5@6123.49,5972.98 cw(c6113.81,5963.3) 6127.5,5963.3 ; U54.5@6123.49,6006.79 ccw(c6113.57,6016.71) 6127.6,6016.71 ccw(c6141.63,6016.71) U54.5@6131.71,6006.79 ; R254.1@6126.18,1240 6151.48,1240 v1(6153.19,1241.71) ; U60.4@6127.5,5652 6127.5,5989.78 U54.5@6127.6,5989.88 6127.6,6025 6131.86,6029.26 v1(6131.86,6055.71) ; U60.4@6127.5,5656.36 U60.4@6124.45,5653.31 6156.69,5653.31 6173.52,5636.48 v1(6173.52,5608.37) v1@6170.52,5611.37 ; 6127.5,5683.09 ccw(c6145.37,5683.09) U60.4@6132.73,5670.45 ; 6127.5,5962.82 cw(c6141.86,5962.82) U54.5@6131.71,5972.98 ; v1@6127.97,6051.82 cw(c6118.58,6042.43) 6131.86,6042.43 cw(c6145.14,6042.43) v1@6135.75,6051.82 ; U60.4@6132.73,5645.02 cw(c6152.73,5625.02) 6152.73,5653.31 cw(c6152.73,5681.59) U60.4@6132.73,5661.59 ; R254.1@6135.79,1240 ccw(c6135.79,1259.11) v1@6149.3,1245.6 ; v1(6148.52,6166.71) 6148.19,6166.71 6148.19,6161.67 6150.88,6164.35 6151.52,6165 C172.2@6184.33,6165 ; v1@6152.41,6170.6 ccw(c6165.93,6184.11) 6165.93,6165 ; v1@6169.64,5612.26 ccw(c6160.25,5621.65) 6173.52,5621.65 ccw(c6186.8,5621.65) v1@6177.41,5612.26 ; U14.33@6170.59,4624.25 6221.98,4624.25 6223.52,4625.79 6223.52,4658.37 ; C172.2@6180.22,6160.89 ccw(c6170.3,6150.97) 6170.3,6165 ccw(c6170.3,6179.03) C172.2@6180.22,6169.11 ; v1@6211.3,4662.82 cw(c6181.79,4633.31) 6223.52,4633.31 ; v1(6285,1240.19) R255.1@6363.82,1240 ; v1@6288.88,1236.3 cw(c6298.25,1226.88) 6298.28,1240.16 cw(c6298.31,1253.44) v1@6288.9,1244.07 ; C168.1@6300.67,6215 6319.86,6215 6329.86,6225 v1(6329.86,6264.71) ; C168.1@6304.78,6210.89 cw(c6314.7,6200.97) 6314.7,6215 cw(c6314.7,6229.03) C168.1@6304.78,6219.11 ; v1@6325.97,6260.82 cw(c6316.58,6251.43) 6329.86,6251.43 cw(c6343.14,6251.43) v1@6333.75,6260.82 ; R255.1@6360.05,1236.25 ccw(c6350.95,1227.19) 6350.98,1240.03 ccw(c6351.01,1252.87) R255.1@6360.07,1243.77 ; 6456.86,5964.85 6457,5964.85 6459.33,5962.51 ; J29.4@6501.75,1361.54 ccw(c6529.54,1361.54) v1@6509.89,1341.89 ; J29.4@6501.75,1404.65 6501.75,1341.15 6505.19,1337.71 6505.48,1338 v1(6506,1338) ; J30.4@6574.47,1166.9 ccw(c6548.47,1194.1) 6586.1,1194.1 ccw(c6623.73,1194.1) J30.4@6597.73,1166.9 ; J30.4@6586.1,1128.35 6586.1,1178.1 6586.1,1194.1 6594,1202 v1(6614,1202) v1@6614,1206 ; v1@6610.11,1198.11 ccw(c6600.72,1188.72) 6600.72,1202 ccw(c6600.72,1215.28) v1@6610.11,1205.89 ; U14.11@6619.41,4655.75 6657.19,4655.75 6661.86,4660.41 6661.86,4660.71 v1(6665.19,4664.04) ; U14.11@6631.89,4655.75 ccw(c6631.89,4697.34) v1@6661.3,4667.93 ; R253.1@6686.18,1240 6710,1240 6715,1235 v1(6715,1205) v1@6715,1205.19 ; R253.1@6689.94,1236.24 cw(c6699.02,1227.16) 6699.02,1240 cw(c6699.02,1252.84) R253.1@6689.94,1243.76 ; C173.2@6700.67,5915 6721.86,5915 6723.52,5916.67 6723.52,5925.04 6740.19,5941.71 v1(6755.19,5941.71) ; v1(6703,4865) 6703,4866.18 6703.52,4866.71 6708.19,4871.38 C73.1@6735,4871.38 ; C173.2@6704.78,5910.89 cw(c6714.7,5900.97) 6714.7,5915 ; C173.2@6704.78,5919.11 ccw(c6714.7,5929.03) 6714.7,5915 ; v1@6706.89,4861.11 cw(c6731.67,4836.33) C73.1@6731.67,4871.38 ; v1@6711.11,1208.89 ccw(c6701.72,1218.28) 6715,1218.28 ccw(c6728.28,1218.28) v1@6718.89,1208.89 ; 6720.19,5921.71 cw(c6755.19,5886.72) v1@6755.19,5936.21 ; C71.1@6730.89,4453.36 ccw(c6720.97,4463.29) 6735,4463.29 ccw(c6749.03,4463.28) C71.1@6739.11,4453.36 ; C75.1@6730.89,4544.51 cw(c6720.97,4534.59) 6735,4534.59 cw(c6749.03,4534.6) 6739.11,4544.51 cw(c6749.03,4534.6) 6749.03,4548.62 cw(c6749.03,4562.65) C75.1@6739.11,4552.73 ; C77.1@6730.89,4685.22 cw(c6720.97,4675.3) 6735,4675.3 cw(c6749.03,4675.3) C77.1@6739.11,4685.22 ; C73.1@6730.89,4867.27 ccw(c6720.97,4857.35) 6720.97,4871.38 ccw(c6720.97,4885.41) C73.1@6730.89,4875.49 ; v1@6731.11,4498.89 ccw(c6721.72,4508.28) 6735,4508.28 ccw(c6748.28,4508.28) v1@6738.89,4498.89 ; C71.1@6735,4449.26 6735,4474.85 ; v1(6735,4495) 6735,4474.85 ; 6740.68,5942.2 cw(c6755.19,5927.69) v1@6755.19,5948.21 ; v1@6746.89,4662.44 cw(c6771.34,4689.33) C77.1@6735,4689.33 6735,4665.71 6742.67,4658.04 6742.86,4658.04 v1(6743.19,4658.37) 6767.07,4658.37 6806.86,4618.58 ; v1@6747.08,4654.49 cw(c6756.47,4645.1) 6756.47,4658.37 cw(c6756.47,4671.65) v1@6747.08,4662.26 ; v4(6795.66,6026.73) 6817.91,6048.98 6883.8,6048.98 v1(6885.19,6050.37) ; U15.33@6845.59,4624.25 6812.52,4624.25 6806.86,4618.58 ; 6868.56,6048.98 ccw(c6868.56,6067.01) 6881.3,6054.26 ccw(c6872.37,6063.19) 6885,6063.19 ; C175.1@6870.47,6111.34 cw(c6839.62,6078.06) 6885,6078.06 cw(c6930.38,6078.06) C175.1@6899.53,6111.34 ; v1(6880,1225) 6885,1225 6885.62,1224.38 6885.62,1228.13 6897.48,1240 R256.1@6923.82,1240 ; v1@6880,1230.5 ccw(c6880,1249.77) 6893.63,1236.15 ; 6885,6064.11 ccw(c6898.93,6064.11) v1@6889.08,6054.26 ; C176.1@6891.56,5959.11 ccw(c6881.64,5969.03) 6895.67,5969.03 ccw(c6909.7,5969.03) C176.1@6899.78,5959.11 ; C177.1@6891.56,5995.89 cw(c6881.64,5985.97) 6895.67,5985.97 cw(c6909.7,5985.97) C177.1@6899.78,5995.89 ; C177.1@6891.56,6004.11 ccw(c6881.64,6014.03) 6895.67,6014.03 ccw(c6909.7,6014.03) C177.1@6899.78,6004.11 ; C176.1@6895.67,5955 C177.1@6895.67,6000 6895.67,6034.37 6898.34,6037.04 6898.34,6037.23 v1(6885.19,6050.37) ; C175.1@6917.77,6110.21 cw(c6947.01,6093.17) 6947.01,6127.01 ; C175.1@6917.77,6143.81 ccw(c6947.01,6160.85) 6947.01,6127.01 ; R256.1@6920.06,1236.24 ccw(c6910.98,1227.16) 6910.98,1240 ccw(c6910.98,1252.84) R256.1@6920.06,1243.76 ; R251.1@7022.42,6134.25 ccw(c7013.34,6143.33) 7026.18,6143.33 ccw(c7039.02,6143.33) R251.1@7029.94,6134.25 ; R252.2@7022.42,6185.75 cw(c7013.34,6176.67) 7026.18,6176.67 cw(c7039.02,6176.67) R252.2@7029.94,6185.75 ; R252.2@7022.42,6194.25 ccw(c7013.34,6203.33) 7026.18,6203.33 ccw(c7039.02,6203.33) R252.2@7029.94,6194.25 ; R250.1@7026.18,6250 7026.18,6271.18 v1(7030,6275) ; R250.1@7026.18,6252.5 cw(c7052.5,6252.5) v1@7033.89,6271.11 ; R251.1@7029.94,6126.24 cw(c7039.02,6117.16) 7039.02,6130 cw(c7039.02,6142.84) R251.1@7029.94,6133.76 ; v1@7144.64,1018.82 cw(c7135.25,1009.43) 7148.52,1009.43 cw(c7161.8,1009.43) v1@7152.41,1018.82 ; v1(7148.52,1022.71) 7148.52,995.29 R115.2@7153.82,990 ; NT45.1@7173.19,6112.13 ccw(c7156.54,6128.77) 7180.08,6128.77 ccw(c7203.61,6128.77) NT45.1@7186.97,6112.13 ; NT45.1@7180.08,6105.24 7180.08,6146.82 7160.19,6166.71 7095.86,6166.71 7059.19,6130.04 R251.1@7026.18,6130 R252.2@7026.18,6190 7026.18,6203.82 7016.63,6213.37 6968.52,6213.37 6958.52,6203.37 6958.52,6138.52 6947.01,6127.01 ; R113.1@7192.42,705.75 cw(c7183.34,696.67) 7196.18,696.67 cw(c7209.02,696.67) R113.1@7199.94,705.75 ; R114.1@7192.42,824.25 ccw(c7183.34,833.33) 7196.18,833.33 ccw(c7209.02,833.33) R114.1@7199.94,824.25 ; R113.1@7196.18,710 7196.18,673.82 7208.58,661.42 v4(7234.34,661.42) U19.17@7265.67,661.42 ; R114.1@7196.18,820 7196.18,846.48 7207.97,858.27 v4(7234.34,858.27) ; v1@7248.86,4655.75 U15.11@7294.41,4655.75 7305.37,4666.71 7371.86,4666.71 v1@7385,4653.56 ; v1@7250.08,4651.82 cw(c7259.56,4642.34) 7259.56,4655.75 ; v1@7250.08,4659.6 ccw(c7259.37,4668.89) 7259.37,4655.75 ; C95.1@7255.22,1110.89 cw(c7245.3,1100.97) 7259.33,1100.97 cw(c7273.36,1100.97) C95.1@7263.44,1110.89 ; C95.1@7259.33,1115 7259.33,1060.67 7274.33,1045.67 C91.2@7274.33,990 ; v1@7269.64,944.6 ccw(c7259.91,954.32) 7273.66,954.32 ; C91.2@7270.22,985.89 cw(c7261.91,977.58) 7273.66,977.58 ; C91.2@7270.22,994.11 ccw(c7260.3,1004.03) 7274.33,1004.03 ccw(c7288.36,1004.03) C91.2@7278.44,994.11 ; 7271.17,1350 ccw(c7271.17,1386.97) C93.1@7306.55,1376.26 ; v1@7273.66,940.85 C91.2@7273.66,990 ; 7273.66,953.65 ccw(c7286.46,953.65) v1@7277.41,944.6 ; 7273.66,974.36 cw(c7289.97,974.36) C91.2@7278.44,985.89 ; v1@7279.97,540.49 cw(c7254.13,514.65) C94.1@7290.67,514.65 ; v1(7283.86,544.37) 7290.67,537.56 C94.1@7290.67,515 ; 7287.34,1350 ccw(c7287.34,1382.07) C93.1@7318.04,1372.78 ; C93.1@7295.07,1379.73 cw(c7255,1391.86) NT4.2@7255,1350 7303.01,1350 C93.1@7327.01,1374 7327.01,1311.52 ; U15.11@7306.31,4661.4 cw(c7319.12,4648.6) 7319.12,4666.71 ; C93.1@7310.01,1341.35 cw(c7292.35,1311.53) 7327.01,1311.53 ; U15.11@7314.8,4652.92 cw(c7348.09,4619.63) 7348.09,4666.71 ; v1(7324.76,1293.18) 7321.72,1293.18 7315.19,1299.71 7327.01,1311.52 ; C93.1@7344.01,1341.35 ccw(c7361.66,1311.53) 7327.01,1311.53 ; C76.1@7380.89,4453.36 ccw(c7370.97,4463.29) 7385,4463.29 ccw(c7399.03,4463.28) C76.1@7389.11,4453.36 ; C72.1@7380.89,4685.22 cw(c7370.97,4675.3) 7385,4675.3 cw(c7399.03,4675.3) C72.1@7389.11,4685.22 ; C74.1@7382.58,4542.93 ccw(c7387.85,4555.32) 7397.37,4545.8 ; v1@7384.69,4648.37 ccw(c7371.41,4648.37) 7380.8,4657.76 ccw(c7390.19,4667.15) v1@7390.19,4653.87 ; C76.1@7385,4449.26 7385,4503.9 v1@7390,4508.9 ; 7385,4489.65 cw(c7415.35,4489.65) v1@7393.89,4511.11 ; C74.1@7385,4548.62 7396.86,4548.62 7398.52,4546.96 ; 7385,4674.18 ccw(c7416,4674.18) v1@7394.08,4652.26 ; C72.1@7385,4689.33 7385,4661.9 ; C78.1@7385,4830.04 7436.85,4830.04 v1(7442.52,4835.71) ; C74.1@7387.27,4553.97 ccw(c7395.34,4572.97) 7409.94,4558.37 ; C78.1@7389.11,4825.93 cw(c7399.03,4816.01) 7399.03,4830.04 cw(c7399.03,4844.07) C78.1@7389.11,4834.15 ; v1(7390,4515) 7390,4525.04 7385,4530.04 7385,4533.43 ; v1@7392.81,4519.73 cw(c7400.93,4533.43) 7385,4533.43 ; 7415.55,4830.04 ccw(c7415.55,4862.68) v1@7438.64,4839.6 ; C92.2@7416.56,994.11 ccw(c7406.64,1004.03) 7420.67,1004.03 ccw(c7434.7,1004.03) C92.2@7424.78,994.11 ; C92.2@7420.67,990 7420.67,1070.67 v1@7430,1080 ; 7420.67,1044.39 cw(c7465.8,1044.39) v1@7433.89,1076.3 ; 7420.67,1073.36 cw(c7436.83,1073.36) v1@7425.4,1084.79 ; v1@7446.64,4554.49 ccw(c7437.25,4545.1) 7437.25,4558.37 ccw(c7437.25,4571.65) v1@7446.64,4562.26 ; v1(7450.52,4558.37) 7409.94,4558.37 ; C90.2@7535.67,495 7595.67,495 7600,490.67 v1(7600,445) v1@7600,449.33 ; C90.2@7539.78,490.89 cw(c7549.7,480.97) 7549.7,495 cw(c7549.7,509.03) C90.2@7539.78,499.11 ; v1@7594.64,1300.49 cw(c7582.25,1288.1) 7599.76,1288.1 ; v1@7596.11,448.89 ccw(c7586.72,458.28) 7600,458.28 ccw(c7613.28,458.28) v1@7603.89,448.89 ; v1(7598.52,1304.37) 7598.52,1309.04 7599.76,1310.28 7599.76,1304.37 NT10.1@7599.76,1255.08 ; R248.2@7667.56,1435.75 cw(c7658.48,1426.67) 7671.32,1426.67 cw(c7684.16,1426.67) R248.2@7675.08,1435.75 ; 7671.32,1421.98 ccw(c7692.13,1421.98) v1@7677.41,1407.26 ; R248.2@7671.32,1440 7671.32,1405.52 7672.65,1404.19 7672.86,1404.19 7672.86,1404.04 v1(7673.52,1403.37) ; v1@7700,3355 7731.86,3355 7736.72,3350.13 C246.1@7736.72,3296.18 ; v1@7703.89,3351.3 cw(c7712.81,3342.38) 7712.81,3355 ; v1@7703.89,3359.08 ccw(c7713.75,3368.94) 7713.75,3355 ; v1@7710,3440 7731.86,3440 7736.72,3435.13 C245.1@7736.72,3406.18 ; v1@7713.89,3436.3 cw(c7722.81,3427.38) 7722.81,3440 ; v1@7713.89,3444.08 ccw(c7723.75,3453.94) 7723.75,3440 ; U49.4@7718.66,1610.45 ccw(c7707.74,1621.38) 7723.19,1621.38 ; v1@7719.3,1652.82 cw(c7709.91,1643.43) 7723.19,1643.43 cw(c7736.47,1643.43) v1@7727.08,1652.82 ; U49.4@7723.19,1613.81 v1(7723.19,1656.71) ; C246.1@7732.62,3300.29 ccw(c7722.7,3310.21) 7736.72,3310.21 ccw(c7750.75,3310.21) C246.1@7740.83,3300.29 ; C245.1@7732.62,3410.29 ccw(c7722.7,3420.21) 7736.72,3420.21 ccw(c7750.75,3420.21) C245.1@7740.83,3410.29 ; C228.1@7740.89,4682.11 ccw(c7730.97,4692.03) 7745,4692.03 ccw(c7759.03,4692.03) C228.1@7749.11,4682.11 ; C227.1@7745,4788 7786.19,4788 7786.23,4788 C247.1@7843.66,4788 ; C227.1@7749.11,4783.89 cw(c7759.03,4773.97) 7759.03,4788 cw(c7759.03,4802.03) C227.1@7749.11,4792.11 ; v5@7764.26,4642.48 ccw(c7747.36,4642.48) 7759.31,4654.43 ccw(c7771.26,4666.38) v5@7771.26,4649.48 ; v5(7771.26,4642.48) 7740.37,4673.37 C228.1@7745,4678 7745,4700 7756.71,4711.71 v1(7795.19,4711.71) ; 7772.81,4788 ccw(c7772.81,4801.42) v1@7782.3,4791.93 ; 7773.01,4788 cw(c7773.01,4774.86) v1@7782.3,4784.15 ; v1@7790.08,4784.15 cw(c7799.37,4774.86) 7799.37,4788 ; v1@7790.08,4791.93 ccw(c7799.57,4801.42) 7799.57,4788 ; v1@7791.3,4707.82 ccw(c7781.91,4698.43) 7781.91,4711.71 ccw(c7781.91,4724.99) v1@7791.3,4715.6 ; C247.1@7839.55,4792.11 cw(c7829.63,4802.03) 7829.63,4788 cw(c7829.63,4773.97) 7839.55,4783.89 cw(c7829.63,4773.97) 7843.66,4773.97 cw(c7857.69,4773.97) C247.1@7847.77,4783.89 ; C247.1@7843.66,4788 7843.66,4751.34 7846.75,4748.25 7883.25,4748.25 7890.02,4741.48 7890.02,4683.02 C248.1@7885,4678 ; C254.1@7872.62,3300.29 ccw(c7862.7,3310.21) 7876.72,3310.21 ccw(c7890.75,3310.21) C254.1@7880.83,3300.29 ; v1(7872.86,2225.04) 7877.9,2220 R39.1@7908.82,2220 ; v1@7876.75,2228.93 ccw(c7898.31,2250.49) R39.1@7898.31,2220 ; C254.1@7876.72,3296.18 7876.72,3328.24 v1(7906.86,3358.37) ; C253.1@7880.83,3402.07 cw(c7890.75,3392.15) 7890.75,3406.18 cw(c7890.75,3420.21) C253.1@7880.83,3410.29 ; C248.1@7880.89,4682.11 ccw(c7858.84,4704.16) 7890.02,4704.16 ; U70.6@7886.85,3783.67 7926.33,3783.67 7931.86,3778.14 v1(7931.86,3758.37) ; 7899.28,3406.18 ccw(c7899.28,3421.81) v1@7912.25,3413.08 ; v1@7901.36,3358.37 cw(c7888.08,3358.37) 7897.47,3348.99 cw(c7906.86,3339.6) v1@7906.86,3352.87 ; v1@7902.3,3419.78 cw(c7876.73,3437.01) C253.1@7876.72,3406.18 7896.33,3406.18 v1(7906.86,3416.71) ; R39.1@7905.06,2216.24 ccw(c7895.98,2207.16) 7895.98,2220 ccw(c7895.98,2232.84) R39.1@7905.06,2223.76 ; v1@7927.97,3762.26 ccw(c7918.58,3771.65) 7931.86,3771.65 ccw(c7945.14,3771.65) v1@7935.75,3762.26 ; 7943.52,1962.39 ccw(c7933.25,1972.66) R163.1@7946.38,1978.89 ; C39.2@7946.56,2514.11 ccw(c7936.64,2524.03) 7950.67,2524.03 ccw(c7964.7,2524.03) C39.2@7954.78,2514.11 ; R161.1@7947.9,1878.66 cw(c7954.28,1867.34) 7963.47,1876.53 ; C39.2@7950.67,2510 7950.67,2545 7956.38,2550.71 v1(7975.86,2550.71) ; R162.1@7951.18,1765 7952.53,1765 7982.73,1795.19 v1(7985,1795.19) ; R162.1@7951.18,1770.81 ccw(c7951.18,1788.1) 7963.41,1775.88 ; R161.1@7951.18,1867.52 cw(c7951.18,1816.11) 7987.54,1852.46 ; R161.1@7951.18,1873.33 7966.67,1873.33 7985,1855 v1(7985,1795.19) ; R161.1@7951.18,1879.52 cw(c7951.18,1857.08) 7967.05,1872.95 ; R163.1@7951.18,1981.67 7951.18,1970.05 7937.96,1956.82 7937.96,1938.75 7950.73,1925.98 7960.88,1925.98 v1@7981.86,1905 ; R161.1@7953.79,1868.21 cw(c7962.34,1853.03) 7974.66,1865.34 ; R161.1@7954.94,1869.57 cw(c7964.02,1860.49) 7964.02,1873.33 cw(c7964.02,1886.17) R161.1@7954.94,1877.09 ; v1@7968.64,2402.93 ccw(c7959.25,2412.32) 7972.52,2412.32 ccw(c7985.8,2412.32) v1@7976.41,2402.93 ; U4.5@7971.51,2451.01 cw(c7981.43,2441.09) 7981.43,2455.12 cw(c7981.43,2469.15) U4.5@7971.51,2459.23 ; 7971.73,1784.2 cw(c7985,1770.93) v1@7985,1789.69 ; v1@7971.97,2546.82 ccw(c7962.58,2537.43) 7962.58,2550.71 ccw(c7962.58,2563.99) v1@7971.97,2554.6 ; 7972.14,1914.72 ccw(c7981.86,1924.44) v1@7981.86,1910.69 ; 7972.61,1914.25 cw(c7963.55,1905.19) v1@7976.36,1905.19 ; v1@7981.11,1799.08 ccw(c7971.72,1808.47) 7985,1808.47 ccw(c7998.28,1808.47) v1@7988.89,1799.08 ; v1@7985,1795 v1(7985,1795.19) ; v1@8044.69,2485.04 cw(c8031.41,2485.04) 8040.8,2475.65 cw(c8050.19,2466.26) v1@8050.19,2479.54 ; v1@8046.3,2488.93 ccw(c8036.91,2498.32) 8050.19,2498.32 ccw(c8063.47,2498.32) v1@8054.08,2488.93 ; R131.2@8070.06,2506.24 ccw(c8060.98,2497.16) 8060.98,2510 ccw(c8060.98,2522.84) R131.2@8070.06,2513.76 ; R131.2@8073.82,2510 8055,2510 8050.19,2505.19 v1(8050.19,2485.04) 8020.27,2455.12 U4.5@7967.4,2455.12 7967.4,2425 7972.52,2419.88 v1@7972.52,2400.92 ; -354.99,2714.99 -349.93,2720.04 -340,2720.04 ; v1@2975,5717.52 v1(2975.19,5717.71) v1@2975,5717.52 ; v1@4001.73,5586.17 v1(4004.52,5583.37) v1@4001.73,5586.17 ; v1@4777.69,3931.69 4780,3934 v1@4777.69,3931.69 ; 4961.8,2641.71 cw(c4961.8,2654.99) 4952.41,2645.6 ccw(c4961.8,2654.99) 4961.8,2641.71 ; 4961.8,2641.71 ccw(c4961.8,2628.43) 4952.41,2637.82 cw(c4961.8,2628.43) 4961.8,2641.71 ; 5997.77,5495 R271.2@6068.82,5495 5997.77,5495 ; 6055.98,5495 ccw(c6055.98,5507.84) 6065.06,5498.76 cw(c6055.98,5507.84) 6055.98,5495 ; 6055.98,5495 cw(c6055.98,5482.16) 6065.06,5491.24 ccw(c6055.98,5482.16) 6055.98,5495 ; 6735,4474.85 6735,4483.04 C75.1@6735,4548.62 6779.19,4548.62 6780.52,4549.96 6780.52,4550.04 6781.86,4550.04 6806.86,4575.04 6806.86,4618.58 ; 6735,4481.72 cw(c6748.28,4481.72) 6738.89,4491.11 ccw(c6748.28,4481.72) 6735,4481.72 ; 6735,4481.72 ccw(c6721.72,4481.72) 6731.11,4491.11 cw(c6721.72,4481.72) 6735,4481.72 ; v1(6885.19,6050.37) 6885,6050.56 C175.1@6885,6127.01 6947.01,6127.01 ; 7385,4533.43 7392.6,4541.03 7398.52,4546.96 ; 7385,4534.59 ccw(c7370.97,4534.59) 7380.89,4544.51 cw(c7370.97,4534.59) 7385,4534.59 ; 7385,4534.6 cw(c7399.03,4534.6) 7389.11,4544.51 ccw(c7399.03,4534.6) 7385,4534.6 ; v1@7385,4653.56 v1(7390.19,4648.37) 7390.19,4656.71 7385,4661.9 ; v1@7385,4653.56 7385,4661.9 ; 7398.52,4546.96 7409.94,4558.37 ; 7967.4,2428.29 ccw(c7953.37,2428.29) 7963.29,2438.21 cw(c7953.37,2428.29) 7967.4,2428.29 ; 7967.4,2428.29 cw(c7981.43,2428.29) 7971.51,2438.21 ccw(c7981.43,2428.29) 7967.4,2428.29 ; v1@7972.52,2400.92 7973.4,2400.04 v1(7972.52,2399.04) v1@7972.52,2400.92
  Bottom Layer w20: v2@5233.72,5113.72 cw(c5209.34,5089.34) R77.2@5243.82,5089.34 ; v2(5235,5115) 5243.82,5106.18 R77.2@5243.82,5085
  other v1: 6325,1010 6704.52,1010.71 7430,1080.19 410,1450 2480,1450 168,1461.51 193,1461.51 2835,1462.5 2890.83,1462.5 2191.14,1465 2295,1465 2835,1485 2890.83,1485 168,1487.5 193,1487.5 2191.14,1487.5 2295,1487.5 375,1490 445,1490 2445,1490 2515,1490 2835,1507.5 2890.83,1507.5 2191.14,1510 2295,1510 168,1513.5 193,1513.5 375,1516.67 445,1516.67 2445,1516.67 2515,1516.67 168,1539.5 193,1539.5 375,1543.33 445,1543.33 2445,1543.33 2515,1543.33 375,1570 445,1570 2445,1570 2515,1570 195,1585 165,1601.02 345,1605 371,1605 445,1605 471,1605 165,1627.01 345,1630 371,1630 445,1630 471,1630 165,1653.01 345,1655 371,1655 445,1655 471,1655 165,1679 680,1690.02 769.51,1702.91 792.01,1702.91 165,1705 680,1716.02 705.01,1716.06 165,1731 680,1742.01 705.01,1742.05 165,1756.99 680,1768.01 705.01,1768.05 165,1782.99 680,1794 705.01,1794.04 165,1808.98 680,1820 705.01,1820.04 747.01,1824.96 769.51,1824.96 792.01,1824.96 165,1834.98 680,1846 705.01,1846.04 165,1860.98 21.14,1885 125,1885 7981.86,1905.19 21.14,1907.5 125,1907.5 165,1919 21.14,1930 125,1930 165,1945 680,1949.98 705,1950.02 165,1971 680,1975.98 705,1976.02 165,1999 679.99,2001.97 705,2002.01 165,2025 679.99,2027.97 705,2028.01 165,2051 679.99,2053.96 705,2054 679.99,2079.96 705,2080 220,2145 246,2145 315,2145 341,2145 366.99,2145 392.99,2145 418.98,2145 444.98,2145 470.98,2145 496.97,2145.01 522.97,2145.01 548.96,2145.01 574.96,2145.01 220,2175 246,2175 315,2175 341,2175 366.99,2175 392.99,2175 418.98,2175 444.98,2175 470.98,2175 496.97,2175.01 522.97,2175.01 548.96,2175.01 574.96,2175.01 7885,2285 5560,2335 7340,2355 7275,2482 5360.19,2641.71 8140,2905.19 776.83,3143.04 808.33,3143.04 7700,3355.19 7710,3440.19 5255.52,3545.37 5920,3660 8027.52,3882.23 4770,3935 4694,4129 6198.52,4208.37 6013,4354 7786.19,4788.04 4033.82,5516.37 3045,5675.19
  other v2: 5538.07,3519.01 4945,3565 6049.4,3915.9 5785,5665 6455,5980
3V3A: C53.2 L2.2 U5.36 | length 1127.5
  MidLayer2 w12: v1(2489.52,5733.37) 2842.52,5733.37 v1(2906.86,5669.04) ; v1@2493.41,5729.49 cw(c2502.8,5720.1) 2502.8,5733.37 cw(c2502.8,5746.65) v1@2493.41,5737.26 ; v1@2901.36,5669.04 ccw(c2888.08,5669.04) 2897.47,5678.43 ccw(c2906.86,5687.82) v1@2906.86,5674.54
  Bottom Layer w12: U5.36@2469.13,5657.32 2469.13,5712.98 v1(2489.52,5733.37) ; v1@2484.02,5733.37 cw(c2470.75,5733.37) 2480.14,5723.99 cw(c2489.52,5714.6) v1@2489.52,5727.87 ; v1@2902.97,5665.15 cw(c2893.58,5655.76) 2906.86,5655.76 cw(c2920.14,5655.76) v1@2910.75,5665.15 ; v1(2906.86,5669.04) 2906.86,5608.37 2930.12,5585.12 3024.88,5585.12 3054.06,5555.94 L2.2@3125,5555.94 3145.67,5535.28 C53.2@3145.67,5500 ; L2.2@3085.8,5546.27 ccw(c3062.43,5522.91) 3062.43,5555.94 ccw(c3062.43,5588.98) L2.2@3085.8,5565.62 ; C53.2@3141.56,5504.11 ccw(c3131.64,5514.03) 3145.67,5514.03 ccw(c3159.7,5514.03) C53.2@3149.78,5504.11 ; C53.2@3145.67,5501.52 cw(c3208.95,5501.52) L2.2@3164.2,5546.27 ; 3145.67,5530.49 cw(c3179.98,5530.49) L2.2@3155.72,5554.75
3V3SET: R205.1 R206.1 U41.1 | length 445.6
  Bottom Layer w4: U41.1@510,1525 U41.1@510.04,1525.04
  Bottom Layer w12: U41.1@510,1525 545,1560 710,1560 741.18,1591.18 R205.1@741.18,1625 R206.1@833.82,1625 ; R205.1@737.42,1620.75 cw(c728.34,1611.67) 741.18,1611.67 cw(c754.02,1611.67) R205.1@744.94,1620.75 ; R205.1@744.94,1621.24 cw(c754.02,1612.16) 754.02,1625 cw(c754.02,1637.84) R205.1@744.94,1628.76 ; R206.1@830.06,1621.24 ccw(c820.98,1612.16) 820.98,1625 ccw(c820.98,1637.84) R206.1@830.06,1628.76