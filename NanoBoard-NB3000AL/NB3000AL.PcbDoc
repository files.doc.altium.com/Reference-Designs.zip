# Altium PCB NB3000AL.PcbDoc (part 37 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_SRAM1.D6: U8.G24 U14.15 | length 1229.2
  Top Layer w4: U8.G24@5764.02,4485.28 v3(5783.7,4504.96) ; U8.G24@5764.02,4492.62 ccw(c5764.02,4510.34) 5776.55,4497.81 ccw(c5789.08,4485.28) U8.G24@5771.36,4485.28 ; 5770.9,4492.16 cw(c5783.7,4479.35) 5783.7,4497.46 ccw(c5783.7,4479.35) 5770.9,4492.16 ; 5770.9,4492.16 ccw(c5758.09,4504.96) 5776.2,4504.96 cw(c5758.09,4504.96) 5770.9,4492.16
  MidLayer1 w4: v3@5784.35,4512.43 ccw(c5785.93,4530.47) 5797.57,4516.6 ccw(c5809.21,4502.73) v3@5791.17,4504.31 ; 5797.28,4516.35 cw(c5807.21,4506.42) 5807.21,4520.47 5821.14,4520.47 5881.33,4520.47 5900.75,4520.47 5941.18,4520.47 5950.47,4520.47 6001.68,4520.47 6008.25,4527.05 6040.63,4559.42 6041.23,4559.42 6048.52,4566.71 6048.52,4583.37 6081.86,4616.71 6232.11,4616.71 6267.1,4651.7 6268.81,4653.41 6294.9,4653.41 6307.44,4640.87 6355,4640.87 6360.83,4646.71 v1(6395.19,4646.71) ; v1@6388.47,4639.99 ccw(c6372.26,4623.77) 6372.26,4646.71 ccw(c6372.26,4669.64) v1@6388.47,4653.43 ; v1@6391.3,4642.82 ccw(c6381.91,4633.43) 6381.91,4646.71 ccw(c6381.91,4659.99) v1@6391.3,4650.6
  Bottom Layer w4: v1@6395.19,4637.21 cw(c6395.19,4614.27) 6411.41,4630.49 cw(c6427.63,4646.71) v1@6404.69,4646.71 ; v1@6395.19,4641.21 cw(c6395.19,4627.93) 6404.58,4637.32 cw(c6413.97,4646.71) v1@6400.69,4646.71 ; v1(6395.19,4646.71) 6486.9,4555 6544.53,4555 6569.76,4529.76 U14.15@6619.41,4529.76 ; U14.15@6596.19,4524.11 ccw(c6582.54,4510.45) 6582.54,4529.76 ccw(c6582.54,4549.08) U14.15@6596.19,4535.42
DB_SRAM1.D7: U8.H23 U14.16 | length 1433
  Top Layer w4: U8.H23@5724.65,4445.91 v3(5744.33,4465.59) ; U8.H23@5724.65,4453.25 ccw(c5724.65,4470.97) 5737.18,4458.44 ccw(c5749.71,4445.91) U8.H23@5731.99,4445.91 ; 5731.53,4452.79 cw(c5744.33,4439.98) 5744.33,4458.09 ccw(c5744.33,4439.98) 5731.53,4452.79 ; 5731.53,4452.79 ccw(c5718.72,4465.59) 5736.83,4465.59 cw(c5718.72,4465.59) 5731.53,4452.79
  MidLayer1 w4: v3@5744.98,4473.06 ccw(c5746.56,4491.1) 5758.2,4477.23 ; v3@5751.8,4464.94 cw(c5769.84,4463.36) 5758.2,4477.23 ; 5821.14,4489.45 5807.21,4489.45 ; v1@6666.81,4569.32 ccw(c6650.59,4553.11) 6650.59,4576.04 ccw(c6650.59,4598.98) v1@6666.81,4582.76 ; v1@6669.64,4572.15 ccw(c6660.25,4562.76) 6660.25,4576.04 ccw(c6660.25,4589.32) v1@6669.64,4579.93 ; v1(6673.52,4576.04) 6583.84,4576.04 6531.38,4628.5 6495,4628.5 6301,4628.5 6281.04,4608.54 6255,4608.54 6204.04,4608.54 6120.72,4525.21 6115.36,4525.21 6100,4525.21 6080.04,4525.21 6076.75,4528.5 6034.57,4528.5 5995.52,4489.45 5950.55,4489.45 5941.18,4489.45 5900.75,4489.45 5881.33,4489.45 5807.21,4489.45 ; 5758.2,4477.23 cw(c5787.71,4447.72) 5787.71,4489.45 5807.21,4489.45
  Bottom Layer w4: U14.16@6619.41,4498.27 6622.02,4500.87 6660.37,4500.87 ; U14.16@6639.98,4495.63 cw(c6651.55,4485.49) 6651.55,4500.87 ; U14.16@6642.63,4503.92 ccw(c6649.99,4511.28) 6649.99,4500.87 ; U14.16@6642.98,4492.99 cw(c6660.37,4477.75) 6660.37,4500.87 ; v1@6666.81,4569.32 cw(c6650.59,4553.11) 6673.52,4553.11 cw(c6696.46,4553.11) v1@6680.24,4569.32 ; v1@6669.64,4572.15 cw(c6660.25,4562.76) 6673.52,4562.76 cw(c6686.8,4562.76) v1@6677.41,4572.15 ; v1(6673.52,4576.04) 6673.52,4514.02 6660.37,4500.87
DB_SRAM1.D8: U8.G25 U14.29 | length 859.1
  Top Layer w4: U8.G25@5803.39,4485.28 v3(5823.07,4504.96) ; U8.G25@5803.39,4492.62 ccw(c5803.39,4510.34) 5815.92,4497.81 ccw(c5828.45,4485.28) U8.G25@5810.73,4485.28 ; 5810.27,4492.16 cw(c5823.07,4479.35) 5823.07,4497.46 ccw(c5823.07,4479.35) 5810.27,4492.16 ; 5810.27,4492.16 ccw(c5797.46,4504.96) 5815.57,4504.96 cw(c5797.46,4504.96) 5810.27,4492.16
  MidLayer1 w4: v3(5823.07,4504.96) 5881.33,4504.96 5900.75,4504.96 5941.18,4504.96 5950.04,4504.96 5999.71,4504.96 6031.25,4536.5 6080.06,4536.5 6090.19,4546.63 6090.19,4560 6081.86,4568.33 v1(6081.86,4591.71) ; v3@5828.26,4499.77 cw(c5840.8,4487.23) 5840.8,4504.96 cw(c5840.8,4522.69) v3@5828.26,4510.15 ; v1@6075.14,4584.99 cw(c6058.92,4568.77) 6081.86,4568.77 cw(c6104.79,4568.77) v1@6088.57,4584.99 ; v1@6077.97,4587.82 cw(c6068.58,4578.43) 6081.86,4578.43 cw(c6095.14,4578.43) v1@6085.75,4587.82 ; 5841.18,4504.96 cw(c5841.18,4523.07) 5828.37,4510.26 ccw(c5841.18,4523.07) 5841.18,4504.96 ; 5841.18,4504.96 ccw(c5841.18,4486.85) 5828.37,4499.66 cw(c5841.18,4486.85) 5841.18,4504.96
  Bottom Layer w4: v1@6075.14,4584.99 cw(c6058.92,4568.77) 6081.86,4568.77 cw(c6104.79,4568.77) v1@6088.57,4584.99 ; v1@6077.97,4587.82 cw(c6068.58,4578.43) 6081.86,4578.43 cw(c6095.14,4578.43) v1@6085.75,4587.82 ; v1(6081.86,4591.71) 6081.86,4563.33 6090.19,4555 6090.19,4526.71 6108.52,4508.37 6135,4508.37 6145.11,4498.27 U14.29@6150,4498.27 ; 6138.96,4504.41 ccw(c6143.43,4508.88) U14.29@6147.66,4504.2 ; 6141.93,4501.44 ccw(c6146.25,4505.76) U14.29@6150.35,4501.23 ; U14.29@6167.89,4498.27 U14.29@6150,4498.27 ; U14.29@6188.27,4498.27 U14.29@6150,4498.27
DB_SRAM1.D9: U8.E28 U14.30 | length 393.3
  Top Layer w4: U8.E28@5921.5,4564.02 5941.18,4564.02 5949.18,4564.02 5965.45,4564.02 5996.09,4533.37 6006.63,4533.37 6098.52,4533.37 v1(6111.19,4546.04) ; U8.E28@5926.69,4558.82 cw(c5939.22,4546.29) 5939.22,4564.02 cw(c5939.22,4581.74) U8.E28@5926.69,4569.21
  Bottom Layer w4: v1@6111.19,4536.54 cw(c6111.19,4513.61) 6127.41,4529.82 cw(c6143.63,4546.04) v1@6120.69,4546.04 ; v1@6111.19,4540.54 cw(c6111.19,4527.26) 6120.58,4536.65 cw(c6129.97,4546.04) v1@6116.69,4546.04 ; v1(6111.19,4546.04) 6127.47,4529.76 U14.30@6175,4529.76 ; U14.30@6147.37,4524.11 ccw(c6133.72,4510.45) 6133.72,4529.76 ccw(c6133.72,4549.08) U14.30@6147.37,4535.42
DB_SRAM1.D10: U8.D26 U14.31 | length 834
  Top Layer w4: v1@6036.02,4733.37 cw(c6013.09,4733.37) 6029.31,4717.16 cw(c6045.52,4700.94) v1@6045.52,4723.87 ; v1@6040.02,4733.37 cw(c6026.75,4733.37) 6036.14,4723.99 cw(c6045.52,4714.6) v1@6045.52,4727.87 ; v1(6045.52,4733.37) 6025,4712.85 6025,4685 6030,4680 6030,4636.31 6014.19,4620.5 5997.07,4620.5 5976.94,4620.5 5970.19,4627.25 5949.18,4627.25 5941.18,4627.25 ; 5855.29,4615.92 cw(c5842.76,4628.45) 5842.76,4610.73 ccw(c5842.76,4628.45) 5855.29,4615.92 ; 5855.29,4615.92 ccw(c5867.82,4603.39) 5850.1,4603.39 cw(c5867.82,4603.39) 5855.29,4615.92 ; 5855.29,4615.92 cw(c5882.64,4588.57) 5882.64,4627.25 ; 5855.29,4615.92 cw(c5882.64,4588.57) 5882.64,4627.25 ; 5882.64,4627.25 5941.18,4627.25 ; 5882.64,4627.25 5941.18,4627.25
  Bottom Layer w4: v1@6045.52,4723.87 cw(c6045.52,4700.94) 6061.74,4717.16 cw(c6077.96,4733.37) v1@6055.02,4733.37 ; v1@6045.52,4727.87 cw(c6045.52,4714.6) 6054.91,4723.99 cw(c6064.3,4733.37) v1@6051.02,4733.37 ; v1(6045.52,4733.37) 6100.86,4678.04 6100.86,4629.14 6130,4600 6130,4575 6143.74,4561.26 U14.31@6170.59,4561.26 ; 6134.65,4570.35 ccw(c6143.3,4579.01) U14.31@6149.19,4568.27 ; 6138.42,4566.58 ccw(c6145.97,4574.14) U14.31@6151.11,4564.77 ; 6142.19,4562.81 ccw(c6148.65,4569.26) U14.31@6153.03,4561.26
DB_SRAM1.D11: U8.D28 U14.32 | length 864.5
  Top Layer w4: U8.D28@5921.5,4603.39 5941.18,4603.39 5949.18,4603.39 5986.61,4603.39 v1(5995,4595) ; U8.D28@5926.69,4598.19 cw(c5939.22,4585.66) 5939.22,4603.39 cw(c5939.22,4621.11) U8.D28@5926.69,4608.58 ; 5951.82,4603.39 cw(c5951.82,4551.82) v1@5988.28,4588.28 ; 5961.48,4603.39 cw(c5961.48,4561.48) v1@5991.11,4591.11 ; 5971.13,4603.39 cw(c5971.13,4571.13) v1@5993.94,4593.94 ; 5980.79,4603.39 cw(c5980.79,4580.79) v1@5996.77,4596.77
  MidLayer2 w4: v1(5995,4595) 6027.04,4627.04 6060,4627.04 6082.59,4627.04 6094.63,4615 6235,4615 6261.86,4615 v1(6281.86,4635) ; v1@5995,4600.5 ccw(c5995,4613.78) 6004.39,4604.39 ccw(c6013.78,4595) v1@6000.5,4595 ; v1@5995,4604.5 ccw(c5995,4627.43) 6011.22,4611.22 ccw(c6027.43,4595) v1@6004.5,4595 ; v1@6272.36,4635 cw(c6249.42,4635) 6265.64,4618.78 cw(c6281.86,4602.56) v1@6281.86,4625.5 ; v1@6276.36,4635 cw(c6263.08,4635) 6272.47,4625.61 cw(c6281.86,4616.22) v1@6281.86,4629.5
  Bottom Layer w4: U14.32@6170.59,4592.75 6220,4592.75 6239.61,4592.75 v1(6281.86,4635) ; U14.32@6193.81,4587.1 cw(c6207.46,4573.44) 6207.46,4592.75 cw(c6207.46,4612.07) U14.32@6193.81,4598.41 ; v1@6272.36,4635 cw(c6249.42,4635) 6265.64,4618.78 cw(c6281.86,4602.56) v1@6281.86,4625.5 ; v1@6276.36,4635 cw(c6263.08,4635) 6272.47,4625.61 cw(c6281.86,4616.22) v1@6281.86,4629.5
DB_SRAM1.D12: U8.G10 U14.35 | length 3789.7
  Top Layer w4: v3(5193.15,4504.96) U8.G10@5212.83,4485.28 ; U8.G10@5205.49,4485.28 ccw(c5187.77,4485.28) 5200.3,4497.81 ccw(c5212.83,4510.34) U8.G10@5212.83,4492.62 ; 5205.95,4492.16 cw(c5218.76,4504.96) 5200.65,4504.96 ccw(c5218.76,4504.96) 5205.95,4492.16 ; 5205.95,4492.16 ccw(c5193.15,4479.35) 5193.15,4497.46 cw(c5193.15,4479.35) 5205.95,4492.16
  MidLayer2 w4: 5177.64,4542.4 5177.64,4528.47 ; 5177.64,4738.53 5177.64,4680.27 ; 5181.76,4518.54 cw(c5191.69,4528.47) 5177.64,4528.47 ; v3@5185.68,4505.61 ccw(c5167.64,4507.19) 5181.51,4518.83 ccw(c5195.38,4530.47) v3@5193.8,4512.43 ; v1(6256.86,4766.71) 6273.52,4783.37 6365.19,4783.37 6431.86,4850.04 v1(6473.52,4850.04) ; v1@6256.86,4772.21 ccw(c6256.86,4785.49) 6266.25,4776.1 ccw(c6275.64,4766.71) v1@6262.36,4766.71 ; v1@6256.86,4776.21 ccw(c6256.86,4799.14) 6273.07,4782.93 ccw(c6289.29,4766.71) v1@6266.36,4766.71 ; v1@6466.81,4843.32 ccw(c6450.59,4827.11) 6450.59,4850.04 ccw(c6450.59,4872.98) v1@6466.81,4856.76 ; v1@6469.64,4846.15 ccw(c6460.25,4836.76) 6460.25,4850.04 ccw(c6460.25,4863.32) v1@6469.64,4853.93 ; v1(6506.86,4941.71) 6533.86,4941.71 6548.52,4956.37 6548.52,5000.04 6465.19,5083.37 6465.19,5166.71 6448.52,5183.37 5768.86,5183.37 5760.48,5175 5615,5175 5610,5180 5516.46,5180 5511.25,5185.21 5483.69,5185.21 5473.52,5175.04 5473.52,5157.37 5480.86,5150.04 5573.52,5150.04 5583.48,5160 5607.37,5160 5620,5147.37 5620,5135 5609.21,5124.21 5591.28,5124.21 5582.11,5133.37 5486.82,5133.37 5486.66,5133.21 5465.35,5133.21 5465.19,5133.37 5423.52,5091.71 5400.21,5091.71 5340.86,5032.36 5325.5,5017 5178.31,5017 5061.69,4900.37 5054.52,4900.37 5040.35,4886.2 5040.35,4869.65 5046.84,4863.16 5054,4856 5069.69,4856 5140.94,4856 5174,4856 5193.5,4836.5 5193.5,4803.44 5178.56,4788.5 5177.64,4787.58 5177.64,4782.36 5177.64,4749.18 5177.64,4741.18 5177.64,4680.27 ; v1@6510.75,4937.82 cw(c6520.14,4928.43) 6520.14,4941.71 cw(c6520.14,4954.99) v1@6510.75,4945.6 ; v1@6513.57,4934.99 cw(c6529.79,4918.77) 6529.79,4941.71 cw(c6529.79,4964.64) v1@6513.57,4948.43 ; 5177.64,4528.47 5177.64,4622.01 5177.64,4680.27
  Bottom Layer w4: U14.35@6193.81,4681.59 cw(c6207.46,4667.93) 6207.46,4687.24 cw(c6207.46,4706.56) U14.35@6193.81,4692.9 ; v1@6250.14,4759.99 cw(c6233.92,4743.77) 6256.86,4743.77 cw(c6279.79,4743.77) v1@6263.57,4759.99 ; v1@6252.97,4762.82 cw(c6243.58,4753.43) 6256.86,4753.43 cw(c6270.14,4753.43) v1@6260.75,4762.82 ; v1(6256.86,4766.71) 6256.86,4704.1 6240,4687.24 U14.35@6171.47,4687.24 ; v1(6473.52,4850.04) 6506.86,4883.37 v1(6506.86,4941.71) ; v1@6473.52,4855.54 ccw(c6473.52,4868.82) 6482.91,4859.43 ccw(c6492.3,4850.04) v1@6479.02,4850.04 ; v1@6473.52,4859.54 ccw(c6473.52,4882.48) 6489.74,4866.26 ccw(c6505.96,4850.04) v1@6483.02,4850.04 ; v1@6500.14,4934.99 cw(c6483.92,4918.77) 6506.86,4918.77 cw(c6529.79,4918.77) v1@6513.57,4934.99 ; v1@6502.97,4937.82 cw(c6493.58,4928.43) 6506.86,4928.43 cw(c6520.14,4928.43) v1@6510.75,4937.82 ; U14.35@6171.47,4687.24 U14.35@6170.59,4687.24 U14.35@6171.47,4687.24
DB_SRAM1.D13: U8.B19 U14.36 | length 2012.8
  Top Layer w4: 5582,4827.25 5578.5,4830.75 ; v1@5712.69,5110.71 ccw(c5689.76,5110.71) 5705.97,5126.93 ccw(c5722.19,5143.14) v1@5722.19,5120.21 ; v1@5716.69,5110.71 ccw(c5703.41,5110.71) 5712.8,5120.1 ccw(c5722.19,5129.49) v1@5722.19,5116.21 ; v1(5722.19,5110.71) 5691.19,5141.71 5643.71,5141.71 5564.52,5062.52 5564.52,4962 5575.65,4950.87 5589.11,4950.87 5599.36,4940.62 5599.36,4882.31 5578.5,4861.45 5578.5,4830.75 ; 5578.5,4830.75 5582.67,4826.58 5582.67,4748.33 5582.67,4740.67 5582.67,4701.84 ; 5579.7,4694.66 ccw(c5572.52,4701.84) 5582.67,4701.84 ; 5579.7,4694.66 ccw(c5592.23,4682.13) 5574.51,4682.13 cw(c5592.23,4682.13) 5579.7,4694.66 ; 5579.7,4694.66 cw(c5567.17,4707.19) 5567.17,4689.47 ccw(c5567.17,4707.19) 5579.7,4694.66 ; 5579.7,4694.66 ccw(c5572.52,4701.84) 5582.67,4701.84
  MidLayer2 w4: v1@5722.19,5101.21 cw(c5722.19,5078.27) 5738.41,5094.49 cw(c5754.63,5110.71) v1@5731.69,5110.71 ; v1@5722.19,5105.21 cw(c5722.19,5091.93) 5731.58,5101.32 cw(c5740.97,5110.71) v1@5727.69,5110.71 ; v1(5722.19,5110.71) 5783.69,5049.21 5966.79,5049.21 6001.29,5083.71 6214.98,5083.71 6282.19,5016.5 6282.19,4963.98 6323.52,4922.65 v1(6323.52,4850.04) ; v1@6316.81,4856.76 ccw(c6300.59,4872.98) 6323.52,4872.98 ccw(c6346.46,4872.98) v1@6330.24,4856.76 ; v1@6319.64,4853.93 ccw(c6310.25,4863.32) 6323.52,4863.32 ccw(c6336.8,4863.32) v1@6327.41,4853.93
  Bottom Layer w4: U14.36@6195.44,4715.44 cw(c6200.55,4713.12) 6200.55,4718.74 ; U14.36@6195.44,4722.04 ccw(c6200.55,4724.36) 6200.55,4718.74 ; v1@6316.81,4843.32 cw(c6300.59,4827.11) 6323.52,4827.11 cw(c6346.46,4827.11) v1@6330.24,4843.32 ; v1@6319.64,4846.15 cw(c6310.25,4836.76) 6323.52,4836.76 cw(c6336.8,4836.76) v1@6327.41,4846.15 ; v1(6323.52,4850.04) 6323.52,4808.52 6305,4790 6250,4790 6235,4775 6235,4730 6223.74,4718.74 U14.36@6170.59,4718.74 6200.55,4718.74
DB_SRAM1.D14: U8.D21 U14.37 | length 1146.9
  Top Layer w4: U8.D21@5645.91,4603.39 v3(5665.59,4623.07) ; U8.D21@5645.91,4610.73 ccw(c5645.91,4628.45) 5658.44,4615.92 ccw(c5670.97,4603.39) U8.D21@5653.25,4603.39 ; 5652.79,4610.27 cw(c5665.59,4597.46) 5665.59,4615.57 ccw(c5665.59,4597.46) 5652.79,4610.27 ; 5652.79,4610.27 ccw(c5639.98,4623.07) 5658.09,4623.07 cw(c5639.98,4623.07) 5652.79,4610.27
  MidLayer1 w4: v3@5660.29,4628.37 ccw(c5647.48,4641.18) 5665.59,4641.18 ccw(c5683.7,4641.18) v3@5670.89,4628.37 ; v3@5660.4,4628.26 ccw(c5647.86,4640.8) 5665.59,4640.8 ccw(c5683.32,4640.8) v3@5670.78,4628.26 ; v3(5665.59,4623.07) 5665.59,4700.75 5665.59,4741.18 5665.59,4749.18 5665.59,4764.58 5677.08,4776.07 5677.08,4785.32 5697.81,4806.05 5697.81,4838.41 5748.4,4889 5843.39,4889 5851.39,4881 5875.8,4881 5905.94,4881 5909.44,4884.5 5942.31,4884.5 6061.43,4765.38 6068.52,4765.38 v1(6099.52,4734.37) ; v1@6090.02,4734.37 ccw(c6067.09,4734.37) 6083.31,4750.59 ccw(c6099.52,4766.81) v1@6099.52,4743.87 ; v1@6094.02,4734.37 ccw(c6080.75,4734.37) 6090.14,4743.76 ccw(c6099.52,4753.15) v1@6099.52,4739.87
  Bottom Layer w4: v1(6099.52,4734.37) 6126.19,4734.37 6141.86,4750.04 6170.59,4750.04 6173.52,4750.04 6173.52,4750.23 U14.37@6170.59,4750.23 ; v1@6103.41,4730.49 cw(c6112.8,4721.1) 6112.8,4734.37 cw(c6112.8,4747.65) v1@6103.41,4738.26 ; v1@6106.24,4727.66 cw(c6122.46,4711.44) 6122.46,4734.37 cw(c6122.46,4757.31) v1@6106.24,4741.09 ; 6127.51,4735.7 cw(c6152.95,4710.25) U14.37@6153.02,4746.23 ; 6134.32,4742.51 cw(c6152.98,4723.85) U14.37@6153.03,4750.23 ; 6141.13,4749.32 cw(c6153.01,4737.44) U14.37@6153.04,4754.23
DB_SRAM1.D15: U8.D19 U14.38 | length 1260.9
  Top Layer w4: U8.D19@5567.17,4603.39 v3(5586.85,4623.07) ; U8.D19@5567.17,4610.73 ccw(c5567.17,4628.45) 5579.7,4615.92 ccw(c5592.23,4603.39) U8.D19@5574.51,4603.39 ; 5574.05,4610.27 cw(c5586.85,4597.46) 5586.85,4615.57 ccw(c5586.85,4597.46) 5574.05,4610.27 ; 5574.05,4610.27 ccw(c5561.24,4623.07) 5579.35,4623.07 cw(c5561.24,4623.07) 5574.05,4610.27
  MidLayer1 w4: v3@5581.66,4628.26 ccw(c5569.12,4640.8) 5586.85,4640.8 ccw(c5604.58,4640.8) v3@5592.04,4628.26 ; v3(5586.85,4623.07) 5586.85,4700.75 5586.85,4741.18 5586.85,4749.18 5586.85,4774.21 5629.96,4774.21 5645.08,4789.33 5645.08,4798.58 5665.81,4819.31 5665.81,4851.66 5735.15,4921 5749.82,4921 5795.52,4966.71 5804.19,4975.37 5883.7,4975.37 5892.37,4966.71 5905.7,4953.38 5965.19,4893.88 5965.19,4887.31 6060.79,4791.71 ; v1@6074.74,4785.42 ccw(c6060.79,4773.1) 6060.79,4791.71 ; v1@6074.74,4798 cw(c6060.79,4810.31) 6060.79,4791.71 ; v1@6077.73,4788.07 ccw(c6069.66,4780.94) 6069.66,4791.71 ccw(c6069.66,4802.48) v1@6077.73,4795.35 ; v1(6081.86,4791.71) 6060.79,4791.71 ; 5586.85,4641.18 cw(c5568.74,4641.18) 5581.55,4628.37 ccw(c5568.74,4641.18) 5586.85,4641.18 ; 5586.85,4641.18 ccw(c5604.96,4641.18) 5592.15,4628.37 cw(c5604.96,4641.18) 5586.85,4641.18
  Bottom Layer w4: v1(6081.86,4791.71) 6115.02,4791.71 6125,4781.73 U14.38@6170.59,4781.73 ; v1@6085.75,4787.82 cw(c6095.14,4778.43) 6095.14,4791.71 cw(c6095.14,4804.99) v1@6085.75,4795.6 ; v1@6088.57,4784.99 cw(c6104.79,4768.77) 6104.79,4791.71 cw(c6104.79,4814.64) v1@6088.57,4798.43 ; U14.38@6147.37,4776.07 ccw(c6133.72,4762.42) 6133.72,4781.73 ccw(c6133.72,4801.04) U14.38@6147.37,4787.39
DB_SRAM1.NBHE: U8.G16 U14.40 | length 1508.2
  Top Layer w4: U8.G16@5449.06,4485.28 v3(5468.74,4504.96) ; U8.G16@5449.05,4492.62 ccw(c5449.05,4510.34) 5461.59,4497.81 ccw(c5474.12,4485.28) U8.G16@5456.4,4485.28 ; 5455.94,4492.16 cw(c5468.74,4479.35) 5468.74,4497.46 ccw(c5468.74,4479.35) 5455.94,4492.16 ; 5455.94,4492.16 ccw(c5443.13,4504.96) 5461.24,4504.96 cw(c5443.13,4504.96) 5455.94,4492.16
  MidLayer2 w4: v3@5468.09,4512.43 ccw(c5466.51,4530.47) 5480.38,4518.83 ccw(c5494.25,4507.19) v3@5476.21,4505.61 ; 5480.13,4518.54 ccw(c5470.2,4528.47) 5484.25,4528.47 5484.25,4622.01 5484.25,4741.18 5484.25,4751.18 5484.25,4804.1 5513.52,4833.37 5568.52,4833.37 5581.4,4820.5 5603.25,4820.5 5613.5,4830.75 5613.5,4868.5 5620,4875 5657.75,4875 5665.5,4882.75 5665.5,4901.25 5651.37,4915.37 5633.52,4915.37 5623.52,4925.37 5623.52,4941.37 5633.52,4951.37 5665,4951.37 5674.67,4941.71 5804.13,4941.71 5829.63,4967.21 5967.02,4967.21 6059.19,4875.04 6098.52,4875.04 v1(6123.52,4850.04) ; v1@6114.02,4850.04 ccw(c6091.09,4850.04) 6107.31,4866.26 ccw(c6123.52,4882.48) v1@6123.52,4859.54 ; v1@6118.02,4850.04 ccw(c6104.75,4850.04) 6114.14,4859.43 ccw(c6123.52,4868.82) v1@6123.52,4855.54
  Bottom Layer w4: v1(6123.52,4850.04) 6128.84,4844.72 U14.40@6170.59,4844.72 ; v1@6124.58,4851.1 ccw(c6139.98,4866.5) 6139.98,4844.72 ; v1@6127.41,4853.93 ccw(c6149.64,4876.16) U14.40@6149.64,4844.72 ; v1@6130.24,4856.76 ccw(c6159.3,4885.81) U14.40@6159.3,4844.72
DB_SRAM1.NBLE: U8.D18 U14.39 | length 1324.9
  Top Layer w4: U8.D18@5527.8,4603.39 v3(5547.48,4623.07) ; U8.D18@5527.8,4610.73 ccw(c5527.8,4628.45) 5540.33,4615.92 ccw(c5552.86,4603.39) U8.D18@5535.14,4603.39 ; 5534.68,4610.27 cw(c5547.48,4597.46) 5547.48,4615.57 ccw(c5547.48,4597.46) 5534.68,4610.27 ; 5534.68,4610.27 ccw(c5521.87,4623.07) 5539.98,4623.07 cw(c5521.87,4623.07) 5534.68,4610.27
  MidLayer1 w4: v3@5542.18,4628.37 ccw(c5529.37,4641.18) 5547.48,4641.18 ccw(c5565.59,4641.18) v3@5552.78,4628.37 ; v3@5542.29,4628.26 ccw(c5529.75,4640.8) 5547.48,4640.8 ccw(c5565.21,4640.8) v3@5552.67,4628.26 ; v3(5547.48,4623.07) 5547.48,4700.75 5547.48,4741.18 5547.48,4749.18 5547.48,4776.17 5558,4786.69 5558,4836.89 5620,4898.89 5620,4956.31 5655.06,4991.37 5922.81,4991.37 6016.81,4897.38 6016.81,4880.75 v1(6055.86,4841.71) ; v1@6046.36,4841.71 ccw(c6023.42,4841.71) 6039.64,4857.93 ccw(c6055.86,4874.14) v1@6055.86,4851.21 ; v1@6050.36,4841.71 ccw(c6037.08,4841.71) 6046.47,4851.1 ccw(c6055.86,4860.49) v1@6055.86,4847.21
  Bottom Layer w4: v1@6055.86,4832.21 cw(c6055.86,4809.27) 6072.07,4825.49 cw(c6088.29,4841.71) v1@6065.36,4841.71 ; v1@6055.86,4836.21 cw(c6055.86,4822.93) 6065.25,4832.32 cw(c6074.64,4841.71) v1@6061.36,4841.71 ; v1(6055.86,4841.71) 6084.34,4813.23 U14.39@6170.59,4813.23 ; U14.39@6147.37,4807.57 ccw(c6133.72,4793.91) 6133.72,4813.23 ccw(c6133.72,4832.54) U14.39@6147.37,4818.88
DB_SRAM1.NCS: U8.G20 U14.6 | length 1743.2
  Top Layer w4: U8.G20@5606.54,4485.28 v3(5626.22,4504.96) ; U8.G20@5606.54,4492.62 ccw(c5606.54,4510.34) 5619.07,4497.81 ccw(c5631.6,4485.28) U8.G20@5613.88,4485.28 ; 5613.42,4492.16 cw(c5626.22,4479.35) 5626.22,4497.46 ccw(c5626.22,4479.35) 5613.42,4492.16 ; 5613.42,4492.16 ccw(c5600.61,4504.96) 5618.72,4504.96 cw(c5600.61,4504.96) 5613.42,4492.16
  MidLayer2 w4: v3@5625.57,4512.43 ccw(c5623.99,4530.47) 5637.86,4518.83 ccw(c5651.73,4507.19) v3@5633.69,4505.61 ; 5637.61,4518.54 ccw(c5627.68,4528.47) 5641.73,4528.47 ; 5641.73,4542.4 5641.73,4528.47 ; v1@6531.47,4784.99 ccw(c6515.26,4768.77) 6515.26,4791.71 ccw(c6515.26,4814.64) v1@6531.47,4798.43 ; v1@6534.3,4787.82 ccw(c6524.91,4778.43) 6524.91,4791.71 ccw(c6524.91,4804.99) v1@6534.3,4795.6 ; v1(6538.19,4791.71) 6501.86,4791.71 6419.02,4708.87 6088.96,4708.87 6065.19,4732.65 6065.19,4743.37 5999.19,4809.37 5920.81,4809.37 5863.48,4866.71 5863.15,4867.04 5848.56,4867.04 ; 5641.73,4528.47 5641.73,4622.01 5641.73,4741.18 5641.73,4749.18 5641.73,4760.62 5692.19,4811.08 5692.19,4858.1 5717.47,4883.37 5832.23,4883.37 ; 5832.23,4883.37 5848.56,4867.04 ; 5832.23,4883.37 5848.56,4867.04
  Bottom Layer w4: v1(6538.19,4791.71) 6559.71,4813.23 U14.6@6619.41,4813.23 ; v1@6538.19,4797.21 ccw(c6538.19,4810.49) 6547.58,4801.1 ccw(c6556.97,4791.71) v1@6543.69,4791.71 ; v1@6538.19,4801.21 ccw(c6538.19,4824.14) 6554.41,4807.93 ccw(c6570.63,4791.71) v1@6547.69,4791.71 ; U14.6@6596.19,4807.57 ccw(c6582.54,4793.91) 6582.54,4813.23 ccw(c6582.54,4832.54) U14.6@6596.19,4818.88
DB_SRAM1.NOE: U8.E15 U14.41 | length 1738.5
  Top Layer w4: U8.E15@5409.68,4564.02 v3(5429.37,4583.7) ; U8.E15@5409.69,4571.36 ccw(c5409.69,4589.08) 5422.22,4576.55 ccw(c5434.75,4564.02) U8.E15@5417.03,4564.02 ; 5416.57,4570.9 cw(c5429.37,4558.09) 5429.37,4576.2 ccw(c5429.37,4558.09) 5416.57,4570.9 ; 5416.57,4570.9 ccw(c5403.76,4583.7) 5421.87,4583.7 cw(c5403.76,4583.7) 5416.57,4570.9
  MidLayer1 w4: v3@5428.72,4591.17 ccw(c5427.14,4609.21) 5441.01,4597.57 ccw(c5454.88,4585.93) v3@5436.84,4584.35 ; 5440.76,4597.28 ccw(c5430.83,4607.21) 5444.88,4607.21 5444.88,4621.14 5444.88,4681.33 5444.88,4700.75 5444.88,4741.18 5444.88,4751.18 5444.88,4761.93 5426.19,4780.62 5426.19,4833.13 ; 5426.19,4833.13 5431.93,4838.86 ; 5426.19,4833.13 5431.93,4838.86 ; 5431.93,4838.86 5436.68,4843.62 5436.68,4859.64 5436.68,4880.18 5436.68,4895.18 5440,4898.5 ; 5440,4898.5 v1(5468.4,4898.5) 5440,4898.5
  MidLayer2 w4: v1(5789.86,4850.04) 5820.67,4850.04 5855,4815.71 5886.19,4815.71 5928.71,4773.19 5948.38,4773.19 5958.56,4783.37 v1(5971.86,4783.37) ; v1@5793.75,4846.15 cw(c5803.14,4836.76) 5803.14,4850.04 cw(c5803.14,4863.32) v1@5793.75,4853.93 ; v1@5796.57,4843.32 cw(c5812.79,4827.11) 5812.79,4850.04 cw(c5812.79,4872.98) v1@5796.57,4856.76 ; 5946.7,4771.51 cw(c5964.34,4753.87) v1@5970.5,4778.05 ; 5951.67,4776.48 cw(c5966.36,4761.79) v1@5971.49,4781.92 ; 5956.64,4781.45 cw(c5968.38,4769.71) v1@5972.47,4785.8
  Bottom Layer w4: v1(5468.4,4898.5) 5498.19,4928.29 5498.19,4939.38 5534.52,4975.71 5699.69,4975.71 5789.86,4885.54 v1(5789.86,4850.04) ; v1@5468.4,4904 ccw(c5468.4,4917.28) 5477.79,4907.89 ccw(c5487.18,4898.5) v1@5473.9,4898.5 ; v1@5468.4,4908 ccw(c5468.4,4930.94) 5484.62,4914.72 ccw(c5500.83,4898.5) v1@5477.9,4898.5 ; v1@5783.14,4856.76 ccw(c5766.92,4872.98) 5789.86,4872.98 ccw(c5812.79,4872.98) v1@5796.57,4856.76 ; v1@5785.97,4853.93 ccw(c5776.58,4863.32) 5789.86,4863.32 ccw(c5803.14,4863.32) v1@5793.75,4853.93 ; v1(5971.86,4783.37) 6031.86,4843.37 6031.86,4854.37 6053.7,4876.22 U14.41@6170.59,4876.22 ; v1@5971.86,4788.87 ccw(c5971.86,4802.15) 5981.25,4792.76 ccw(c5990.64,4783.37) v1@5977.36,4783.37 ; v1@5971.86,4792.87 ccw(c5971.86,4815.81) 5988.07,4799.59 ccw(c6004.29,4783.37) v1@5981.36,4783.37 ; U14.41@6147.37,4870.56 ccw(c6133.72,4856.9) 6133.72,4876.22 ccw(c6133.72,4895.53) U14.41@6147.37,4881.88
DB_SRAM1.NWE: U8.K22 U14.17 | length 1303.6
  Top Layer w4: U8.K22@5685.28,4367.17 v3(5704.96,4386.85) ; U8.K22@5685.28,4374.51 ccw(c5685.28,4392.23) 5697.81,4379.7 ccw(c5710.34,4367.17) U8.K22@5692.62,4367.17 ; 5692.16,4374.05 cw(c5704.96,4361.24) 5704.96,4379.35 ccw(c5704.96,4361.24) 5692.16,4374.05 ; 5692.16,4374.05 ccw(c5679.35,4386.85) 5697.46,4386.85 cw(c5679.35,4386.85) 5692.16,4374.05
  MidLayer2 w4: v3@5705.61,4394.32 ccw(c5707.19,4412.36) 5718.83,4398.49 ccw(c5730.47,4384.62) v3@5712.43,4386.2 ; 5718.54,4398.24 cw(c5728.47,4388.31) 5728.47,4402.36 5742.4,4402.36 5802.59,4402.36 5822.01,4402.36 6004.96,4402.36 6019.81,4387.5 6096.81,4387.5 6125.31,4416 6257.28,4416 6287.78,4385.5 6368.98,4385.5 v1(6441.86,4458.37) ; v1@6432.36,4458.37 cw(c6409.42,4458.37) 6425.64,4442.16 cw(c6441.86,4425.94) v1@6441.86,4448.87 ; v1@6436.36,4458.37 cw(c6423.08,4458.37) 6432.47,4448.99 cw(c6441.86,4439.6) v1@6441.86,4452.87
  Bottom Layer w4: v1(6441.86,4458.37) 6459.52,4476.04 6619.41,4476.04 6623.52,4476.04 6623.52,4466.77 U14.17@6619.41,4466.77 ; v1@6441.86,4463.87 ccw(c6441.86,4477.15) 6451.25,4467.76 ccw(c6460.64,4458.37) v1@6447.36,4458.37 ; v1@6441.86,4467.87 ccw(c6441.86,4490.81) 6458.08,4474.59 ccw(c6474.29,4458.37) v1@6451.36,4458.37 ; 6579.47,4476.04 cw(c6579.47,4444.39) U14.17@6601.85,4466.77 ; 6581.02,4475.96 cw(c6581.02,4456.93) U14.17@6597.1,4467.1 ; 6589.13,4476.04 cw(c6589.13,4454.05) U14.17@6604.68,4469.6
DB_SRAM2.A0: U8.E17 U15.1 | length 2488.8
  Top Layer w4: U8.E17@5488.43,4564.02 v3(5508.11,4583.7) ; U8.E17@5488.42,4571.36 ccw(c5488.42,4589.08) 5500.96,4576.55 ccw(c5513.49,4564.02) U8.E17@5495.77,4564.02 ; 5495.31,4570.9 cw(c5508.11,4558.09) 5508.11,4576.2 ccw(c5508.11,4558.09) 5495.31,4570.9 ; 5495.31,4570.9 ccw(c5482.5,4583.7) 5500.61,4583.7 cw(c5482.5,4583.7) 5495.31,4570.9
  MidLayer1 w4: v3@5507.46,4591.17 ccw(c5505.88,4609.21) 5519.75,4597.57 ccw(c5533.62,4585.93) v3@5515.58,4584.35 ; 5519.5,4597.28 ccw(c5509.57,4607.21) 5523.62,4607.21 ; 5523.62,4621.14 5523.62,4607.21 ; v1@7272.36,5000.02 cw(c7249.6,4999.97) 7265.69,4983.88 ; v1@7276.36,5000.03 cw(c7263.18,5000) 7272.5,4990.68 cw(c7281.81,4981.37) v1@7281.84,4994.54 ; v1@7281.84,4990.54 ccw(c7281.78,4967.78) 7265.69,4983.88 ; v1(7281.86,5000.04) 7265.69,4983.87 ; 5523.62,4607.21 5523.62,4700.75 5523.62,4741.18 5523.62,4749.18 5523.62,4771.38 5508.11,4786.89 5508.11,4809.63 5604,4905.52 5604,4965.62 5646.76,5008.37 5918.17,5008.37 6009.84,5100.04 6505,5100.04 6549.96,5100.04 6587.96,5062.04 6714.5,5062.04 6726.5,5050.04 6834.84,5050.04 6869.17,5015.71 6917.17,5015.71 6934.84,5033.37 7090.19,5033.37 7139.69,4983.87 7265.69,4983.87
  Bottom Layer w4: v1(7281.86,5000.04) 7294.41,4987.49 ; U15.1@7289.37,4976.92 ccw(c7280.81,4987.49) 7294.41,4987.49 ; U15.1@7294.41,4970.71 7294.41,4987.49 ; U15.1@7299.45,4976.92 cw(c7308.01,4987.49) 7294.41,4987.49
DB_SRAM2.A1: U8.F18 U15.2 | length 2578.5
  Top Layer w4: U8.F18@5527.8,4524.65 v3(5547.48,4544.33) ; U8.F18@5527.8,4531.99 ccw(c5527.8,4549.71) 5540.33,4537.18 ccw(c5552.86,4524.65) U8.F18@5535.14,4524.65 ; 5534.68,4531.53 cw(c5547.48,4518.72) 5547.48,4536.83 ccw(c5547.48,4518.72) 5534.68,4531.53 ; 5534.68,4531.53 ccw(c5521.87,4544.33) 5539.98,4544.33 cw(c5521.87,4544.33) 5534.68,4531.53
  MidLayer1 w4: v3@5546.83,4551.8 ccw(c5545.25,4569.84) 5559.12,4558.2 ; v3@5554.95,4544.98 cw(c5572.99,4546.56) 5559.12,4558.2 ; 5571.34,4621.14 5571.34,4607.21 ; v1@5752.02,4963.04 cw(c5729.09,4963.04) 5745.31,4946.82 cw(c5761.52,4930.61) v1@5761.52,4953.54 ; v1@5756.02,4963.04 cw(c5742.75,4963.04) 5752.13,4953.65 cw(c5761.52,4944.26) v1@5761.52,4957.54 ; v1(5761.52,4963.04) 5740.19,4941.71 5696.23,4941.71 5674.52,4920 5674.52,4891.78 5674.52,4884.52 5665,4875 5625,4875 5615,4865 5615,4832.25 5577.21,4794.46 5577.21,4782.21 5571.34,4776.34 5571.34,4700.75 5571.34,4681.33 5571.34,4607.21 ; 5559.12,4558.2 ccw(c5529.61,4587.71) 5571.34,4587.71 5571.34,4607.21
  Bottom Layer w4: v1(5761.52,4963.04) 5883.54,4963.04 6031.95,5111.44 6067.5,5147 6362.48,5147 6374.61,5134.87 6533.36,5134.87 6574.52,5176.04 6829.9,5176.04 6855.23,5150.71 7130.58,5150.71 7139.58,5141.71 7259.19,5022.1 7259.19,4946.21 7266.19,4939.21 U15.2@7294.41,4939.21 ; v1@5765.41,4959.15 cw(c5774.8,4949.76) 5774.8,4963.04 cw(c5774.8,4976.32) v1@5765.41,4966.93 ; v1@5768.24,4956.32 cw(c5784.46,4940.11) 5784.46,4963.04 cw(c5784.46,4985.98) v1@5768.24,4969.76
DB_SRAM2.A2: U8.B21 U15.3 | length 2557.5
  Top Layer w4: U8.B21@5645.91,4689.47 ccw(c5645.91,4707.19) 5658.44,4694.66 ; U8.B21@5653.25,4682.13 cw(c5670.97,4682.13) 5658.44,4694.66 ; v1@5793.14,5143.32 ccw(c5776.92,5127.11) 5776.92,5150.04 ccw(c5776.92,5172.98) v1@5793.14,5156.76 ; v1@5795.97,5146.15 ccw(c5786.58,5136.76) 5786.58,5150.04 ccw(c5786.58,5163.32) v1@5795.97,5153.93 ; v1(5799.86,5150.04) 5759.19,5150.04 5745,5135.85 5745,5052.18 5719.52,5026.71 5719.52,4834.52 5661.41,4776.41 5661.41,4701.84 cw(c5651.26,4701.84) 5658.44,4694.66
  MidLayer1 w4: v1(5799.86,5150.04) 5852.52,5202.71 6556.86,5202.71 6575.52,5184.04 6805,5184.04 ; v1@5799.86,5155.54 ccw(c5799.86,5168.82) 5809.25,5159.43 ccw(c5818.64,5150.04) v1@5805.36,5150.04 ; v1@5799.86,5159.54 ccw(c5799.86,5182.48) 5816.07,5166.26 ccw(c5832.29,5150.04) v1@5809.36,5150.04 ; v1@7230.69,5001.37 ccw(c7207.76,5001.37) 7223.97,5017.59 ccw(c7240.19,5033.81) v1@7240.19,5010.87 ; v1@7234.69,5001.37 ccw(c7221.41,5001.37) 7230.8,5010.76 ccw(c7240.19,5020.15) v1@7240.19,5006.87 ; v1(7240.19,5001.37) 7172.38,5069.18 6970.82,5069.18 6855.96,5184.04 ; 6805,5184.04 6855.96,5184.04 ; 6805,5184.04 6855.96,5184.04
  Bottom Layer w4: v1@7233.47,4994.66 cw(c7217.26,4978.44) 7240.19,4978.44 cw(c7263.13,4978.44) v1@7246.91,4994.66 ; v1@7236.3,4997.49 cw(c7226.91,4988.1) 7240.19,4988.1 cw(c7253.47,4988.1) v1@7244.08,4997.49 ; v1(7240.19,5001.37) 7240.19,4924.72 7257.19,4907.72 U15.3@7294.41,4907.72 ; U15.3@7271.19,4902.06 ccw(c7257.54,4888.4) 7257.54,4907.72 ccw(c7257.54,4927.03) U15.3@7271.19,4913.37
DB_SRAM2.A3: U8.E19 U15.4 | length 2565.3
  Top Layer w4: U8.E19@5567.17,4564.02 v3(5586.85,4583.7) ; U8.E19@5567.17,4571.36 ccw(c5567.17,4589.08) 5579.7,4576.55 ccw(c5592.23,4564.02) U8.E19@5574.51,4564.02 ; 5574.05,4570.9 cw(c5586.85,4558.09) 5586.85,4576.2 ccw(c5586.85,4558.09) 5574.05,4570.9 ; 5574.05,4570.9 ccw(c5561.24,4583.7) 5579.35,4583.7 cw(c5561.24,4583.7) 5574.05,4570.9
  MidLayer1 w4: v3@5586.2,4591.17 ccw(c5584.62,4609.21) 5598.49,4597.57 ccw(c5612.36,4585.93) v3@5594.32,4584.35 ; 5598.24,4597.28 ccw(c5588.31,4607.21) 5602.36,4607.21 ; 5602.36,4621.14 5602.36,4607.21 ; v1@5833.47,4934.99 ccw(c5817.26,4918.77) 5817.26,4941.71 ccw(c5817.26,4964.64) v1@5833.47,4948.43 ; v1@5836.3,4937.82 ccw(c5826.91,4928.43) 5826.91,4941.71 ccw(c5826.91,4954.99) v1@5836.3,4945.6 ; v1(5840.19,4941.71) 5781.86,4941.71 5753.15,4913 5738.46,4913 5673.81,4848.35 5673.81,4816 5653.08,4795.26 5653.08,4786.01 5633.27,4766.21 5607.8,4766.21 5602.36,4760.76 5602.36,4749.18 5602.36,4741.18 5602.36,4700.75 5602.36,4607.21
  Bottom Layer w4: v1(5840.19,4941.71) 5873.52,4941.71 6070.82,5139 6359.17,5139 6371.29,5126.87 6536.67,5126.87 6577.84,5168.04 6826.58,5168.04 6851.92,5142.71 7127.27,5142.71 7136.6,5133.37 7220,5049.98 7220,4903.74 7247.52,4876.22 U15.4@7294.41,4876.22 ; v1@5844.08,4937.82 cw(c5853.47,4928.43) 5853.47,4941.71 cw(c5853.47,4954.99) v1@5844.08,4945.6 ; v1@5846.91,4934.99 cw(c5863.13,4918.77) 5863.13,4941.71 cw(c5863.13,4964.64) v1@5846.91,4948.43 ; U15.4@7271.19,4870.56 ccw(c7257.54,4856.9) 7257.54,4876.22 ccw(c7257.54,4895.53) U15.4@7271.19,4881.88
DB_SRAM2.A4: U8.F19 U15.5 | length 2878.3
  Top Layer w4: U8.F19@5567.17,4524.65 v3(5586.85,4544.33) ; U8.F19@5567.17,4531.99 ccw(c5567.17,4549.71) 5579.7,4537.18 ccw(c5592.23,4524.65) U8.F19@5574.51,4524.65 ; 5574.05,4531.53 cw(c5586.85,4518.72) 5586.85,4536.83 ccw(c5586.85,4518.72) 5574.05,4531.53 ; 5574.05,4531.53 ccw(c5561.24,4544.33) 5579.35,4544.33 cw(c5561.24,4544.33) 5574.05,4531.53
  MidLayer1 w4: v3@5586.2,4551.8 ccw(c5584.62,4569.84) 5598.49,4558.2 ; v3@5594.32,4544.98 cw(c5612.36,4546.56) 5598.49,4558.2 ; 5610.71,4621.14 5610.71,4607.21 ; v1@5913.28,4903.28 ccw(c5897.06,4887.06) 5897.06,4910 ccw(c5897.06,4932.93) v1@5913.28,4916.72 ; v1@5916.11,4906.11 ccw(c5906.72,4896.72) 5906.72,4910 ccw(c5906.72,4923.28) v1@5916.11,4913.89 ; v1@5920,4910.23 v1(5920,4910) 5895.04,4910 5888.33,4916.71 5880,4925.04 5857.19,4925.04 5837.15,4905 5741.78,4905 5681.81,4845.03 5681.81,4812.68 5661.08,4791.95 5661.08,4782.7 5636.59,4758.21 5611.11,4758.21 5610.71,4757.81 5610.71,4749.18 5610.71,4741.18 5610.71,4700.75 5610.71,4681.33 5610.71,4607.21 ; v1@6050.14,4956.76 ccw(c6032.37,4974.53) 6057.5,4974.53 ; v1@6052.97,4953.93 ccw(c6042.03,4964.87) 6057.5,4964.87 ; v1(6056.86,4950.04) 6057.5,4950.68 6057.5,5050.68 6098.52,5091.71 6500,5091.71 ; 6057.5,4961.77 ccw(c6068.58,4961.77) v1@6060.75,4953.93 ; 6057.5,4971.42 ccw(c6078.24,4971.42) v1@6063.57,4956.76 ; 6518.17,5091.71 6500,5091.71 ; v1@7044.13,5002.85 ccw(c7033.38,4995.15) 7033.38,5008.37 ; v1@7044.13,5013.9 cw(c7033.38,5021.6) 7033.38,5008.37 ; v1(7051.86,5008.37) 7033.37,5008.37 ; 5598.49,4558.2 ccw(c5568.98,4587.71) 5610.71,4587.71 5610.71,4607.21 ; 6500,5091.71 6544.61,5091.71 6582.27,5054.04 6585.96,5054.04 6711.19,5054.04 6723.52,5041.71 6831.86,5041.71 6865.86,5007.71 6944.52,5007.71 6948.52,5011.71 7030.04,5011.71 7033.37,5008.37
  Bottom Layer w4: v1@5913.28,4903.28 cw(c5897.06,4887.06) 5920,4887.06 cw(c5942.93,4887.06) v1@5926.72,4903.28 ; v1@5916.11,4906.11 cw(c5906.72,4896.72) 5920,4896.72 cw(c5933.28,4896.72) v1@5923.89,4906.11 ; v1(5920,4910) 5920,4885 5935,4870 5935,4825 5942.5,4817.5 5962.25,4817.5 5980.67,4817.5 6015.52,4852.36 6015.52,4870.78 6015.52,4875.77 6039.88,4900.12 6056.86,4917.1 v1(6056.86,4950.04) ; v1@6050.14,4943.32 cw(c6033.92,4927.11) 6056.86,4927.11 cw(c6079.79,4927.11) v1@6063.57,4943.32 ; v1@6052.97,4946.15 cw(c6043.58,4936.76) 6056.86,4936.76 cw(c6070.14,4936.76) v1@6060.75,4946.15 ; v1(7051.86,5008.37) 7098.52,5008.37 7262.18,4844.72 ; v1@7055.75,5004.49 cw(c7065.14,4995.1) 7065.14,5008.37 cw(c7065.14,5021.65) v1@7055.75,5012.26 ; v1@7058.57,5001.66 cw(c7074.79,4985.44) 7074.79,5008.37 cw(c7074.79,5031.31) v1@7058.57,5015.09 ; U15.5@7270.13,4840.39 ccw(c7262.18,4835.27) 7262.18,4844.72 ; U15.5@7270.13,4849.06 cw(c7262.18,4854.18) 7262.18,4844.72 ; U15.5@7294.41,4844.72 7262.18,4844.72
DB_SRAM2.A5: U8.J23 U15.18 | length 2573.2
  Top Layer w4: U8.J23@5724.65,4406.54 v3(5744.33,4426.22) ; U8.J23@5724.65,4413.88 ccw(c5724.65,4431.6) 5737.18,4419.07 ccw(c5749.71,4406.54) U8.J23@5731.99,4406.54 ; 5731.53,4413.42 cw(c5744.33,4400.61) 5744.33,4418.72 ccw(c5744.33,4400.61) 5731.53,4413.42 ; 5731.53,4413.42 ccw(c5718.72,4426.22) 5736.83,4426.22 cw(c5718.72,4426.22) 5731.53,4413.42
  MidLayer1 w4: v3@5744.98,4433.69 ccw(c5746.56,4451.73) 5758.2,4437.86 ; v3@5751.8,4425.57 cw(c5769.84,4423.99) 5758.2,4437.86 ; 5821.14,4450.08 5807.21,4450.08 ; v1@6064.28,4455.28 ccw(c6048.06,4439.06) 6048.06,4462 ccw(c6048.06,4484.93) v1@6064.28,4468.72 ; v1@6067.11,4458.11 ccw(c6057.72,4448.72) 6057.72,4462 ccw(c6057.72,4475.28) v1@6067.11,4465.89 ; v1(6071,4462) 6045.75,4462 6035.25,4472.5 6014.75,4472.5 5992.33,4450.08 5950.08,4450.08 5941.18,4450.08 5900.75,4450.08 5881.33,4450.08 5807.21,4450.08 ; 5758.2,4437.86 cw(c5787.71,4408.35) 5787.71,4450.08 5807.21,4450.08
  MidLayer2 w4: v1(6071,4462) 6087.99,4462 ; v1@6079.09,4457.03 cw(c6087.99,4451.57) 6087.99,4462 ; v1@6079.09,4466.97 ccw(c6087.99,4472.43) 6087.99,4462 ; v1@6530.69,4533.37 cw(c6507.76,4533.37) 6523.97,4517.16 cw(c6540.19,4500.94) v1@6540.19,4523.87 ; v1@6534.69,4533.37 cw(c6521.41,4533.37) 6530.8,4523.99 cw(c6540.19,4514.6) v1@6540.19,4527.87 ; v1(6540.19,4533.37) 6482.86,4476.04 6440,4476.04 6407.67,4508.37 6356.86,4508.37 6330,4508.37 6272.37,4508.37 6264.37,4500.37 6177.83,4500.37 6150,4472.54 6146.46,4469 6103.86,4469 6094.99,4469 6087.99,4462
  Bottom Layer w4: v1@6533.47,4526.66 ccw(c6517.26,4510.44) 6517.26,4533.37 ccw(c6517.26,4556.31) v1@6533.47,4540.09 ; v1@6536.3,4529.49 ccw(c6526.91,4520.1) 6526.91,4533.37 ccw(c6526.91,4546.65) v1@6536.3,4537.26 ; v1(6540.19,4533.37) 6460,4533.37 6438.37,4533.37 6424.36,4519.36 6424.36,4410.39 6427.5,4407.25 6427.5,4392.75 6424.36,4389.61 6424.36,4285.64 6435,4275 6474.81,4275 6500,4275 6604.88,4275 6637.17,4242.71 6774.9,4242.71 6775.06,4242.87 6786.66,4242.87 6786.82,4242.71 6966.19,4242.71 7031.86,4308.37 7031.86,4316.71 7141.26,4426.11 7150.42,4435.27 U15.18@7294.41,4435.27 7298.52,4435.28 7298.52,4433.37 U15.18@7294.41,4433.37 ; U15.18@7271.19,4429.62 ccw(c7257.54,4415.96) 7257.54,4435.27 ccw(c7257.54,4454.59) U15.18@7271.19,4440.93
DB_SRAM2.A6: U8.M25 U15.19 | length 2149.9
  Top Layer w4: U8.M25@5803.39,4288.42 v3(5823.07,4308.11) ; U8.M25@5803.39,4295.77 ccw(c5803.39,4313.49) 5815.92,4300.96 ccw(c5828.45,4288.42) U8.M25@5810.73,4288.42 ; 5810.27,4295.31 cw(c5823.07,4282.5) 5823.07,4300.61 ccw(c5823.07,4282.5) 5810.27,4295.31 ; 5810.27,4295.31 ccw(c5797.46,4308.11) 5815.57,4308.11 cw(c5797.46,4308.11) 5810.27,4295.31
  MidLayer1 w4: v3(5823.07,4308.11) 5881.33,4308.11 5900.75,4308.11 5941.18,4308.11 5949.18,4308.11 6018.61,4308.11 6025.37,4314.87 6027.54,4317.04 6069.52,4317.04 6071.06,4315.5 6081.86,4304.71 6081.86,4278.02 6093.5,4266.37 6161.19,4266.37 6190.19,4295.37 6190.19,4324.19 6201.71,4335.71 6240.84,4335.71 6260.17,4316.37 6295.21,4316.37 6312.21,4333.37 6423.52,4333.37 6442.65,4352.5 6443.7,4353.55 6520.02,4353.55 6521.06,4352.5 6522.52,4351.04 6620,4351.04 6634.45,4351.04 6676.12,4309.37 6688.12,4309.37 6695,4309.37 6899.52,4309.37 6928.94,4309.37 6964.69,4345.13 6964.69,4349.69 6964.69,4394.62 6981.02,4410.96 6981.02,4430 6981.02,4440.62 6994,4453.6 6994,4453.85 7023.52,4483.37 7065.19,4483.37 7091.63,4483.37 7099.19,4475.81 7099.19,4410.81 7113.86,4396.14 v1(7113.86,4366.71) ; v3@5828.26,4302.92 cw(c5840.8,4290.38) 5840.8,4308.11 cw(c5840.8,4325.84) v3@5828.26,4313.3 ; v3@5828.37,4302.81 cw(c5841.18,4290) 5841.18,4308.11 cw(c5841.18,4326.22) v3@5828.37,4313.41 ; v1@7107.14,4373.43 ccw(c7090.92,4389.64) 7113.86,4389.64 ccw(c7136.79,4389.64) v1@7120.57,4373.43 ; v1@7109.97,4370.6 ccw(c7100.58,4379.99) 7113.86,4379.99 ccw(c7127.14,4379.99) v1@7117.75,4370.6
  Bottom Layer w4: v1(7113.86,4366.71) 7150.93,4403.78 U15.19@7293.97,4403.78 ; v1@7113.86,4372.21 ccw(c7113.86,4385.49) 7123.25,4376.1 ccw(c7132.64,4366.71) v1@7119.36,4366.71 ; v1@7113.86,4376.21 ccw(c7113.86,4399.14) 7130.07,4382.93 ccw(c7146.29,4366.71) v1@7123.36,4366.71 ; U15.19@7271.19,4398.12 ccw(c7257.54,4384.46) 7257.54,4403.78 ccw(c7257.54,4423.09) U15.19@7271.19,4409.44 ; U15.19@7293.97,4403.78 U15.19@7294.41,4403.78 U15.19@7293.97,4403.78
DB_SRAM2.A7: U8.R21 U15.20 | length 2066.9
  Top Layer w4: U8.R21@5645.91,4162.97 cw(c5645.91,4145.25) 5658.44,4157.78 cw(c5670.97,4170.31) U8.R21@5653.25,4170.31 ; U8.R21@5645.91,4170.31 v3(5665.59,4150.63) ; 5652.79,4163.43 cw(c5639.98,4150.63) 5658.09,4150.63 ccw(c5639.98,4150.63) 5652.79,4163.43 ; 5652.79,4163.43 ccw(c5665.59,4176.24) 5665.59,4158.13 cw(c5665.59,4176.24) 5652.79,4163.43
  MidLayer2 w4: v3@5666.24,4143.16 cw(c5667.82,4125.12) 5679.46,4138.99 ; v3@5673.06,4151.28 ccw(c5691.1,4152.86) 5679.46,4138.99 ; 6015,4226 6015,4225.75 ; 6882.51,4226.04 cw(c6882.51,4199.69) v1@6901.14,4218.32 ; 6887.34,4226.04 ccw(c6887.34,4245.56) v1@6901.14,4231.76 ; 6892.16,4226.04 cw(c6892.16,4209.35) v1@6903.97,4221.15 ; v1(6907.86,4225.04) 6906.86,4226.04 6608.86,4226.04 6590.19,4207.37 6560.52,4207.37 6500.9,4267 6403.62,4267 6344.44,4267 6328.31,4250.87 6148.5,4250.87 6141.63,4244 6033.25,4244 6015,4225.75 ; 5679.46,4138.99 ccw(c5708.97,4168.5) 5708.97,4126.77 5728.47,4126.77 5802.59,4126.77 5822.01,4126.77 5948.77,4126.77 6015,4193 6015,4225.75
  Bottom Layer w4: v1(6907.86,4225.04) 6965.24,4225.04 7065.24,4325.04 7184.62,4325.04 7231.86,4372.28 U15.20@7294.41,4372.28 ; v1@6911.75,4221.15 cw(c6921.14,4211.76) 6921.14,4225.04 cw(c6921.14,4238.32) v1@6911.75,4228.93 ; v1@6914.57,4218.32 cw(c6930.79,4202.11) 6930.79,4225.04 cw(c6930.79,4247.98) v1@6914.57,4231.76 ; U15.20@7271.19,4366.63 ccw(c7257.54,4352.97) 7257.54,4372.28 ccw(c7257.54,4391.6) U15.20@7271.19,4377.94
DB_SRAM2.A8: U8.L27 U15.21 | length 1931.3
  Top Layer w4: U8.L27@5882.13,4335.14 ccw(c5882.13,4352.86) 5894.66,4340.33 ; U8.L27@5889.47,4327.79 cw(c5907.19,4327.79) 5894.66,4340.33 ; v1@6042.5,4290 ccw(c6019.56,4290) 6035.78,4306.22 ccw(c6052,4322.43) v1@6052,4299.5 ; v1@6046.5,4290 ccw(c6033.22,4290) 6042.61,4299.39 ccw(c6052,4308.78) v1@6052,4295.5 ; v1@6050,4292 6022.26,4319.74 ; 5894.66,4340.33 cw(c5901.84,4333.15) 5901.84,4343.3 5941.18,4343.3 5949.18,4343.3 5975.7,4343.3 5999.26,4319.74 ; 5999.26,4319.74 6022.26,4319.74 ; 5999.26,4319.74 6022.26,4319.74
  MidLayer2 w4: v1@6056.83,4292.63 ccw(c6066.23,4297.74) 6066.23,4287.04 ; v1@6058.72,4283.28 cw(c6067.79,4274.21) 6067.79,4287.04 ; v1@6059.19,4287.04 v1@6054.96,4287.04 ; v1@6060.35,4294.54 ccw(c6072.96,4301.4) 6072.96,4287.04 ; v1@7241.81,4326.66 cw(c7225.59,4310.44) 7248.52,4310.44 cw(c7271.46,4310.44) v1@7255.24,4326.66 ; v1@7244.64,4329.49 cw(c7235.25,4320.1) 7248.52,4320.1 cw(c7261.8,4320.1) v1@7252.41,4329.49 ; v1(7248.52,4333.37) 7248.52,4303.37 7195.03,4249.88 7135.12,4249.88 7118.29,4266.71 6993.86,4266.71 6983.86,4256.71 6945,4256.71 ; v1@6054.96,4287.04 6072.96,4287.04 ; v1@6054.96,4287.04 v1(6052,4290) v1@6054.96,4287.04 ; 6072.96,4287.04 6108,4252 6138.31,4252 6145.19,4258.87 6325,4258.87 6341.13,4275 6505,4275 6521.63,4258.37 6599.86,4258.37 ; 6599.86,4258.37 6609.86,4248.37 ; 6599.86,4258.37 6609.86,4248.37 ; 6609.86,4248.37 6616.19,4242.04 6850,4242.04 ; 6850,4242.04 6873.19,4242.04 ; 6850,4242.04 6873.19,4242.04 ; 6873.19,4242.04 6883.54,4242.04 6898.21,4256.71 ; 6898.21,4256.71 6945,4256.71 ; 6898.21,4256.71 6945,4256.71
  Bottom Layer w4: v1@7246.76,4335.14 cw(c7260.38,4321.52) 7260.38,4340.79 ; v1(7248.52,4333.37) 7255.94,4340.79 U15.21@7294.41,4340.79 ; v1@7249.58,4332.31 cw(c7270.04,4311.86) U15.21@7270.04,4340.79 ; v1@7252.41,4329.49 cw(c7279.7,4302.2) U15.21@7279.7,4340.79 ; v1@7255.24,4326.66 cw(c7289.35,4292.55) U15.21@7289.35,4340.79
DB_SRAM2.A9: U8.U20 U15.22 | length 2328.9
  Top Layer w4: U8.U20@5606.54,4084.23 cw(c5606.54,4066.51) 5619.07,4079.04 cw(c5631.6,4091.57) U8.U20@5613.88,4091.57 ; U8.U20@5606.54,4091.57 v3(5626.22,4071.89) ; 5613.42,4084.69 cw(c5600.61,4071.89) 5618.72,4071.89 ccw(c5600.61,4071.89) 5613.42,4084.69 ; 5613.42,4084.69 ccw(c5626.22,4097.5) 5626.22,4079.39 cw(c5626.22,4097.5) 5613.42,4084.69
  MidLayer2 w4: v1(6981.86,4175.04) 7031.67,4175.04 7050.78,4194.16 7184.16,4194.16 7211.21,4221.21 7265.04,4275.04 v1(7306.86,4275.04) ; v1@6985.75,4171.15 cw(c6995.14,4161.76) 6995.14,4175.04 cw(c6995.14,4188.32) v1@6985.75,4178.93 ; v1@6988.57,4168.32 cw(c7004.79,4152.11) 7004.79,4175.04 cw(c7004.79,4197.98) v1@6988.57,4181.76 ; v1@7300.14,4268.32 ccw(c7283.92,4252.11) 7283.92,4275.04 ccw(c7283.92,4297.98) v1@7300.14,4281.76 ; v1@7302.97,4271.15 ccw(c7293.58,4261.76) 7293.58,4275.04 ccw(c7293.58,4288.32) v1@7302.97,4278.93
  Bottom Layer w4: v3@5626.87,4064.42 cw(c5628.45,4046.38) 5640.09,4060.25 cw(c5651.73,4074.12) v3@5633.69,4072.54 ; 5639.8,4060.5 ccw(c5649.73,4070.43) 5649.73,4056.38 5663.66,4056.38 5723.85,4056.38 5743.27,4056.38 5801.53,4056.38 5859.79,4056.38 5918.05,4056.38 5941.18,4056.38 5949.18,4056.38 5960,4056.38 5964.5,4060.88 5964.5,4242.25 5980.29,4258.04 6599.21,4258.04 6631.21,4226.04 6780.86,4226.04 6848.52,4158.37 6965.19,4158.37 v1(6981.86,4175.04) ; v1@6972.36,4175.04 cw(c6949.42,4175.04) 6965.64,4158.82 cw(c6981.86,4142.61) v1@6981.86,4165.54 ; v1@6976.36,4175.04 cw(c6963.08,4175.04) 6972.47,4165.65 cw(c6981.86,4156.26) v1@6981.86,4169.54 ; U15.22@7288.75,4303.63 cw(c7275.1,4289.98) 7294.41,4289.98 cw(c7313.72,4289.98) U15.22@7300.07,4303.63 ; U15.22@7294.41,4309.29 7294.41,4287.49 v1(7306.86,4275.04)
DB_SRAM2.A10: U8.M28 U15.23 | length 1222.2
  Top Layer w4: U8.M28@5921.5,4288.42 5941.18,4288.42 5949.18,4288.42 5972.64,4288.42 6000.56,4260.5 6027.56,4260.5 6054.69,4233.37 v1(6156.86,4233.37) ; U8.M28@5926.69,4283.23 cw(c5939.22,4270.7) 5939.22,4288.42 cw(c5939.22,4306.15) U8.M28@5926.69,4293.62 ; v1@6150.14,4226.66 ccw(c6133.92,4210.44) 6133.92,4233.37 ccw(c6133.92,4256.31) v1@6150.14,4240.09 ; v1@6152.97,4229.49 ccw(c6143.58,4220.1) 6143.58,4233.37 ccw(c6143.58,4246.65) v1@6152.97,4237.26
  MidLayer1 w4: v1(6156.86,4233.37) 6201.48,4278 6239.15,4278 6250.44,4266.71 6698.52,4266.71 6706.82,4275 ; v1@6156.86,4238.87 ccw(c6156.86,4252.15) 6166.25,4242.76 ccw(c6175.64,4233.37) v1@6162.36,4233.37 ; v1@6156.86,4242.87 ccw(c6156.86,4265.81) 6173.07,4249.59 ccw(c6189.29,4233.37) v1@6166.36,4233.37 ; v1@6716.7,4269.72 ccw(c6706.82,4263.11) 6706.82,4275 ; v1@6716.7,4280.28 cw(c6706.82,4286.89) 6706.82,4275 ; v1(6724.6,4275) 6706.82,4275
  Bottom Layer w4: v1(6724.6,4275) 6739.6,4260 6823.5,4260 6846.9,4283.4 U15.23@6846.9,4308.5 ; U15.23@6839.93,4303.63 cw(c6823.12,4286.82) 6846.9,4286.82 ; U15.23@6842.76,4306.46 cw(c6832.77,4296.47) 6846.9,4296.47 ; 6846.9,4293.14 cw(c6861.74,4293.14) U15.23@6851.25,4303.63
DB_SRAM2.A11: U8.N25 U15.24 | length 1625.5
  Top Layer w4: U8.N25@5803.39,4249.05 v3(5823.07,4268.74) ; U8.N25@5803.39,4256.4 ccw(c5803.39,4274.12) 5815.92,4261.59 ccw(c5828.45,4249.05) U8.N25@5810.73,4249.05 ; 5810.27,4255.94 cw(c5823.07,4243.13) 5823.07,4261.24 ccw(c5823.07,4243.13) 5810.27,4255.94 ; 5810.27,4255.94 ccw(c5797.46,4268.74) 5815.57,4268.74 cw(c5797.46,4268.74) 5810.27,4255.94
  MidLayer1 w4: v3(5823.07,4268.74) 5881.33,4268.74 5900.75,4268.74 5941.18,4268.74 5951.18,4268.74 6068.51,4268.74 6087.25,4250 6115,4250 6150,4215 6165,4215 6213,4263 6227,4263 6232,4263 6236.63,4258.37 6245,4258.37 6250,4258.37 6325,4258.37 6351.29,4258.37 6718.54,4258.37 6726.88,4250.04 6730,4250.04 6795,4250.04 6840.15,4250 ; v3@5828.26,4263.55 cw(c5840.8,4251.01) 5840.8,4268.74 cw(c5840.8,4286.47) v3@5828.26,4273.93 ; v1@6864.02,4283.37 cw(c6841.09,4283.37) 6857.31,4267.16 cw(c6873.52,4250.94) v1@6873.52,4273.87 ; v1@6868.02,4283.37 cw(c6854.75,4283.37) 6864.14,4273.99 cw(c6873.52,4264.6) v1@6873.52,4277.87 ; v1(6873.52,4283.37) 6840.19,4250.04 ; 5841.18,4268.74 cw(c5841.18,4286.85) 5828.37,4274.04 ccw(c5841.18,4286.85) 5841.18,4268.74 ; 5841.18,4268.74 ccw(c5841.18,4250.63) 5828.37,4263.44 cw(c5841.18,4250.63) 5841.18,4268.74 ; 6840.15,4250 6840.19,4250.04
  Bottom Layer w4: U15.24@6845.59,4340.79 6874.21,4340.79 6895,4320 6895,4304.85 v1(6873.52,4283.37) ; U15.24@6863.15,4332.79 cw(c6863.15,4286.76) 6895.69,4319.31 ; U15.24@6863.15,4336.79 cw(c6863.15,4300.42) 6888.86,4326.14 ; U15.24@6863.15,4340.79 cw(c6863.15,4314.08) 6882.04,4332.96 ; U15.24@6863.15,4344.79 cw(c6863.15,4327.73) 6875.21,4339.79 ; v1@6873.52,4288.87 ccw(c6873.52,4302.15) 6882.91,4292.76 ccw(c6892.3,4283.37) v1@6879.02,4283.37 ; v1@6873.52,4292.87 ccw(c6873.52,4315.81) 6889.74,4299.59 ccw(c6905.96,4283.37) v1@6883.02,4283.37
DB_SRAM2.A12: U8.M24 U15.25 | length 1447.3
  Top Layer w4: U8.M24@5764.02,4288.42 v3(5783.7,4308.11) ; U8.M24@5764.02,4295.77 ccw(c5764.02,4313.49) 5776.55,4300.96 ccw(c5789.08,4288.42) U8.M24@5771.36,4288.42 ; 5770.9,4295.31 cw(c5783.7,4282.5) 5783.7,4300.61 ccw(c5783.7,4282.5) 5770.9,4295.31 ; 5770.9,4295.31 ccw(c5758.09,4308.11) 5776.2,4308.11 cw(c5758.09,4308.11) 5770.9,4295.31
  MidLayer1 w4: v3@5784.35,4315.58 ccw(c5785.93,4333.62) 5797.57,4319.75 ccw(c5809.21,4305.88) v3@5791.17,4307.46 ; 5797.28,4319.5 cw(c5807.21,4309.57) 5807.21,4323.62 5821.14,4323.62 5881.33,4323.62 5900.75,4323.62 5941.18,4323.62 5949.18,4323.62 5985,4323.62 5996.01,4323.62 6022.81,4323.62 6024.23,4325.04 6143.17,4325.04 6217.17,4399.04 6279.9,4399.04 6291.44,4387.5 6305,4387.5 6312.56,4387.5 6366.71,4387.5 ; v1@6795.47,4389.99 ccw(c6779.26,4373.77) 6779.26,4396.71 ccw(c6779.26,4419.64) v1@6795.47,4403.43 ; v1@6798.3,4392.82 ccw(c6788.91,4383.43) 6788.91,4396.71 ccw(c6788.91,4409.99) v1@6798.3,4400.6 ; v1(6802.19,4396.71) 6775.21,4396.71 6770,4391.5 6527.32,4391.5 6502.01,4416.81 6471.35,4416.81 6434.08,4379.54 6374.67,4379.54 ; 6366.71,4387.5 6374.67,4379.54 ; 6366.71,4387.5 6374.67,4379.54
  Bottom Layer w4: v1@6802.19,4387.21 cw(c6802.19,4364.27) 6818.41,4380.49 cw(c6834.63,4396.71) v1@6811.69,4396.71 ; v1@6802.19,4391.21 cw(c6802.19,4377.93) 6811.58,4387.32 cw(c6820.97,4396.71) v1@6807.69,4396.71 ; v1(6802.19,4396.71) 6832.19,4366.71 6845.59,4366.71 6848.52,4366.71 6848.52,4372.28 U15.25@6845.59,4372.28 ; 6811.96,4386.94 ccw(c6828.03,4403.02) U15.25@6828.03,4380.28 ; 6815.38,4383.52 cw(c6804.14,4372.28) U15.25@6820.03,4372.28 ; 6818.79,4380.11 ccw(c6828.03,4389.36) U15.25@6828.03,4376.28