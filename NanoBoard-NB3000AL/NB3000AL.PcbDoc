# Altium PCB NB3000AL.PcbDoc (part 67 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
PBIO.D24: EXTHDR1.50 U8.AE2 | length 5542
  Top Layer w4: EXTHDR1.50@1375.42,2814.13 cw(c1367.75,2802.29) 1381.86,2802.29 ; EXTHDR1.50@1375.42,2859.25 1375.42,2811.44 1381.86,2805 v1(1381.86,2788.37) ; v1@1377.03,2796.56 ccw(c1372.06,2805) 1381.86,2805 ccw(c1391.65,2805) v1@1386.68,2796.56 ; v1(4765,3740) 4769.5,3744.5 4777.5,3752.5 4788.82,3752.5 ; 4788.82,3752.5 4783.98,3752.5 4788.82,3752.5 ; 4788.82,3752.5 4797.42,3761.11 4830.82,3761.11 4838.82,3761.11 ; 4838.82,3761.11 4878.16,3761.11 ; 4838.82,3761.11 4878.16,3761.11 ; 4878.16,3761.11 ccw(c4878.16,3771.26) 4885.34,3764.08 ; 4878.16,3761.11 ccw(c4878.16,3771.26) 4885.34,3764.08 ; 4885.34,3764.08 ccw(c4872.81,3776.61) 4890.53,3776.61 cw(c4872.81,3776.61) 4885.34,3764.08 ; 4885.34,3764.08 cw(c4897.87,3751.55) 4897.87,3769.27 ccw(c4897.87,3751.55) 4885.34,3764.08
  MidLayer1 w4: v1(3307.86,2775.04) 3311.19,2775.04 3315.19,2779.04 3315.19,2783.37 3326.71,2794.9 ; v1@3307.86,2780.54 ccw(c3307.86,2791.4) 3315.54,2783.72 ; v1@3307.86,2784.54 ccw(c3307.86,2805.06) 3322.37,2790.55 ; v1@3313.36,2775.04 cw(c3329.05,2775.04) 3317.95,2786.14 ; v1@3317.36,2775.04 cw(c3342.71,2775.04) 3324.78,2792.97 ; 3327.21,2794.4 3355,2822.18 3355,3225 3481.52,3351.52 3481.52,3771.73 3501.5,3791.71 3690.19,3791.71 v1(3715.19,3816.71) ; v1@3705.69,3816.71 cw(c3682.76,3816.71) 3698.97,3800.49 cw(c3715.19,3784.27) v1@3715.19,3807.21 ; v1@3709.69,3816.71 cw(c3696.41,3816.71) 3705.8,3807.32 cw(c3715.19,3797.93) v1@3715.19,3811.21
  MidLayer2 w4: v1(3715.19,3816.71) 3773.52,3816.71 3923.93,3967.11 3936.82,3980 4035.23,3980 ; v1@3719.08,3812.82 cw(c3728.47,3803.43) 3728.47,3816.71 cw(c3728.47,3829.99) v1@3719.08,3820.6 ; v1@3721.91,3809.99 cw(c3738.13,3793.77) 3738.13,3816.71 cw(c3738.13,3839.64) v1@3721.91,3823.43 ; 4741.16,3740.37 cw(c4741.16,3716.16) v1@4758.28,3733.28 ; 4742.97,3740.37 ccw(c4742.97,3762.03) v1@4758.28,3746.72 ; 4750.82,3740.37 cw(c4750.82,3725.82) v1@4761.11,3736.11 ; 4752.63,3740.37 ccw(c4752.63,3752.37) v1@4761.11,3743.89 ; v1@4765,3740.37 4690.68,3740.37 4674.27,3723.96 4674.27,3689.86 4652.31,3667.91 4505,3667.91 ; 4035.23,3980 4050,3980 ; 4035.23,3980 4050,3980 ; 4050,3980 4185.16,3980 4190.12,3975.04 4196.29,3968.87 4339.45,3968.87 4388.02,3920.29 ; 4388.02,3914.28 4388.02,3920.29 ; 4388.02,3914.28 4388.02,3838.02 4380,3830 4380,3785 4395,3770 4395,3675 4402.09,3667.91 4480.85,3667.91 ; 4388.02,3914.28 4388.02,3920.29 ; 4480.85,3667.91 4505,3667.91 ; 4480.85,3667.91 4505,3667.91
  Bottom Layer w4: v1@1375.86,2795.74 ccw(c1365.56,2808.37) 1381.86,2808.37 ; v1@1378.38,2792.64 ccw(c1372.42,2799.95) 1381.86,2799.95 ccw(c1391.29,2799.95) v1@1385.33,2792.64 ; v1(1381.86,2788.37) 1381.86,2808.37 ; v1@1387.86,2795.74 cw(c1398.16,2808.37) 1381.86,2808.37 ; v1@3301.14,2768.32 ccw(c3284.92,2752.11) 3284.92,2775.04 ccw(c3284.92,2797.98) v1@3301.14,2781.76 ; v1@3303.97,2771.15 ccw(c3294.58,2761.76) 3294.58,2775.04 ccw(c3294.58,2788.32) v1@3303.97,2778.93 ; v1(3307.86,2775.04) 3273.52,2775.04 3248.52,2750.04 3248.52,2725.04 3223.52,2700.04 1687.21,2700.04 1562.21,2825.04 1398.52,2825.04 1381.86,2808.37
PBIO.D25: EXTHDR1.52 U8.Y7 | length 6236.9
  Top Layer w4: EXTHDR1.52@1338.26,2910.03 ccw(c1324.61,2923.68) 1343.92,2923.68 ccw(c1363.23,2923.68) EXTHDR1.52@1349.58,2910.03 ; v1(1340.19,2975.04) 1340.19,2959.81 1345.5,2954.5 1345.5,2929.44 1343.92,2927.86 EXTHDR1.52@1343.92,2859.25 ; v3(5075.04,3953.78) U8.Y7@5094.72,3973.46 ; U8.Y7@5087.38,3973.46 cw(c5069.66,3973.46) 5082.19,3960.93 cw(c5094.72,3948.4) U8.Y7@5094.72,3966.12 ; 5087.84,3966.58 cw(c5075.04,3979.39) 5075.04,3961.28 ccw(c5075.04,3979.39) 5087.84,3966.58 ; 5087.84,3966.58 ccw(c5100.65,3953.78) 5082.54,3953.78 cw(c5100.65,3953.78) 5087.84,3966.58
  MidLayer1 w4: v1@1333.47,2968.32 ccw(c1317.26,2952.11) 1317.26,2975.04 ccw(c1317.26,2997.98) v1@1333.47,2981.76 ; v1@1336.3,2971.15 ccw(c1326.91,2961.76) 1326.91,2975.04 ccw(c1326.91,2988.32) v1@1336.3,2978.93 ; v1(1340.19,2975.04) 1281.86,2975.04 1265.19,2991.71 1265.19,3083.37 1365.19,3183.37 1603.88,3183.37 1653.88,3133.37 1748.17,3133.37 1798.5,3183.71 2154.98,3183.71 2170,3168.69 2170,2999.79 2123.52,2953.31 2123.52,2808.37 2174.77,2757.13 2830,2757.13 3231.86,3158.98 3231.86,4041.71 3240.19,4050.04 3600,4050.04 3608.33,4041.71 v1(3648.52,4041.71) ; v1@3641.81,4034.99 ccw(c3625.59,4018.77) 3625.59,4041.71 ccw(c3625.59,4064.64) v1@3641.81,4048.43 ; v1@3644.64,4037.82 ccw(c3635.25,4028.43) 3635.25,4041.71 ccw(c3635.25,4054.99) v1@3644.64,4045.6
  MidLayer2 w4: v1(3648.52,4041.71) 3948.52,4041.71 3965.19,4058.37 3990.19,4058.37 4004.06,4044.5 4205.56,4044.5 4209.06,4048 4293.7,4048 4333.7,4008 4398.31,4008 4409.5,3996.81 4409.5,3954.44 4428.73,3935.21 4463.63,3935.21 4502.95,3974.54 4534.54,3974.54 4567.5,4007.5 4567.5,4017.25 4577.75,4027.5 4592.25,4027.5 4597.25,4022.5 4623.25,4022.5 4647.5,3998.25 4647.5,3998.12 4703.92,3941.71 4738.54,3941.71 4752.5,3927.75 ; v1@3652.41,4037.82 cw(c3661.8,4028.43) 3661.8,4041.71 cw(c3661.8,4054.99) v1@3652.41,4045.6 ; v1@3655.24,4034.99 cw(c3671.46,4018.77) 3671.46,4041.71 cw(c3671.46,4064.64) v1@3655.24,4048.43 ; 5061.46,3942.39 cw(c5051.53,3952.32) 5051.53,3938.27 5037.6,3938.27 4977.41,3938.27 4957.99,3938.27 4899.73,3938.27 4841.47,3938.27 4838.82,3938.27 4830.82,3938.27 4807.5,3938.27 4798.02,3938.27 4787.5,3927.75 ; v3@5067.57,3954.43 cw(c5049.53,3956.01) 5061.17,3942.14 cw(c5072.81,3928.27) v3@5074.39,3946.31 ; 4752.5,3927.75 4762.75,3917.5 ; 4752.5,3927.75 4762.75,3917.5 ; 4762.75,3917.5 4777.25,3917.5 ; 4777.25,3917.5 4787.5,3927.75 ; 4777.25,3917.5 4787.5,3927.75
PBIO.D26: EXTHDR1.54 U8.AD1 | length 5113.5
  Top Layer w4: v1(1265.19,2950.04) 1281.86,2966.71 1318.04,2966.71 1337.5,2947.25 1337.5,2932.75 1327.25,2922.5 1312.65,2922.5 1312.42,2922.27 ; v1@1265.19,2955.54 ccw(c1265.19,2968.82) 1274.58,2959.43 ccw(c1283.97,2950.04) v1@1270.69,2950.04 ; v1@1265.19,2959.54 ccw(c1265.19,2982.48) 1281.41,2966.26 ccw(c1297.63,2950.04) v1@1274.69,2950.04 ; EXTHDR1.54@1307.09,2910.33 ccw(c1296.39,2922.27) 1312.42,2922.27 ; EXTHDR1.54@1312.43,2904.36 EXTHDR1.54@1312.42,2859.25 1312.42,2922.27 ; EXTHDR1.54@1317.76,2910.33 cw(c1328.46,2922.27) 1312.42,2922.27 ; v1@4685.05,3723.43 ccw(c4668.83,3739.64) 4691.77,3739.64 ccw(c4714.7,3739.64) v1@4698.48,3723.43 ; v1@4687.88,3720.6 ccw(c4678.49,3729.99) 4691.77,3729.99 ccw(c4705.04,3729.99) v1@4695.66,3720.6 ; v1(4691.77,3716.71) 4691.77,3767.83 4711.13,3787.19 4717.62,3787.19 4746.75,3787.19 4749.44,3784.5 4770.56,3784.5 4775.56,3784.5 4790.5,3799.44 4790.5,3813.15 4793.34,3815.98 4830.82,3815.98 4838.82,3815.98 U8.AD1@4858.5,3815.98 ; U8.AD1@4853.31,3810.79 ccw(c4840.78,3798.26) 4840.78,3815.98 ccw(c4840.78,3833.71) U8.AD1@4853.31,3821.18
  MidLayer1 w4: v1@4690.19,3716.71 v1(4691.77,3716.71)
  Bottom Layer w4: v1@1259.29,2942.6 cw(c1249.59,2930.38) 1265.19,2930.38 ; v1(1265.19,2950.04) 1265.19,2930.37 ; v1@1271.1,2942.6 ccw(c1280.79,2930.38) 1265.19,2930.38 ; 1792.34,3145.54 1813.5,3166.7 1843.16,3166.7 1901.5,3225.04 2756.86,3225.04 2806.86,3175.04 4010,3175.04 4023.19,3188.23 4023.19,3266 4052.19,3295 4052.19,3315 4045.52,3321.67 4045.52,3470.35 4040.19,3475.69 4040.19,3516.71 4069.16,3545.68 ; 1796.8,3150 1727,3080.2 1727,2897 1707.87,2877.87 1501.78,2877.87 1487.95,2891.71 1303.86,2891.71 1265.19,2930.37 ; 4073.52,3550.04 4069.16,3545.68 ; v1(4691.77,3716.71) 4684.29,3709.24 4684.29,3678.46 4672.21,3666.37 4463.63,3666.37 4456.86,3673.14 4456.86,3703.14 4371.63,3788.37 4103.37,3788.37 4080,3765 4080,3556.52 4069.16,3545.68
PBIO.D27: EXTHDR1.56 U8.AC1 | length 5870
  Top Layer w4: EXTHDR1.56@1276.93,2904.37 cw(c1294.82,2904.37) 1282.17,2917.02 ; EXTHDR1.56@1278.2,2911.89 ccw(c1276.79,2915.78) 1280.93,2915.78 ; EXTHDR1.56@1280.93,2859.25 1280.93,2915.78 ; EXTHDR1.56@1280.93,2904.37 cw(c1308.47,2904.37) 1289,2923.85 ; EXTHDR1.56@1283.65,2911.89 cw(c1285.06,2915.78) 1280.93,2915.78 ; EXTHDR1.56@1284.93,2904.37 cw(c1322.13,2904.37) 1295.82,2930.68 ; 1285.26,2920.11 cw(c1320,2885.37) v1@1320,2934.5 ; EXTHDR1.56@1288.93,2904.37 cw(c1335.79,2904.37) 1302.65,2937.5 ; 1292.09,2926.94 cw(c1320,2899.03) v1@1320,2938.5 ; 1298.92,2933.77 cw(c1320,2912.68) v1@1320,2942.5 ; 1305.74,2940.6 cw(c1320,2926.34) v1@1320,2946.5 ; v1(1320,2940) 1308.56,2940 1306.86,2941.71 1280.93,2915.78 ; v1@4678.28,3873.28 cw(c4662.06,3857.06) 4685,3857.06 cw(c4707.93,3857.06) v1@4691.72,3873.28 ; v1@4681.11,3876.11 cw(c4671.72,3866.72) 4685,3866.72 cw(c4698.28,3866.72) v1@4688.89,3876.11 ; v1(4685,3880) 4685,3855 4690.67,3849.33 4715.23,3849.33 4724.37,3840.19 4765.63,3840.19 4769.32,3840.19 4775.32,3846.19 4784.48,3855.35 4830.82,3855.35 4838.82,3855.35 U8.AC1@4858.5,3855.35 ; U8.AC1@4853.31,3850.16 ccw(c4840.78,3837.63) 4840.78,3855.35 ccw(c4840.78,3873.08) U8.AC1@4853.31,3860.55
  Bottom Layer w4: v1(1320,2940) 1480,2940 1491,2951 1540,2951 1557,2968 1603.48,2968 1641.01,3005.53 1810.52,3175.04 1840.19,3175.04 1898.52,3233.37 2759.84,3233.37 2810.17,3183.04 4005,3183.04 4015.19,3193.23 4015.19,3315 4037.52,3337.33 4037.52,3467.04 4032.19,3472.37 4032.19,3512.81 3995,3550 3615.23,3550 3598.52,3566.71 3598.52,3766.71 3604.86,3773.04 4063.19,3773.04 4086.52,3796.37 4374.94,3796.37 4464.86,3706.46 4464.86,3680.14 4470.63,3674.37 4668.9,3674.37 4672.52,3678 4672.52,3800 4672.52,3840 4672.52,3858.52 4672.52,3867.52 v1(4685,3880) ; v1@1323.89,2936.11 cw(c1333.28,2926.72) 1333.28,2940 cw(c1333.28,2953.28) v1@1323.89,2943.89 ; v1@1326.72,2933.28 cw(c1342.93,2917.06) 1342.93,2940 cw(c1342.93,2962.93) v1@1326.72,2946.72
PBIO.D28: EXTHDR1.58 U8.AB3 | length 7113.8
  Top Layer w4: EXTHDR1.58@1249.43,2806.13 cw(c1249.43,2782.79) 1265.93,2799.3 ; EXTHDR1.58@1249.43,2810.13 cw(c1249.43,2796.45) 1259.11,2806.13 ; EXTHDR1.58@1249.43,2859.25 1249.43,2815.8 1265.19,2800.04 1265.19,2765 1206.86,2706.67 1206.86,2441.71 1265.19,2383.37 v1(1356.86,2383.37) ; EXTHDR1.58@1257.43,2814.13 ccw(c1272.72,2814.13) 1261.91,2803.32 ; v1@1350.14,2376.66 ccw(c1333.92,2360.44) 1333.92,2383.37 ccw(c1333.92,2406.31) v1@1350.14,2390.09 ; v1@1352.97,2379.49 ccw(c1343.58,2370.1) 1343.58,2383.37 ccw(c1343.58,2396.65) v1@1352.97,2387.26 ; v1@4475.47,3850.43 ccw(c4459.25,3866.64) 4482.19,3866.64 ccw(c4505.12,3866.64) v1@4488.9,3850.43 ; v1@4478.3,3847.6 ccw(c4468.91,3856.99) 4482.19,3856.99 ccw(c4495.46,3856.99) v1@4486.08,3847.6 ; v1@4480.19,3845.7 v1(4482.19,3843.71) 4482.19,3942.23 4490,3950.04 4699.19,3950.04 4707.52,3941.71 4709.27,3939.97 4709.27,3930 4709.27,3913.39 4708.19,3912.32 4703.19,3907.32 4703.19,3872.68 4727.68,3848.19 4762.32,3848.19 4766,3848.19 4772,3854.19 4788.68,3870.86 4830.82,3870.86 4838.82,3870.86 ; 4838.82,3870.86 4897.36,3870.86 ; 4838.82,3870.86 4897.36,3870.86 ; 4897.36,3870.86 ccw(c4897.36,3909.54) 4924.71,3882.19 ; 4897.36,3870.86 ccw(c4897.36,3909.54) 4924.71,3882.19 ; 4924.71,3882.19 cw(c4937.24,3869.66) 4937.24,3887.38 ccw(c4937.24,3869.66) 4924.71,3882.19 ; 4924.71,3882.19 ccw(c4912.18,3894.72) 4929.9,3894.72 cw(c4912.18,3894.72) 4924.71,3882.19
  MidLayer1 w4: v1@1356.86,2373.87 cw(c1356.86,2350.94) 1373.07,2367.16 cw(c1389.29,2383.37) v1@1366.36,2383.37 ; v1@1356.86,2377.87 cw(c1356.86,2364.6) 1366.25,2373.99 cw(c1375.64,2383.37) v1@1362.36,2383.37 ; v1(1356.86,2383.37) 1377,2363.23 1377,1904.9 1400.9,1881 1911.63,1881 1951.63,1841 1993.34,1841 2017.63,1816.71 2080,1816.71 2113.29,1850 2395.5,1850 2473.86,1928.35 2473.86,2322.54 2501.81,2350.5 3082.32,2350.5 3631.86,2900.04 3631.86,3541.71 3640.19,3550.04 4065.19,3550.04 4073.52,3558.37 4073.52,3773.37 4056.19,3790.71 v1(4031.86,3790.71) ; v1@4035.75,3786.82 cw(c4045.14,3777.43) 4045.14,3790.71 cw(c4045.14,3803.99) v1@4035.75,3794.6 ; v1@4038.57,3783.99 cw(c4054.79,3767.77) 4054.79,3790.71 cw(c4054.79,3813.64) v1@4038.57,3797.43
  Bottom Layer w4: v1(4031.86,3790.71) 4069.54,3790.71 4083.21,3804.37 4378.25,3804.37 4391.92,3790.71 4410,3790.71 ; v1@4035.75,3786.82 cw(c4045.14,3777.43) 4045.14,3790.71 cw(c4045.14,3803.99) v1@4035.75,3794.6 ; v1@4038.57,3783.99 cw(c4054.79,3767.77) 4054.79,3790.71 cw(c4054.79,3813.64) v1@4038.57,3797.43 ; v1@4472.69,3843.71 cw(c4449.75,3843.71) 4465.97,3827.49 cw(c4482.19,3811.27) v1@4482.19,3834.21 ; v1@4476.69,3843.71 cw(c4463.41,3843.71) 4472.8,3834.32 cw(c4482.19,3824.93) v1@4482.19,3838.21 ; v1@4480.19,3843.71 v1(4482.19,3843.71) 4429.19,3790.71 4427.19,3790.71 ; 4410,3790.71 4427.19,3790.71 ; 4410,3790.71 4427.19,3790.71
PBIO.D29: EXTHDR1.60 U8.AB2 | length 6118.9
  Top Layer w4: EXTHDR1.60@1217.94,2806.13 cw(c1217.94,2795.28) 1225.61,2802.95 ; EXTHDR1.60@1217.94,2859.25 1217.94,2810.63 v1(1240.19,2788.37) ; EXTHDR1.60@1221.94,2814.13 ccw(c1240.05,2814.13) 1227.24,2801.32 ; v1@1230.69,2788.37 ccw(c1207.76,2788.37) 1223.97,2804.59 ccw(c1240.19,2820.81) v1@1240.19,2797.87 ; v1@1234.69,2788.37 ccw(c1221.41,2788.37) 1230.8,2797.76 ccw(c1240.19,2807.15) v1@1240.19,2793.87 ; v1(4698.52,2891.71) 4790.19,2983.37 4790.19,3130 ; v1@4698.52,2897.21 ccw(c4698.52,2910.49) 4707.91,2901.1 ccw(c4717.3,2891.71) v1@4704.02,2891.71 ; v1@4698.52,2901.21 ccw(c4698.52,2924.14) 4714.74,2907.93 ccw(c4730.96,2891.71) v1@4708.02,2891.71 ; 4464.69,3944.18 4478.54,3958.04 ; 4464.69,3944.18 4478.54,3958.04 ; 4464.69,3944.18 4464.69,3791.97 4464.69,3763.79 4470.52,3757.96 4470.52,3720.79 4477.5,3713.82 4477.5,3687.73 4480,3685.23 4484.31,3680.92 ; 4478.54,3958.04 4564.58,3958.04 ; 4484.31,3680.92 4490.19,3675.04 ; 4484.31,3680.92 4490.19,3675.04 ; 4490.19,3675.04 4648.52,3675.04 4665.19,3658.37 4665.19,3400.04 ; 4564.58,3958.04 4585,3958.04 ; 4564.58,3958.04 4585,3958.04 ; 4585,3958.04 4595,3958.04 ; 4595,3958.04 4605.42,3958.04 ; 4595,3958.04 4605.42,3958.04 ; 4605.42,3958.04 4702.51,3958.04 ; 4665.19,3400.04 4675.19,3390.04 ; 4665.19,3400.04 4675.19,3390.04 ; 4675.19,3390.04 4681.52,3383.71 ; 4675.19,3390.04 4681.52,3383.71 ; 4681.52,3383.71 4703.54,3383.71 4723.52,3363.73 4723.52,3333.37 4731.19,3325.71 4731.19,3310 ; 4702.51,3958.04 4717.27,3943.28 ; 4702.51,3958.04 4717.27,3943.28 ; 4717.27,3943.28 4717.27,3910.08 4716.19,3909 4711.19,3904 4711.19,3876 4731,3856.19 4759,3856.19 4762.69,3856.19 4768.69,3862.19 4785.72,3879.22 4830.82,3879.22 4838.82,3879.22 ; 4731.19,3286.69 4731.19,3310 ; 4731.19,3286.69 4731.19,3310 ; 4731.19,3286.69 4790.19,3227.69 4790.19,3141.71 ; 4790.19,3130 4790.19,3141.71 ; 4790.19,3130 4790.19,3141.71 ; 4838.82,3879.22 4878.16,3879.22 ; 4838.82,3879.22 4878.16,3879.22 ; 4878.16,3879.22 ccw(c4878.16,3889.37) 4885.34,3882.19 ; 4878.16,3879.22 ccw(c4878.16,3889.37) 4885.34,3882.19 ; 4885.34,3882.19 ccw(c4872.81,3894.72) 4890.53,3894.72 cw(c4872.81,3894.72) 4885.34,3882.19 ; 4885.34,3882.19 cw(c4897.87,3869.66) 4897.87,3887.38 ccw(c4897.87,3869.66) 4885.34,3882.19
  MidLayer2 w4: v1(1240.19,2788.37) 1240.19,2791.71 1256.86,2808.37 ; v1@1240.19,2797.87 ccw(c1240.19,2812.76) 1250.72,2802.24 ; v1@1245.68,2788.77 cw(c1262.84,2790.02) 1250.67,2802.19 ; v1@1249.67,2789.06 cw(c1274.37,2790.86) 1256.86,2808.37 ; 2128.88,2783.37 1975,2783.37 ; 4674.39,2891.21 ccw(c4674.39,2915.84) v1@4691.81,2898.43 ; 4676.79,2891.21 cw(c4676.79,2869.97) v1@4691.81,2884.99 ; 4684.05,2891.21 ccw(c4684.05,2906.18) v1@4694.64,2895.6 ; 4686.44,2891.21 cw(c4686.44,2879.63) v1@4694.64,2887.82 ; v1@4698.03,2891.21 4671.04,2891.21 4670.54,2891.71 4320.39,2891.71 4270.06,2841.37 3326.17,2841.37 3325.34,2842.2 3320.37,2842.2 3314.86,2836.69 3236.21,2758.04 3005.33,2758.04 2980,2783.37 1975,2783.37 ; 1256.86,2808.37 1950,2808.37 1975,2783.37
PBIO.D30: EXTHDR1.62 U8.AC3 | length 5040.5
  Top Layer w4: v1(1173.52,2975.04) 1173.52,2960.67 1189.19,2945 1189.19,2917.71 1190.19,2916.71 ; EXTHDR1.62@1186.05,2912.36 ccw(c1185.84,2916.71) 1190.19,2916.71 ; EXTHDR1.62@1190.19,2883.37 1190.19,2916.71 ; 1190.19,2914.63 ccw(c1196.7,2914.63) EXTHDR1.62@1192.1,2910.03 ; v1(4699.34,3613.05) 4684.29,3628.1 4684.29,3650 4684.29,3661.9 4674.27,3671.93 4674.27,3708.19 ; 4674.27,3708.19 4674.27,3745 ; 4674.27,3708.19 4674.27,3745 ; 4674.27,3745 4674.27,3785 4685.78,3796.51 4748.74,3796.51 4752.75,3792.5 4767.25,3792.5 4772.25,3792.5 4782.5,3802.75 4782.5,3816.46 ; 4782.5,3816.46 4796.23,3830.19 ; 4782.5,3816.46 4796.23,3830.19 ; 4796.23,3830.19 4797.53,3831.49 4830.82,3831.49 4838.82,3831.49 ; 4838.82,3831.49 4897.36,3831.49 ; 4838.82,3831.49 4897.36,3831.49 ; 4897.36,3831.49 ccw(c4897.36,3870.17) 4924.71,3842.82 ; 4897.36,3831.49 ccw(c4897.36,3870.17) 4924.71,3842.82 ; 4924.71,3842.82 cw(c4937.24,3830.29) 4937.24,3848.01 ccw(c4937.24,3830.29) 4924.71,3842.82 ; 4924.71,3842.82 ccw(c4912.18,3855.35) 4929.9,3855.35 cw(c4912.18,3855.35) 4924.71,3842.82
  MidLayer2 w4: v1(1173.52,2975.04) 1390.19,3191.71 1659.71,3191.71 1685,3217 1721.69,3217 1746.98,3191.71 1850,3191.71 1891.67,3233.37 2723.52,3233.37 2798.52,3308.37 3756.86,3308.37 3770.02,3321.54 4003.36,3321.54 4048.52,3366.71 ; v1@1173.52,2980.54 ccw(c1173.52,2993.82) 1182.91,2984.43 ccw(c1192.3,2975.04) v1@1179.02,2975.04 ; v1@1173.52,2984.54 ccw(c1173.52,3007.48) 1189.74,2991.26 ccw(c1205.96,2975.04) v1@1183.02,2975.04 ; v1@4692.24,3606.74 ccw(c4678.2,3594.27) 4678.2,3613.05 ; v1@4692.24,3619.36 cw(c4678.2,3631.83) 4678.2,3613.05 ; v1@4695.23,3609.4 ccw(c4687.1,3602.18) 4687.1,3613.05 ccw(c4687.1,3623.92) v1@4695.23,3616.7 ; v1(4699.34,3613.05) 4678.2,3613.05 ; 4048.52,3366.71 4093.54,3366.71 ; 4048.52,3366.71 4080,3366.71 ; 4080,3366.71 4093.54,3366.71 ; 4080,3366.71 4093.54,3366.71 ; 4093.54,3366.71 4099.5,3366.71 ; 4093.54,3366.71 4099.5,3366.71 ; 4099.5,3366.71 4123.19,3390.39 ; 4099.5,3366.71 4114.78,3381.98 ; 4099.5,3366.71 4114.78,3381.98 ; 4114.78,3381.98 4123.19,3390.39 ; 4114.78,3381.98 4123.19,3390.39 ; 4114.79,3381.98 4123.19,3390.38 ; 4123.19,3390.39 4123.19,3391.22 4123.19,3401.88 4123.52,3402.21 ; 4123.19,3390.39 4124.02,3391.22 ; 4123.19,3390.39 4124.02,3391.22 ; 4123.19,3390.39 4124.02,3391.22 ; 4123.52,3402.21 4123.52,3396.69 4124.02,3396.19 ; 4123.52,3402.21 4205.18,3483.87 ; 4123.52,3402.21 4145,3423.69 ; 4124.02,3391.22 4124.02,3396.19 ; 4124.02,3391.22 4124.02,3396.19 ; 4124.02,3396.19 4124.02,3402.7 4145,3423.69 ; 4145,3423.69 4205.18,3483.87 ; 4205.18,3483.87 4435,3483.87 ; 4435,3483.87 4442.68,3483.87 ; 4435,3483.87 4442.68,3483.87 ; 4442.68,3483.87 4499.02,3483.87 ; 4499.02,3483.87 4510.2,3495.05 ; 4499.02,3483.87 4510.2,3495.05 ; 4510.2,3495.05 4565.19,3550.04 4615.19,3550.04 4678.2,3613.05
PBIO.D31: EXTHDR1.64 U8.AD3 | length 5001.7
  Top Layer w4: 1148.52,2917.28 ccw(c1164.72,2917.28) 1154.94,2904.37 1148.52,2904.36 1148.52,2933.37 ; 1148.52,2925.33 ccw(c1170.81,2925.33) EXTHDR1.64@1157.36,2907.56 ; 1148.69,2933.54 cw(c1158.27,2923.96) v1@1163.19,2936.58 ; 1153.02,2937.87 cw(c1160.7,2930.19) v1@1164.65,2940.31 ; EXTHDR1.64@1154.94,2859.25 EXTHDR1.64@1154.95,2904.36 ; EXTHDR1.64@1159.77,2910.75 cw(c1176.91,2933.37) 1148.52,2933.37 ; v1(1165.19,2941.71) 1156.86,2941.71 1148.52,2933.37 ; v1(4730,3760) 4746.5,3760 ; v1@4738.22,3755.23 cw(c4746.5,3750.42) 4746.5,3760 ; v1@4738.22,3764.77 ccw(c4746.5,3769.58) 4746.5,3760 ; 4746.5,3760 4755,3768.5 ; 4755,3768.5 4782.19,3768.5 ; 4755,3768.5 4777.19,3768.5 4782.19,3768.5 ; 4782.19,3768.5 4805.81,3792.12 4832.88,3792.12 4838.82,3792.12 ; 4838.82,3792.12 4897.36,3792.12 ; 4838.82,3792.12 4897.36,3792.12 ; 4897.36,3792.12 ccw(c4897.36,3830.8) 4924.71,3803.45 ; 4897.36,3792.12 ccw(c4897.36,3830.8) 4924.71,3803.45 ; 4924.71,3803.45 cw(c4937.24,3790.92) 4937.24,3808.64 ccw(c4937.24,3790.92) 4924.71,3803.45 ; 4924.71,3803.45 ccw(c4912.18,3815.98) 4929.9,3815.98 cw(c4912.18,3815.98) 4924.71,3803.45
  MidLayer2 w4: v1(1165.19,2941.71) 1215.19,2991.71 1215.19,3001.16 1389.07,3175.04 1675.96,3175.04 1697,3154 1735.82,3154 1765.19,3183.37 1852.98,3183.37 1894.98,3225.37 2766.33,3225.37 2775,3216.71 2973.52,3216.71 3031.86,3275.04 3090.19,3275.04 3132.19,3233.04 3286.21,3233.04 3328.21,3275.04 4087.21,3275.04 4162.09,3349.92 4175,3362.83 4175,3442.37 4207.67,3475.04 4415,3475.04 ; v1@1165.19,2947.21 ccw(c1165.19,2960.49) 1174.58,2951.1 ccw(c1183.97,2941.71) v1@1170.69,2941.71 ; v1@1165.19,2951.21 ccw(c1165.19,2974.14) 1181.41,2957.93 ccw(c1197.63,2941.71) v1@1174.69,2941.71 ; 4456.86,3458.37 4440.19,3475.04 ; v1(4730,3760) 4750,3760 ; v1@4734.26,3756.53 cw(c4741.58,3750.56) 4741.58,3760 cw(c4741.58,3769.44) v1@4734.26,3763.47 ; v1@4737.36,3754 cw(c4750,3743.7) 4750,3760 ; v1@4737.36,3766 ccw(c4750,3776.3) 4750,3760 ; 4415,3475.04 4440.19,3475.04 ; 4415,3475.04 4440.19,3475.04 ; 4440.19,3475.04 4440.96,3475.04 4470,3446 4513.48,3446 4575.86,3508.37 4588.37,3508.37 4675.55,3595.55 ; 4675.55,3595.55 4706.61,3595.55 ; 4675.55,3595.55 4700,3595.55 ; 4700,3595.55 4706.61,3595.55 ; 4700,3595.55 4706.61,3595.55 ; 4706.61,3595.55 4722,3610.94 4765.56,3654.5 ; 4750,3760 4752.5,3760 ; 4750,3760 4752.5,3760 ; 4752.5,3760 4769.75,3760 4782.5,3747.25 4782.5,3732.75 4772.19,3722.44 4772.19,3698.87 4780.5,3690.56 4780.5,3669.44 ; 4765.56,3654.5 4780.5,3669.44 ; 4765.56,3654.5 4780.5,3669.44
PBIO.D32: EXTHDR1.66 U8.W8 | length 9020.5
  Top Layer w4: EXTHDR1.66@1117.79,2808.48 cw(c1104.13,2794.82) 1123.45,2794.82 cw(c1142.76,2794.82) EXTHDR1.66@1129.1,2808.48 ; EXTHDR1.66@1123.45,2859.25 1123.45,2425.12 1165.19,2383.37 v1(1165.19,2150.04) ; v1@1158.47,2156.76 ccw(c1142.26,2172.98) 1165.19,2172.98 ccw(c1188.13,2172.98) v1@1171.91,2156.76 ; v1@1161.3,2153.93 ccw(c1151.91,2163.32) 1165.19,2163.32 ccw(c1178.47,2163.32) v1@1169.08,2153.93 ; v1@2408.47,3347.99 cw(c2392.26,3331.77) 2415.19,3331.77 cw(c2438.13,3331.77) v1@2421.91,3347.99 ; v1@2411.3,3350.82 cw(c2401.91,3341.43) 2415.19,3341.43 cw(c2428.47,3341.43) v1@2419.08,3350.82 ; v1(2415.19,3354.71) 2415.19,3211.36 3005.69,2620.86 3019.37,2620.86 v1(3040.19,2600.04) ; v1@3030.69,2600.04 ccw(c3007.76,2600.04) 3023.97,2616.26 ccw(c3040.19,2632.48) v1@3040.19,2609.54 ; v1@3034.69,2600.04 ccw(c3021.41,2600.04) 3030.8,2609.43 ccw(c3040.19,2618.82) v1@3040.19,2605.54 ; v3(5114.41,3993.15) U8.W8@5134.09,4012.83 ; U8.W8@5126.75,4012.83 cw(c5109.03,4012.83) 5121.56,4000.3 cw(c5134.09,3987.77) U8.W8@5134.09,4005.49 ; 5127.21,4005.95 cw(c5114.41,4018.76) 5114.41,4000.65 ccw(c5114.41,4018.76) 5127.21,4005.95 ; 5127.21,4005.95 ccw(c5140.02,3993.15) 5121.91,3993.15 cw(c5140.02,3993.15) 5127.21,4005.95
  MidLayer1 w4: v1@1790.19,2140.54 cw(c1790.19,2117.61) 1806.41,2133.82 cw(c1822.63,2150.04) v1@1799.69,2150.04 ; v1@1790.19,2144.54 cw(c1790.19,2131.26) 1799.58,2140.65 cw(c1808.97,2150.04) v1@1795.69,2150.04 ; v1(1790.19,2150.04) 1812.23,2128 1918.31,2128 1938,2108.31 1938,1913.55 1978.55,1873 2018.25,1873 2027.75,1882.5 2042.25,1882.5 2064.75,1860 2394.19,1860 2465.86,1931.67 2465.86,2325.86 2498.5,2358.5 3043.5,2358.5 v1(3065,2380) ; v1@3055.5,2380 cw(c3032.56,2380) 3048.78,2363.78 cw(c3065,2347.56) v1@3065,2370.5 ; v1@3059.5,2380 cw(c3046.22,2380) 3055.61,2370.61 cw(c3065,2361.22) v1@3065,2374.5
  MidLayer2 w4: v1(1165.19,2150.04) 1190,2150.04 1195,2155.04 1195,2223.69 1247.69,2276.37 1406,2276.37 1478.37,2204 1542.55,2204 1598.55,2260 1623.66,2260 1624.45,2259.21 1650.83,2259.21 1760,2150.04 v1(1790.19,2150.04) ; v1@1169.08,2146.15 cw(c1178.47,2136.76) 1178.47,2150.04 cw(c1178.47,2163.32) v1@1169.08,2153.93 ; v1@1171.91,2143.32 cw(c1188.13,2127.11) 1188.13,2150.04 cw(c1188.13,2172.98) v1@1171.91,2156.76 ; v1@1783.47,2143.32 ccw(c1767.26,2127.11) 1767.26,2150.04 ccw(c1767.26,2172.98) v1@1783.47,2156.76 ; v1@1786.3,2146.15 ccw(c1776.91,2136.76) 1776.91,2150.04 ccw(c1776.91,2163.32) v1@1786.3,2153.93 ; v1(2415.19,3354.71) 2603.19,3354.71 2623.52,3375.04 2623.52,3525.04 2648.52,3550.04 2898.52,3550.04 2931.86,3583.37 2931.86,3641.71 2948.52,3658.37 3405,3658.37 3431.52,3684.9 3431.52,4045.21 3448.31,4062 3622,4062 3660.71,4100.71 3849.29,4100.71 3854.5,4095.5 3895.5,4095.5 3900.71,4100.71 4061.54,4100.71 4109.75,4052.5 4202.25,4052.5 4205.75,4056 4297.02,4056 4337.02,4016 4401.63,4016 4417.5,4000.13 4417.5,3957.75 4432.04,3943.21 4460.31,3943.21 4499.64,3982.54 4531.23,3982.54 4559.5,4010.81 4559.5,4020.56 4574.44,4035.5 4595.56,4035.5 4600.56,4030.5 4626.56,4030.5 4655.5,4001.56 4655.5,4001.44 4670.44,3986.5 4670.56,3986.5 4671.5,3985.56 ; v1@2419.08,3350.82 cw(c2428.47,3341.43) 2428.47,3354.71 cw(c2428.47,3367.99) v1@2419.08,3358.6 ; v1@2421.91,3347.99 cw(c2438.13,3331.77) 2438.13,3354.71 cw(c2438.13,3377.64) v1@2421.91,3361.43 ; v3@5106.94,3993.8 cw(c5088.9,3995.38) 5100.54,3981.51 ; v3@5113.76,3985.68 ccw(c5112.18,3967.64) 5100.54,3981.51 ; 4671.5,3985.56 4687.77,3969.29 ; 4671.5,3985.56 4687.77,3969.29 ; 4687.77,3969.29 4779.22,3969.29 4957.99,3969.29 4977.41,3969.29 5051.53,3969.29 5071.03,3969.29 ccw(c5071.03,4011.02) 5100.54,3981.51
  Bottom Layer w4: v1@3033.47,2593.32 cw(c3017.26,2577.11) 3040.19,2577.11 cw(c3063.13,2577.11) v1@3046.91,2593.32 ; v1@3036.3,2596.15 cw(c3026.91,2586.76) 3040.19,2586.76 cw(c3053.47,2586.76) v1@3044.08,2596.15 ; v1(3040.19,2600.04) 3040.19,2404.81 v1(3065,2380) ; v1@3055.5,2380 ccw(c3032.56,2380) 3048.78,2396.22 ccw(c3065,2412.43) v1@3065,2389.5 ; v1@3059.5,2380 ccw(c3046.22,2380) 3055.61,2389.39 ccw(c3065,2398.78) v1@3065,2385.5
PBIO.D33: EXTHDR1.68 U8.V8 | length 6375.1
  Top Layer w4: v1@1081.28,2730.72 ccw(c1055.53,2756.47) 1091.95,2756.47 ; v1@1084.11,2727.89 ccw(c1065.18,2746.82) 1091.95,2746.82 ; EXTHDR1.68@1086.29,2808.48 cw(c1072.64,2794.82) 1091.95,2794.82 cw(c1111.27,2794.82) EXTHDR1.68@1097.61,2808.48 ; v1@1086.94,2725.06 ccw(c1074.84,2737.16) 1091.95,2737.16 ; v1@1091.95,2727.95 EXTHDR1.68@1091.95,2859.25 ; 1091.95,2737.4 ccw(c1101.4,2737.4) v1@1094.72,2730.72 ; v3(5114.41,4032.52) U8.V8@5134.09,4052.2 ; U8.V8@5126.75,4052.2 cw(c5109.03,4052.2) 5121.56,4039.67 cw(c5134.09,4027.14) U8.V8@5134.09,4044.86 ; 5127.21,4045.32 cw(c5114.41,4058.13) 5114.41,4040.02 ccw(c5114.41,4058.13) 5127.21,4045.32 ; 5127.21,4045.32 ccw(c5140.02,4032.52) 5121.91,4032.52 cw(c5140.02,4032.52) 5127.21,4045.32
  MidLayer1 w4: v1(3481.86,2583.37) 3594.94,2583.37 3690.19,2678.63 v1(3690.19,3350.04) ; v1@3485.75,2579.49 cw(c3495.14,2570.1) 3495.14,2583.37 cw(c3495.14,2596.65) v1@3485.75,2587.26 ; v1@3488.57,2576.66 cw(c3504.79,2560.44) 3504.79,2583.37 cw(c3504.79,2606.31) v1@3488.57,2590.09 ; v1@3683.47,3343.32 cw(c3667.26,3327.11) 3690.19,3327.11 cw(c3713.13,3327.11) v1@3696.91,3343.32 ; v1@3686.3,3346.15 cw(c3676.91,3336.76) 3690.19,3336.76 cw(c3703.47,3336.76) v1@3694.08,3346.15
  MidLayer2 w4: v1@1089.04,2725.04 1939.96,2725.04 2097,2568 3052.96,2568 3093.67,2608.71 3456.52,2608.71 v1(3481.86,2583.37) ; v1@1091.89,2720.11 cw(c1103.79,2708.21) 1103.79,2725.04 ; v1@1094.72,2717.28 cw(c1113.45,2698.55) 1113.45,2725.04 ; v1@1094.72,2730.72 ccw(c1108.42,2744.42) 1108.42,2725.04 ; v1@3472.36,2583.37 ccw(c3449.42,2583.37) 3465.64,2599.59 ccw(c3481.86,2615.81) v1@3481.86,2592.87 ; v1@3476.36,2583.37 ccw(c3463.08,2583.37) 3472.47,2592.76 ccw(c3481.86,2602.15) v1@3481.86,2588.87 ; v1@4444,4040 4443.92,4039.92 v1(4443.92,4039.79) 4457.84,4025.87 4553.49,4025.87 4571.12,4043.5 4598.88,4043.5 4603.88,4038.5 4629.88,4038.5 4663.5,4004.88 ; 4667.45,4000.93 4663.5,4004.88 ; v3@5106.94,4033.17 cw(c5088.9,4034.75) 5100.54,4020.88 ; v3@5113.76,4025.05 ccw(c5112.18,4007.01) 5100.54,4020.88 ; 4663.5,4004.88 4663.5,4004.75 4673.75,3994.5 4694.5,3994.5 4708.66,4008.66 4828.82,4008.66 4838.82,4008.66 4957.99,4008.66 4977.41,4008.66 5051.53,4008.66 5071.03,4008.66 ccw(c5071.03,4050.39) 5100.54,4020.88
  Bottom Layer w4: v1@3683.47,3343.32 ccw(c3667.26,3327.11) 3667.26,3350.04 ccw(c3667.26,3372.98) v1@3683.47,3356.76 ; v1@3686.3,3346.15 ccw(c3676.91,3336.76) 3676.91,3350.04 ccw(c3676.91,3363.32) v1@3686.3,3353.93 ; v1(3690.19,3350.04) 3648.52,3350.04 3631.86,3366.71 3631.86,3405.37 3573.52,3463.71 3573.52,3780 3573.86,3780.33 3573.86,3855.06 3612.12,3893.32 3612.12,3907.12 3687.5,3982.5 3872.25,3982.5 3886.5,3996.75 3886.5,4004.3 3935.74,4053.54 4005.94,4053.54 4042.68,4016.79 4393.28,4016.79 4417.19,4040.71 v1@4443,4040.71 ; 4418.77,4040.71 cw(c4418.77,4014.65) v1@4437.2,4033.07 ; 4423.19,4040.71 ccw(c4423.19,4060.52) v1@4437.2,4046.51 ; 4428.43,4040.71 cw(c4428.43,4024.3) v1@4440.03,4035.9
  other v1: 1088,2724
PBIO.D34: EXTHDR1.70 U8.W10 | length 6946.3
  Top Layer w4: EXTHDR1.70@1054.8,2808.48 cw(c1041.14,2794.82) 1060.46,2794.82 cw(c1079.77,2794.82) EXTHDR1.70@1066.11,2808.48 ; 1060.46,2789.01 ccw(c1083.01,2789.01) v1@1067.06,2773.06 ; 1060.46,2798.66 ccw(c1092.66,2798.66) v1@1069.89,2775.89 ; EXTHDR1.70@1060.46,2808.32 ccw(c1102.32,2808.32) v1@1072.72,2778.72 ; EXTHDR1.70@1060.46,2866.71 EXTHDR1.70@1060.46,2859.25 1060.46,2777.54 v1(1066,2772) ; v3(5193.15,3993.15) U8.W10@5212.83,4012.83 ; U8.W10@5205.49,4012.83 cw(c5187.77,4012.83) 5200.3,4000.3 cw(c5212.83,3987.77) U8.W10@5212.83,4005.49 ; 5205.95,4005.95 cw(c5193.15,4018.76) 5193.15,4000.65 ccw(c5193.15,4018.76) 5205.95,4005.95 ; 5205.95,4005.95 ccw(c5218.76,3993.15) 5200.65,3993.15 cw(c5218.76,3993.15) 5205.95,4005.95
  MidLayer1 w4: v1@4200.14,2798.43 ccw(c4183.92,2814.64) 4206.86,2814.64 ccw(c4229.79,2814.64) v1@4213.57,2798.43 ; v1@4202.97,2795.6 ccw(c4193.58,2804.99) 4206.86,2804.99 ccw(c4220.14,2804.99) v1@4210.75,2795.6 ; v1(4206.86,2791.71) 4206.86,2946.71 4373.52,3113.37 4373.52,3225.04 4348.84,3249.72 4343.09,3249.72 4304.52,3288.29 4304.52,3714.52 4323.37,3733.37 4381.86,3733.37 4401.86,3753.37 v1(4401.86,3808.37) ; v1@4395.14,3801.66 cw(c4378.92,3785.44) 4401.86,3785.44 cw(c4424.79,3785.44) v1@4408.57,3801.66 ; v1@4397.97,3804.49 cw(c4388.58,3795.1) 4401.86,3795.1 cw(c4415.14,3795.1) v1@4405.75,3804.49
  MidLayer2 w4: v1@1064.23,2773.77 cw(c1078.57,2759.43) 1078.57,2779.71 ; v1(1066,2772) 1066,2772.18 1073.52,2779.71 1118.86,2779.71 1165.19,2733.37 1959.31,2733.37 1985.31,2759.37 2969.71,2759.37 2995.04,2734.04 3139.65,2734.04 3194.65,2679.04 3599.54,2679.04 3695.54,2775.04 4165.19,2775.04 4181.86,2791.71 v1(4206.86,2791.71) ; v1@1067.06,2770.94 cw(c1088.23,2749.77) 1088.23,2779.71 ; v1@1069.89,2768.11 cw(c1097.89,2740.11) 1097.89,2779.71 ; v1@1072.72,2765.28 cw(c1107.54,2730.46) 1107.54,2779.71 ; v1@4200.14,2784.99 ccw(c4183.92,2768.77) 4183.92,2791.71 ccw(c4183.92,2814.64) v1@4200.14,2798.43 ; v1@4202.97,2787.82 ccw(c4193.58,2778.43) 4193.58,2791.71 ccw(c4193.58,2804.99) v1@4202.97,2795.6
  Bottom Layer w4: v1@4395.14,3815.09 ccw(c4378.92,3831.31) 4401.86,3831.31 ccw(c4424.79,3831.31) v1@4408.57,3815.09 ; v1@4397.97,3812.26 ccw(c4388.58,3821.65) 4401.86,3821.65 ccw(c4415.14,3821.65) v1@4405.75,3812.26 ; v1(4401.86,3808.37) 4401.86,3866.86 4410,3875 4445,3875 4465.69,3895.69 4465.69,3947.56 4481.63,3963.5 4660,3963.5 4670,3953.5 4670,3915.23 4680.23,3905 4689.75,3905 4703.19,3891.56 4703.19,3863.44 4688.88,3849.13 4688.88,3753.75 4721.5,3721.12 4721.5,3665.14 4733.68,3652.96 4733.68,3642.38 4781.19,3594.87 4781.19,3559.4 4859.71,3480.88 4895.42,3480.88 4909.79,3466.5 4972.56,3466.5 4975.56,3469.5 5014.4,3469.5 5051.02,3432.87 5087.87,3432.87 5093.02,3438.02 5093.02,3573.02 5115,3595 5115,3605 5120,3610 5135,3610 5138.18,3613.18 5138.18,3630.82 5138.18,3638.82 5138.18,3640.41 5138.18,3698.67 5138.18,3914.41 cw(c5153.78,3914.41) 5153.78,3930.01 ccw(c5153.78,3953.78) 5177.55,3953.78 5177.55,3961.9 ; 5177.6,3961.95 cw(c5201.32,3963.56) 5182.72,3978.35 ; v3@5185.76,3991.85 cw(c5167.93,3988.7) 5182.76,3978.32 cw(c5197.6,3967.93) v3@5194.45,3985.76
PBIO.D35: EXTHDR1.72 U8.Y3 | length 7130.2
  Top Layer w4: EXTHDR1.72@1023.3,2808.48 cw(c1009.65,2794.82) 1028.96,2794.82 cw(c1048.27,2794.82) EXTHDR1.72@1034.62,2808.48 ; EXTHDR1.72@1028.96,2814.13 EXTHDR1.72@1028.96,2859.25 1028.96,2770.43 1023.52,2765 1023.52,2391.71 1040.19,2375.04 v1(1081.86,2375.04) ; v1@1075.14,2368.32 ccw(c1058.92,2352.11) 1058.92,2375.04 ccw(c1058.92,2397.98) v1@1075.14,2381.76 ; v1@1077.97,2371.15 ccw(c1068.58,2361.76) 1068.58,2375.04 ccw(c1068.58,2388.32) v1@1077.97,2378.93 ; v1@4616,3995.5 cw(c4616,3972.56) 4632.22,3988.78 cw(c4648.43,4005) v1@4625.5,4005 ; v1@4616,3999.5 cw(c4616,3986.22) 4625.39,3995.61 cw(c4634.78,4005) v1@4621.5,4005 ; v1(4616,4005) 4637.96,3983.04 4716.96,3983.04 4745,3955 4775,3955 4780.4,3949.6 4830.82,3949.6 4838.82,3949.6 4897.36,3949.6 ccw(c4897.36,3988.28) 4924.71,3960.93 ; U8.Y3@4929.9,3973.46 cw(c4912.18,3973.46) 4924.71,3960.93 ; U8.Y3@4937.24,3966.12 ccw(c4937.24,3948.4) 4924.71,3960.93
  MidLayer1 w4: v1@1075.14,2368.32 cw(c1058.92,2352.11) 1081.86,2352.11 cw(c1104.79,2352.11) v1@1088.57,2368.32 ; v1@1077.97,2371.15 cw(c1068.58,2361.76) 1081.86,2361.76 cw(c1095.14,2361.76) v1@1085.75,2371.15 ; v1(1081.86,2375.04) 1081.86,2293.14 1273.86,2101.14 1273.86,1911.14 1320,1865 1905,1865 1945,1825 1986.71,1825 2070,1741.71 2135,1741.71 2235.29,1842 2398.82,1842 2481.86,1925.04 2481.86,2319.23 2505.13,2342.5 3085.63,2342.5 3108.73,2365.6 ; 3090.98,2347.85 3640,2896.87 3640,3441.52 3665.19,3466.71 v1(3665.19,3525.04) ; v1@3658.47,3518.32 cw(c3642.26,3502.11) 3665.19,3502.11 cw(c3688.13,3502.11) v1@3671.91,3518.32 ; v1@3661.3,3521.15 cw(c3651.91,3511.76) 3665.19,3511.76 cw(c3678.47,3511.76) v1@3669.08,3521.15
  Bottom Layer w4: v1@3658.47,3518.32 ccw(c3642.26,3502.11) 3642.26,3525.04 ccw(c3642.26,3547.98) v1@3658.47,3531.76 ; v1@3661.3,3521.15 ccw(c3651.91,3511.76) 3651.91,3525.04 ccw(c3651.91,3538.32) v1@3661.3,3528.93 ; v1(3665.19,3525.04) 3623.52,3525.04 3590.19,3558.37 3590.19,3815 3626.06,3850.87 3694.28,3850.87 4026.63,3850.87 4029.63,3847.87 4076.71,3847.87 4095.21,3866.37 4109.67,3866.37 4110,3866.71 4268.17,3866.71 4385.34,3983.88 4428.1,3983.88 4470.22,4026 4576.25,4026 4577.75,4027.5 4592.25,4027.5 4614.75,4005 v1(4616,4005) ; 4597.65,4022.1 ccw(c4616,4040.46) v1@4616,4014.5 ; 4600.67,4019.08 cw(c4586.59,4005) v1@4606.5,4005 ; 4604.47,4015.27 ccw(c4616,4026.8) v1@4616,4010.5
PBIO.D36: EXTHDR1.74 U8.W3 | length 5814.6
  Top Layer w4: v1@861.81,2979.99 cw(c845.59,2963.77) 868.52,2963.77 cw(c891.46,2963.77) v1@875.24,2979.99 ; v1@864.64,2982.82 cw(c855.25,2973.43) 868.52,2973.43 cw(c881.8,2973.43) v1@872.41,2982.82 ; v1(868.52,2986.71) 868.52,2958.37 893.52,2933.37 981.86,2933.37 997.46,2917.77 ; EXTHDR1.74@993.67,2911.41 ccw(c990.24,2917.77) 997.46,2917.77 ; EXTHDR1.74@997.46,2859.25 997.46,2917.77 ; EXTHDR1.74@1001.26,2911.41 cw(c1004.69,2917.77) 997.46,2917.77 ; v1@4615,4046.5 cw(c4615,4023.56) 4631.22,4039.78 cw(c4647.43,4056) v1@4624.5,4056 ; v1@4615,4050.5 cw(c4615,4037.22) 4624.39,4046.61 cw(c4633.78,4056) v1@4620.5,4056 ; v1(4615,4056) 4656.86,4014.14 4656.86,4008.37 4670.73,3994.5 4688.25,3994.5 4698.5,4004.75 4702.12,4008.37 ; 4702.12,4008.37 4710,4008.37 ; 4702.12,4008.37 4710,4008.37 ; 4710,4008.37 4746.63,4008.37 4766.03,3988.97 4830.82,3988.97 4838.82,3988.97 ; 4838.82,3988.97 4897.36,3988.97 ; 4838.82,3988.97 4897.36,3988.97 ; 4897.36,3988.97 ccw(c4897.36,4027.65) 4924.71,4000.3 ; 4897.36,3988.97 ccw(c4897.36,4027.65) 4924.71,4000.3 ; 4924.71,4000.3 cw(c4937.24,3987.77) 4937.24,4005.49 ccw(c4937.24,3987.77) 4924.71,4000.3 ; 4924.71,4000.3 ccw(c4912.18,4012.83) 4929.9,4012.83 cw(c4912.18,4012.83) 4924.71,4000.3
  MidLayer1 w4: v1@861.81,2993.43 ccw(c845.59,3009.64) 868.52,3009.64 ccw(c891.46,3009.64) v1@875.24,2993.43 ; v1@864.64,2990.6 ccw(c855.25,2999.99) 868.52,2999.99 ccw(c881.8,2999.99) v1@872.41,2990.6 ; v1(868.52,2986.71) 868.52,3035.9 882.34,3049.71 1024.71,3049.71 1038,3063 1038,3183 1055.04,3200.04 1615.19,3200.04 1665.19,3150.04 1731.86,3150.04 1906.82,3325 2080,3325 2123.52,3368.52 v1(2123.52,3441.71) ; v1@2116.81,3434.99 cw(c2100.59,3418.77) 2123.52,3418.77 cw(c2146.46,3418.77) v1@2130.24,3434.99 ; v1@2119.64,3437.82 cw(c2110.25,3428.43) 2123.52,3428.43 cw(c2136.8,3428.43) v1@2127.41,3437.82
  MidLayer2 w4: v1(2123.52,3441.71) 2140.19,3458.37 2298.52,3458.37 2315.19,3475.04 2315.19,3533.37 2340.19,3558.37 2698.52,3558.37 2715.19,3575.04 2715.19,3650.04 2731.86,3666.71 3398.52,3666.71 3423.52,3691.71 3423.52,4048.52 3445,4070 3615.48,4070 3654.19,4108.71 3852.6,4108.71 3857.81,4103.5 3892.19,4103.5 3897.4,4108.71 4064.86,4108.71 4095.64,4077.93 4132.74,4077.93 4155.31,4100.5 4290.39,4100.5 4320.08,4070.81 4547.56,4070.81 4552.87,4065.5 4585,4065.5 4594.5,4056 ; v1@2123.52,3447.21 ccw(c2123.52,3460.49) 2132.91,3451.1 ccw(c2142.3,3441.71) v1@2129.02,3441.71 ; v1@2123.52,3451.21 ccw(c2123.52,3474.14) 2139.74,3457.93 ccw(c2155.96,3441.71) v1@2133.02,3441.71 ; v1@4607.75,4049.86 ccw(c4594.5,4038.63) 4594.5,4056 ; v1@4607.75,4062.14 cw(c4594.5,4073.37) 4594.5,4056 ; v1@4610.8,4052.44 ccw(c4603.13,4045.95) 4603.13,4056 ccw(c4603.13,4066.05) v1@4610.8,4059.56 ; v1(4615,4056) 4594.5,4056
PBIO.D37: EXTHDR1.76 U8.V3 | length 7650.9
  Top Layer w4: EXTHDR1.76@960.31,2808.48 cw(c948.53,2796.69) 965.19,2796.69 ; 965.19,2792.94 cw(c987.16,2792.94) EXTHDR1.76@971.62,2808.48 ; 965.19,2802.6 cw(c977.5,2802.6) EXTHDR1.76@968.8,2811.3 ; EXTHDR1.76@965.19,2857.71 965.19,2780 973.52,2771.67 v1(973.52,2741.71) ; v1@966.81,2748.43 ccw(c950.59,2764.64) 973.52,2764.64 ccw(c996.46,2764.64) v1@980.24,2748.43 ; v1@969.64,2745.6 ccw(c960.25,2754.99) 973.52,2754.99 ccw(c986.8,2754.99) v1@977.41,2745.6 ; v1@3000.14,2809.99 cw(c2983.92,2793.77) 3006.86,2793.77 cw(c3029.79,2793.77) v1@3013.57,2809.99 ; v1@3002.97,2812.82 cw(c2993.58,2803.43) 3006.86,2803.43 cw(c3020.14,2803.43) v1@3010.75,2812.82 ; v1(3006.86,2816.71) 3006.86,2778.14 3027.46,2757.54 3469.4,2757.54 3506.86,2795 3506.86,4036.36 3523.86,4053.36 3523.86,4939.86 v2(3524,4940) ; v2@3517.06,4933.06 cw(c3500.66,4916.66) 3523.86,4916.66 ; v2@3519.89,4935.89 cw(c3510.32,4926.32) 3523.86,4926.32 ; 3523.86,4915.97 cw(c3548.03,4915.97) v2@3530.94,4933.06 ; 3523.86,4925.63 cw(c3538.37,4925.63) v2@3528.11,4935.89 ; v2@3789,4891.19 cw(c3789,4867.5) 3805.75,4884.25 cw(c3822.5,4901) v2@3798.81,4901 ; v2@3789,4895.19 cw(c3789,4881.16) 3798.92,4891.08 cw(c3808.84,4901) v2@3794.81,4901 ; v2(3789,4901) 3820,4870 3910.15,4870 3973.52,4933.37 4154.67,4933.37 4173.52,4914.52 4173.52,4832.02 4158,4816.5 4158,4503.86 4206.86,4455 4206.86,4332.29 4272.96,4266.19 4329.95,4266.19 4381.86,4214.28 4381.86,4161.36 4401.84,4141.37 4473.86,4141.37 4532.23,4083 4669.18,4083 4676,4076.19 4719.81,4032.37 4765.46,4032.37 4769.49,4028.34 4830.82,4028.34 4838.82,4028.34 4897.36,4028.34 ccw(c4897.36,4067.02) 4924.71,4039.67 ; U8.V3@4929.9,4052.2 cw(c4912.18,4052.2) 4924.71,4039.67 ; U8.V3@4937.24,4044.86 ccw(c4937.24,4027.14) 4924.71,4039.67
  MidLayer1 w4: v2(3524,4940) 3750,4940 v2(3789,4901) ; v2@3528.11,4935.89 cw(c3538.03,4925.97) 3538.03,4940 cw(c3538.03,4954.03) v2@3528.11,4944.11 ; v2@3530.94,4933.06 cw(c3547.69,4916.31) 3547.69,4940 cw(c3547.69,4963.69) v2@3530.94,4946.94 ; v2@3779.19,4901 ccw(c3755.5,4901) 3772.25,4917.75 ccw(c3789,4934.5) v2@3789,4910.81 ; v2@3783.19,4901 ccw(c3769.16,4901) 3779.08,4910.92 ccw(c3789,4920.84) v2@3789,4906.81
  MidLayer2 w4: v1(973.52,2741.71) 1048.52,2816.71 1952.98,2816.71 1977.98,2791.71 2981.86,2791.71 v1(3006.86,2816.71) ; v1@973.52,2747.21 ccw(c973.52,2760.49) 982.91,2751.1 ccw(c992.3,2741.71) v1@979.02,2741.71 ; v1@973.52,2751.21 ccw(c973.52,2774.14) 989.74,2757.93 ccw(c1005.96,2741.71) v1@983.02,2741.71 ; v1@2997.36,2816.71 cw(c2974.42,2816.71) 2990.64,2800.49 cw(c3006.86,2784.27) v1@3006.86,2807.21 ; v1@3001.36,2816.71 cw(c2988.08,2816.71) 2997.47,2807.32 cw(c3006.86,2797.93) v1@3006.86,2811.21
PBIO.D38: EXTHDR1.78 U8.AD5 | length 8264.5
  Top Layer w4: EXTHDR1.78@928.81,2808.48 cw(c901.35,2781.01) 940.19,2781.01 ; EXTHDR1.78@931.64,2811.3 cw(c911.01,2790.67) 940.19,2790.67 ; EXTHDR1.78@934.47,2814.13 cw(c920.66,2800.32) 940.19,2800.32 ; EXTHDR1.78@940.19,2858.37 940.19,2745 931.52,2736.33 931.52,2150 951.52,2130 1265,2130 1340,2205 1546.31,2205 1651.23,2309.92 1672.31,2331 2107.69,2331 2290.69,2148 3061.75,2148 3081.76,2127.99 v1@3081.76,2121 ; v3(4996.3,3796.3) U8.AD5@5015.98,3815.98 ; U8.AD5@5008.64,3815.98 cw(c4990.92,3815.98) 5003.45,3803.45 cw(c5015.98,3790.92) U8.AD5@5015.98,3808.64 ; 5009.1,3809.1 cw(c4996.3,3821.91) 4996.3,3803.8 ccw(c4996.3,3821.91) 5009.1,3809.1 ; 5009.1,3809.1 ccw(c5021.91,3796.3) 5003.8,3796.3 cw(c5021.91,3796.3) 5009.1,3809.1
  MidLayer1 w4: v1@2924,2198.5 cw(c2924,2175.56) 2940.22,2191.78 cw(c2956.43,2208) v1@2933.5,2208 ; v1@2924,2202.5 cw(c2924,2189.22) 2933.39,2198.61 cw(c2942.78,2208) v1@2929.5,2208 ; v1(2924,2208) 2968.5,2163.5 3154.34,2163.5 3279.05,2288.22 3279.05,2330.57 3423.52,2475.04 3423.52,2600.04 3665.19,2841.71 v1(3665.19,3383.37) ; v1@3658.47,3376.66 cw(c3642.26,3360.44) 3665.19,3360.44 cw(c3688.13,3360.44) v1@3671.91,3376.66 ; v1@3661.3,3379.49 cw(c3651.91,3370.1) 3665.19,3370.1 cw(c3678.47,3370.1) v1@3669.08,3379.49
  Bottom Layer w4: v1(2924,2208) 3032,2208 3082,2158 v1(3082,2121) ; v1@2927.89,2204.11 cw(c2937.28,2194.72) 2937.28,2208 cw(c2937.28,2221.28) v1@2927.89,2211.89 ; v1@2930.72,2201.28 cw(c2946.93,2185.06) 2946.93,2208 cw(c2946.93,2230.93) v1@2930.72,2214.72 ; v1@3075.28,2127.72 ccw(c3059.06,2143.93) 3082,2143.93 ccw(c3104.93,2143.93) v1@3088.72,2127.72 ; v1@3078.11,2124.89 ccw(c3068.72,2134.28) 3082,2134.28 ccw(c3095.28,2134.28) v1@3085.89,2124.89 ; v1@3655.69,3383.37 ccw(c3632.76,3383.37) 3648.97,3399.59 ccw(c3665.19,3415.81) v1@3665.19,3392.87 ; v1@3659.69,3383.37 ccw(c3646.41,3383.37) 3655.8,3392.76 ccw(c3665.19,3402.15) v1@3665.19,3388.87 ; v1(3665.19,3383.37) 3581.86,3466.71 3581.86,3817.98 3622.75,3858.87 4029.94,3858.87 4032.94,3855.87 4067.34,3855.87 4086.17,3874.71 4264.86,3874.71 4383.86,3993.71 4426.56,3993.71 4461.42,4028.57 4461.42,4050.74 4473.49,4062.81 4583.44,4062.81 4607.75,4038.5 4622.25,4038.5 4648.25,4064.5 4675.25,4064.5 4698.5,4041.25 4698.5,3963.87 4724.19,3938.18 4724.19,3905.69 4719.19,3900.69 4719.19,3856.81 4704.88,3842.5 4704.88,3769.94 4704.88,3760.37 4722.75,3742.5 4737.5,3727.75 4737.5,3687.25 4737.5,3685 4737.5,3671.77 4749.68,3659.58 4749.68,3649.01 4767.19,3631.5 4797.19,3601.5 4797.19,3566.02 4854.11,3509.11 4866.34,3496.88 4875,3496.88 4902.05,3496.88 4916.42,3482.5 4932.25,3482.5 4945.5,3495.75 4945.5,3500.25 4956.65,3511.4 4994.5,3511.4 4998,3514.9 5001.72,3514.9 5012.5,3525.68 5012.5,3539.13 4993.63,3558 4982.81,3558 4959.19,3581.62 4959.19,3599.38 4972.53,3612.72 4972.53,3630.82 4972.53,3638.82 4972.53,3640.41 4972.53,3698.67 4972.53,3756.93 cw(c4996.3,3756.93) 4979.49,3773.74 4985.91,3781.47 ; v3@4988.91,3795 cw(c4971.08,3791.85) 4985.91,3781.47 ; v3@4997.6,3788.91 ccw(c5000.75,3771.08) 4985.91,3781.47
PBIO.D39: EXTHDR1.80 U8.AB4 | length 5901.3
  Top Layer w4: v1@900.14,2795.09 ccw(c893.3,2801.94) 902.97,2801.94 ; v1@902.97,2792.26 EXTHDR1.80@902.97,2859.25 ; 902.97,2801.37 ccw(c919.85,2801.37) v1@907.92,2789.44 ; EXTHDR1.80@902.97,2811.03 ccw(c929.51,2811.03) v1@910.75,2792.26 ; EXTHDR1.80@902.97,2820.68 ccw(c939.17,2820.68) v1@913.57,2795.09 ; v3(4956.93,3875.04) U8.AB4@4976.61,3894.72 ; U8.AB4@4969.27,3894.72 cw(c4951.55,3894.72) 4964.08,3882.19 cw(c4976.61,3869.66) U8.AB4@4976.61,3887.38 ; 4969.73,3887.84 cw(c4956.93,3900.65) 4956.93,3882.54 ccw(c4956.93,3900.65) 4969.73,3887.84 ; 4969.73,3887.84 ccw(c4982.54,3875.04) 4964.43,3875.04 cw(c4982.54,3875.04) 4969.73,3887.84
  MidLayer1 w4: v1@3866.81,2806.76 ccw(c3850.59,2822.98) 3873.52,2822.98 ccw(c3896.46,2822.98) v1@3880.24,2806.76 ; v1@3869.64,2803.93 ccw(c3860.25,2813.32) 3873.52,2813.32 ccw(c3886.8,2813.32) v1@3877.41,2803.93 ; v1(3873.52,2800.04) 3873.52,2930.39 4264.52,3321.39 4264.52,3959.15 4311.13,4005.75 4311.13,4037.44 4337.89,4064.21 4415,4064.21 4428.15,4064.21 4429.44,4065.5 4434.75,4070.81 4470.17,4070.81 4530.25,4070.81 4551.36,4049.7 4551.36,3994.83 4559.5,3986.69 4580.69,3965.5 4600,3965.5 4620,3965.5 4657.5,3965.5 4660.5,3962.5 4689.04,3962.5 4718,3933.54 4718,3878.31 4726.12,3870.19 4750.62,3870.19 4760,3870.19 4800,3870.19 4804.85,3875.04 4830.82,3875.04 4838.82,3875.04 4879.25,3875.04 4898.67,3875.04 v3(4956.93,3875.04) ; v3@4951.74,3869.85 ccw(c4939.2,3857.31) 4939.2,3875.04 ccw(c4939.2,3892.77) v3@4951.74,3880.23 ; 4938.82,3875.04 cw(c4938.82,3856.93) 4951.63,3869.74 ccw(c4938.82,3856.93) 4938.82,3875.04 ; 4938.82,3875.04 ccw(c4938.82,3893.15) 4951.63,3880.34 cw(c4938.82,3893.15) 4938.82,3875.04
  MidLayer2 w4: v1@900.14,2781.66 cw(c883.92,2765.44) 906.86,2765.44 cw(c929.79,2765.44) v1@913.57,2781.66 ; v1@902.97,2784.49 cw(c893.58,2775.1) 906.86,2775.1 cw(c920.14,2775.1) v1@910.75,2784.49 ; v1(906.86,2788.37) 906.86,2743.14 933.29,2716.71 979.52,2716.71 1071.19,2808.37 1101.5,2808.37 1168.17,2741.71 1956.33,2741.71 1982,2767.37 2973.02,2767.37 2998.35,2742.04 3142.96,2742.04 3184.96,2700.04 3205.86,2700.04 3305.86,2800.04 v1(3873.52,2800.04) ; v1@3866.81,2793.32 ccw(c3850.59,2777.11) 3850.59,2800.04 ccw(c3850.59,2822.98) v1@3866.81,2806.76 ; v1@3869.64,2796.15 ccw(c3860.25,2786.76) 3860.25,2800.04 ccw(c3860.25,2813.32) v1@3869.64,2803.93
PBIO.D40: EXTHDR1.82 U8.AA6 | length 6655.1
  Top Layer w4: EXTHDR1.82@865.82,2808.48 cw(c847.23,2789.88) 873.52,2789.88 ; EXTHDR1.82@868.65,2811.3 cw(c856.88,2799.54) 873.52,2799.54 ; 873.52,2799.76 cw(c885.85,2799.76) EXTHDR1.82@877.14,2808.48 ; EXTHDR1.82@873.52,2859.25 873.52,2766.48 923.52,2716.48 923.52,2146.69 948.21,2122 1268.31,2122 1343.31,2197 1549.63,2197 1675.63,2323 2104.37,2323 2287.37,2140 3020,2140 3030,2130 v1(3055,2130) ; v1@3048.28,2123.28 ccw(c3032.06,2107.06) 3032.06,2130 ccw(c3032.06,2152.93) v1@3048.28,2136.72 ; v1@3051.11,2126.11 ccw(c3041.72,2116.72) 3041.72,2130 ccw(c3041.72,2143.28) v1@3051.11,2133.89 ; v3(5035.67,3914.41) U8.AA6@5055.35,3934.09 ; U8.AA6@5048.01,3934.09 cw(c5030.29,3934.09) 5042.82,3921.56 cw(c5055.35,3909.03) U8.AA6@5055.35,3926.75 ; 5048.47,3927.21 cw(c5035.67,3940.02) 5035.67,3921.91 ccw(c5035.67,3940.02) 5048.47,3927.21 ; 5048.47,3927.21 ccw(c5061.28,3914.41) 5043.17,3914.41 cw(c5061.28,3914.41) 5048.47,3927.21
  MidLayer1 w4: v1(3055,2130) 3063.6,2138.6 3206.73,2138.6 3806.86,2738.73 3806.86,2875.04 4234.16,3302.35 4256.52,3324.71 4256.52,3962.46 4303.13,4009.06 4303.13,4040.76 4334.58,4072.21 4405,4072.21 4424.83,4072.21 4426.12,4073.5 4431.44,4078.81 4466.86,4078.81 4533.57,4078.81 4559.36,4053.02 4559.36,3998.15 4584.01,3973.5 4589,3973.5 4615,3973.5 4660.81,3973.5 4663.81,3970.5 4680,3970.5 4692.36,3970.5 4739.77,3923.09 4750.05,3912.81 4753.36,3909.5 4759.44,3909.5 ; 4958.86,3890.55 4972.79,3890.55 ; v3@5028.2,3915.06 cw(c5010.16,3916.64) 5021.8,3902.77 ; v3@5035.02,3906.94 ccw(c5033.44,3888.9) 5021.8,3902.77 ; 4759.44,3909.5 4760.69,3909.5 4761.69,3909.5 ; 4759.44,3909.5 4761.69,3909.5 ; 4761.69,3909.5 4775.93,3895.25 4780.64,3890.55 4830.82,3890.55 4838.82,3890.55 4879.25,3890.55 4898.67,3890.55 4972.79,3890.55 ; 4972.79,3890.55 4992.29,3890.55 ccw(c4992.29,3932.28) 5021.8,3902.77