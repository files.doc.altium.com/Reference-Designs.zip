# Altium PCB NB3000AL.PcbDoc (part 14 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.MIDI#.MIDI_RX_N: D9.1 J20.5 J33.B22 U36.2 | length 8790.9
  MidLayer1 w4: J20.5@2854.61,6275.72 cw(c2854.61,6161.74) 2935.2,6242.34 cw(c3015.8,6322.94) J20.5@2901.82,6322.94 ; J20.5@2854.61,6279.72 cw(c2854.61,6175.4) 2928.37,6249.17 cw(c3002.14,6322.94) J20.5@2897.82,6322.94 ; J20.5@2854.61,6283.72 cw(c2854.61,6189.06) 2921.55,6256 cw(c2988.49,6322.94) J20.5@2893.82,6322.94 ; J20.5@2854.61,6287.72 cw(c2854.61,6202.71) 2914.72,6262.83 cw(c2974.83,6322.94) J20.5@2889.82,6322.94 ; J20.5@2854.61,6291.72 cw(c2854.61,6216.37) 2907.89,6269.65 cw(c2961.17,6322.94) J20.5@2885.82,6322.94 ; J20.5@2854.61,6295.72 cw(c2854.61,6230.03) 2901.06,6276.48 cw(c2947.52,6322.94) J20.5@2881.82,6322.94 ; J20.5@2854.61,6299.72 cw(c2854.61,6243.69) 2894.23,6283.31 cw(c2933.86,6322.94) J20.5@2877.82,6322.94 ; J20.5@2854.61,6322.94 2995.19,6182.35 v1(2995.19,6135.37) ; v1@2988.47,6142.09 ccw(c2972.26,6158.31) 2995.19,6158.31 ccw(c3018.13,6158.31) v1@3001.91,6142.09 ; v1@2991.3,6139.26 ccw(c2981.91,6148.65) 2995.19,6148.65 ccw(c3008.47,6148.65) v1@2999.08,6139.26
  MidLayer2 w4: -701.48,4205 -701.48,4136.48 -627.42,4062.42 -627.42,4017.84 -665.98,3979.29 -665.98,3964.79 -655.72,3954.54 -556.54,3954.54 -497,3895 -497,3771.14 -591.44,3676.71 -636.41,3631.73 -660,3608.14 -660,3584.81 -677.62,3567.19 -692.66,3567.19 -697.5,3562.35 -697.5,3380 -687,3369.5 v1(-687,3341) ; -701.35,4205 -673.81,4232.54 -603.46,4232.54 -600.19,4235.81 -587.73,4235.81 -559.81,4263.73 -559.81,4454.04 -612.81,4507.04 -612.81,4785 -559.81,4838 -559.81,5870 ; v1@-693.72,3347.72 ccw(c-709.94,3363.93) -687,3363.93 ccw(c-664.07,3363.93) v1@-680.28,3347.72 ; v1@-690.89,3344.89 ccw(c-700.28,3354.28) -687,3354.28 ccw(c-673.72,3354.28) v1@-683.11,3344.89 ; -560,5870 -560,5930 -546.66,5943.34 81.91,5943.34 82.75,5942.5 271.44,5942.5 411.98,6083.04 2942.86,6083.04 2959.86,6100.04 v1(2995.19,6135.37) ; v1@2985.69,6135.37 cw(c2962.76,6135.37) 2978.97,6119.16 cw(c2995.19,6102.94) v1@2995.19,6125.87 ; v1@2989.69,6135.37 cw(c2976.41,6135.37) 2985.8,6125.99 cw(c2995.19,6116.6) v1@2995.19,6129.87
  Bottom Layer w4: J33.B22@-785.98,3361.52 -690,3361.52 ; J33.B22@-711.39,3356.22 cw(c-699.2,3344.85) -699.2,3361.52 cw(c-699.2,3378.19) J33.B22@-711.39,3366.83 ; J33.B22@-708.47,3353.49 cw(c-690,3336.28) -690,3361.52 ; J33.B22@-708.47,3369.55 ccw(c-690,3386.76) -690,3361.52 ; v1@-692.18,3348.96 ccw(c-698.41,3358.52) -687,3358.52 ; v1(-687,3341) -687,3358.52 ; v1@-681.82,3348.96 cw(c-675.59,3358.52) -687,3358.52 ; D9.1@2986.02,6098.16 ccw(c2965.9,6119.18) 2995,6119.18 ; D9.1@2988.78,6095.26 ccw(c2974.86,6109.82) 2995,6109.82 ccw(c3015.15,6109.82) D9.1@3001.22,6095.26 ; v1@2990.64,6127.03 cw(c2986.47,6119.38) 2995.19,6119.38 ; v1(2995.19,6135.37) 2995.19,6119.37 ; v1@2999.74,6127.03 ccw(c3003.91,6119.38) 2995.19,6119.38 ; D9.1@3001.36,6074.9 cw(c3016.73,6059.53) 3016.73,6081.26 cw(c3016.73,6102.99) D9.1@3001.36,6087.62 ; D9.1@3003.99,6098.15 cw(c3024.1,6119.18) 2995,6119.18 ; D9.1@3004.19,6072.07 cw(c3026.38,6049.88) 3026.38,6081.26 cw(c3026.39,6112.65) D9.1@3004.19,6090.45 ; U36.2@3088.47,6079.35 ccw(c3062.27,6065.24) 3062.27,6095 ; U36.2@3088.46,6110.65 cw(c3062.27,6124.76) 3062.27,6095 ; U36.2@3091.99,6081.25 ccw(c3068.96,6068.85) 3068.96,6095 ccw(c3068.96,6121.15) U36.2@3091.99,6108.75 ; U36.2@3095.51,6083.15 ccw(c3075.66,6072.46) 3075.66,6095 ccw(c3075.66,6117.54) U36.2@3095.51,6106.85 ; U36.2@3099.03,6085.04 ccw(c3082.36,6076.06) 3082.36,6095 ccw(c3082.36,6113.94) U36.2@3099.03,6104.96 ; U36.2@3122.52,6095 3062.26,6095 ; -690,3361.52 -687,3358.52 ; 2995,6119.18 D9.1@2995,6081.26 3048.52,6081.26 3062.26,6095
ATE.MIDI#.MIDI_RX_P: J20.4 J33.B21 R194.2 | length 8176.5
  MidLayer1 w4: v1@-633.19,3381.76 ccw(c-649.41,3397.98) -626.48,3397.98 ccw(c-603.54,3397.98) v1@-619.76,3381.76 ; v1@-630.36,3378.93 ccw(c-639.75,3388.32) -626.48,3388.32 ccw(c-613.2,3388.32) v1@-622.59,3378.93 ; v1(-626.48,3375.04) -626.48,3401.67 -618.14,3410 -618.14,3425.04 -634.81,3441.71 -634.81,3511.5 -534.81,3611.5 -534.81,3710 -492.81,3752 -492.81,4119.88 -468,4144.69 -468,4203 -492.81,4227.81 -492.81,4562.43 -564.14,4633.76 -564.14,5274.8 -555.52,5283.43 -555.52,5889.67 -367.38,6077.81 -342.19,6077.81 -211.05,6208.95 64.61,6208.95 v1(81.86,6191.71) ; v1@72.36,6191.71 ccw(c49.42,6191.71) 65.64,6207.93 ccw(c81.86,6224.14) v1@81.86,6201.21 ; v1@76.36,6191.71 ccw(c63.08,6191.71) 72.47,6201.1 ccw(c81.86,6210.49) v1@81.86,6197.21 ; v1(3043.52,6220.04) 3146.42,6322.94 ; v1@3043.52,6225.54 ccw(c3043.52,6238.82) 3052.91,6229.43 ccw(c3062.3,6220.04) v1@3049.02,6220.04 ; v1@3043.52,6229.54 ccw(c3043.52,6252.48) 3059.74,6236.26 ccw(c3075.96,6220.04) v1@3053.02,6220.04 ; J20.4@3212.29,6292.42 ccw(c3146.42,6236.61) 3146.42,6322.94 ; J20.4@3212.29,6353.46 cw(c3146.42,6409.26) 3146.42,6322.94 ; J20.4@3215.34,6295 ccw(c3155.06,6243.93) 3155.06,6322.94 ccw(c3155.06,6401.95) J20.4@3215.34,6350.87 ; J20.4@3218.39,6297.59 ccw(c3163.69,6251.24) 3163.69,6322.94 ccw(c3163.69,6394.63) J20.4@3218.39,6348.29 ; J20.4@3221.44,6300.17 ccw(c3172.32,6258.55) 3172.32,6322.94 ccw(c3172.32,6387.32) J20.4@3221.44,6345.7 ; J20.4@3224.49,6302.76 ccw(c3180.95,6265.87) 3180.95,6322.94 ccw(c3180.95,6380.01) J20.4@3224.49,6343.11 ; J20.4@3227.55,6305.35 ccw(c3189.58,6273.18) 3189.58,6322.94 ccw(c3189.58,6372.69) J20.4@3227.54,6340.53 ; J20.4@3230.6,6307.93 ccw(c3198.22,6280.5) 3198.22,6322.94 ccw(c3198.21,6365.38) J20.4@3230.6,6337.94 ; J20.4@3248.31,6322.94 3146.42,6322.94
  Bottom Layer w4: J33.B21@-785.98,3400.89 -680,3400.89 -654.15,3375.04 v1(-626.48,3375.04) ; J33.B21@-711.58,3395.39 cw(c-698.3,3382.11) -698.3,3400.89 cw(c-698.3,3419.67) J33.B21@-711.58,3406.39 ; J33.B21@-708.76,3392.56 cw(c-688.65,3372.45) -688.65,3400.89 cw(c-688.65,3429.33) J33.B21@-708.76,3409.22 ; v1@-633.19,3368.32 ccw(c-649.41,3352.11) -649.41,3375.04 ccw(c-649.41,3397.98) v1@-633.19,3381.76 ; v1@-630.36,3371.15 ccw(c-639.75,3361.76) -639.75,3375.04 ccw(c-639.75,3388.32) v1@-630.36,3378.93 ; v1@75.14,6198.43 ccw(c58.92,6214.64) 81.86,6214.64 ccw(c104.79,6214.64) v1@88.57,6198.43 ; v1@77.97,6195.6 ccw(c68.58,6204.99) 81.86,6204.99 ccw(c95.14,6204.99) v1@85.75,6195.6 ; v1@82.73,6192.58 v1(81.86,6191.71) 81.86,6222.06 154.8,6295 2053.69,6295 2105.69,6347 2559.31,6347 2647.61,6258.71 3004.86,6258.71 v1(3043.52,6220.04) 3028.48,6205 R194.2@3016.18,6205 ; R194.2@3015.33,6202.95 ccw(c3019.84,6216.35) 3029.84,6206.35 ; v1@3034.02,6220.04 ccw(c3011.09,6220.04) 3027.31,6236.26 ccw(c3043.52,6252.48) v1@3043.52,6229.54 ; v1@3038.02,6220.04 ccw(c3024.75,6220.04) 3034.14,6229.43 ccw(c3043.52,6238.82) v1@3043.52,6225.54
ATE.MIDI#.MIDI_THRU_GND: J21.2 NT47.2 | length 176.1
  Bottom Layer w4: J21.2@3867.43,6375.4 cw(c3864.23,6361.77) NT47.2@3878.23,6361.77 ; J21.2@3868.35,6379.29 cw(c3865.42,6366.82) 3878.23,6366.82 cw(c3891.04,6366.82) J21.2@3888.11,6379.29 ; J21.2@3869.26,6383.19 cw(c3866.6,6371.87) 3878.23,6371.87 cw(c3889.85,6371.87) J21.2@3887.2,6383.19 ; J21.2@3878.23,6378.43 ccw(c3893.93,6378.43) NT47.2@3882.83,6367.33 ; NT47.2@3880,6365 NT47.2@3878.23,6361.77 ; J21.2@3889.02,6375.4 ccw(c3892.23,6361.77) NT47.2@3878.23,6361.77
  Bottom Layer w12: J21.2@3878.23,6421.36 3880,6419.59 NT47.2@3880,6365
ATE.MIDI#.MIDI_THRU_PWR: J21.4 J33.B15 R197.2 | length 10373.1
  MidLayer1 w4: v1(-682.14,3626.71) -570,3626.71 -559.81,3636.9 -559.81,3980.44 -542.5,3997.75 -542.5,4012.25 -563,4032.75 -563,4161.81 -557.19,4167.62 -557.19,4227.19 -580.04,4250.04 v1(-626.48,4250.04) ; v1@-678.25,3622.82 cw(c-668.86,3613.43) -668.86,3626.71 cw(c-668.86,3639.99) v1@-678.25,3630.6 ; v1@-675.43,3619.99 cw(c-659.21,3603.77) -659.21,3626.71 cw(c-659.21,3649.64) v1@-675.43,3633.43 ; v1@-622.59,4246.15 cw(c-613.2,4236.76) -613.2,4250.04 cw(c-613.2,4263.32) v1@-622.59,4253.93 ; v1@-619.76,4243.32 cw(c-603.54,4227.11) -603.54,4250.04 cw(c-603.54,4272.98) v1@-619.76,4256.76
  MidLayer2 w4: v1(-626.48,4250.04) -584.81,4250.04 -568.14,4266.71 -568.14,4451.06 -620.81,4503.73 -620.81,4788.31 -568.14,4840.98 -568.14,5991.86 -542.81,6017.19 -287.62,6017.19 -257.19,6047.62 -257.19,6067.38 -272.19,6082.38 -272.19,6106.5 -177.73,6200.95 -73.19,6200.95 -42.38,6170.14 -27.62,6170.14 -17.19,6180.57 -17.19,6268.87 130,6416.06 130,6537 355,6762 2780.37,6762 2918.37,6624 4036,6624 4075.08,6584.92 J21.4@4075.08,6322.94 ; v1@-622.59,4246.15 cw(c-613.2,4236.76) -613.2,4250.04 cw(c-613.2,4263.32) v1@-622.59,4253.93 ; v1@-619.76,4243.32 cw(c-603.54,4227.11) -603.54,4250.04 cw(c-603.54,4272.98) v1@-619.76,4256.76 ; J21.4@4041.69,6356.32 ccw(c3961.1,6436.92) 4075.08,6436.92 ccw(c4189.06,6436.92) J21.4@4108.46,6356.32 ; J21.4@4044.52,6353.49 ccw(c3970.75,6427.26) 4075.08,6427.26 ccw(c4179.4,6427.26) J21.4@4105.63,6353.49 ; J21.4@4047.35,6350.66 ccw(c3980.41,6417.6) 4075.08,6417.6 ccw(c4169.75,6417.6) J21.4@4102.81,6350.66 ; J21.4@4050.18,6347.84 ccw(c3990.07,6407.95) 4075.08,6407.95 ccw(c4160.09,6407.95) J21.4@4099.98,6347.84 ; J21.4@4053.01,6345.01 ccw(c3999.72,6398.29) 4075.08,6398.29 ccw(c4150.43,6398.29) J21.4@4097.15,6345.01 ; J21.4@4055.84,6342.18 ccw(c4009.38,6388.63) 4075.08,6388.63 ccw(c4140.78,6388.63) J21.4@4094.32,6342.18 ; J21.4@4058.67,6339.35 ccw(c4019.04,6378.98) 4075.08,6378.98 ccw(c4131.12,6378.98) J21.4@4091.49,6339.35
  Bottom Layer w4: J33.B15@-785.98,3637.11 -692.55,3637.11 ; J33.B15@-711.01,3632.25 cw(c-700.88,3624.13) -700.88,3637.11 cw(c-700.88,3650.1) J33.B15@-711.01,3641.98 ; J33.B15@-707.89,3629.75 cw(c-692.55,3617.45) -692.55,3637.11 ; J33.B15@-707.89,3644.48 ccw(c-692.55,3656.77) -692.55,3637.11 ; v1(-682.14,3626.71) -692.55,3637.11 ; R197.2@3901.18,6155 3938.41,6192.23 3944.37,6192.23 J21.4@4075.08,6322.94 ; R197.2@3901.18,6160.81 ccw(c3901.18,6174.84) R197.2@3911.1,6164.92 ; R197.2@3901.18,6164.81 ccw(c3901.18,6188.5) 3917.93,6171.75 ; R197.2@3906.5,6155.49 cw(c3918.15,6155.49) R197.2@3909.91,6163.73 ; R197.2@3910.5,6155.49 cw(c3931.81,6155.49) 3916.74,6170.56 ; J21.4@4028.2,6317.31 cw(c3952.43,6308.22) 4006.39,6254.25 cw(c4060.36,6200.29) J21.4@4069.45,6276.06 ; J21.4@4032.17,6317.79 cw(c3962.82,6309.46) 4012.21,6260.07 cw(c4061.61,6210.68) J21.4@4069.93,6280.03 ; J21.4@4036.15,6318.26 cw(c3973.21,6310.71) 4018.03,6265.89 cw(c4062.85,6221.07) J21.4@4070.41,6284 ; J21.4@4040.12,6318.74 cw(c3983.6,6311.96) 4023.85,6271.71 cw(c4064.1,6231.46) J21.4@4070.88,6287.98 ; J21.4@4044.09,6319.22 cw(c3993.99,6313.21) 4029.67,6277.53 cw(c4065.35,6241.85) J21.4@4071.36,6291.95 ; J21.4@4048.06,6319.69 cw(c4004.39,6314.45) 4035.49,6283.35 cw(c4066.59,6252.24) J21.4@4071.84,6295.92
ATE.MIDI#.MIDI_THRU_TX: J21.5 J33.A1 R198.2 | length 10748.2
  Top Layer w4: J33.A1@-765.79,4267.54 -562.54,4267.54 -560,4270.08 -560,4535 -601.87,4576.87 ; J33.A1@-711.58,4261.53 cw(c-697.08,4247.03) -697.08,4267.54 ; J33.A1@-711.58,4272.54 ccw(c-699.53,4284.59) -699.53,4267.54 ; J33.A1@-708.76,4258.7 cw(c-687.42,4237.37) -687.42,4267.54 ; v2@-661.94,4678.06 cw(c-678.69,4661.31) -655,4661.31 cw(c-631.31,4661.31) v2@-648.06,4678.06 ; v2@-659.11,4680.89 cw(c-669.03,4670.97) -655,4670.97 cw(c-640.97,4670.97) v2@-650.89,4680.89 ; v2(-655,4685) -655,4629.88 -602,4576.87 ; J21.5@3681.38,6322.94 J21.5@3681.86,6322.94
  MidLayer1 w4: v2(-505,5915) -405,6015 v1(-265,6015) ; v2@-505,5920.81 ccw(c-505,5934.84) -495.08,5924.92 ccw(c-485.16,5915) v2@-499.19,5915 ; v2@-505,5924.81 ccw(c-505,5948.5) -488.25,5931.75 ccw(c-471.5,5915) v2@-495.19,5915 ; v1@-271.72,6008.28 ccw(c-287.94,5992.06) -287.94,6015 ccw(c-287.94,6037.93) v1@-271.72,6021.72 ; v1@-268.89,6011.11 ccw(c-278.28,6001.72) -278.28,6015 ccw(c-278.28,6028.28) v1@-268.89,6018.89
  MidLayer2 w4: v2@-661.94,4691.94 ccw(c-678.69,4708.69) -655,4708.69 ccw(c-631.31,4708.69) v2@-648.06,4691.94 ; v2@-659.11,4689.11 ccw(c-669.03,4699.03) -655,4699.03 ccw(c-640.97,4699.03) v2@-650.89,4689.11 ; v2(-655,4685) -655,4776.75 -584.48,4847.28 -584.48,5544.48 -605,5565 v2(-605,5640) ; v2@-611.94,5633.06 cw(c-628.69,5616.31) -605,5616.31 cw(c-581.31,5616.31) v2@-598.06,5633.06 ; v2@-609.11,5635.89 cw(c-619.03,5625.97) -605,5625.97 cw(c-590.97,5625.97) v2@-600.89,5635.89
  Bottom Layer w4: v2@-611.94,5646.94 ccw(c-628.69,5663.69) -605,5663.69 ccw(c-581.31,5663.69) v2@-598.06,5646.94 ; v2@-609.11,5644.11 ccw(c-619.03,5654.03) -605,5654.03 ccw(c-590.97,5654.03) v2@-600.89,5644.11 ; v2(-605,5640) -605,5740 -505,5840 v2(-505,5915) ; v2@-511.94,5908.06 cw(c-528.69,5891.31) -505,5891.31 cw(c-481.31,5891.31) v2@-498.06,5908.06 ; v2@-509.11,5910.89 cw(c-519.03,5900.97) -505,5900.97 cw(c-490.97,5900.97) v2@-500.89,5910.89 ; v1(-265,6015) -150.2,6015 106.52,6271.73 106.52,6493.08 399.44,6786 2770.06,6786 2847.35,6708.71 3641.29,6708.71 3681.38,6668.62 J21.5@3681.38,6322.94 3848.44,6490 4015,6490 4165,6340 4165,5995 4130,5960 3951.18,5960 R198.2@3901.18,6010 ; v1@-261.11,6011.11 cw(c-251.72,6001.72) -251.72,6015 cw(c-251.72,6028.28) v1@-261.11,6018.89 ; v1@-258.28,6008.28 cw(c-242.07,5992.06) -242.07,6015 cw(c-242.07,6037.93) v1@-258.28,6021.72 ; J21.5@3647.99,6356.32 ccw(c3567.4,6436.92) 3681.38,6436.92 ccw(c3795.36,6436.92) J21.5@3714.76,6356.32 ; J21.5@3650.82,6353.49 ccw(c3577.05,6427.26) 3681.38,6427.26 ccw(c3785.7,6427.26) J21.5@3711.93,6353.49 ; J21.5@3653.65,6350.66 ccw(c3586.71,6417.6) 3681.38,6417.6 ccw(c3776.05,6417.6) J21.5@3709.11,6350.66 ; J21.5@3656.48,6347.84 ccw(c3596.37,6407.95) 3681.38,6407.95 ccw(c3766.39,6407.95) J21.5@3706.28,6347.84 ; J21.5@3659.31,6345.01 ccw(c3606.02,6398.29) 3681.38,6398.29 ccw(c3756.73,6398.29) J21.5@3703.45,6345.01 ; J21.5@3662.14,6342.18 ccw(c3615.68,6388.63) 3681.38,6388.63 ccw(c3747.08,6388.63) J21.5@3700.62,6342.18 ; J21.5@3664.96,6339.35 ccw(c3625.34,6378.98) 3681.38,6378.98 ccw(c3737.42,6378.98) J21.5@3697.79,6339.35 ; J21.5@3681.38,6346.15 ccw(c3681.38,6402.19) 3721,6362.56 ccw(c3760.63,6322.94) J21.5@3704.59,6322.94 ; J21.5@3681.38,6350.15 ccw(c3681.38,6415.85) 3727.83,6369.39 ccw(c3774.29,6322.94) J21.5@3708.59,6322.94 ; J21.5@3681.38,6354.15 ccw(c3681.38,6429.5) 3734.66,6376.22 ccw(c3787.94,6322.94) J21.5@3712.59,6322.94 ; J21.5@3681.38,6358.15 ccw(c3681.38,6443.16) 3741.49,6383.05 ccw(c3801.6,6322.94) J21.5@3716.59,6322.94 ; J21.5@3681.38,6362.15 ccw(c3681.38,6456.82) 3748.32,6389.88 ccw(c3815.26,6322.94) J21.5@3720.59,6322.94 ; J21.5@3681.38,6366.15 ccw(c3681.38,6470.47) 3755.15,6396.71 ccw(c3828.92,6322.94) J21.5@3724.59,6322.94 ; J21.5@3681.38,6370.15 ccw(c3681.38,6484.13) 3761.97,6403.53 ccw(c3842.57,6322.94) J21.5@3728.59,6322.94 ; R198.2@3901.18,6000.19 cw(c3901.18,5976.5) 3917.93,5993.25 ; R198.2@3901.18,6004.19 cw(c3901.18,5990.16) R198.2@3911.1,6000.08 ; R198.2@3906.5,6009.51 ccw(c3918.15,6009.51) R198.2@3909.91,6001.27 ; R198.2@3910.5,6009.51 ccw(c3931.81,6009.51) 3916.74,5994.44
ATE.MIDI#.MIDI_TX_GND: J22.2 NT48.2 | length 220
  Bottom Layer w4: J22.2@4692.9,6375.73 cw(c4688.73,6360) NT48.2@4705,6360 ; J22.2@4693.93,6379.59 cw(c4690.11,6365.2) 4705,6365.2 cw(c4719.89,6365.2) J22.2@4716.07,6379.59 ; J22.2@4694.95,6383.46 cw(c4691.49,6370.4) 4705,6370.4 cw(c4718.51,6370.4) J22.2@4715.05,6383.46 ; 4705,6371.57 ccw(c4722.07,6371.57) NT48.2@4710,6359.5 ; J22.2@4705,6381.23 ccw(c4731.73,6381.23) NT48.2@4712.83,6362.33 ; J22.2@4705,6421.36 NT48.2@4705,6360 ; NT48.2@4710,6355 NT48.2@4705,6360 ; J22.2@4717.1,6375.73 ccw(c4721.27,6360) NT48.2@4705,6360
ATE.MIDI#.MIDI_TX_N: J22.5 J33.B23 R200.2 | length 11316.4
  MidLayer1 w4: v1(-659.81,3308.37) -669.14,3317.71 -669.14,3415.04 -643.14,3441.04 -643.14,3514.48 -543.14,3614.48 -543.14,3974.48 -526.5,3991.12 -526.5,4018.88 -547,4039.38 -547,4155.18 -541.19,4161 -541.19,4599.5 -572.14,4630.45 -572.14,5278.11 -563.52,5286.74 -563.52,5892.99 -480.48,5976.03 v1(-480.48,6058.37) ; v1@-487.19,6051.66 cw(c-503.41,6035.44) -480.48,6035.44 cw(c-457.54,6035.44) v1@-473.76,6051.66 ; v1@-484.36,6054.49 cw(c-493.75,6045.1) -480.48,6045.1 cw(c-467.2,6045.1) v1@-476.59,6054.49
  Bottom Layer w4: J33.B23@-785.98,3322.15 -673.59,3322.15 v1(-659.81,3308.37) ; J33.B23@-711.58,3316.65 cw(c-698.3,3303.37) -698.3,3322.15 cw(c-698.3,3340.94) J33.B23@-711.58,3327.65 ; J33.B23@-708.76,3313.82 cw(c-688.65,3293.72) -688.65,3322.15 cw(c-688.64,3350.59) J33.B23@-708.76,3330.48 ; v1(-480.48,6058.37) -455.14,6083.71 -273.52,6083.71 -239.81,6050 -126.52,6050 -118.14,6058.37 98.52,6275.04 98.52,6496.39 396.13,6794 2773.37,6794 2850.66,6716.71 4433.29,6716.71 4508.15,6641.85 J22.5@4508.15,6322.94 ; v1@-480.48,6063.87 ccw(c-480.48,6077.15) -471.09,6067.76 ccw(c-461.7,6058.37) v1@-474.98,6058.37 ; v1@-480.48,6067.87 ccw(c-480.48,6090.81) -464.26,6074.59 ccw(c-448.04,6058.37) v1@-470.98,6058.37 ; J22.5@4474.77,6356.32 ccw(c4394.17,6436.92) 4508.15,6436.92 ccw(c4622.13,6436.92) J22.5@4541.53,6356.32 ; J22.5@4477.59,6353.49 ccw(c4403.83,6427.26) 4508.15,6427.26 ccw(c4612.47,6427.26) J22.5@4538.71,6353.49 ; J22.5@4480.42,6350.66 ccw(c4413.48,6417.6) 4508.15,6417.6 ccw(c4602.82,6417.6) J22.5@4535.88,6350.66 ; J22.5@4483.25,6347.84 ccw(c4423.14,6407.95) 4508.15,6407.95 ccw(c4593.16,6407.95) J22.5@4533.05,6347.84 ; J22.5@4486.08,6345.01 ccw(c4432.8,6398.29) 4508.15,6398.29 ccw(c4583.5,6398.29) J22.5@4530.22,6345.01 ; J22.5@4488.91,6342.18 ccw(c4442.45,6388.63) 4508.15,6388.63 ccw(c4573.85,6388.63) J22.5@4527.39,6342.18 ; J22.5@4491.74,6339.35 ccw(c4452.11,6378.98) 4508.15,6378.98 ccw(c4564.19,6378.98) J22.5@4524.56,6339.35 ; J22.5@4508.15,6275.72 cw(c4508.15,6161.74) 4588.75,6242.34 ; J22.5@4508.15,6279.72 cw(c4508.15,6175.4) 4581.92,6249.17 cw(c4655.69,6322.94) J22.5@4551.36,6322.94 ; J22.5@4508.15,6283.72 cw(c4508.15,6189.06) 4575.09,6256 cw(c4642.03,6322.94) J22.5@4547.36,6322.94 ; J22.5@4508.15,6287.72 cw(c4508.15,6202.71) 4568.26,6262.83 cw(c4628.37,6322.94) J22.5@4543.36,6322.94 ; J22.5@4508.15,6291.72 cw(c4508.15,6216.37) 4561.43,6269.65 cw(c4614.72,6322.94) J22.5@4539.36,6322.94 ; J22.5@4508.15,6295.72 cw(c4508.15,6230.03) 4554.6,6276.48 cw(c4601.06,6322.94) J22.5@4535.36,6322.94 ; J22.5@4508.15,6299.72 cw(c4508.15,6243.68) 4547.78,6283.31 cw(c4587.4,6322.94) J22.5@4531.36,6322.94 ; R200.2@4536.18,5900 4588.75,5952.57 4588.75,6242.34 ; R200.2@4536.18,5905.81 ccw(c4536.18,5919.84) R200.2@4546.1,5909.92 ; R200.2@4536.18,5909.81 ccw(c4536.18,5933.5) 4552.93,5916.75 ; R200.2@4541.5,5900.49 cw(c4553.15,5900.49) R200.2@4544.91,5908.73 ; R200.2@4545.5,5900.49 cw(c4566.81,5900.49) 4551.74,5915.56 ; J22.5@4555.36,6322.94 ccw(c4669.34,6322.94) 4588.75,6242.34
ATE.MSE#.CLOCK: J32.5 J33.B44 R86.2 R89.2 | length 6872.3
  MidLayer1 w4: v1@3348.52,815.54 cw(c3348.52,792.61) 3364.74,808.82 cw(c3380.96,825.04) v1@3358.02,825.04 ; v1@3348.52,819.54 cw(c3348.52,806.26) 3357.91,815.65 cw(c3367.3,825.04) v1@3354.02,825.04 ; v1(3348.52,825.04) 3482.05,691.52 J32.5@3482.05,421.1 ; J32.5@3461.19,441.96 ccw(c3410.84,492.31) 3482.05,492.31 ccw(c3553.26,492.31) J32.5@3502.9,441.96 ; J32.5@3464.02,439.13 ccw(c3420.49,482.66) 3482.05,482.66 ccw(c3543.6,482.66) J32.5@3500.08,439.13 ; J32.5@3466.85,436.3 ccw(c3430.15,473) 3482.05,473 ccw(c3533.94,473) J32.5@3497.25,436.3 ; J32.5@3469.68,433.47 ccw(c3439.81,463.34) 3482.05,463.34 ccw(c3524.29,463.34) J32.5@3494.42,433.47 ; J32.5@3472.5,430.65 ccw(c3449.47,453.68) 3482.05,453.68 ccw(c3514.63,453.68) J32.5@3491.59,430.65
  MidLayer2 w4: v1@-658.19,2459.99 ccw(c-674.41,2443.77) -674.41,2466.71 ccw(c-674.41,2489.64) v1@-658.19,2473.43 ; v1@-655.36,2462.82 ccw(c-664.75,2453.43) -664.75,2466.71 ccw(c-664.75,2479.99) v1@-655.36,2470.6 ; v1(-651.48,2466.71) -689.3,2466.71 -707,2449.01 -707,2357 -695,2345 -646,2345 -618.5,2317.5 -573.25,2317.5 -545.63,2289.88 -355,2289.88 -315,2249.88 -315,1790 -190,1665 -190,1593.94 39.94,1364 2095.88,1364 2559.04,900.84 2572.88,887 2985.69,887 3013.69,915 3258.56,915 v1(3348.52,825.04) ; v1@3339.02,825.04 ccw(c3316.09,825.04) 3332.31,841.26 ccw(c3348.52,857.48) v1@3348.52,834.54 ; v1@3343.02,825.04 ccw(c3329.75,825.04) 3339.14,834.43 ccw(c3348.52,843.82) v1@3348.52,830.54
  Bottom Layer w4: J33.B44@-785.98,2495.38 -695.42,2495.37 ; J33.B44@-710.56,2491.15 cw(c-702.78,2486.11) -702.78,2495.37 cw(c-702.77,2504.64) J33.B44@-710.55,2499.61 ; J33.B44@-707.2,2488.97 cw(c-695.42,2481.33) -695.42,2495.37 ; J33.B44@-707.19,2501.78 ccw(c-695.42,2509.4) -695.42,2495.37 ; -693.14,2495.37 -695.2,2495.37 ; v1@-657.41,2474.13 ccw(c-667.29,2486.47) -651.48,2486.47 ; v1(-651.48,2466.71) -651.48,2486.48 ; v1@-645.54,2474.13 cw(c-635.66,2486.47) -651.48,2486.47 ; v1(3348.52,825.04) 3390.87,867.38 R86.2@3390.87,950 R89.2@3390.87,1005 ; v1@3348.52,830.54 ccw(c3348.52,843.82) 3357.91,834.43 ccw(c3367.3,825.04) v1@3354.02,825.04 ; v1@3348.52,834.54 ccw(c3348.52,857.48) 3364.74,841.26 ccw(c3380.96,825.04) v1@3358.02,825.04 ; R86.2@3384.28,942.92 cw(c3368.37,927.01) 3390.87,927.01 cw(c3413.36,927.01) R86.2@3397.46,942.92 ; R86.2@3384.28,957.08 ccw(c3368.37,972.99) 3390.87,972.99 ccw(c3413.36,972.99) R86.2@3397.46,957.08 ; R89.2@3384.28,997.92 cw(c3368.37,982.01) 3390.87,982.01 cw(c3413.36,982.01) R89.2@3397.46,997.92 ; R86.2@3387.11,945.75 cw(c3378.02,936.67) 3390.87,936.67 cw(c3403.71,936.67) R86.2@3394.63,945.75 ; R86.2@3387.11,954.25 ccw(c3378.02,963.33) 3390.87,963.33 ccw(c3403.71,963.33) R86.2@3394.63,954.25 ; R89.2@3387.11,1000.75 cw(c3378.02,991.67) 3390.87,991.67 cw(c3403.71,991.67) R89.2@3394.63,1000.75 ; -695.42,2495.37 -695.2,2495.37 ; -695.2,2495.37 -660.37,2495.37 -651.48,2486.48
ATE.MSE#.DATA: J32.1 J33.B43 R87.2 R88.2 | length 7454.9
  MidLayer1 w4: v1@-633.19,2509.99 cw(c-649.41,2493.77) -626.48,2493.77 cw(c-603.54,2493.77) v1@-619.76,2509.99 ; v1@-630.36,2512.82 cw(c-639.75,2503.43) -626.48,2503.43 cw(c-613.2,2503.43) v1@-622.59,2512.82 ; v1(-626.48,2516.71) -626.48,2428.27 -512.42,2314.21 -328.96,2314.21 -189.87,2175.13 ; -190,2175 -165.27,2150.27 v1(-165.27,2070) ; v1@-171.99,2076.72 ccw(c-188.2,2092.93) -165.27,2092.93 ccw(c-142.33,2092.93) v1@-158.55,2076.72 ; v1@-169.16,2073.89 ccw(c-178.55,2083.28) -165.27,2083.28 ccw(c-151.99,2083.28) v1@-161.38,2073.89 ; v1(2823.52,916.71) 3071.67,916.71 3080,925.04 v1(3523.52,925.04) 3523.52,858.37 3560.79,821.11 J32.1@3560.79,322.68 ; v1@2827.41,912.82 cw(c2836.8,903.43) 2836.8,916.71 cw(c2836.8,929.99) v1@2827.41,920.6 ; v1@2830.24,909.99 cw(c2846.46,893.77) 2846.46,916.71 cw(c2846.46,939.64) v1@2830.24,923.43 ; v1@3516.81,931.76 cw(c3500.59,947.98) 3500.59,925.04 cw(c3500.59,902.11) 3516.81,918.32 cw(c3500.59,902.11) 3523.52,902.11 cw(c3546.46,902.11) v1@3530.24,918.32 ; v1@3519.64,928.93 cw(c3510.25,938.32) 3510.25,925.04 cw(c3510.25,911.76) 3519.64,921.15 cw(c3510.25,911.76) 3523.52,911.76 cw(c3536.8,911.76) v1@3527.41,921.15 ; J32.1@3539.93,343.53 ccw(c3489.58,393.89) 3560.79,393.89 ccw(c3632,393.89) J32.1@3581.64,343.53 ; J32.1@3542.76,340.71 ccw(c3499.23,384.23) 3560.79,384.23 ccw(c3622.34,384.23) J32.1@3578.82,340.71 ; J32.1@3545.59,337.88 ccw(c3508.89,374.57) 3560.79,374.57 ccw(c3612.68,374.57) J32.1@3575.99,337.88 ; J32.1@3548.42,335.05 ccw(c3518.55,364.92) 3560.79,364.92 ccw(c3603.03,364.92) J32.1@3573.16,335.05 ; J32.1@3551.24,332.22 ccw(c3528.21,355.26) 3560.79,355.26 ccw(c3593.37,355.26) J32.1@3570.33,332.22
  MidLayer2 w4: v1(-165.27,2070) -70,2070 -50,2050 -50,1890 21.5,1818.5 21.5,1710.66 -47,1642.16 -47,1473.57 46.57,1380 2102.51,1380 2565.8,916.71 v1(2823.52,916.71) ; v1@-161.38,2066.11 cw(c-151.99,2056.72) -151.99,2070 cw(c-151.99,2083.28) v1@-161.38,2073.89 ; v1@-158.55,2063.28 cw(c-142.33,2047.06) -142.33,2070 cw(c-142.33,2092.93) v1@-158.55,2076.72 ; v1@2816.81,909.99 ccw(c2800.59,893.77) 2800.59,916.71 ccw(c2800.59,939.64) v1@2816.81,923.43 ; v1@2819.64,912.82 ccw(c2810.25,903.43) 2810.25,916.71 ccw(c2810.25,929.99) v1@2819.64,920.6
  Bottom Layer w4: J33.B43@-785.98,2534.75 -644.52,2534.75 v1(-626.48,2516.71) ; J33.B43@-711.58,2529.25 cw(c-698.3,2515.97) -698.3,2534.75 cw(c-698.3,2553.53) J33.B43@-711.58,2540.25 ; J33.B43@-708.76,2526.42 cw(c-688.65,2506.31) -688.65,2534.75 cw(c-688.65,2563.19) J33.B43@-708.76,2543.08 ; v1@-635.98,2516.71 ccw(c-658.91,2516.71) -642.69,2532.93 ccw(c-626.48,2549.14) v1@-626.48,2526.21 ; v1@-631.98,2516.71 ccw(c-645.25,2516.71) -635.86,2526.1 ccw(c-626.48,2535.49) v1@-626.48,2522.21 ; v1(3523.52,925.04) 3644.96,925.04 3646.77,926.85 R87.2@3646.77,950 R88.2@3646.77,1005 ; v1@3527.41,921.15 cw(c3536.8,911.76) 3536.8,925.04 cw(c3536.8,938.32) v1@3527.41,928.93 ; v1@3530.24,918.32 cw(c3546.46,902.11) 3546.46,925.04 cw(c3546.46,947.98) v1@3530.24,931.76 ; R87.2@3640.18,942.92 cw(c3624.27,927.01) 3646.77,927.01 cw(c3669.27,927.01) R87.2@3653.36,942.92 ; R87.2@3640.18,957.08 ccw(c3624.27,972.99) 3646.77,972.99 ccw(c3669.27,972.99) R87.2@3653.36,957.08 ; R88.2@3640.18,997.92 cw(c3624.27,982.01) 3646.77,982.01 cw(c3669.27,982.01) R88.2@3653.36,997.92 ; R87.2@3643.01,945.75 cw(c3633.93,936.67) 3646.77,936.67 cw(c3659.61,936.67) R87.2@3650.53,945.75 ; R87.2@3643.01,954.25 ccw(c3633.93,963.33) 3646.77,963.33 ccw(c3659.61,963.33) R87.2@3650.53,954.25 ; R88.2@3643.01,1000.75 cw(c3633.93,991.67) 3646.77,991.67 cw(c3659.61,991.67) R88.2@3650.53,1000.75
ATE.PWM.OUT0: J16.2 J33.A3 Q5.2 | length 7243.6
  Top Layer w4: J33.A3@-785.98,4188.29 -702.89,4188.29 ; J33.A3@-705.51,4186.12 cw(c-702.89,4185.63) -702.89,4188.29 ; J33.A3@-705.51,4190.46 ccw(c-702.89,4190.95) -702.89,4188.29 ; v1(-683.81,4191.71) -699.48,4191.71 -702.89,4188.29
  Top Layer w30: Q5.2@3389.21,5430 3389.21,5736.45 J16.2@3532.77,5880.01 ; J16.2@3506.43,5880.01 cw(c3442.84,5880.01) 3487.81,5835.04 cw(c3532.77,5790.08) J16.2@3532.77,5853.67
  MidLayer2 w4: v1(-683.81,4191.71) -650.98,4224.54 -600.15,4224.54 -596.87,4227.81 -584.41,4227.81 -550.98,4261.24 -550.98,4608.62 -543.14,4616.46 -543.14,4690 -481.14,4752 416.74,4752 437.5,4772.76 437.5,4935 437.5,4937.25 428,4946.75 428,5305.69 405,5328.69 405,5400 360,5445 360,5495 464,5599 2039.23,5599 2063.3,5574.94 2139.52,5498.71 2198.52,5498.71 2203.36,5503.54 2523,5503.54 2551.5,5475.04 3025.9,5475.04 3026.06,5475.2 3037.66,5475.2 3037.82,5475.04 3110,5475.04 3124.78,5460.26 3160.26,5460.26 v1(3160,5460) ; v1@-683.81,4197.21 ccw(c-683.81,4210.49) -674.42,4201.1 ccw(c-665.03,4191.71) v1@-678.31,4191.71 ; v1@-683.81,4201.21 ccw(c-683.81,4224.14) -667.59,4207.93 ccw(c-651.37,4191.71) v1@-674.31,4191.71 ; 3136.44,5460.26 cw(c3136.44,5436.44) v1@3153.28,5453.28 ; 3137.69,5460.26 ccw(c3137.69,5482.31) v1@3153.28,5466.72 ; 3146.09,5460.26 cw(c3146.09,5446.09) v1@3156.11,5456.11 ; 3147.35,5460.26 ccw(c3147.35,5472.65) v1@3156.11,5463.89
  Bottom Layer w4: v1(3160,5460) 3206.86,5506.86 3206.86,5899.2 3235,5927.34 3485.43,5927.34 ; v1@3160,5465.5 ccw(c3160,5478.78) 3169.39,5469.39 ccw(c3178.78,5460) v1@3165.5,5460 ; v1@3160,5469.5 ccw(c3160,5492.43) 3176.22,5476.22 ccw(c3192.43,5460) v1@3169.5,5460 ; J16.2@3494.93,5890.77 ccw(c3459.06,5900.97) 3485.43,5927.34 ; J16.2@3498.78,5889.68 ccw(c3466.56,5898.84) 3490.25,5922.53 ccw(c3513.93,5946.22) J16.2@3523.1,5914 ; J16.2@3502.63,5888.58 ccw(c3474.05,5896.71) 3495.06,5917.72 ccw(c3516.07,5938.72) J16.2@3524.19,5910.15 ; J16.2@3506.47,5887.49 ccw(c3481.55,5894.58) 3499.87,5912.9 ccw(c3518.2,5931.23) J16.2@3525.29,5906.3 ; J16.2@3522,5917.84 cw(c3511.8,5953.71) 3485.43,5927.34 ; J16.2@3532.77,5880.01 3485.43,5927.34
ATE.PWM.OUT1: J16.3 J33.B10 Q1.2 | length 8868.6
  Top Layer w30: Q1.2@3389.21,5285 3435,5330.79 3435,5650 3555,5770 3619.61,5770 J16.3@3729.62,5880.01 ; J16.3@3703.28,5880.01 cw(c3639.69,5880.01) 3684.66,5835.04 cw(c3729.62,5790.08) J16.3@3729.62,5853.67
  MidLayer1 w4: -698.37,3921.94 ccw(c-678,3942.31) v1@-678,3913.5 ; -692.5,3916.06 cw(c-704.56,3904) v1@-687.5,3904 ; -691.55,3915.11 ccw(c-678,3928.66) v1@-678,3909.5 ; v1(-678,3904) -678.69,3903.3 -679.74,3903.3 -718.14,3941.71 -718.14,4258.37 -700.48,4276.04 -588.12,4276.04 -565.19,4298.98 -565.19,4544.75 -628.81,4608.37 -628.81,4781.63 -596.14,4814.3 -596.14,5305 -615,5323.86 v1@-615,5352.35 ; v1@-621.72,5345.78 cw(c-637.94,5329.56) -615,5329.56 cw(c-592.07,5329.56) v1@-608.28,5345.78 ; v1@-618.89,5348.61 cw(c-628.28,5339.22) -615,5339.22 cw(c-601.72,5339.22) v1@-611.11,5348.61 ; v1(-615,5352.5) v1@-615,5352.35 ; v1@-614.21,5351.56 v1@-615,5352.35
  Bottom Layer w4: J33.B10@-775.67,3908.37 -769.73,3902.43 -679.57,3902.43 v1(-678,3904) ; J33.B10@-714.06,3914.98 ccw(c-700.84,3924.92) -700.84,3908.37 ; J33.B10@-710.87,3917.38 ccw(c-692.83,3930.95) -692.83,3908.37 ; J33.B10@-708.76,3904.37 cw(c-699.1,3894.72) -699.1,3908.37 ; J33.B10@-704.71,3902.43 ccw(c-704.71,3930.71) v1@-684.72,3910.72 ; -697.16,3902.43 cw(c-697.16,3884.84) v1@-684.72,3897.28 ; -695.06,3902.43 ccw(c-695.06,3921.06) v1@-681.89,3907.89 ; v1(-615,5352.5) -615,5351.78 -614.78,5351.56 -342.16,5351.56 -339.03,5351.56 -335.52,5355.08 -335.52,5804.69 29.8,6170 90,6170 115,6195 115,6243.89 158.11,6287 2057,6287 2109,6339 2556,6339 2605,6290 2644.29,6250.71 2926.83,6250.71 2941.36,6236.19 2941.36,5983.64 2982,5943 3145.68,5943 3146.03,5943.34 3576.71,5943.34 3640.04,5880.01 J16.3@3729.62,5880.01 ; v1@-611.11,5356.39 ccw(c-599.47,5368.03) -599.47,5351.56 ; v1@-608.28,5345.78 cw(c-594.32,5331.82) -594.32,5351.56 ; v1@-608.28,5359.22 ccw(c-589.81,5377.69) -589.81,5351.56 ; J16.3@3700.65,5853.39 ccw(c3640.05,5797.71) 3640.05,5880.01 ccw(c3640.05,5962.31) J16.3@3700.65,5906.62 ; J16.3@3703.6,5856.1 ccw(c3649.16,5806.07) 3649.16,5880.01 ccw(c3649.16,5953.94) J16.3@3703.6,5903.92 ; J16.3@3706.54,5858.8 ccw(c3658.26,5814.44) 3658.26,5880.01 ccw(c3658.26,5945.57) J16.3@3706.54,5901.21 ; J16.3@3709.49,5861.51 ccw(c3667.37,5822.81) 3667.37,5880.01 ccw(c3667.37,5937.2) J16.3@3709.49,5898.5 ; J16.3@3712.43,5864.22 ccw(c3676.48,5831.18) 3676.48,5880.01 ccw(c3676.48,5928.83) J16.3@3712.43,5895.8 ; J16.3@3715.38,5866.92 ccw(c3685.59,5839.55) 3685.59,5880.01 ccw(c3685.59,5920.46) J16.3@3715.38,5893.09
ATE.PWM.OUT2: J16.4 J33.B11 Q2.2 | length 9379.8
  Top Layer w30: Q2.2@3594.21,5425 3594.21,5547.75 J16.4@3926.47,5880.01 ; J16.4@3900.13,5880.01 cw(c3836.54,5880.01) 3881.51,5835.04 cw(c3926.47,5790.08) J16.4@3926.47,5853.67
  MidLayer1 w4: v1@-666.53,3890.09 ccw(c-682.74,3906.31) -659.81,3906.31 ccw(c-636.87,3906.31) v1@-653.09,3890.09 ; v1@-663.7,3887.26 ccw(c-673.09,3896.65) -659.81,3896.65 ccw(c-646.53,3896.65) v1@-655.92,3887.26 ; v1(-659.81,3883.37) -659.81,3924.81 -710.14,3975.14 -710.14,4255.06 -697.16,4268.04 -584.81,4268.04 -557.19,4295.66 -557.19,4548.06 -620.81,4611.69 -620.81,4778.31 -588.14,4810.98 -588.14,5284.74 -579.52,5293.37 -579.52,5734.52 -585.19,5740.19 -634.81,5740.19 v1(-635,5740) ; v1@-631.11,5736.11 cw(c-621.26,5726.26) -621.26,5740.19 ; v1@-631.11,5743.89 ccw(c-622.18,5752.82) -622.18,5740.19 ; v1@-628.28,5733.28 cw(c-611.61,5716.61) -611.61,5740.19 ; v1@-628.28,5746.72 ccw(c-612.52,5762.48) -612.52,5740.19
  Bottom Layer w4: J33.B11@-785.98,3873.33 -669.85,3873.33 v1(-659.81,3883.37) ; J33.B11@-711.58,3867.83 cw(c-698.3,3854.55) -698.3,3873.33 ; J33.B11@-711.58,3878.83 ccw(c-698.3,3892.12) -698.3,3873.33 ; J33.B11@-708.76,3865 cw(c-688.65,3844.9) -688.65,3873.33 cw(c-688.64,3901.77) J33.B11@-708.76,3881.66 ; v1(-635,5740) -616.31,5740 ; v1@-627.32,5734.4 cw(c-616.31,5726.37) -616.31,5740 ; v1@-627.32,5745.6 ccw(c-616.31,5753.63) -616.31,5740 ; 55,6207.48 55.96,6207.48 ; 3061,5951 3095,5951 ; J16.4@3897.86,5853 ccw(c3835.23,5793.87) 3835.23,5880.01 ; J16.4@3897.86,5907.01 cw(c3835.23,5966.14) 3835.23,5880.01 ; J16.4@3900.77,5855.75 ccw(c3844.51,5802.63) 3844.51,5880.01 ccw(c3844.51,5957.38) J16.4@3900.77,5904.27 ; J16.4@3903.68,5858.49 ccw(c3853.78,5811.38) 3853.78,5880.01 ccw(c3853.79,5948.62) J16.4@3903.68,5901.52 ; J16.4@3906.59,5861.24 ccw(c3863.06,5820.14) 3863.06,5880.01 ccw(c3863.06,5939.87) J16.4@3906.59,5898.77 ; J16.4@3909.5,5863.98 ccw(c3872.34,5828.9) 3872.34,5880.01 ccw(c3872.34,5931.11) J16.4@3909.5,5896.03 ; J16.4@3912.41,5866.73 ccw(c3881.62,5837.66) 3881.62,5880.01 ccw(c3881.62,5922.35) J16.4@3912.41,5893.28 ; J16.4@3926.47,5880.01 3835.23,5880.01 ; -616.31,5740 -560,5796.31 -560,5920 -538.29,5941.71 -209.81,5941.71 55.96,6207.48 ; 55.96,6207.48 151.48,6303 2050.37,6303 2052.38,6305.01 2102.37,6355 2562.63,6355 2650.92,6266.71 3050,6266.71 3070,6246.71 3070,6185 3065,6180 3005,6180 2995,6190 2995,6235 2990,6240 2965,6240 2949.36,6224.36 2949.36,5986.96 2985.31,5951 3095,5951 ; 3095,5951 3095.34,5951.34 3581.08,5951.34 3594.43,5938 3777.23,5938 3835.23,5880.01
ATE.PWM.OUT3: J16.5 J33.B12 Q3.2 | length 6930.5
  Top Layer w4: v1(3555,5285) 3555,5287.12 3556.92,5289.04 3560.96,5289.04 3565,5285 Q3.2@3594.21,5285 ; v1@3558.89,5281.11 cw(c3568.28,5271.72) 3568.28,5285 cw(c3568.28,5298.28) v1@3558.89,5288.89 ; v1@3561.72,5278.28 cw(c3577.93,5262.06) 3577.93,5285 cw(c3577.93,5307.93) v1@3561.72,5291.72 ; Q3.2@3583.27,5278.83 ccw(c3572.19,5271.96) 3572.19,5285 ccw(c3572.19,5298.04) Q3.2@3583.27,5291.17
  Top Layer w30: Q3.2@3594.21,5285 3645,5335.79 3645,5530 3675.94,5560.94 3732.95,5560.94 4052.02,5880.01 J16.5@4123.32,5880.01 ; J16.5@4104.7,5861.38 ccw(c4059.73,5816.42) 4059.73,5880.01 ccw(c4059.73,5943.59) J16.5@4104.7,5898.63
  MidLayer1 w4: v1(1315,5005) 1315,5008.18 1315.19,5008.37 1381.86,5075.04 1573.52,5075.04 1616.86,5118.37 1863.77,5118.37 1899.61,5082.54 3449.87,5082.54 3536.79,5169.46 3555,5187.67 v1(3555,5285) ; v1@1315,5014.5 ccw(c1315,5029.75) 1325.78,5018.97 ; v1@1320.5,5005 cw(c1341.47,5005) 1326.64,5019.83 ; v1@1324.5,5005 cw(c1355.12,5005) 1333.47,5026.65 ; v1@3548.28,5278.28 cw(c3532.06,5262.06) 3555,5262.06 cw(c3577.93,5262.06) v1@3561.72,5278.28 ; v1@3551.11,5281.11 cw(c3541.72,5271.72) 3555,5271.72 cw(c3568.28,5271.72) v1@3558.89,5281.11
  Bottom Layer w4: J33.B12@-785.98,3755.22 -462.4,3755.22 -443,3774.63 -443,4372.2 -247.16,4568.04 306.7,4568.04 ; J33.B12@-711.58,3749.72 cw(c-698.3,3736.44) -698.3,3755.22 cw(c-698.3,3774.01) J33.B12@-711.58,3760.72 ; J33.B12@-708.76,3746.89 cw(c-688.65,3726.79) -688.65,3755.22 cw(c-688.65,3783.66) J33.B12@-708.76,3763.55 ; 1286.78,5007.19 cw(c1286.78,4976.78) v1@1308.28,4998.28 ; 1296.44,5007.19 cw(c1296.44,4986.44) v1@1311.11,5001.11 ; 1297.35,5007.19 ccw(c1297.35,5022.65) v1@1308.28,5011.72 ; v1(1315,5005) 1315,5008.18 1314,5007.19 627.19,5007.19 577.21,4957.21 577.21,4683.38 461.84,4568 306.75,4568 ; 306.7,4568.04 306.75,4568
ATE.RS232#.CTS: J17.8 U59.8 | length 2046.8
  Top Layer w4: J17.8@793,6490.89 cw(c739.62,6437.51) 815.11,6437.51 cw(c890.6,6437.51) J17.8@837.22,6490.89 ; J17.8@795.83,6493.72 cw(c749.28,6447.17) 815.11,6447.17 cw(c880.94,6447.17) J17.8@834.39,6493.72 ; J17.8@798.66,6496.55 cw(c758.94,6456.83) 815.11,6456.83 cw(c871.28,6456.83) J17.8@831.56,6496.55 ; J17.8@801.49,6499.38 cw(c768.59,6466.48) 815.11,6466.48 cw(c861.63,6466.48) J17.8@828.73,6499.38 ; J17.8@804.31,6502.2 cw(c778.25,6476.14) 815.11,6476.14 cw(c851.97,6476.14) J17.8@825.91,6502.2 ; J17.8@815.11,6513 815.11,6285.08 940.19,6160 940.19,5364.81 970,5335 v1(1030,5335) ; v1@1023.28,5328.28 ccw(c1007.06,5312.06) 1007.06,5335 ccw(c1007.06,5357.93) v1@1023.28,5341.72 ; v1@1026.11,5331.11 ccw(c1016.72,5321.72) 1016.72,5335 ccw(c1016.72,5348.28) v1@1026.11,5338.89
  Bottom Layer w4: U59.8@929,5370.08 994.92,5370.08 v1(1030,5335) ; U59.8@956.15,5364.58 cw(c969.43,5351.3) 969.43,5370.08 cw(c969.43,5388.86) U59.8@956.15,5375.58 ; U59.8@958.98,5361.75 cw(c979.09,5341.64) 979.09,5370.08 cw(c979.09,5398.52) U59.8@958.98,5378.41 ; v1@1020.5,5335 ccw(c997.56,5335) 1013.78,5351.22 ccw(c1030,5367.43) v1@1030,5344.5 ; v1@1024.5,5335 ccw(c1011.22,5335) 1020.61,5344.39 ccw(c1030,5353.78) v1@1030,5340.5
ATE.RS232#.DCD: J17.1 J17.4 J17.6 | length 1647.9
  Top Layer w4: J17.1@542.47,6401.19 597,6455.72 ; J17.1@542.47,6416.46 ccw(c542.47,6453.32) 568.54,6427.25 ccw(c594.6,6401.19) J17.1@557.74,6401.19 ; J17.1@542.47,6420.46 ccw(c542.47,6466.97) 575.36,6434.08 ccw(c608.26,6401.19) J17.1@561.74,6401.19 ; J17.1@542.47,6424.46 ccw(c542.47,6480.63) 582.19,6440.91 ccw(c621.91,6401.19) J17.1@565.74,6401.19 ; J17.1@542.47,6428.46 ccw(c542.47,6494.29) 589.02,6447.74 ccw(c635.57,6401.19) J17.1@569.74,6401.19 ; J17.1@542.47,6432.46 ccw(c542.47,6507.94) 595.85,6454.57 ccw(c649.23,6401.19) J17.1@573.74,6401.19 ; J17.6@580.09,6486.7 cw(c560.17,6455.72) 597,6455.72 ; J17.6@582.25,6490.06 cw(c564.88,6463.05) 597,6463.05 cw(c629.12,6463.05) J17.6@611.75,6490.06 ; J17.6@584.42,6493.43 cw(c569.59,6470.38) 597,6470.38 cw(c624.41,6470.38) J17.6@609.58,6493.43 ; J17.6@586.58,6496.79 cw(c574.3,6477.7) 597,6477.7 cw(c619.7,6477.7) J17.6@607.42,6496.79 ; J17.6@597,6513 597,6455.72 ; J17.6@613.91,6486.7 ccw(c633.83,6455.72) 597,6455.72
  Bottom Layer w12: J17.1@542.47,6401.19 596.28,6455 815.83,6455 J17.4@869.64,6401.19 ; J17.1@542.47,6416.46 ccw(c542.47,6453.32) 568.54,6427.25 ccw(c594.6,6401.19) J17.1@557.74,6401.19 ; J17.1@542.47,6428.46 ccw(c542.47,6494.29) 589.02,6447.74 ccw(c635.57,6401.19) J17.1@569.74,6401.19 ; J17.6@579.81,6491.83 cw(c550.47,6455.72) 597,6455.72 ; J17.6@597,6513 597,6455.72 ; J17.6@614.19,6491.83 ccw(c643.53,6455.72) 597,6455.72 ; J17.4@842.37,6401.19 ccw(c776.54,6401.19) 823.09,6447.74 ccw(c869.64,6494.29) J17.4@869.64,6428.46 ; J17.4@854.37,6401.19 ccw(c817.51,6401.19) 843.57,6427.25 ccw(c869.64,6453.32) J17.4@869.64,6416.46
ATE.RS232#.RI: J17.9
ATE.RS232#.RTS: J17.7 U59.7 | length 1981.6
  Top Layer w4: J17.7@683.95,6490.89 cw(c630.57,6437.51) 706.06,6437.51 cw(c781.54,6437.51) J17.7@728.17,6490.89 ; J17.7@686.78,6493.72 cw(c640.23,6447.17) 706.06,6447.17 cw(c771.89,6447.17) J17.7@725.34,6493.72 ; J17.7@689.6,6496.55 cw(c649.88,6456.83) 706.06,6456.83 cw(c762.23,6456.83) J17.7@722.51,6496.55 ; J17.7@692.43,6499.38 cw(c659.54,6466.48) 706.06,6466.48 cw(c752.57,6466.48) J17.7@719.68,6499.38 ; J17.7@695.26,6502.2 cw(c669.2,6476.14) 706.06,6476.14 cw(c742.92,6476.14) J17.7@716.85,6502.2 ; J17.7@706.06,6513 706.06,6380 930,6156.06 930,5420 924.43,5414.43 v1(845,5414.43) ; v1@848.89,5410.54 cw(c858.28,5401.15) 858.28,5414.43 cw(c858.28,5427.71) v1@848.89,5418.32 ; v1@851.72,5407.72 cw(c867.93,5391.5) 867.93,5414.43 cw(c867.93,5437.37) v1@851.72,5421.15
  Bottom Layer w4: v1(845,5414.43) 875,5414.43 880.64,5420.08 ; v1@848.89,5410.54 cw(c858.28,5401.15) 858.28,5414.43 cw(c858.28,5427.71) v1@848.89,5418.32 ; v1@851.72,5407.72 cw(c867.93,5391.5) 867.93,5414.43 cw(c867.93,5437.37) v1@851.72,5421.15 ; U59.7@898.65,5412.14 ccw(c880.65,5395.71) 880.65,5420.08 ; U59.7@898.65,5428.02 cw(c880.65,5444.45) 880.65,5420.08 ; U59.7@901.6,5414.83 ccw(c889.71,5403.98) 889.71,5420.08 ccw(c889.71,5436.17) U59.7@901.6,5425.32 ; U59.7@929,5420.08 880.64,5420.08
ATE.RS232#.RXD: J17.2 J33.B8 U59.13 | length 4527.7
  Top Layer w4: J17.2@639.05,6372.52 cw(c630.75,6353.47) 651.53,6353.47 ; J17.2@640.64,6376.19 cw(c633.41,6359.58) 651.53,6359.58 cw(c669.65,6359.58) J17.2@662.41,6376.19 ; J17.2@642.24,6379.86 cw(c636.07,6365.68) 651.53,6365.68 cw(c666.99,6365.68) J17.2@660.82,6379.86 ; J17.2@651.53,6401.19 651.53,6353.47 ; J17.2@664.01,6372.52 ccw(c672.3,6353.47) 651.53,6353.47 ; v2@768.06,5536.94 ccw(c751.31,5553.69) 775,5553.69 ccw(c798.69,5553.69) v2@781.94,5536.94 ; v2@770.89,5534.11 ccw(c760.97,5544.03) 775,5544.03 ccw(c789.03,5544.03) v2@779.11,5534.11 ; v2(775,5530) 775,5690 685,5780 685,6320 651.53,6353.47
  Bottom Layer w4: J33.B8@-785.98,3991.44 -709.81,3991.44 -705.3,3995.95 -705.3,4000.77 -691.08,4015 -583.71,4015 -565,4033.71 -487.46,4033.71 -459,4062.16 -459,4381 -255,4585 -255,4630.1 -227.31,4657.79 -227.31,4707.29 -212.56,4722.04 296.86,4722.04 306.86,4732.04 306.86,4797.04 259.52,4844.37 259.52,4919.37 273.52,4933.37 273.52,5133.37 223.52,5183.37 223.52,5563.52 260,5600 580,5600 609.92,5570.08 U59.13@704.59,5570.08 769.78,5570.08 775,5564.86 v2(775,5530) ; J33.B8@-717.08,3999.22 ccw(c-717.08,4023.92) -699.62,4006.46 ; J33.B8@-717.08,4003.22 ccw(c-717.08,4037.58) -692.79,4013.29 ; J33.B8@-709.3,3991.44 cw(c-696.44,3991.44) J33.B8@-705.54,4000.54 ; J33.B8@-705.3,3991.44 cw(c-682.79,3991.44) -698.71,4007.37 ; U59.13@674.61,5561.75 ccw(c654.5,5541.64) 654.5,5570.08 ccw(c654.5,5598.52) U59.13@674.61,5578.41 ; U59.13@677.44,5564.58 ccw(c664.16,5551.3) 664.16,5570.08 ccw(c664.16,5588.86) U59.13@677.44,5575.58 ; U59.13@731.75,5564.58 cw(c745.03,5551.3) 745.03,5570.08 cw(c745.03,5588.86) U59.13@731.75,5575.58 ; U59.13@734.57,5561.75 cw(c754.68,5541.64) 754.68,5570.08 cw(c754.68,5598.52) U59.13@734.57,5578.41 ; v2@768.06,5536.94 ccw(c751.31,5553.69) 775,5553.69 ccw(c798.69,5553.69) v2@781.94,5536.94 ; v2@770.89,5534.11 ccw(c760.97,5544.03) 775,5544.03 ccw(c789.03,5544.03) v2@779.11,5534.11
ATE.RS232#.TXD: J17.3 J33.B5 U59.14 | length 5436.2
  Top Layer w4: v2@538.71,5930 ccw(c515.03,5930) 531.78,5946.75 ccw(c548.52,5963.5) v2@548.52,5939.81 ; v2@541.59,5923.06 cw(c524.84,5906.31) 548.52,5906.31 cw(c572.21,5906.31) v2@555.46,5923.06 ; v2@542.71,5930 ccw(c528.68,5930) 538.6,5939.92 ccw(c548.52,5949.84) v2@548.52,5935.81 ; v2@544.42,5925.89 cw(c534.5,5915.97) 548.52,5915.97 cw(c562.55,5915.97) v2@552.63,5925.89 ; v2@565.19,5660 ccw(c541.5,5660) 558.25,5676.75 ccw(c575,5693.5) v2@575,5669.81 ; v2@569.19,5660 ccw(c555.16,5660) 565.08,5669.92 ccw(c575,5679.84) v2@575,5665.81 ; v2(575,5660) 548.52,5686.48 v2(548.52,5930) 475,6003.52 475,6505 525,6555 735.58,6555 760.58,6530 J17.3@760.58,6401.19 ; J17.3@738.47,6423.3 ccw(c685.1,6476.68) 760.58,6476.68 ccw(c836.07,6476.68) J17.3@782.69,6423.3 ; J17.3@741.3,6420.47 ccw(c694.75,6467.02) 760.58,6467.02 ccw(c826.41,6467.02) J17.3@779.86,6420.47 ; J17.3@744.13,6417.64 ccw(c704.41,6457.36) 760.58,6457.36 ccw(c816.76,6457.36) J17.3@777.03,6417.64 ; J17.3@746.96,6414.81 ccw(c714.07,6447.71) 760.58,6447.71 ccw(c807.1,6447.71) J17.3@774.21,6414.81 ; J17.3@749.79,6411.99 ccw(c723.72,6438.05) 760.58,6438.05 ccw(c797.44,6438.05) J17.3@771.38,6411.99
  Bottom Layer w4: J33.B5@-785.98,4109.55 -781.43,4105 -643,4105 -635,4113 -582,4113 -551.65,4143.35 -551.65,5321.91 -530,5343.56 -335.72,5343.56 -327.52,5351.76 -327.52,5685 ; J33.B5@-714.41,4112.23 ccw(c-696.97,4129.67) -696.97,4105 ; J33.B5@-711.58,4115.05 ccw(c-687.31,4139.33) -687.31,4105 ; J33.B5@-708.76,4101.22 cw(c-699.64,4092.11) -699.64,4105 ; J33.B5@-708.76,4117.88 ccw(c-677.65,4148.99) -677.65,4105 ; -327.52,5694.55 -327.52,5685 ; v2@541.59,5923.06 ccw(c524.84,5906.31) 524.84,5930 ccw(c524.84,5953.69) v2@541.59,5936.94 ; v2@544.42,5925.89 ccw(c534.5,5915.97) 534.5,5930 ccw(c534.5,5944.03) v2@544.42,5934.11 ; v2(548.52,5930) -198.89,5930 -327.52,5801.37 -327.52,5685 ; v2@575,5650.19 cw(c575,5626.5) 591.75,5643.25 cw(c608.5,5660) v2@584.81,5660 ; v2@575,5654.19 cw(c575,5640.16) 584.92,5650.08 cw(c594.84,5660) v2@580.81,5660 ; v2(575,5660) 614.92,5620.08 U59.14@704.59,5620.08 ; U59.14@674.61,5611.75 ccw(c654.5,5591.64) 654.5,5620.08 ccw(c654.5,5648.52) U59.14@674.61,5628.41 ; U59.14@677.44,5614.58 ccw(c664.16,5601.3) 664.16,5620.08 ccw(c664.16,5638.86) U59.14@677.44,5625.58
ATE.RS485#.RX_N: J23.6 J33.B9 R212.1 U46.11 | length 5823
  Top Layer w4: v1@933.94,4597.32 ccw(c923.3,4610.19) 940,4610.19 ; v1@936.49,4594.24 ccw(c930.33,4601.69) 940,4601.69 ccw(c949.67,4601.69) v1@943.51,4594.24 ; v1(940,4590) 940,4610.19 ; v1@946.06,4597.32 cw(c956.7,4610.19) 940,4610.19 ; v1@1639.02,5650.04 cw(c1616.09,5650.04) 1632.31,5633.82 cw(c1648.52,5617.61) v1@1648.52,5640.54 ; v1@1643.02,5650.04 cw(c1629.75,5650.04) 1639.14,5640.65 cw(c1648.52,5631.26) v1@1648.52,5644.54 ; v1(1648.52,5650.04) 1618.48,5620 1405,5620 1402.18,5617.18 1402.18,5266.05 998.13,4862 948.86,4862 931.86,4845 931.86,4618.33 940,4610.19
  MidLayer1 w4: 1605,5763.12 cw(c1662.08,5763.12) v1@1621.72,5803.48 ; 1605,5772.77 cw(c1652.42,5772.77) v1@1618.89,5806.3 ; 1605,5782.43 cw(c1642.76,5782.43) v1@1616.06,5809.13 ; 1605,5792.09 cw(c1633.11,5792.09) v1@1613.23,5811.96 ; 1605,5801.74 cw(c1623.45,5801.74) v1@1610.4,5814.79 ; 1605,5818.64 ccw(c1623.45,5818.64) v1@1610.4,5805.6 ; 1605,5828.3 ccw(c1633.11,5828.3) v1@1613.23,5808.43 ; 1605,5837.96 ccw(c1642.76,5837.96) v1@1616.06,5811.25 ; 1605,5847.61 ccw(c1652.42,5847.61) v1@1618.89,5814.08 ; 1605,5857.27 ccw(c1662.08,5857.27) v1@1621.72,5816.91 ; v1@1640.82,5644.48 ccw(c1629.96,5636.65) 1629.96,5650.04 ; v1@1640.82,5655.6 cw(c1629.96,5663.43) 1629.96,5650.04 ; v1(1648.52,5650.04) 1629.96,5650.04 ; 1740.26,6225.26 cw(c1764.02,6201.5) J23.6@1778.89,6231.63 ; 1744.2,6229.2 cw(c1766.62,6206.78) J23.6@1780.67,6235.21 ; 1748.15,6233.15 cw(c1769.23,6212.06) J23.6@1782.44,6238.8 ; 1752.09,6237.09 cw(c1771.84,6217.34) J23.6@1784.21,6242.38 ; J23.6@1784,6241.96 1756.96,6241.96 1738,6223 1738,6136.69 1605,6003.69 1605,5693.56 1614.86,5683.71 1614.86,5665.14 1629.96,5650.04
  MidLayer2 w4: v1(-648.48,3972.04) -620.17,4000.35 -610.71,4000.35 -579.06,4032 -561.28,4032 -422,4171.28 -422,4486.5 -374.19,4534.31 -363.62,4544.87 -323.41,4544.87 -306.41,4527.87 -201.62,4527.87 -171.46,4558.04 458.31,4558.04 512.08,4611.81 863.19,4611.81 882.81,4592.19 937.81,4592.19 v1(940,4590) ; v1@-648.48,3977.54 ccw(c-648.48,3990.82) -639.09,3981.43 ccw(c-629.7,3972.04) v1@-642.98,3972.04 ; v1@-648.48,3981.54 ccw(c-648.48,4004.48) -632.26,3988.26 ccw(c-616.04,3972.04) v1@-638.98,3972.04 ; 911.78,4592.19 cw(c911.78,4561.78) v1@933.28,4583.28 ; 921.44,4592.19 cw(c921.44,4571.44) v1@936.11,4586.11 ; 922.35,4592.19 ccw(c922.35,4607.65) v1@933.28,4596.72
  Bottom Layer w4: J33.B9@-785.98,3952.07 -668.44,3952.07 v1(-648.48,3972.04) ; J33.B9@-711.58,3946.57 cw(c-698.3,3933.29) -698.3,3952.07 cw(c-698.3,3970.85) J33.B9@-711.58,3957.57 ; J33.B9@-708.76,3943.74 cw(c-688.65,3923.64) -688.65,3952.07 cw(c-688.65,3980.51) J33.B9@-708.76,3960.4 ; v1@-657.98,3972.04 cw(c-680.91,3972.04) -664.69,3955.82 cw(c-648.48,3939.61) v1@-648.48,3962.54 ; v1@-653.98,3972.04 cw(c-667.25,3972.04) -657.87,3962.65 cw(c-648.48,3953.26) v1@-648.48,3966.54 ; R212.1@1430,5478.82 1463.97,5478.82 1465.19,5480.04 1465.19,5560.08 1475.19,5570.08 U46.11@1542.57,5570.08 1550,5570.08 1586.89,5570.08 1595.08,5570.08 ; R212.1@1434.25,5475.06 cw(c1443.33,5465.98) 1443.33,5478.82 cw(c1443.33,5491.66) R212.1@1434.25,5482.58 ; R212.1@1437.08,5472.23 cw(c1452.99,5456.32) 1452.99,5478.82 cw(c1452.99,5501.32) R212.1@1437.08,5485.41 ; U46.11@1504.13,5563.14 ccw(c1487.39,5546.39) 1487.39,5570.08 ccw(c1487.38,5593.76) U46.11@1504.13,5577.01 ; U46.11@1506.96,5565.97 ccw(c1497.04,5556.05) 1497.04,5570.08 ccw(c1497.04,5584.11) U46.11@1506.96,5574.19 ; U46.11@1578.52,5566.35 cw(c1586.51,5559.65) 1586.51,5570.08 cw(c1586.51,5580.5) U46.11@1578.52,5573.81 ; U46.11@1581.58,5563.78 cw(c1595.08,5552.48) 1595.08,5570.08 ; U46.11@1581.58,5576.38 ccw(c1595.08,5587.67) 1595.08,5570.08 ; v1@1639.02,5650.04 cw(c1616.09,5650.04) 1632.31,5633.82 cw(c1648.52,5617.61) v1@1648.52,5640.54 ; v1@1643.02,5650.04 cw(c1629.75,5650.04) 1639.14,5640.65 cw(c1648.52,5631.26) v1@1648.52,5644.54 ; v1(1648.52,5650.04) 1626.62,5628.13 1626.62,5601.62 1595.08,5570.08
  other v1: 1615,5810.19