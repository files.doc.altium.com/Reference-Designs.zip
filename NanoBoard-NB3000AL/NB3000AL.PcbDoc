# Altium PCB NB3000AL.PcbDoc (part 15 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.RS485#.RX_P: J23.3 J26.1 J33.B7 U46.12 | length 6025.4
  Top Layer w4: v2@908.06,4616.94 ccw(c869.93,4655.07) 923.86,4655.07 ; v2@910.89,4614.11 ccw(c879.59,4645.41) 923.86,4645.41 ; v2@913.72,4611.28 ccw(c889.24,4635.76) 923.86,4635.76 ; v2(915,4610) 923.86,4618.86 923.86,4848.31 945.54,4870 994.82,4870 1394.18,5269.36 1394.18,5699.34 1429.71,5734.87 ; v2@916.55,4608.45 ccw(c898.9,4626.1) 923.86,4626.1 ; J26.1@1415.08,5761.3 cw(c1398.51,5734.87) 1429.71,5734.87 ; J26.1@1417.21,5764.69 cw(c1403.04,5742.1) 1429.71,5742.1 cw(c1456.37,5742.1) J26.1@1442.21,5764.69 ; J26.1@1419.33,5768.08 cw(c1407.58,5749.33) 1429.71,5749.33 cw(c1451.84,5749.33) J26.1@1440.08,5768.08 ; J26.1@1429.71,5784.62 1429.71,5734.87 ; J26.1@1444.33,5761.3 ccw(c1460.91,5734.87) 1429.71,5734.87
  MidLayer1 w4: v1@1570,5785 1597,5785 ; v1@1573.89,5781.3 cw(c1582.81,5772.38) 1582.81,5785 ; v1@1573.89,5789.08 ccw(c1583.75,5798.94) 1583.75,5785 ; v1@1576.72,5778.48 cw(c1592.47,5762.73) 1592.47,5785 ; v1@1576.72,5791.91 ccw(c1593.4,5808.6) 1593.4,5785 ; v1(1606.86,5644.04) 1606.86,5680.39 1597,5690.25 1597,5785 ; J23.3@1634,6314.43 cw(c1634,6247.39) 1681.41,6294.8 ; J23.3@1634,6318.43 cw(c1634,6261.05) 1674.58,6301.62 ; J23.3@1634,6322.43 cw(c1634,6274.7) 1667.75,6308.45 ; J23.3@1634,6326.43 cw(c1634,6288.36) 1660.92,6315.28 ; J23.3@1634,6341.96 1634.24,6341.96 1730,6246.2 1730,6140 1597,6007 1597,5785 ; J23.3@1649.53,6341.96 ccw(c1686.43,6341.96) 1660.33,6315.87 ; J23.3@1653.53,6341.96 ccw(c1700.08,6341.96) 1667.16,6309.04 ; J23.3@1657.53,6341.96 ccw(c1713.74,6341.96) 1673.99,6302.21 ; J23.3@1661.53,6341.96 ccw(c1727.4,6341.96) 1680.82,6295.38
  MidLayer2 w4: v2(-605,4040) -579.41,4040 -564.58,4040.01 -430,4174.59 -430,4489.81 -392.62,4527.19 -382.19,4537.62 -366.94,4552.87 -320.1,4552.87 -303.1,4535.87 -204.94,4535.87 -174.77,4566.04 455,4566.04 508.77,4619.81 869.06,4619.81 880,4608.87 913.87,4608.87 v2(915,4610) ; v2@-600.89,4035.89 cw(c-590.97,4025.97) -590.97,4040 cw(c-590.97,4054.03) v2@-600.89,4044.11 ; v2@-598.06,4033.06 cw(c-581.31,4016.31) -581.31,4040 cw(c-581.31,4063.69) v2@-598.06,4046.94 ; 888.58,4608.87 ccw(c888.58,4636.42) v2@908.06,4616.94 ; 894.04,4608.87 cw(c894.04,4589.04) v2@908.06,4603.06 ; 898.24,4608.87 ccw(c898.24,4626.76) v2@910.89,4614.11 ; J26.1@1429.71,5784.62 1495.18,5784.62 ; J26.1@1440.8,5773.76 cw(c1466.64,5748.47) 1466.64,5784.62 cw(c1466.64,5820.78) J26.1@1440.8,5795.48 ; J26.1@1443.66,5770.96 cw(c1476.15,5739.15) 1476.15,5784.62 cw(c1476.15,5830.09) J26.1@1443.66,5798.28 ; J26.1@1446.52,5768.16 cw(c1485.67,5729.84) 1485.67,5784.62 cw(c1485.67,5839.41) J26.1@1446.52,5801.08 ; J26.1@1449.38,5765.36 cw(c1495.18,5720.52) 1495.18,5784.62 ; J26.1@1449.38,5803.88 ccw(c1495.18,5848.72) 1495.18,5784.62 ; v1@1563.28,5778.48 ccw(c1547.06,5762.26) 1547.06,5785.19 ccw(c1547.06,5808.13) v1@1563.28,5791.91 ; v1@1566.11,5781.3 ccw(c1556.72,5771.92) 1556.72,5785.19 ccw(c1556.72,5798.47) v1@1566.11,5789.08 ; v1(1570,5785.19) 1495.76,5785.19 1495.18,5784.62
  Bottom Layer w4: J33.B7@-785.98,4030.81 -778.17,4023 -670,4023 -668.06,4023 -642,4023 -625,4040 ; J33.B7@-717.24,4030.66 ccw(c-698.84,4048.94) -698.84,4023 ; J33.B7@-714.4,4033.48 ccw(c-689.23,4058.49) -689.23,4023 ; J33.B7@-711.57,4036.3 ccw(c-679.61,4068.04) -679.61,4023 ; J33.B7@-708.73,4039.12 ccw(c-670,4077.58) -670,4023 ; v2@-612.76,4034 ccw(c-625,4024.52) -625,4040 ; v2@-612.76,4046 cw(c-625,4055.48) -625,4040 ; v2@-609.6,4036.44 ccw(c-616.85,4030.83) -616.85,4040 ccw(c-616.85,4049.17) v2@-609.6,4043.56 ; v2(-605,4040) -625,4040 ; U46.12@1542.57,5620.08 1598.86,5620.08 1606.86,5628.08 ; U46.12@1578.17,5615.97 cw(c1588.09,5606.05) 1588.09,5620.08 cw(c1588.09,5634.11) U46.12@1578.17,5624.19 ; U46.12@1581,5613.14 cw(c1597.75,5596.39) 1597.75,5620.08 ; U46.12@1581,5627.01 ccw(c1597.75,5643.76) 1597.75,5620.08 ; v1@1602.33,5635.69 cw(c1598.2,5628.08) 1606.86,5628.08 ; v1(1606.86,5644.04) 1606.86,5628.08 ; v1@1611.39,5635.69 ccw(c1615.52,5628.08) 1606.86,5628.08
ATE.RS485#.TX_N: J23.2 J33.B16 U46.10 | length 6293.5
  Top Layer w4: v2(-685,3585) -611.69,3585 -600.64,3573.96 -600.64,3559.46 -610.89,3549.21 -689.21,3549.21 -695,3543.42 -695,3515 -690,3510 -635,3510 -619.13,3525.87 -566.19,3525.87 -532.56,3559.5 -404.44,3559.5 -389.5,3574.44 -389.5,3595.56 -404.44,3610.5 -452.93,3610.5 -477,3634.57 -477,4607.75 -462.25,4622.5 -290,4622.5 -276.69,4609.19 v2(-276.69,4606.78) ; v2@-680.89,3580.89 cw(c-670.97,3570.97) -670.97,3585 cw(c-670.97,3599.03) v2@-680.89,3589.11 ; v2@-678.06,3578.06 cw(c-661.31,3561.31) -661.31,3585 cw(c-661.31,3608.69) v2@-678.06,3591.94
  MidLayer1 w4: J23.2@1556.57,6239.69 cw(c1506.43,6235.54) 1542,6199.96 ; J23.2@1560.55,6240.02 cw(c1517.7,6236.47) 1548.1,6206.07 cw(c1578.51,6175.66) J23.2@1582.06,6218.51 ; J23.2@1564.54,6240.35 cw(c1528.97,6237.4) 1554.21,6212.17 cw(c1579.44,6186.93) J23.2@1582.39,6222.5 ; J23.2@1568.53,6240.68 cw(c1540.24,6238.34) 1560.31,6218.27 cw(c1580.38,6198.2) J23.2@1582.72,6226.49 ; J23.2@1581.73,6214.53 ccw(c1577.58,6164.39) 1542,6199.96 ; J23.2@1584,6241.96 1542,6199.96 ; v1@1610.81,5552.66 ccw(c1594.59,5536.44) 1594.59,5559.37 ccw(c1594.59,5582.31) v1@1610.81,5566.09 ; v1@1613.64,5555.49 ccw(c1604.25,5546.1) 1604.25,5559.37 ccw(c1604.25,5572.65) v1@1613.64,5563.26 ; v1(1617.52,5559.37) 1568.84,5559.37 1542,5586.21 1542,6199.96
  MidLayer2 w4: v2(-276.69,4606.78) -250.1,4633.37 73.37,4633.37 184,4744 420.06,4744 445.5,4769.44 445.5,4940.56 436,4950.06 436,5309 414.19,5330.81 414.19,5524.19 465.98,5575.98 472.86,5582.86 1594.04,5582.86 v1(1617.52,5559.37) ; v2@-276.69,4612.59 ccw(c-276.69,4626.62) -266.77,4616.7 ccw(c-256.85,4606.78) v2@-270.88,4606.78 ; v2@-276.69,4616.59 ccw(c-276.69,4640.28) -259.94,4623.53 ccw(c-243.19,4606.78) v2@-266.88,4606.78 ; v1@1608.02,5559.37 ccw(c1585.09,5559.37) 1601.31,5575.59 ccw(c1617.52,5591.81) v1@1617.52,5568.87 ; v1@1612.02,5559.37 ccw(c1598.75,5559.37) 1608.14,5568.76 ccw(c1617.52,5578.15) v1@1617.52,5564.87
  Bottom Layer w4: J33.B16@-785.98,3597.74 -697.74,3597.74 ; J33.B16@-706.62,3592.34 cw(c-697.74,3587.75) -697.74,3597.74 ; J33.B16@-706.62,3603.15 ccw(c-697.74,3607.73) -697.74,3597.74 ; v2(-685,3585) -697.74,3597.74 ; U46.10@1542.57,5520.08 1610.08,5520.08 1617.52,5527.52 v1(1617.52,5559.37) ; U46.10@1578.17,5515.97 cw(c1588.09,5506.05) 1588.09,5520.08 cw(c1588.09,5534.11) U46.10@1578.17,5524.19 ; U46.10@1581,5513.14 cw(c1597.75,5496.39) 1597.75,5520.08 cw(c1597.75,5543.76) U46.10@1581,5527.01 ; v1@1610.81,5552.66 cw(c1594.59,5536.44) 1617.52,5536.44 cw(c1640.46,5536.44) v1@1624.24,5552.66 ; v1@1613.64,5555.49 cw(c1604.25,5546.1) 1617.52,5546.1 cw(c1630.8,5546.1) v1@1621.41,5555.49
ATE.RS485#.TX_P: J23.1 J33.B18 U46.9 | length 6345.3
  Top Layer w4: v1(-675,3530) -638.37,3530 -628.37,3540 -563.37,3540 -549.4,3553.98 -535.87,3567.5 -407.75,3567.5 -397.5,3577.75 -397.5,3592.25 -407.75,3602.5 -456.25,3602.5 -485,3631.25 -485,4611.06 -465.02,4631.04 -260.18,4631.04 v1(-233.51,4604.37) ; v1@-671.11,3526.11 cw(c-661.72,3516.72) -661.72,3530 cw(c-661.72,3543.28) v1@-671.11,3533.89 ; v1@-668.28,3523.28 cw(c-652.07,3507.06) -652.07,3530 cw(c-652.07,3552.93) v1@-668.28,3536.72 ; v1@-243.01,4604.37 ccw(c-265.95,4604.37) -249.73,4620.59 ccw(c-233.51,4636.81) v1@-233.51,4613.87 ; v1@-239.01,4604.37 ccw(c-252.29,4604.37) -242.9,4613.76 ccw(c-233.51,4623.15) v1@-233.51,4609.87
  MidLayer1 w4: J23.1@1514.54,6322.5 cw(c1467.54,6275.5) 1534,6275.5 cw(c1600.46,6275.5) J23.1@1553.46,6322.5 ; J23.1@1517.36,6325.32 cw(c1477.2,6285.16) 1534,6285.16 cw(c1590.8,6285.16) J23.1@1550.64,6325.32 ; J23.1@1520.19,6328.15 cw(c1486.86,6294.82) 1534,6294.82 cw(c1581.14,6294.82) J23.1@1547.81,6328.15 ; J23.1@1523.02,6330.98 cw(c1496.51,6304.47) 1534,6304.47 cw(c1571.49,6304.47) J23.1@1544.98,6330.98 ; J23.1@1534,6341.96 1534,5582.9 1565.52,5551.37 1590,5551.37 1606.86,5534.52 v1(1606.86,5494.04) ; v1@1600.14,5500.76 ccw(c1583.92,5516.98) 1606.86,5516.98 ccw(c1629.79,5516.98) v1@1613.57,5500.76 ; v1@1602.97,5497.93 ccw(c1593.58,5507.32) 1606.86,5507.32 ccw(c1620.14,5507.32) v1@1610.75,5497.93
  MidLayer2 w4: v1(-233.51,4604.37) -212.51,4625.37 76.68,4625.37 187.31,4736 423.37,4736 453.5,4766.13 453.5,4943.88 444,4953.38 444,5312.31 422.19,5334.12 422.19,5520.88 476.18,5574.86 1567.14,5574.86 1575,5567 1575,5525.9 v1(1606.86,5494.04) ; v1@-233.51,4609.87 ccw(c-233.51,4623.15) -224.12,4613.76 ccw(c-214.74,4604.37) v1@-228.01,4604.37 ; v1@-233.51,4613.87 ccw(c-233.51,4636.81) -217.3,4620.59 ccw(c-201.08,4604.37) v1@-224.01,4604.37 ; v1@1597.36,5494.04 ccw(c1574.42,5494.04) 1590.64,5510.26 ccw(c1606.86,5526.48) v1@1606.86,5503.54 ; v1@1601.36,5494.04 ccw(c1588.08,5494.04) 1597.47,5503.43 ccw(c1606.86,5512.82) v1@1606.86,5499.54
  Bottom Layer w4: J33.B18@-785.98,3519 -686,3519 v1(-675,3530) ; J33.B18@-711.58,3513.5 cw(c-698.3,3500.22) -698.3,3519 cw(c-698.3,3537.78) J33.B18@-711.58,3524.5 ; J33.B18@-708.76,3510.67 cw(c-688.65,3490.56) -688.65,3519 cw(c-688.65,3547.44) J33.B18@-708.76,3527.33 ; U46.9@1542.57,5470.08 1604.92,5470.08 1606.86,5472.01 ; U46.9@1578.17,5465.97 cw(c1588.09,5456.05) 1588.09,5470.08 cw(c1588.09,5484.11) U46.9@1578.17,5474.19 ; U46.9@1581,5463.14 cw(c1597.75,5446.39) 1597.75,5470.08 cw(c1597.75,5493.76) U46.9@1581,5477.01 ; v1@1600.34,5487.13 cw(c1586.07,5472.01) 1606.86,5472.01 ; v1@1603.08,5490.04 cw(c1594.82,5481.29) 1606.86,5481.29 cw(c1618.89,5481.29) v1@1610.63,5490.04 ; v1(1606.86,5494.04) 1606.86,5472.01 ; v1@1613.38,5487.13 ccw(c1627.64,5472.01) 1606.86,5472.01
ATE.SPDIF.IN: J33.B42 U3.4 U8.AF4 | length 10567.8
  Top Layer w4: v1(4874,3574) 4875,3575 4893.31,3575 ; v1@4878.62,3571.01 cw(c4885.95,3566.26) 4885.95,3575 ; v1@4881.01,3580.42 ccw(c4893.31,3591.68) 4893.31,3575 ; v1@4881.97,3568.84 cw(c4893.31,3561.5) 4893.31,3575 ; 4930.85,3609.98 4938.85,3609.98 ; 4893.31,3575 4902.81,3584.5 4928.29,3609.98 4938.85,3609.98 ; 4938.85,3609.98 4952.75,3623.88 4952.75,3630.75 4952.75,3638.82 ; 4952.75,3638.82 4952.75,3697.36 ; 4952.75,3638.82 4952.75,3697.36 ; 4952.75,3697.36 cw(c4991.43,3697.36) 4964.08,3724.71 ; 4952.75,3697.36 cw(c4991.43,3697.36) 4964.08,3724.71 ; 4964.08,3724.71 ccw(c4951.55,3737.24) 4969.27,3737.24 cw(c4951.55,3737.24) 4964.08,3724.71 ; 4964.08,3724.71 cw(c4976.61,3712.18) 4976.61,3729.9 ccw(c4976.61,3712.18) 4964.08,3724.71
  MidLayer1 w4: v1@-660.98,2575.04 cw(c-683.91,2575.04) -667.69,2558.82 cw(c-651.48,2542.61) v1@-651.48,2565.54 ; v1@-656.98,2575.04 cw(c-670.25,2575.04) -660.86,2565.65 cw(c-651.48,2556.26) v1@-651.48,2569.54 ; v1(-651.48,2575.04) -668.98,2557.54 -668.98,2459.46 -515.73,2306.21 -332.28,2306.21 -200,2173.94 -200,1932.9 v1(-0.48,1733.37) ; v1@-9.98,1733.37 ccw(c-32.91,1733.37) -16.69,1749.59 ccw(c-0.48,1765.81) v1@-0.48,1742.87 ; v1@-5.98,1733.37 ccw(c-19.25,1733.37) -9.86,1742.76 ccw(c-0.48,1752.15) v1@-0.48,1738.87 ; v1@4503.12,1081.76 ccw(c4486.9,1097.98) 4509.84,1097.98 ccw(c4532.77,1097.98) v1@4516.56,1081.76 ; v1@4505.95,1078.93 ccw(c4496.56,1088.32) 4509.84,1088.32 ccw(c4523.12,1088.32) v1@4513.73,1078.93 ; v1(4509.84,1075.04) 4509.84,1098.39 4490.19,1118.04 4490.19,2544.69 4631.86,2686.36 4631.86,2861.36 4715.19,2944.69 4715.19,3240.71 4739.19,3264.71 4739.19,3308.71 4748.52,3318.04 4770,3318.04 ; 4852.29,3275.37 4870.37,3275.37 ; v1@4864.5,3574 cw(c4841.56,3574) 4857.78,3557.78 cw(c4874,3541.56) v1@4874,3564.5 ; v1@4868.5,3574 cw(c4855.22,3574) 4864.61,3564.61 cw(c4874,3555.22) v1@4874,3568.5 ; v1@4873.74,3574.26 v1@4874,3574.52 ; v1(4874,3574) 4857.52,3557.52 4849.19,3549.19 4849.19,3370.81 4890,3330 4890,3295 4870.37,3275.37 ; 4770,3318.04 4780,3318.04 ; 4770,3318.04 4775,3318.04 ; 4775,3318.04 4780,3318.04 ; 4775,3318.04 4780,3318.04 ; 4780,3318.04 4798.88,3318.04 ; 4780,3318.04 4798.52,3318.04 ; 4780,3318.04 4798.52,3318.04 ; 4798.52,3318.04 4798.88,3318.04 ; 4798.88,3318.04 4821.92,3295 4841.54,3275.37 4870.37,3275.37
  MidLayer2 w4: v1@-7.19,1726.66 cw(c-23.41,1710.44) -0.48,1710.44 cw(c22.46,1710.44) v1@6.24,1726.66 ; v1@-4.36,1729.49 cw(c-13.75,1720.1) -0.48,1720.1 cw(c12.8,1720.1) v1@3.41,1729.49 ; v1(-0.48,1733.37) -0.48,1700 -55,1645.48 -55,1470.26 43.26,1372 2099.19,1372 2576.19,895 2850,895 2930,975 3601.46,975 3626.5,1000.04 4434.84,1000.04 v1(4509.84,1075.04) ; v1@4500.34,1075.04 cw(c4477.4,1075.04) 4493.62,1058.82 cw(c4509.84,1042.61) v1@4509.84,1065.54 ; v1@4504.34,1075.04 cw(c4491.06,1075.04) 4500.45,1065.65 cw(c4509.84,1056.26) v1@4509.84,1069.54
  Bottom Layer w4: J33.B42@-785.98,2574.12 -668.73,2574.12 -667.81,2575.04 ; J33.B42@-711.58,2568.62 cw(c-698.3,2555.34) -698.3,2574.12 cw(c-698.3,2592.9) J33.B42@-711.58,2579.62 ; J33.B42@-708.76,2565.79 cw(c-688.65,2545.68) -688.65,2574.12 cw(c-688.65,2602.56) J33.B42@-708.76,2582.45 ; v1@-659.73,2570.34 ccw(c-667.81,2565.75) -667.81,2575.04 ; v1@-659.73,2579.74 cw(c-667.81,2584.33) -667.81,2575.04 ; v1(-651.48,2575.04) -667.81,2575.04 ; U3.4@4295,1123.23 4335.34,1123.23 4383.52,1075.04 v1(4509.84,1075.04) ; U3.4@4324.31,1120.4 cw(c4331.14,1113.57) 4331.14,1123.23 cw(c4331.14,1132.89) U3.4@4324.31,1126.06 ; v1@4503.12,1068.32 ccw(c4486.9,1052.11) 4486.9,1075.04 ccw(c4486.9,1097.98) v1@4503.12,1081.76 ; v1@4505.95,1071.15 ccw(c4496.56,1061.76) 4496.56,1075.04 ccw(c4496.56,1088.32) v1@4505.95,1078.93
ATE.SPDIF.OUT: J33.B41 U3.11 U8.AH6 | length 11496.4
  Top Layer w4: v1(-609.81,2600.04) -565,2600.04 -550,2585.04 -550,2370.18 -529.87,2350.04 -351.48,2350.04 -327.52,2326.08 -327.52,1799.35 -459.83,1667.04 -506.1,1667.04 -518.14,1655 v1(-518.14,1491.71) ; v1@-605.92,2596.15 cw(c-596.53,2586.76) -596.53,2600.04 cw(c-596.53,2613.32) v1@-605.92,2603.93 ; v1@-603.09,2593.32 cw(c-586.87,2577.11) -586.87,2600.04 cw(c-586.87,2622.98) v1@-603.09,2606.76 ; v1@-524.86,1498.43 ccw(c-541.08,1514.64) -518.14,1514.64 ccw(c-495.21,1514.64) v1@-511.43,1498.43 ; v1@-522.03,1495.6 ccw(c-531.42,1504.99) -518.14,1504.99 ccw(c-504.86,1504.99) v1@-514.25,1495.6 ; v1(4155,1116.71) 4558.29,1116.71 4592.79,1082.21 4675.45,999.55 4914.7,999.55 5056.86,1141.71 5056.86,1925.04 4880,2101.9 4880,2395 4907.5,2422.5 4957.25,2422.5 4967.5,2432.75 4967.5,2442.75 4907,2503.25 4907,3167 5014.71,3274.71 5064.19,3324.19 5064.19,3350.04 5058.52,3355.71 5026.19,3355.71 5023.52,3358.37 5023.52,3443.54 4997.56,3469.5 4975.56,3469.5 4973.56,3467.5 4932.75,3467.5 4907.5,3492.75 4907.5,3507.25 4917.75,3517.5 4953.69,3517.5 ; v1@4158.89,1112.82 cw(c4168.28,1103.43) 4168.28,1116.71 cw(c4168.28,1129.99) v1@4158.89,1120.6 ; v1@4161.72,1109.99 cw(c4177.93,1093.77) 4177.93,1116.71 cw(c4177.93,1139.64) v1@4161.72,1123.43 ; U8.AH6@5050.16,3653.31 cw(c5037.63,3640.78) 5055.35,3640.78 cw(c5073.08,3640.78) U8.AH6@5060.55,3653.31 ; U8.AH6@5055.35,3658.5 5055.35,3638.82 5055.35,3630.82 5055.35,3615.35 5054,3614 5054,3558.31 5010.59,3514.9 4987.23,3514.9 4978.04,3514.9 4956.28,3514.9 ; 4953.69,3517.5 4956.28,3514.9 ; 4953.69,3517.5 4956.28,3514.9
  Bottom Layer w4: J33.B41@-768.14,2600.04 v1(-609.81,2600.04) ; J33.B41@-722.9,2607.68 ccw(c-704.46,2626.12) -704.46,2600.04 ; J33.B41@-720.07,2610.51 ccw(c-694.8,2635.77) -694.8,2600.04 ; J33.B41@-717.24,2613.34 ccw(c-685.15,2645.43) -685.15,2600.04 ; J33.B41@-714.41,2616.16 ccw(c-675.49,2655.09) -675.49,2600.04 ; J33.B41@-711.58,2618.99 ccw(c-665.83,2664.74) -665.83,2600.04 ; J33.B41@-708.76,2621.82 ccw(c-656.17,2674.4) -656.17,2600.04 ; v1@-616.53,2593.32 ccw(c-632.74,2577.11) -632.74,2600.04 ccw(c-632.74,2622.98) v1@-616.53,2606.76 ; v1@-613.7,2596.15 ccw(c-623.09,2586.76) -623.09,2600.04 ccw(c-623.09,2613.32) v1@-613.7,2603.93 ; v1(-518.14,1491.71) -187.79,1491.71 -63.12,1367.04 3620,1367.04 3670,1317.04 3670,985 3675,980 3710,980 3720,990 3720,1170 3730,1180 3850,1180 3875,1155 3928.23,1155 3960,1123.23 U3.11@4076.5,1123.23 4115.19,1123.23 4115.19,1123.04 4121.52,1116.71 v1(4155,1116.71) ; U3.11@4047.19,1120.4 ccw(c4040.36,1113.57) 4040.36,1123.23 ccw(c4040.36,1132.88) U3.11@4047.19,1126.06 ; U3.11@4105.8,1120.4 cw(c4112.63,1113.57) 4112.63,1123.23 cw(c4112.63,1132.89) U3.11@4105.8,1126.06 ; v1@4148.28,1109.99 ccw(c4132.06,1093.77) 4132.06,1116.71 ccw(c4132.06,1139.64) v1@4148.28,1123.43 ; v1@4151.11,1112.82 ccw(c4141.72,1103.43) 4141.72,1116.71 ccw(c4141.72,1129.99) v1@4151.11,1120.6
ATE.UIO.IO0: J33.A19 PROTOTYPE1.B1 U8.N4 UH1.2 | length 9028.8
  Top Layer w4: J33.A19@-785.98,3479.63 -575.55,3479.63 v1(-532.81,3522.37) ; J33.A19@-711.58,3474.13 cw(c-698.3,3460.85) -698.3,3479.63 cw(c-698.3,3498.41) J33.A19@-711.58,3485.13 ; J33.A19@-708.76,3471.3 cw(c-688.65,3451.19) -688.65,3479.63 cw(c-688.65,3508.07) J33.A19@-708.76,3487.96 ; v1@-542.31,3522.37 cw(c-565.24,3522.37) -549.03,3506.16 cw(c-532.81,3489.94) v1@-532.81,3512.87 ; v1@-538.31,3522.37 cw(c-551.59,3522.37) -542.2,3512.99 cw(c-532.81,3503.6) v1@-532.81,3516.87 ; v3(4956.93,4268.74) U8.N4@4976.61,4249.05 ; U8.N4@4969.27,4249.05 ccw(c4951.55,4249.05) 4964.08,4261.59 ccw(c4976.61,4274.12) U8.N4@4976.61,4256.4 ; 4969.73,4255.94 cw(c4982.54,4268.74) 4964.43,4268.74 ccw(c4982.54,4268.74) 4969.73,4255.94 ; 4969.73,4255.94 ccw(c4956.93,4243.13) 4956.93,4261.24 cw(c4956.93,4243.13) 4969.73,4255.94
  MidLayer1 w4: PROTOTYPE1.B1@247.22,4010.62 ccw(c194.34,4014.98) 231.86,4052.5 ; PROTOTYPE1.B1@251.21,4010.29 ccw(c205.62,4014.05) 237.96,4046.39 ccw(c270.3,4078.73) PROTOTYPE1.B1@274.07,4033.15 ; PROTOTYPE1.B1@255.19,4009.96 ccw(c216.9,4013.12) 244.07,4040.29 ccw(c271.24,4067.45) PROTOTYPE1.B1@274.39,4029.16 ; PROTOTYPE1.B1@259.18,4009.63 ccw(c228.18,4012.19) 250.17,4034.18 ccw(c272.17,4056.17) PROTOTYPE1.B1@274.72,4025.18 ; PROTOTYPE1.B1@273.74,4037.14 cw(c269.37,4090.01) 231.86,4052.5 ; PROTOTYPE1.B1@276.12,4008.23 231.86,4052.5 ; 931.03,4771.03 cw(c976.12,4725.94) UH1.2@976.12,4789.71 ; 931.17,4771.17 ccw(c889.11,4813.23) UH1.2@948.59,4813.23 ; 937.86,4777.86 cw(c976.12,4739.59) UH1.2@976.12,4793.71 ; 938,4778 ccw(c902.76,4813.23) UH1.2@952.59,4813.23 ; 944.69,4784.69 cw(c976.12,4753.25) UH1.2@976.12,4797.71 ; 944.83,4784.83 ccw(c916.42,4813.23) UH1.2@956.59,4813.23 ; 951.51,4791.51 cw(c976.12,4766.91) UH1.2@976.12,4801.71 ; 951.66,4791.66 ccw(c930.08,4813.23) UH1.2@960.59,4813.23 ; UH1.2@976.12,4813.23 973.23,4813.23 431.86,4271.86 431.86,4200.04 398.52,4166.71 265.19,4166.71 231.86,4133.37 231.86,4052.5 ; v1(4700,4283) 4715.5,4298.5 4715.5,4312.25 4725.75,4322.5 4740.25,4322.5 4750.5,4312.25 4756.25,4306.5 ; v3@4951.74,4263.55 ccw(c4939.2,4251.01) 4939.2,4268.74 ccw(c4939.2,4286.47) v3@4951.74,4273.93 ; v3(4956.93,4268.74) 4898.67,4268.74 4879.25,4268.74 4838.82,4268.74 4830.82,4268.74 4824.76,4268.74 4787,4306.5 4770,4306.5 ; 4756.25,4306.5 4770,4306.5 ; 4756.25,4306.5 4770,4306.5 ; 4938.82,4268.74 cw(c4938.82,4250.63) 4951.63,4263.44 ccw(c4938.82,4250.63) 4938.82,4268.74 ; 4938.82,4268.74 ccw(c4938.82,4286.85) 4951.63,4274.04 cw(c4938.82,4286.85) 4938.82,4268.74
  MidLayer2 w4: v1@-539.53,3529.09 ccw(c-555.74,3545.31) -532.81,3545.31 ccw(c-509.87,3545.31) v1@-526.09,3529.09 ; v1@-536.7,3526.26 ccw(c-546.09,3535.65) -532.81,3535.65 ccw(c-519.53,3535.65) v1@-528.92,3526.26 ; v1(-532.81,3522.37) -532.81,3550.5 -552.31,3570 -552.31,3617.32 -500.71,3668.93 -449,3720.63 -449,3979.89 -430.84,3998.05 -370.51,4058.37 -189.77,4058.37 -172.9,4041.5 -111.5,4041.5 -90.78,4020.78 -25.87,3955.87 223.76,3955.87 PROTOTYPE1.B1@276.12,4008.23 ; PROTOTYPE1.B1@247.12,4008.23 cw(c177.11,4008.23) 226.62,3958.73 cw(c276.12,3909.22) PROTOTYPE1.B1@276.12,3979.23 ; PROTOTYPE1.B1@251.12,4008.23 cw(c190.77,4008.23) 233.44,3965.56 cw(c276.12,3922.88) PROTOTYPE1.B1@276.12,3983.23 ; PROTOTYPE1.B1@255.12,4008.23 cw(c204.42,4008.23) 240.27,3972.39 cw(c276.12,3936.54) PROTOTYPE1.B1@276.12,3987.23 ; PROTOTYPE1.B1@259.12,4008.23 cw(c218.08,4008.23) 247.1,3979.21 cw(c276.12,3950.19) PROTOTYPE1.B1@276.12,3991.23 ; PROTOTYPE1.B1@263.12,4008.23 cw(c231.74,4008.23) 253.93,3986.04 cw(c276.12,3963.85) PROTOTYPE1.B1@276.12,3995.23
  Bottom Layer w4: UH1.2@976.12,4813.23 1037.93,4875.04 1623.52,4875.04 1640.19,4858.37 1640.19,4691.71 1656.86,4675.04 1698.52,4675.04 1715.19,4691.71 1715.19,4728.02 1745.87,4758.7 1901.3,4758.7 2076.29,4583.71 4139.86,4583.71 4398.52,4325.04 4552.78,4325.04 4604.22,4273.59 4634.34,4273.59 4646.44,4261.5 4678.5,4261.5 v1(4700,4283) ; UH1.2@976.12,4828.76 ccw(c976.12,4866.25) 1002.63,4839.74 ccw(c1029.14,4813.23) UH1.2@991.65,4813.23 ; UH1.2@976.12,4832.76 ccw(c976.12,4879.91) 1009.46,4846.57 ccw(c1042.79,4813.23) UH1.2@995.65,4813.23 ; UH1.2@976.12,4836.76 ccw(c976.12,4893.56) 1016.29,4853.4 ccw(c1056.45,4813.23) UH1.2@999.65,4813.23 ; UH1.2@976.12,4840.76 ccw(c976.12,4907.22) 1023.11,4860.23 ccw(c1070.11,4813.23) UH1.2@1003.65,4813.23
ATE.UIO.IO1: J33.A17 PROTOTYPE1.A1 U8.R6 UH1.3 | length 9003.1
  Top Layer w4: J33.A17@-785.98,3558.37 -777.65,3566.71 v1(-618.14,3566.71) ; J33.A17@-717.24,3558.53 cw(c-697.49,3538.78) -697.49,3566.71 ; J33.A17@-714.41,3555.7 cw(c-687.84,3529.13) -687.84,3566.71 ; J33.A17@-711.58,3552.87 cw(c-678.18,3519.47) -678.18,3566.71 ; J33.A17@-708.76,3550.04 cw(c-668.52,3509.81) -668.52,3566.71 ; v1@-624.86,3559.99 ccw(c-641.08,3543.77) -641.08,3566.71 ccw(c-641.08,3589.64) v1@-624.86,3573.43 ; v1@-622.03,3562.82 ccw(c-631.42,3553.43) -631.42,3566.71 ccw(c-631.42,3579.99) v1@-622.03,3570.6 ; v3(5035.67,4150.63) U8.R6@5055.35,4170.31 ; U8.R6@5048.01,4170.31 cw(c5030.29,4170.31) 5042.82,4157.78 cw(c5055.35,4145.25) U8.R6@5055.35,4162.97 ; 5048.47,4163.43 cw(c5035.67,4176.24) 5035.67,4158.13 ccw(c5035.67,4176.24) 5048.47,4163.43 ; 5048.47,4163.43 ccw(c5061.28,4150.63) 5043.17,4150.63 cw(c5061.28,4150.63) 5048.47,4163.43
  MidLayer1 w4: PROTOTYPE1.A1@276.12,4108.23 315.19,4108.23 ; PROTOTYPE1.A1@300.05,4101 cw(c309.8,4098.05) 309.8,4108.23 cw(c309.8,4118.42) PROTOTYPE1.A1@300.05,4115.47 ; PROTOTYPE1.A1@303.88,4099.84 cw(c315.19,4096.42) 315.19,4108.23 ; PROTOTYPE1.A1@303.88,4116.63 ccw(c315.19,4120.05) 315.19,4108.23 ; UH1.3@1048.59,4713.23 cw(c982.14,4713.23) 1029.13,4666.24 cw(c1076.12,4619.25) UH1.3@1076.12,4685.71 ; UH1.3@1052.59,4713.23 cw(c995.79,4713.23) 1035.96,4673.07 cw(c1076.12,4632.91) UH1.3@1076.12,4689.71 ; UH1.3@1056.59,4713.23 cw(c1009.45,4713.23) 1042.79,4679.9 cw(c1076.12,4646.56) UH1.3@1076.12,4693.71 ; UH1.3@1060.59,4713.23 cw(c1023.11,4713.23) 1049.61,4686.73 cw(c1076.12,4660.22) UH1.3@1076.12,4697.71 ; UH1.3@1076.12,4713.23 957.5,4594.61 957.5,4582.75 947.25,4572.5 925,4572.5 902.5,4595 782.13,4595 515.19,4328.06 515.19,4275 515.19,4175.04 498.52,4158.37 365.33,4158.37 315.19,4108.23 ; v1(4666,4205) 4693.5,4232.5 4716.25,4232.5 4720.75,4228 4724,4228 4756.5,4195.5 4766.25,4195.5 4800,4161.75 4800,4135 4808.23,4126.77 4833.23,4126.77 4838.82,4126.77 4879.25,4126.77 4898.67,4126.77 4972.79,4126.77 4992.29,4126.77 ccw(c4992.29,4168.5) 5021.8,4138.99 ; v1@4666,4210.5 ccw(c4666,4223.78) 4675.39,4214.39 ccw(c4684.78,4205) v1@4671.5,4205 ; v1@4666,4214.5 ccw(c4666,4237.43) 4682.22,4221.22 ccw(c4698.43,4205) v1@4675.5,4205 ; v3@5028.2,4151.28 cw(c5010.16,4152.86) 5021.8,4138.99 ; v3@5035.02,4143.16 ccw(c5033.44,4125.12) 5021.8,4138.99
  Bottom Layer w4: v1(-618.14,3566.71) -580,3566.71 -575,3561.71 -575,3515 -553,3493 -162,3493 -152.79,3502.21 -24.11,3502.21 15,3541.31 15,3805.59 3.88,3816.71 -68.14,3816.71 -100.64,3849.2 -109.51,3858.07 -109.51,3945.49 5,4060 150,4060 198.23,4108.23 PROTOTYPE1.A1@276.12,4108.23 ; v1@-614.25,3562.82 cw(c-604.86,3553.43) -604.86,3566.71 cw(c-604.86,3579.99) v1@-614.25,3570.6 ; v1@-611.43,3559.99 cw(c-595.21,3543.77) -595.21,3566.71 cw(c-595.21,3589.64) v1@-611.43,3573.43 ; PROTOTYPE1.A1@255.62,4087.73 ccw(c206.11,4038.22) 206.11,4108.23 ccw(c206.11,4178.25) PROTOTYPE1.A1@255.62,4128.74 ; PROTOTYPE1.A1@258.44,4090.56 ccw(c215.77,4047.88) 215.77,4108.23 ccw(c215.77,4168.59) PROTOTYPE1.A1@258.44,4125.91 ; PROTOTYPE1.A1@261.27,4093.39 ccw(c225.42,4057.54) 225.42,4108.23 ccw(c225.42,4158.93) PROTOTYPE1.A1@261.27,4123.08 ; PROTOTYPE1.A1@264.1,4096.21 ccw(c235.08,4067.19) 235.08,4108.23 ccw(c235.08,4149.28) PROTOTYPE1.A1@264.1,4120.26 ; PROTOTYPE1.A1@266.93,4099.04 ccw(c244.74,4076.85) 244.74,4108.23 ccw(c244.74,4139.62) PROTOTYPE1.A1@266.93,4117.43 ; UH1.3@1076.12,4713.23 1112.93,4750.04 ; UH1.3@1079.76,4732.42 ccw(c1084.45,4757.12) 1102.23,4739.34 ccw(c1120.01,4721.56) UH1.3@1095.31,4716.88 ; UH1.3@1080.51,4736.35 ccw(c1086.16,4766.11) 1107.58,4744.69 ccw(c1129,4723.27) UH1.3@1099.24,4717.62 ; UH1.3@1081.25,4740.28 ccw(c1087.86,4775.1) 1112.93,4750.04 ; UH1.3@1103.17,4718.37 cw(c1137.99,4724.98) 1112.93,4750.04 ; v1@4659.28,4198.28 cw(c4643.06,4182.06) 4666,4182.06 cw(c4688.93,4182.06) v1@4672.72,4198.28 ; v1@4662.11,4201.11 cw(c4652.72,4191.72) 4666,4191.72 cw(c4679.28,4191.72) v1@4669.89,4201.11 ; v1(4666,4205) 4666,4193.25 4666,4181.5 4655.31,4170.81 4643.56,4170.81 4635,4170.81 4589.07,4170.81 4534,4225.88 4534,4233.82 4514,4253.81 4506.07,4253.81 4487.03,4253.81 4449.13,4291.71 4430,4291.71 4342.48,4291.71 4332.38,4301.81 4317.62,4301.81 4297.35,4281.54 4246.29,4281.54 4214.36,4313.48 4214.36,4372.5 4225,4383.14 4225,4455 4215,4465 3483.56,4465 3448.19,4500.37 1356.48,4500.37 1331.86,4525 1331.86,4733.37 1315.19,4750.04 1112.93,4750.04
ATE.UIO.IO2: J33.A11 PROTOTYPE1.H1 U8.M8 UH1.4 | length 9602.7
  Top Layer w4: J33.A11@-785.98,3873.33 -692.96,3873.33 ; J33.A11@-710.95,3868.55 cw(c-701.15,3860.91) -701.15,3873.33 cw(c-701.15,3885.76) J33.A11@-710.95,3878.12 ; J33.A11@-707.8,3866.09 cw(c-692.96,3854.52) -692.96,3873.33 ; J33.A11@-707.8,3880.58 ccw(c-692.96,3892.15) -692.96,3873.33 ; v1@-566.72,3998.28 cw(c-582.94,3982.06) -560,3982.06 cw(c-537.07,3982.06) v1@-553.28,3998.28 ; v1@-563.89,4001.11 cw(c-573.28,3991.72) -560,3991.72 cw(c-546.72,3991.72) v1@-556.11,4001.11 ; v1(-560,4005) -560,3875 -569.63,3865.37 -685,3865.37 -692.96,3873.33 ; v3(5114.41,4308.11) U8.M8@5134.09,4288.42 ; U8.M8@5126.75,4288.42 ccw(c5109.03,4288.42) 5121.56,4300.96 ccw(c5134.09,4313.49) U8.M8@5134.09,4295.77 ; 5127.21,4295.31 cw(c5140.02,4308.11) 5121.91,4308.11 ccw(c5140.02,4308.11) 5127.21,4295.31 ; 5127.21,4295.31 ccw(c5114.41,4282.5) 5114.41,4300.61 cw(c5114.41,4282.5) 5127.21,4295.31
  MidLayer1 w4: PROTOTYPE1.H1@255.62,4228.74 ccw(c206.11,4278.25) 276.12,4278.25 ccw(c346.13,4278.25) PROTOTYPE1.H1@296.63,4228.74 ; PROTOTYPE1.H1@258.44,4225.91 ccw(c215.77,4268.59) 276.12,4268.59 ccw(c336.48,4268.59) PROTOTYPE1.H1@293.8,4225.91 ; PROTOTYPE1.H1@261.27,4223.08 ccw(c225.42,4258.93) 276.12,4258.93 ccw(c326.82,4258.93) PROTOTYPE1.H1@290.97,4223.08 ; PROTOTYPE1.H1@264.1,4220.26 ccw(c235.08,4249.28) 276.12,4249.28 ccw(c317.16,4249.28) PROTOTYPE1.H1@288.14,4220.26 ; PROTOTYPE1.H1@266.93,4217.43 ccw(c244.74,4239.62) 276.12,4239.62 ccw(c307.51,4239.62) PROTOTYPE1.H1@285.31,4217.43 ; v1@461.14,4393.32 ccw(c444.92,4377.11) 444.92,4400.04 ccw(c444.92,4422.98) v1@461.14,4406.76 ; v1@463.97,4396.15 ccw(c454.58,4386.76) 454.58,4400.04 ccw(c454.58,4413.32) v1@463.97,4403.93 ; v1@467.86,4405.54 ccw(c467.86,4418.82) 477.25,4409.43 ccw(c486.64,4400.04) v1@473.36,4400.04 ; v1@467.86,4409.54 ccw(c467.86,4432.48) 484.07,4416.26 ccw(c500.29,4400.04) v1@477.36,4400.04 ; v1@658.47,4901.66 ccw(c642.26,4885.44) 642.26,4908.37 ccw(c642.26,4931.31) v1@658.47,4915.09 ; v1@661.3,4904.49 ccw(c651.91,4895.1) 651.91,4908.37 ccw(c651.91,4921.65) v1@661.3,4912.26 ; v1(665.19,4908.37) 613.37,4908.37 598.52,4893.52 598.52,4530.71 v1(467.86,4400.04) 360.04,4400.04 276.12,4316.12 PROTOTYPE1.H1@276.12,4208.23 ; PROTOTYPE1.H1@276.12,4208.23 PROTOTYPE1.H1@276.12,4208.23 PROTOTYPE1.H1@276.12,4208.23
  MidLayer2 w4: v1(-560,4005) -520,4005 -497,4028 -497,4073.65 -300.14,4270.51 -300.14,4400.04 -382,4481.9 -386,4485.89 -386,4511.19 -360.31,4536.87 -338.31,4536.87 -330,4528.56 -330,4455.88 -215.5,4341.37 -22.21,4341.37 36.46,4400.04 v1(467.86,4400.04) 4145,4400.04 4160,4400.04 4173,4387.04 4173,4352 4200,4325 4270,4325 4278.81,4333.81 4345,4333.81 4367.32,4333.81 4407.67,4333.81 ; v1@-556.11,4001.11 cw(c-546.72,3991.72) -546.72,4005 cw(c-546.72,4018.28) v1@-556.11,4008.89 ; v1@-553.28,3998.28 cw(c-537.07,3982.06) -537.07,4005 cw(c-537.07,4027.93) v1@-553.28,4011.72 ; v1@461.14,4393.32 ccw(c444.92,4377.11) 444.92,4400.04 ccw(c444.92,4422.98) v1@461.14,4406.76 ; v1@463.97,4396.15 ccw(c454.58,4386.76) 454.58,4400.04 ccw(c454.58,4413.32) v1@463.97,4403.93 ; v1@471.75,4396.15 cw(c481.14,4386.76) 481.14,4400.04 cw(c481.14,4413.32) v1@471.75,4403.93 ; v1@474.57,4393.32 cw(c490.79,4377.11) 490.79,4400.04 cw(c490.79,4422.98) v1@474.57,4406.76 ; v1(665.19,4908.37) 980.98,4908.37 UH1.4@1076.12,4813.23 ; v1@669.08,4904.49 cw(c678.47,4895.1) 678.47,4908.37 cw(c678.47,4921.65) v1@669.08,4912.26 ; v1@671.91,4901.66 cw(c688.13,4885.44) 688.13,4908.37 cw(c688.13,4931.31) v1@671.91,4915.09 ; UH1.4@1048.59,4813.23 ccw(c982.14,4813.23) 1029.13,4860.23 ccw(c1076.12,4907.22) UH1.4@1076.12,4840.76 ; UH1.4@1052.59,4813.23 ccw(c995.79,4813.23) 1035.96,4853.4 ccw(c1076.12,4893.56) UH1.4@1076.12,4836.76 ; UH1.4@1056.59,4813.23 ccw(c1009.45,4813.23) 1042.79,4846.57 ccw(c1076.12,4879.91) UH1.4@1076.12,4832.76 ; UH1.4@1060.59,4813.23 ccw(c1023.11,4813.23) 1049.61,4839.74 ccw(c1076.12,4866.25) UH1.4@1076.12,4828.76 ; v3@5106.94,4307.46 ccw(c5088.9,4305.88) 5100.54,4319.75 ; v3@5113.76,4315.58 cw(c5112.18,4333.62) 5100.54,4319.75 ; 4407.67,4333.81 4409.27,4332.21 ; 4407.67,4333.81 4409.27,4332.21 ; 4409.27,4332.21 4442.54,4332.21 4466.1,4308.64 4558.6,4308.64 4605.75,4261.5 4667.56,4261.5 4682.5,4276.44 4682.5,4290.25 4692.75,4300.5 4707.25,4300.5 4720.25,4287.5 4749.5,4287.5 4766.5,4304.5 4775.56,4304.5 4803.03,4331.97 4838.82,4331.97 4841.47,4331.97 4899.73,4331.97 4957.99,4331.97 4977.41,4331.97 5051.53,4331.97 5071.03,4331.97 cw(c5071.03,4290.24) 5100.54,4319.75
ATE.UIO.IO3: J33.A14 PROTOTYPE1.H2 U8.R4 UH1.5 | length 10105.1
  Top Layer w4: J33.A14@-785.98,3676.48 -718.52,3676.48 -666,3729 -619,3729 v1(-600,3710) ; J33.A14@-717.08,3684.26 ccw(c-717.08,3699.59) J33.A14@-706.25,3688.75 ; J33.A14@-717.08,3688.26 ccw(c-717.08,3713.24) -699.42,3695.58 ; J33.A14@-709.3,3676.48 cw(c-687.07,3676.48) -702.79,3692.21 ; J33.A14@-705.3,3676.48 cw(c-673.41,3676.48) -695.96,3699.04 ; v1@-609.5,3710 ccw(c-632.44,3710) -616.22,3726.22 ccw(c-600,3742.43) v1@-600,3719.5 ; v1@-605.5,3710 ccw(c-618.78,3710) -609.39,3719.39 ccw(c-600,3728.78) v1@-600,3715.5 ; PROTOTYPE1.H2@355.62,4228.74 ccw(c306.11,4278.25) 376.12,4278.25 ccw(c446.13,4278.25) PROTOTYPE1.H2@396.63,4228.74 ; PROTOTYPE1.H2@358.44,4225.91 ccw(c315.77,4268.59) 376.12,4268.59 ccw(c436.48,4268.59) PROTOTYPE1.H2@393.8,4225.91 ; PROTOTYPE1.H2@361.27,4223.08 ccw(c325.42,4258.93) 376.12,4258.93 ccw(c426.82,4258.93) PROTOTYPE1.H2@390.97,4223.08 ; PROTOTYPE1.H2@364.1,4220.26 ccw(c335.08,4249.28) 376.12,4249.28 ccw(c417.16,4249.28) PROTOTYPE1.H2@388.14,4220.26 ; PROTOTYPE1.H2@366.93,4217.43 ccw(c344.74,4239.62) 376.12,4239.62 ccw(c407.51,4239.62) PROTOTYPE1.H2@385.31,4217.43 ; PROTOTYPE1.H2@376.12,4208.23 376.12,4369.81 490.02,4483.71 588.71,4483.71 692.81,4587.81 808.38,4587.81 837.81,4558.37 1059.84,4558.37 1123.52,4622.06 1123.52,4660.64 UH1.5@1176.12,4713.23 ; UH1.5@1148.59,4713.23 cw(c1082.14,4713.23) 1129.13,4666.24 cw(c1176.12,4619.25) UH1.5@1176.12,4685.71 ; UH1.5@1152.59,4713.23 cw(c1095.79,4713.23) 1135.96,4673.07 cw(c1176.12,4632.91) UH1.5@1176.12,4689.71 ; UH1.5@1156.59,4713.23 cw(c1109.45,4713.23) 1142.79,4679.9 cw(c1176.12,4646.56) UH1.5@1176.12,4693.71 ; UH1.5@1160.59,4713.23 cw(c1123.11,4713.23) 1149.61,4686.73 cw(c1176.12,4660.22) UH1.5@1176.12,4697.71 ; v3(4956.93,4150.63) U8.R4@4976.61,4170.31 ; U8.R4@4969.27,4170.31 cw(c4951.55,4170.31) 4964.08,4157.78 cw(c4976.61,4145.25) U8.R4@4976.61,4162.97 ; 4969.73,4163.43 cw(c4956.93,4176.24) 4956.93,4158.13 ccw(c4956.93,4176.24) 4969.73,4163.43 ; 4969.73,4163.43 ccw(c4982.54,4150.63) 4964.43,4150.63 cw(c4982.54,4150.63) 4969.73,4163.43
  MidLayer1 w4: UH1.5@1176.12,4713.23 1210,4679.36 1210,4598.19 1352.19,4456 1636,4456 1675,4495 1675,4605 1680,4610 1715,4610 1774.96,4550.04 4094.96,4550.04 4138.86,4506.14 v1(4138.86,4433.37) ; UH1.5@1181.1,4694.35 cw(c1186.14,4675.19) 1200.15,4689.2 cw(c1214.16,4703.21) UH1.5@1195,4708.26 ; UH1.5@1182.12,4690.48 cw(c1188.2,4667.4) 1205.08,4684.28 cw(c1221.95,4701.16) UH1.5@1198.87,4707.24 ; UH1.5@1183.13,4686.62 cw(c1190.25,4659.61) 1210,4679.36 cw(c1229.75,4699.11) UH1.5@1202.74,4706.22 ; v1@4132.14,4440.09 ccw(c4115.92,4456.31) 4138.86,4456.31 ccw(c4161.79,4456.31) v1@4145.57,4440.09 ; v1@4134.97,4437.26 ccw(c4125.58,4446.65) 4138.86,4446.65 ccw(c4152.14,4446.65) v1@4142.75,4437.26 ; v1@4650.76,4279.84 cw(c4638.8,4266.12) 4657,4266.12 ; v1@4653.39,4282.85 cw(c4646.47,4274.91) 4657,4274.91 cw(c4667.53,4274.91) v1@4660.61,4282.85 ; v1(4657,4287) 4657,4266.12 ; v1@4663.24,4279.84 ccw(c4675.2,4266.12) 4657,4266.12 ; v3@4951.74,4145.44 ccw(c4939.2,4132.9) 4939.2,4150.63 ccw(c4939.2,4168.36) v3@4951.74,4155.82 ; v3(4956.93,4150.63) 4898.67,4150.63 4879.25,4150.63 4838.82,4150.63 4830.82,4150.63 4824.37,4150.63 4816,4159 4816,4192.94 4769.94,4239 4721.06,4239 4719.56,4240.5 4682.62,4240.5 4657,4266.12 ; 4938.82,4150.63 cw(c4938.82,4132.52) 4951.63,4145.33 ccw(c4938.82,4132.52) 4938.82,4150.63 ; 4938.82,4150.63 ccw(c4938.82,4168.74) 4951.63,4155.93 cw(c4938.82,4168.74) 4938.82,4150.63
  MidLayer2 w4: v1@4138.86,4423.87 cw(c4138.86,4400.94) 4155.07,4417.16 cw(c4171.29,4433.37) v1@4148.36,4433.37 ; v1@4138.86,4427.87 cw(c4138.86,4414.6) 4148.25,4423.99 cw(c4157.64,4433.37) v1@4144.36,4433.37 ; v1(4138.86,4433.37) 4164.19,4408.04 4189.1,4383.13 4243.62,4383.13 4365,4383.13 4376.87,4395 4408.53,4395 4420.39,4383.13 4478.53,4325 4564.87,4325 4602.87,4287 v1(4657,4287) ; v1@4650.28,4280.28 ccw(c4634.06,4264.06) 4634.06,4287 ccw(c4634.06,4309.93) v1@4650.28,4293.72 ; v1@4653.11,4283.11 ccw(c4643.72,4273.72) 4643.72,4287 ccw(c4643.72,4300.28) v1@4653.11,4290.89
  Bottom Layer w4: v1(-600,3710) -570.78,3739.22 -455.78,3739.22 -427,3768 -427,4343 -400,4370 -310,4370 -290,4390 -290,4465 -260,4495 -135,4495 -88.29,4541.71 321.67,4541.71 355,4508.37 436.15,4508.37 594.48,4666.71 1129.59,4666.71 ; v1@-600,3715.5 ccw(c-600,3728.78) -590.61,3719.39 ccw(c-581.22,3710) v1@-594.5,3710 ; v1@-600,3719.5 ccw(c-600,3742.43) -583.78,3726.22 ccw(c-567.57,3710) v1@-590.5,3710 ; UH1.5@1148.59,4713.04 cw(c1083.73,4712.58) 1129.6,4666.71 ; UH1.5@1152.59,4713.07 cw(c1097.15,4712.67) 1136.36,4673.47 cw(c1175.56,4634.27) UH1.5@1175.95,4689.71 ; UH1.5@1156.59,4713.1 cw(c1110.58,4712.77) 1143.12,4680.23 cw(c1175.66,4647.69) UH1.5@1175.98,4693.71 ; UH1.5@1160.59,4713.12 cw(c1124.01,4712.86) 1149.88,4686.99 cw(c1175.75,4661.12) UH1.5@1176.01,4697.71 ; UH1.5@1175.93,4685.71 ccw(c1175.46,4620.84) 1129.6,4666.71 ; UH1.5@1176.12,4713.23 1129.59,4666.71
ATE.UIO.IO4: J33.A15 PROTOTYPE1.H3 U8.M4 UH1.6 | length 8619.1
  Top Layer w4: J33.A15@-785.98,3637.11 -697.93,3637.11 ; J33.A15@-706.57,3631.8 cw(c-697.93,3627.43) -697.93,3637.11 ; J33.A15@-706.57,3642.43 ccw(c-697.93,3646.8) -697.93,3637.11 ; v1@-591.72,3638.28 ccw(c-607.94,3622.06) -607.94,3645 ccw(c-607.94,3667.93) v1@-591.72,3651.72 ; v1@-588.89,3641.11 ccw(c-598.28,3631.72) -598.28,3645 ccw(c-598.28,3658.28) v1@-588.89,3648.89 ; v1(-585,3645) -690.04,3645 -691.7,3643.34 -697.93,3637.11 ; v3(4956.93,4308.11) U8.M4@4976.61,4288.42 ; U8.M4@4969.27,4288.42 ccw(c4951.55,4288.42) 4964.08,4300.96 ccw(c4976.61,4313.49) U8.M4@4976.61,4295.77 ; 4969.73,4295.31 cw(c4982.54,4308.11) 4964.43,4308.11 ccw(c4982.54,4308.11) 4969.73,4295.31 ; 4969.73,4295.31 ccw(c4956.93,4282.5) 4956.93,4300.61 cw(c4956.93,4282.5) 4969.73,4295.31
  MidLayer1 w4: PROTOTYPE1.H3@455.62,4228.74 ccw(c406.11,4278.25) 476.12,4278.25 ccw(c546.13,4278.25) PROTOTYPE1.H3@496.63,4228.74 ; PROTOTYPE1.H3@458.44,4225.91 ccw(c415.77,4268.59) 476.12,4268.59 ccw(c536.48,4268.59) PROTOTYPE1.H3@493.8,4225.91 ; PROTOTYPE1.H3@461.27,4223.08 ccw(c425.42,4258.93) 476.12,4258.93 ccw(c526.82,4258.93) PROTOTYPE1.H3@490.97,4223.08 ; PROTOTYPE1.H3@464.1,4220.26 ccw(c435.08,4249.28) 476.12,4249.28 ccw(c517.16,4249.28) PROTOTYPE1.H3@488.14,4220.26 ; PROTOTYPE1.H3@466.93,4217.43 ccw(c444.74,4239.62) 476.12,4239.62 ccw(c507.51,4239.62) PROTOTYPE1.H3@485.31,4217.43 ; PROTOTYPE1.H3@476.12,4208.23 476.12,4300.3 950.86,4775.04 1090.19,4775.04 1128.38,4813.23 ; UH1.6@1152.3,4799.45 ccw(c1128.39,4785.61) 1128.39,4813.23 ; UH1.6@1152.3,4827.02 cw(c1128.39,4840.86) 1128.39,4813.23 ; UH1.6@1155.76,4801.45 ccw(c1135.32,4789.62) 1135.32,4813.23 ccw(c1135.32,4836.84) UH1.6@1155.76,4825.02 ; UH1.6@1159.22,4803.45 ccw(c1142.26,4793.64) 1142.26,4813.23 ccw(c1142.26,4832.83) UH1.6@1159.22,4823.02 ; UH1.6@1176.12,4813.23 1128.38,4813.23 ; v1(4615.5,4306.31) 4616.5,4306.31 4630.69,4320.5 4680,4320.5 4684.94,4315.56 4707.5,4315.56 4730.44,4338.5 4747.25,4338.5 4759.25,4350.5 4769.25,4350.5 4782.5,4337.25 4782.5,4327.19 4801.58,4308.11 4831.89,4308.11 4838.82,4308.11 4879.25,4308.11 4898.67,4308.11 v3(4956.93,4308.11) ; v3@4951.63,4302.81 ccw(c4938.82,4290) 4938.82,4308.11 ccw(c4938.82,4326.22) v3@4951.63,4313.41 ; v3@4951.74,4302.92 ccw(c4939.2,4290.38) 4939.2,4308.11 ccw(c4939.2,4325.84) v3@4951.74,4313.3
  MidLayer2 w4: v1(-585,3645) -585,3660.52 -584.81,3660.71 -526.48,3719.04 -481,3764.52 -481,4067.02 -230.98,4317.04 -153.67,4317.04 -120,4283.37 -68.14,4283.37 -26.48,4241.71 23.52,4241.71 40.19,4258.37 425.98,4258.37 PROTOTYPE1.H3@476.12,4208.23 ; PROTOTYPE1.H3@447.12,4208.23 ccw(c377.11,4208.23) 426.62,4257.74 ccw(c476.12,4307.25) PROTOTYPE1.H3@476.12,4237.23 ; PROTOTYPE1.H3@451.12,4208.23 ccw(c390.77,4208.23) 433.44,4250.91 ccw(c476.12,4293.59) PROTOTYPE1.H3@476.12,4233.23 ; PROTOTYPE1.H3@455.12,4208.23 ccw(c404.42,4208.23) 440.27,4244.08 ccw(c476.12,4279.93) PROTOTYPE1.H3@476.12,4229.23 ; PROTOTYPE1.H3@459.12,4208.23 ccw(c418.08,4208.23) 447.1,4237.26 ccw(c476.12,4266.28) PROTOTYPE1.H3@476.12,4225.23 ; PROTOTYPE1.H3@463.12,4208.23 ccw(c431.74,4208.23) 453.93,4230.43 ccw(c476.12,4252.62) PROTOTYPE1.H3@476.12,4221.23 ; UH1.6@1176.12,4813.23 1254.59,4891.71 v1(2206.86,4891.71) ; UH1.6@1176.12,4828.76 ccw(c1176.12,4866.25) 1202.63,4839.74 ccw(c1229.14,4813.23) UH1.6@1191.65,4813.23 ; UH1.6@1176.12,4832.76 ccw(c1176.12,4879.91) 1209.46,4846.57 ccw(c1242.79,4813.23) UH1.6@1195.65,4813.23 ; UH1.6@1176.12,4836.76 ccw(c1176.12,4893.56) 1216.29,4853.4 ccw(c1256.45,4813.23) UH1.6@1199.65,4813.23 ; UH1.6@1176.12,4840.76 ccw(c1176.12,4907.22) 1223.11,4860.23 ccw(c1270.11,4813.23) UH1.6@1203.65,4813.23 ; v1@2200.14,4884.99 ccw(c2183.92,4868.77) 2183.92,4891.71 ccw(c2183.92,4914.64) v1@2200.14,4898.43 ; v1@2202.97,4887.82 ccw(c2193.58,4878.43) 2193.58,4891.71 ccw(c2193.58,4904.99) v1@2202.97,4895.6
  Bottom Layer w4: v1@2206.86,4882.21 cw(c2206.86,4859.27) 2223.07,4875.49 cw(c2239.29,4891.71) v1@2216.36,4891.71 ; v1@2206.86,4886.21 cw(c2206.86,4872.93) 2216.25,4882.32 cw(c2225.64,4891.71) v1@2212.36,4891.71 ; v1(2206.86,4891.71) 2332.25,4766.31 2403.69,4766.31 2415.19,4754.81 2415.19,4679.81 2494.96,4600.04 4238.19,4600.04 4479.86,4358.37 4497.17,4341.04 4560.15,4341.04 4594.88,4306.31 ; v1@4608.28,4300.14 ccw(c4594.88,4288.68) 4594.88,4306.31 ; v1@4608.28,4312.49 cw(c4594.88,4323.95) 4594.88,4306.31 ; v1@4611.32,4302.74 ccw(c4603.56,4296.1) 4603.56,4306.31 ccw(c4603.56,4316.52) v1@4611.32,4309.89 ; v1(4615.5,4306.31) 4594.88,4306.31
ATE.UIO.IO5: J33.A16 PROTOTYPE1.H4 U8.N3 UH1.7 | length 8780.9
  Top Layer w4: J33.A16@-785.98,3597.74 -780.91,3602.81 -605.07,3602.81 -587.26,3585 v1(-415,3585) ; J33.A16@-714.41,3595.07 cw(c-695.72,3576.38) -695.72,3602.81 ; J33.A16@-711.58,3592.24 cw(c-686.07,3566.73) -686.07,3602.81 ; J33.A16@-708.76,3606.07 ccw(c-700.88,3613.95) -700.88,3602.81 ; v1@-421.72,3578.28 ccw(c-437.94,3562.06) -437.94,3585 ccw(c-437.94,3607.93) v1@-421.72,3591.72 ; v1@-418.89,3581.11 ccw(c-428.28,3571.72) -428.28,3585 ccw(c-428.28,3598.28) v1@-418.89,3588.89 ; PROTOTYPE1.H4@555.62,4228.74 ccw(c506.11,4278.25) 576.12,4278.25 ccw(c646.13,4278.25) PROTOTYPE1.H4@596.63,4228.74 ; PROTOTYPE1.H4@558.44,4225.91 ccw(c515.77,4268.59) 576.12,4268.59 ccw(c636.48,4268.59) PROTOTYPE1.H4@593.8,4225.91 ; PROTOTYPE1.H4@561.27,4223.08 ccw(c525.42,4258.93) 576.12,4258.93 ccw(c626.82,4258.93) PROTOTYPE1.H4@590.97,4223.08 ; PROTOTYPE1.H4@564.1,4220.26 ccw(c535.08,4249.28) 576.12,4249.28 ccw(c617.16,4249.28) PROTOTYPE1.H4@588.14,4220.26 ; PROTOTYPE1.H4@566.93,4217.43 ccw(c544.74,4239.62) 576.12,4239.62 ccw(c607.51,4239.62) PROTOTYPE1.H4@585.31,4217.43 ; PROTOTYPE1.H4@576.12,4208.23 576.12,4321.12 745,4490 785,4490 828.37,4533.37 v1(931.86,4533.37) ; v1@925.14,4526.66 ccw(c908.92,4510.44) 908.92,4533.37 ccw(c908.92,4556.31) v1@925.14,4540.09 ; v1@927.97,4529.49 ccw(c918.58,4520.1) 918.58,4533.37 ccw(c918.58,4546.65) v1@927.97,4537.26 ; v1@1175.14,4465.09 ccw(c1158.92,4481.31) 1181.86,4481.31 ccw(c1204.79,4481.31) v1@1188.57,4465.09 ; v1@1177.97,4462.26 ccw(c1168.58,4471.65) 1181.86,4471.65 ccw(c1195.14,4471.65) v1@1185.75,4462.26 ; v1(1181.86,4458.37) 1181.86,4491.71 1276.12,4585.97 UH1.7@1276.12,4713.23 ; UH1.7@1256.66,4693.77 cw(c1209.66,4646.78) 1276.12,4646.78 cw(c1342.58,4646.78) UH1.7@1295.59,4693.77 ; UH1.7@1259.48,4696.6 cw(c1219.32,4656.43) 1276.12,4656.43 cw(c1332.92,4656.43) UH1.7@1292.76,4696.6 ; UH1.7@1262.31,4699.43 cw(c1228.98,4666.09) 1276.12,4666.09 cw(c1323.26,4666.09) UH1.7@1289.93,4699.43 ; UH1.7@1265.14,4702.26 cw(c1238.63,4675.75) 1276.12,4675.75 cw(c1313.61,4675.75) UH1.7@1287.1,4702.26 ; v1@4381.86,4416.71 4400.48,4416.71 ; v1@4391.36,4411.82 cw(c4400.48,4405.75) 4400.48,4416.71 ; v1@4391.7,4421.8 ccw(c4400.48,4426.82) 4400.48,4416.71 ; 4740,4286.5 4725.31,4286.5 4678.19,4333.62 4678.19,4350.38 4678.5,4350.69 4678.5,4372.56 4663.56,4387.5 4642.44,4387.5 4638.44,4383.5 4559.35,4383.5 4513.35,4337.5 4479.68,4337.5 4400.48,4416.71 ; 4741.42,4287.1 4746.31,4292 4780.37,4292 4785.27,4287.1 4806.71,4287.1 4820.9,4272.92 4830.82,4272.92 4838.82,4272.92 4897.36,4272.92 cw(c4897.36,4234.24) 4924.71,4261.59 ; U8.N3@4929.9,4249.05 ccw(c4912.18,4249.05) 4924.71,4261.59 ; U8.N3@4937.24,4256.4 cw(c4937.24,4274.12) 4924.71,4261.59
  MidLayer2 w4: v1@-415,3575.5 cw(c-415,3552.56) -398.78,3568.78 cw(c-382.57,3585) v1@-405.5,3585 ; v1@-415,3579.5 cw(c-415,3566.22) -405.61,3575.61 cw(c-396.22,3585) v1@-409.5,3585 ; v1(-415,3585) -354.23,3524.23 -90.81,3524.23 -58.04,3557 178.04,3557 185,3550.04 v1(213.86,3550.04) ; v1@207.14,3543.32 ccw(c190.92,3527.11) 190.92,3550.04 ccw(c190.92,3572.98) v1@207.14,3556.76 ; v1@209.97,3546.15 ccw(c200.58,3536.76) 200.58,3550.04 ccw(c200.58,3563.32) v1@209.97,3553.93 ; v1(1181.86,4458.37) 4290.19,4458.37 4299.49,4449.07 4354.25,4449.07 4381.86,4421.46 v1@4381.86,4416.71 ; v1@1185.75,4454.49 cw(c1195.14,4445.1) 1195.14,4458.37 cw(c1195.14,4471.65) v1@1185.75,4462.26 ; v1@1188.57,4451.66 cw(c1204.79,4435.44) 1204.79,4458.37 cw(c1204.79,4481.31) v1@1188.57,4465.09 ; 4365.27,4438.05 cw(c4344.32,4417.09) v1@4373.95,4417.09 ; 4371.97,4431.35 ccw(c4383.45,4442.83) v1@4383.45,4426.59 ; 4372.1,4431.22 cw(c4357.97,4417.09) v1@4377.95,4417.09
  Bottom Layer w4: v1(213.86,3550.04) 315.04,3550.04 325,3560 325,4140 345,4160 527.89,4160 ; v1@217.75,3546.15 cw(c227.14,3536.76) 227.14,3550.04 cw(c227.14,3563.32) v1@217.75,3553.93 ; v1@220.57,3543.32 cw(c236.79,3527.11) 236.79,3550.04 cw(c236.79,3572.98) v1@220.57,3556.76 ; PROTOTYPE1.H4@547.13,4207.7 cw(c481.42,4206.47) 527.89,4160 ; PROTOTYPE1.H4@551.13,4207.77 cw(c494.48,4206.72) 534.54,4166.66 cw(c574.6,4126.59) PROTOTYPE1.H4@575.66,4183.24 ; PROTOTYPE1.H4@555.12,4207.84 cw(c507.54,4206.96) 541.19,4173.31 cw(c574.85,4139.66) PROTOTYPE1.H4@575.73,4187.24 ; PROTOTYPE1.H4@559.12,4207.92 cw(c520.61,4207.2) 547.85,4179.96 cw(c575.09,4152.72) PROTOTYPE1.H4@575.8,4191.24 ; PROTOTYPE1.H4@575.58,4179.24 ccw(c574.36,4113.53) 527.89,4160 ; PROTOTYPE1.H4@576.12,4208.23 527.89,4160 ; v1(931.86,4533.37) 1106.86,4533.37 v1(1181.86,4458.37) ; v1@935.75,4529.49 cw(c945.14,4520.1) 945.14,4533.37 cw(c945.14,4546.65) v1@935.75,4537.26 ; v1@938.57,4526.66 cw(c954.79,4510.44) 954.79,4533.37 cw(c954.79,4556.31) v1@938.57,4540.09 ; v1@1172.36,4458.37 ccw(c1149.42,4458.37) 1165.64,4474.59 ccw(c1181.86,4490.81) v1@1181.86,4467.87 ; v1@1176.36,4458.37 ccw(c1163.08,4458.37) 1172.47,4467.76 ccw(c1181.86,4477.15) v1@1181.86,4463.87
  other v1: 4383.45,4417.09