# Altium PCB NB3000AL.PcbDoc (part 68 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
PBIO.D41: EXTHDR1.84 U8.AB7 | length 6083.2
  Top Layer w4: EXTHDR1.84@835.33,2807.62 cw(c828.87,2798.58) 839.98,2798.58 ; EXTHDR1.84@839.98,2859.25 839.98,2798.58 ; EXTHDR1.84@844.63,2807.62 ccw(c851.09,2798.58) 839.98,2798.58 ; v1(850.52,2788.04) 839.98,2798.58 ; v3(5075.04,3875.04) U8.AB7@5094.72,3894.72 ; U8.AB7@5087.38,3894.72 cw(c5069.66,3894.72) 5082.19,3882.19 cw(c5094.72,3869.66) U8.AB7@5094.72,3887.38 ; 5087.84,3887.84 cw(c5075.04,3900.65) 5075.04,3882.54 ccw(c5075.04,3900.65) 5087.84,3887.84 ; 5087.84,3887.84 ccw(c5100.65,3875.04) 5082.54,3875.04 cw(c5100.65,3875.04) 5087.84,3887.84
  MidLayer1 w4: v1@843.81,2794.76 ccw(c827.59,2810.98) 850.52,2810.98 ccw(c873.46,2810.98) v1@857.24,2794.76 ; v1@846.64,2791.93 ccw(c837.25,2801.32) 850.52,2801.32 ccw(c863.8,2801.32) v1@854.41,2791.93 ; v1(850.52,2788.04) 850.52,3029.21 879.02,3057.71 1021.39,3057.71 1030,3066.31 1030,3198.18 1088.77,3256.96 1140.19,3308.37 1231.86,3308.37 1248.52,3325.04 v1(1248.52,3366.71) ; v1@1241.81,3359.99 cw(c1225.59,3343.77) 1248.52,3343.77 cw(c1271.46,3343.77) v1@1255.24,3359.99 ; v1@1244.64,3362.82 cw(c1235.25,3353.43) 1248.52,3353.43 cw(c1261.8,3353.43) v1@1252.41,3362.82
  Bottom Layer w4: v1@1248.52,3357.21 cw(c1248.52,3334.27) 1264.74,3350.49 cw(c1280.96,3366.71) v1@1258.02,3366.71 ; v1@1248.52,3361.21 cw(c1248.52,3347.93) 1257.91,3357.32 cw(c1267.3,3366.71) v1@1254.02,3366.71 ; v1(1248.52,3366.71) 1274.19,3341.04 1780.15,3341.04 1787.82,3333.37 3490.19,3333.37 3531.86,3375.04 3531.86,3941.71 3548.52,3958.37 3651.51,3958.37 3726.84,4033.71 3885,4033.71 3920.83,4069.54 4012.56,4069.54 4049.31,4032.79 4190,4032.79 4232.25,4075.04 4676.02,4075.04 4706.5,4044.56 4706.5,3967.19 4732.19,3941.5 4732.19,3902.38 4727.19,3897.38 4727.19,3838.31 4742.81,3822.69 4742.81,3802.44 4772.72,3772.53 4830.82,3772.53 4838.82,3772.53 4840.41,3772.53 4898.67,3772.53 4956.93,3772.53 ccw(c4956.93,3796.3) 4980.7,3796.3 cw(c4996.3,3796.3) 4996.3,3811.9 ccw(c4996.3,3835.67) 5020.07,3835.67 cw(c5035.67,3835.67) 5035.67,3851.27 ccw(c5035.67,3875.04) 5052.48,3858.23 5060.21,3864.65 ; v3@5067.65,3876.34 cw(c5049.82,3879.49) 5060.21,3864.65 ; v3@5073.74,3867.65 ccw(c5070.59,3849.82) 5060.21,3864.65
PBIO.D42: EXTHDR1.86 U8.W2 | length 6040.3
  Top Layer w4: EXTHDR1.86@803.22,2808.11 cw(c793.09,2796.51) 808.49,2796.51 ; EXTHDR1.86@808.49,2859.25 808.49,2796.51 ; EXTHDR1.86@813.75,2808.11 ccw(c823.89,2796.51) 808.49,2796.51 ; v1(814.19,2716.71) 825,2727.52 825,2780 808.49,2796.51 ; v1@4682.06,4016.37 4753.63,4016.37 4772.67,3997.33 4830.82,3997.33 4838.82,3997.33 4878.16,3997.33 ; 4878.16,3997.33 ccw(c4878.16,4007.48) 4885.34,4000.3 ; 4878.16,3997.33 ccw(c4878.16,4007.48) 4885.34,4000.3 ; 4885.34,4000.3 ccw(c4872.81,4012.83) 4890.53,4012.83 cw(c4872.81,4012.83) 4885.34,4000.3 ; 4885.34,4000.3 cw(c4897.87,3987.77) 4897.87,4005.49 ccw(c4897.87,3987.77) 4885.34,4000.3
  MidLayer1 w4: v1(2423.52,2425.04) 2473.52,2475.04 3073.52,2475.04 3090.19,2491.71 3090.19,2625.04 3140.19,2675.04 3140.19,3022.06 3473.52,3355.39 3473.52,3775.04 3515.19,3816.71 v1(3684.86,3816.71) ; v1@2423.52,2430.54 ccw(c2423.52,2443.82) 2432.91,2434.43 ccw(c2442.3,2425.04) v1@2429.02,2425.04 ; v1@2423.52,2434.54 ccw(c2423.52,2457.48) 2439.74,2441.26 ccw(c2455.96,2425.04) v1@2433.02,2425.04 ; v1@3678.14,3809.99 ccw(c3661.92,3793.77) 3661.92,3816.71 ccw(c3661.92,3839.64) v1@3678.14,3823.43 ; v1@3680.97,3812.82 ccw(c3671.58,3803.43) 3671.58,3816.71 ccw(c3671.58,3829.99) v1@3680.97,3820.6
  Bottom Layer w4: v1(814.19,2716.71) 1046.77,2716.71 1080.44,2750.37 1089.6,2750.37 1103.68,2736.3 ; v1@818.08,2712.82 cw(c827.47,2703.43) 827.47,2716.71 cw(c827.47,2729.99) v1@818.08,2720.6 ; v1@820.91,2709.99 cw(c837.13,2693.77) 837.13,2716.71 cw(c837.13,2739.64) v1@820.91,2723.43 ; 1103.63,2736.25 1122.5,2717.37 1520.23,2717.37 1561.9,2675.71 1644.29,2675.71 1750,2570 1865,2570 2009.96,2425.04 v1(2423.52,2425.04) ; v1@2416.81,2418.32 ccw(c2400.59,2402.11) 2400.59,2425.04 ccw(c2400.59,2447.98) v1@2416.81,2431.76 ; v1@2419.64,2421.15 ccw(c2410.25,2411.76) 2410.25,2425.04 ccw(c2410.25,2438.32) v1@2419.64,2428.93 ; v1(3684.86,3816.71) 3690.44,3816.71 3707.94,3834.21 ; v1@3684.99,3818.2 ccw(c3686.23,3831.77) 3695.87,3822.14 ; v1@3685.36,3822.19 ccw(c3687.24,3842.83) 3701.91,3828.17 ; v1@3685.72,3826.17 ccw(c3688.26,3853.89) 3707.94,3834.21 ; v1@3694.36,3816.71 cw(c3703.81,3816.71) 3697.13,3823.39 ; 4659.13,3993.44 cw(c4681,3971.57) v1@4681,4002.5 ; 4665.96,4000.27 cw(c4681,3985.23) v1@4681,4006.5 ; 4667.12,4001.43 ccw(c4656.56,4012) v1@4671.5,4012 ; v1@4678.52,4012.83 4645.19,3979.5 4540,3979.5 4475,3979.5 4448.52,3953.02 4448.52,3947.06 4448.52,3935 4448.52,3903.22 4437.52,3892.21 4390.69,3892.21 4356.86,3858.37 4098.52,3858.37 4066.02,3825.87 3951.61,3825.87 3941.61,3815.87 3924.13,3815.87 3905.79,3834.21 3707.94,3834.21
  other v1: 4681,4012
PBIO.D43: EXTHDR1.88 U8.U8 | length 6776.2
  Top Layer w4: EXTHDR1.88@776.99,2859.25 776.99,2902.17 804.02,2929.21 808.19,2933.37 v1(799.86,2933.37) ; EXTHDR1.88@776.99,2908.37 ccw(c776.99,2923.32) 787.56,2912.75 ; EXTHDR1.88@776.99,2912.37 ccw(c776.99,2936.98) 794.39,2919.58 ; EXTHDR1.88@781.16,2906.34 ccw(c758.41,2929.09) v1@790.41,2932.4 ; EXTHDR1.88@784.99,2904.37 cw(c799.01,2904.37) 789.1,2914.28 ; 787.1,2912.28 ccw(c769.18,2930.2) v1@794.39,2932.81 ; 793.04,2918.23 ccw(c779.95,2931.31) v1@798.37,2933.22 ; v3(5114.41,4071.89) U8.U8@5134.09,4091.57 ; U8.U8@5126.75,4091.57 cw(c5109.03,4091.57) 5121.56,4079.04 cw(c5134.09,4066.51) U8.U8@5134.09,4084.23 ; 5127.21,4084.69 cw(c5114.41,4097.5) 5114.41,4079.39 ccw(c5114.41,4097.5) 5127.21,4084.69 ; 5127.21,4084.69 ccw(c5140.02,4071.89) 5121.91,4071.89 cw(c5140.02,4071.89) 5127.21,4084.69
  MidLayer2 w4: v1(799.86,2933.37) 840.19,2973.71 840.19,3008.37 856.86,3025.04 1131.86,3025.04 1305.18,3198.37 1314.86,3208.04 1649.35,3208.04 1691.35,3250.04 2115.19,3250.04 2131.86,3266.71 2131.86,3308.37 2115.19,3325.04 2070,3325.04 2020,3275.04 1768.86,3275.04 1748.52,3295.37 1748.52,3325.04 1763.48,3340 1920,3340 1931.86,3351.86 1931.86,3741.71 1948.52,3758.37 2315.19,3758.37 2331.86,3775.04 2331.86,3933.37 2348.52,3950.04 2515.19,3950.04 2531.86,3966.71 2531.86,4041.71 2556.86,4066.71 3215.19,4066.71 3231.86,4083.37 3231.86,4150.04 3248.52,4166.71 3615.19,4166.71 3673.52,4225.04 3758.9,4225.04 3864.44,4119.5 3885.56,4119.5 3891.1,4125.04 3907.86,4125.04 3923.52,4140.71 3923.52,4213.27 3985.25,4275 4080,4275 4134.54,4275.04 4166.59,4243 4189.69,4243 4289.69,4143 4289.69,4135.15 4330.02,4094.81 4557.5,4094.81 4562.81,4089.5 4628.88,4089.5 4630.19,4088.19 4671.81,4088.19 4725,4035 4810,4035 4823.03,4048.03 4830.82,4048.03 4838.82,4048.03 4957.99,4048.03 4977.41,4048.03 5051.53,4048.03 5071.03,4048.03 ccw(c5071.03,4089.76) 5100.54,4060.25 ; v1@799.86,2938.87 ccw(c799.86,2952.15) 809.25,2942.76 ccw(c818.64,2933.37) v1@805.36,2933.37 ; v1@799.86,2942.87 ccw(c799.86,2965.81) 816.07,2949.59 ccw(c832.29,2933.37) v1@809.36,2933.37 ; v3@5106.94,4072.54 cw(c5088.9,4074.12) 5100.54,4060.25 ; v3@5113.76,4064.42 ccw(c5112.18,4046.38) 5100.54,4060.25
PBIO.D44: EXTHDR1.90 U8.V2 | length 6904.2
  Top Layer w4: v1@577.41,2770.6 ccw(c588.81,2782) 588.81,2765.87 ; v1@580.24,2759.99 cw(c594.45,2745.78) 594.45,2765.87 ; v1@580.24,2773.43 ccw(c598.47,2791.65) 598.47,2765.87 ; EXTHDR1.90@739.84,2808.48 cw(c726.18,2794.82) 745.49,2794.82 cw(c764.81,2794.82) EXTHDR1.90@751.15,2808.48 ; EXTHDR1.90@745.49,2859.25 745.49,2781.97 729.4,2765.87 v1@581.02,2765.87 ; v1(4450,4165) 4485,4165 4503.71,4183.71 4530.88,4183.71 4554.5,4160.08 4554.5,4141.56 4554.5,4120.44 4583.23,4091.71 4655,4091.71 4668.16,4091.71 4671.79,4091.71 4672.5,4091 4679.31,4084.19 4723.12,4040.37 4769.63,4040.37 4773.66,4036.34 4830.83,4036.34 4838.82,4036.7 4878.16,4036.7 ccw(c4878.16,4046.85) 4885.34,4039.67 ; v1@4453.89,4161.11 cw(c4463.28,4151.72) 4463.28,4165 cw(c4463.28,4178.28) v1@4453.89,4168.89 ; v1@4456.72,4158.28 cw(c4472.93,4142.06) 4472.93,4165 cw(c4472.93,4187.93) v1@4456.72,4171.72 ; U8.V2@4890.53,4052.2 cw(c4872.81,4052.2) 4885.34,4039.67 ; U8.V2@4897.87,4044.86 ccw(c4897.87,4027.14) 4885.34,4039.67 ; v1@581.02,2765.87 574.36,2765.87 v1(573.52,2766.71) 580.19,2766.71 v1@581.02,2765.87
  MidLayer1 w4: v1(573.52,2766.71) 558.29,2766.71 547.86,2777.14 547.86,2938.48 521.61,2964.73 521.61,3196.35 627,3301.75 627,4323 v1@580,4370 ; v1@581.86,4357.21 cw(c581.86,4330.81) 600.52,4349.48 ; v1@581.86,4361.21 cw(c581.86,4344.47) 593.7,4356.3 ; v1@591.36,4366.71 ccw(c610.83,4366.71) 597.06,4352.94
  Bottom Layer w4: v1(581.86,4366.71) 615.19,4400.04 1515,4400.04 1540.67,4374.37 2544.33,4374.37 2570,4400.04 4051.54,4400.04 4209.88,4241.71 4415.19,4241.71 4423.52,4250.04 4456.86,4250.04 4482.19,4224.71 4482.19,4212.62 4492.5,4202.31 4492.5,4187.75 4492.5,4172.5 4485,4165 4469.75,4165 v1(4450,4165) ; v1@581.86,4372.21 ccw(c581.86,4385.49) 591.25,4376.1 ccw(c600.64,4366.71) v1@587.36,4366.71 ; v1@581.86,4376.21 ccw(c581.86,4399.14) 598.07,4382.93 ccw(c614.29,4366.71) v1@591.36,4366.71 ; v1@4457.42,4159.07 cw(c4469.75,4149.22) 4469.75,4165 cw(c4469.75,4180.78) v1@4457.42,4170.93
PBIO.D45: EXTHDR1.92 U8.AA5 | length 8019.9
  Top Layer w4: EXTHDR1.92@710.18,2903.17 cw(c720.88,2906.54) 712.95,2914.47 ; EXTHDR1.92@711.44,2911.95 ccw(c710.23,2915.51) 714,2915.51 ; EXTHDR1.92@714,2859.25 714,2915.52 ; EXTHDR1.92@714,2904.37 cw(c727.97,2908.77) 717.61,2919.13 ; EXTHDR1.92@716.56,2911.95 cw(c717.76,2915.51) 714,2915.51 ; EXTHDR1.92@717.81,2905.57 cw(c735.06,2911) 722.28,2923.79 ; EXTHDR1.92@721.63,2906.77 cw(c742.16,2913.24) 726.94,2928.46 ; v1@740.35,2928.53 ccw(c731.86,2923.51) 731.86,2933.37 ; v1@740.35,2938.22 cw(c731.86,2943.24) 731.86,2933.37 ; v1(748.52,2933.37) 731.86,2933.37 ; v3(4996.3,3914.41) U8.AA5@5015.98,3934.09 ; U8.AA5@5008.64,3934.09 cw(c4990.92,3934.09) 5003.45,3921.56 cw(c5015.98,3909.03) U8.AA5@5015.98,3926.75 ; 714,2915.52 726.94,2928.46 ; 726.94,2928.46 731.86,2933.37 ; 5009.1,3927.21 cw(c4996.3,3940.02) 4996.3,3921.91 ccw(c4996.3,3940.02) 5009.1,3927.21 ; 5009.1,3927.21 ccw(c5021.91,3914.41) 5003.8,3914.41 cw(c5021.91,3914.41) 5009.1,3927.21
  MidLayer1 w4: v1@741.81,2926.66 cw(c725.59,2910.44) 748.52,2910.44 cw(c771.46,2910.44) v1@755.24,2926.66 ; v1@744.64,2929.49 cw(c735.25,2920.1) 748.52,2920.1 cw(c761.8,2920.1) v1@752.41,2929.49 ; v1(748.52,2933.37) 748.52,2669.64 868,2550.16 868,1643.06 1070.56,1440.5 1165.56,1440.5 1206.02,1400.04 2645,1400.04 2695,1450.04 2695,2132.5 2710,2147.5 3204.32,2147.5 3798.86,2742.04 3798.86,2878.36 3850.43,2929.93 4181.86,3261.36 4181.86,3466.71 4248.52,3533.37 4248.52,3965.77 4295.13,4012.38 4295.13,4044.07 4331.27,4080.21 4420,4080.21 4421.52,4080.21 4422.81,4081.5 4428.12,4086.81 4463.55,4086.81 4536.88,4086.81 4601.19,4022.5 4625.81,4022.5 4647.5,4000.81 4647.5,3998.12 4667.12,3978.5 4685,3978.5 4695.67,3978.5 4753.36,3920.81 4756.67,3917.5 4762.75,3917.5 ; 4982.72,3903.02 cw(c4972.79,3912.95) 4972.79,3898.9 4958.86,3898.9 4898.67,3898.9 4879.25,3898.9 4838.82,3898.9 4830.82,3898.9 4789.6,3898.9 4783.6,3898.9 4765,3917.5 ; v3@4988.83,3915.06 cw(c4970.79,3916.64) 4982.43,3902.77 cw(c4994.07,3888.9) v3@4995.65,3906.94 ; 4762.75,3917.5 4764,3917.5 4765,3917.5 ; 4762.75,3917.5 4765,3917.5
PBIO.D46: EXTHDR1.94 U8.U7 | length 7210.5
  Top Layer w4: v1(656.86,2783.37) 674.5,2783.37 ; v1@664.79,2778.14 cw(c674.5,2771.74) 674.5,2783.37 ; v1@664.79,2788.6 ccw(c674.5,2795.01) 674.5,2783.37 ; EXTHDR1.94@676.85,2808.48 cw(c663.19,2794.82) 682.5,2794.82 cw(c701.82,2794.82) EXTHDR1.94@688.16,2808.48 ; EXTHDR1.94@682.5,2859.25 682.5,2791.37 674.5,2783.37 ; v3(5075.04,4071.89) U8.U7@5094.72,4091.57 ; U8.U7@5087.38,4091.57 cw(c5069.66,4091.57) 5082.19,4079.04 cw(c5094.72,4066.51) U8.U7@5094.72,4084.23 ; 5087.84,4084.69 cw(c5075.04,4097.5) 5075.04,4079.39 ccw(c5075.04,4097.5) 5087.84,4084.69 ; 5087.84,4084.69 ccw(c5100.65,4071.89) 5082.54,4071.89 cw(c5100.65,4071.89) 5087.84,4084.69
  MidLayer1 w4: v1@650.14,2790.09 ccw(c633.92,2806.31) 656.86,2806.31 ccw(c679.79,2806.31) v1@663.57,2790.09 ; v1@652.97,2787.26 ccw(c643.58,2796.65) 656.86,2796.65 ccw(c670.14,2796.65) v1@660.75,2787.26 ; v1(656.86,2783.37) 656.86,2808.14 650,2815 565,2815 555.86,2824.14 555.86,2941.8 529.61,2968.04 529.61,3193.04 635,3298.43 635,4311.52 v1(688.52,4365.04) ; v1@679.02,4365.04 cw(c656.09,4365.04) 672.31,4348.82 cw(c688.52,4332.61) v1@688.52,4355.54 ; v1@683.02,4365.04 cw(c669.75,4365.04) 679.14,4355.65 cw(c688.52,4346.26) v1@688.52,4359.54
  MidLayer2 w4: v1(688.52,4365.04) 720,4365.04 730.33,4375.37 1344.67,4375.37 1355,4365.04 1355.54,4365.04 1423.52,4297.06 1423.52,4191.71 1448.52,4166.71 1698.52,4166.71 1715.19,4183.37 1715.19,4225.04 1740.19,4250.04 2598.52,4250.04 2615.19,4233.37 2615.19,4165.71 2630.52,4150.37 2630.52,4150 2655,4150 3198.52,4150.04 3215.19,4166.71 3215.19,4225.04 3240.19,4250.04 3745.21,4250.04 3867.75,4127.5 3882.25,4127.5 3888.12,4133.37 3904.88,4133.37 3915.19,4143.69 3915.19,4216.25 3982.31,4283.37 4137.52,4283.37 4169.9,4251 4193,4251 4297.69,4146.31 4297.69,4138.46 4333.34,4102.81 4560.81,4102.81 4566.12,4097.5 4632.19,4097.5 4633.5,4096.19 4679.43,4096.19 4683.81,4091.81 4736.88,4091.81 4743.19,4085.5 4799.5,4085.5 4828.62,4056.38 4830.82,4056.38 4838.82,4056.38 4957.99,4056.38 5051.53,4056.38 ccw(c5051.53,4070.43) 5061.46,4060.5 ; v1@692.41,4361.15 cw(c701.8,4351.76) 701.8,4365.04 cw(c701.8,4378.32) v1@692.41,4368.93 ; v1@695.24,4358.32 cw(c711.46,4342.11) 711.46,4365.04 cw(c711.46,4387.98) v1@695.24,4371.76 ; v3@5067.57,4072.54 cw(c5049.53,4074.12) 5061.17,4060.25 cw(c5072.81,4046.38) v3@5074.39,4064.42
PBIO.D47: EXTHDR1.96 U8.T8 | length 6619
  Top Layer w4: v1(638.52,2933.37) 648.52,2923.37 ; EXTHDR1.96@645.35,2910.03 ccw(c637.68,2917.69) 648.52,2917.69 ; EXTHDR1.96@648.52,2883.37 648.52,2923.37 ; 648.52,2916.12 ccw(c658.42,2916.12) EXTHDR1.96@653.14,2907.75 ; EXTHDR1.96@655.27,2911.13 cw(c663,2923.37) 648.52,2923.37 ; v3(5114.41,4111.26) U8.T8@5134.09,4130.94 ; U8.T8@5126.75,4130.94 cw(c5109.03,4130.94) 5121.56,4118.41 cw(c5134.09,4105.88) U8.T8@5134.09,4123.6 ; 5127.21,4124.06 cw(c5114.41,4136.87) 5114.41,4118.76 ccw(c5114.41,4136.87) 5127.21,4124.06 ; 5127.21,4124.06 ccw(c5140.02,4111.26) 5121.91,4111.26 cw(c5140.02,4111.26) 5127.21,4124.06
  MidLayer1 w4: v1(3298.52,2700.04) 3363,2764.52 3363,3221.69 3489.52,3348.21 3489.52,3768.41 3504.49,3783.37 3723.37,3783.37 3756.19,3816.19 3756.19,4138.06 3785.17,4167.04 3856.31,4167.04 3875,4148.35 v1(3875,4145) ; v1@3298.52,2705.54 ccw(c3298.52,2718.82) 3307.91,2709.43 ccw(c3317.3,2700.04) v1@3304.02,2700.04 ; v1@3298.52,2709.54 ccw(c3298.52,2732.48) 3314.74,2716.26 ccw(c3330.96,2700.04) v1@3308.02,2700.04 ; 3856.42,4166.93 cw(c3834.48,4145) v1@3865.5,4145 ; 3863.24,4160.1 cw(c3848.14,4145) v1@3869.5,4145 ; 3864.5,4158.85 ccw(c3875,4169.35) v1@3875,4154.5
  MidLayer2 w4: v1@3868.28,4151.72 ccw(c3852.06,4167.93) 3875,4167.93 ccw(c3897.93,4167.93) v1@3881.72,4151.72 ; v1@3871.11,4148.89 ccw(c3861.72,4158.28) 3875,4158.28 ccw(c3888.28,4158.28) v1@3878.89,4148.89 ; v1(3875,4145) 3875,4268.18 3899.02,4292.2 4140.17,4292.2 4141,4291.37 4141,4291.21 4173.21,4259 4325,4259 4364.51,4219.49 4364.51,4215.49 4469.19,4110.81 4564.13,4110.81 4569.44,4105.5 4635.5,4105.5 4636.81,4104.19 4682.75,4104.19 4687.13,4099.81 4740.19,4099.81 4746.5,4093.5 4806.5,4093.5 4812.6,4087.4 4957.99,4087.4 4977.41,4087.4 5051.53,4087.4 5071.03,4087.4 ccw(c5071.03,4129.13) 5100.54,4099.62 ; v3@5106.94,4111.91 cw(c5088.9,4113.49) 5100.54,4099.62 ; v3@5113.76,4103.79 ccw(c5112.18,4085.75) 5100.54,4099.62
  Bottom Layer w4: v1@638.52,2923.87 cw(c638.52,2900.94) 654.74,2917.16 cw(c670.96,2933.37) v1@648.02,2933.37 ; v1@638.52,2927.87 cw(c638.52,2914.6) 647.91,2923.99 cw(c657.3,2933.37) v1@644.02,2933.37 ; v1(638.52,2933.37) 761.9,2810 1070,2810 1146.63,2733.37 1526.86,2733.37 1568.52,2691.71 3231.86,2691.71 3240.19,2700.04 v1(3298.52,2700.04) ; v1@3291.81,2693.32 ccw(c3275.59,2677.11) 3275.59,2700.04 ccw(c3275.59,2722.98) v1@3291.81,2706.76 ; v1@3294.64,2696.15 ccw(c3285.25,2686.76) 3285.25,2700.04 ccw(c3285.25,2713.32) v1@3294.64,2703.93
PBIO.D48: EXTHDR1.98 U8.U3 | length 6618.5
  Top Layer w4: EXTHDR1.98@616.39,2806.77 cw(c614.39,2802.06) 619.51,2802.06 ; EXTHDR1.98@619.51,2859.25 619.51,2802.05 ; EXTHDR1.98@622.63,2806.77 ccw(c624.63,2802.06) 619.51,2802.06 ; v1(627.86,2788.37) 627.86,2793.71 619.51,2802.05 ; v1(4475,4195) 4478.29,4191.71 4534.19,4191.71 4562.5,4163.4 4562.5,4123.75 4586.54,4099.71 4675.1,4099.71 4718.62,4056.19 4733.38,4056.19 4752.69,4075.5 4814.5,4075.5 4822.29,4067.71 4830.82,4067.71 4838.82,4067.71 4897.36,4067.71 ccw(c4897.36,4106.39) 4924.71,4079.04 ; v1@4476.06,4196.06 ccw(c4486.57,4206.57) 4486.57,4191.71 ; v1@4478.89,4198.89 ccw(c4496.23,4216.23) 4496.23,4191.71 ; v1@4481.72,4188.28 cw(c4489.99,4180.01) 4489.99,4191.71 ; v1@4481.72,4201.72 ccw(c4505.88,4225.88) 4505.88,4191.71 ; U8.U3@4929.9,4091.57 cw(c4912.18,4091.57) 4924.71,4079.04 ; U8.U3@4937.24,4084.23 ccw(c4937.24,4066.51) 4924.71,4079.04
  MidLayer1 w4: 549.88,3202 578,3230.12 ; v1(627.86,2788.37) 627.86,2787.63 649.61,2765.87 672.69,2765.87 673.52,2766.71 ; v1@764.02,4308.37 cw(c741.09,4308.37) 757.31,4292.16 cw(c773.52,4275.94) v1@773.52,4298.87 ; v1@768.02,4308.37 cw(c754.75,4308.37) 764.14,4298.99 cw(c773.52,4289.6) v1@773.52,4302.87 ; v1(773.52,4308.37) 731.86,4266.71 731.86,3270 719.4,3257.54 691.28,3257.54 686.32,3262.5 610.38,3262.5 578,3230.12 ; 578,3230.12 537.61,3189.73 537.61,2971.36 563.86,2945.11 563.86,2855 577.4,2841.46 673.54,2841.46 681.86,2833.14 681.86,2775.04 ; 673.52,2766.71 681.86,2775.04 ; 673.52,2766.71 681.86,2775.04
  Bottom Layer w4: v1(773.52,4308.37) 1460,4308.37 1502,4350.37 2620.37,4350.37 2654.04,4384.04 4044.92,4384.04 4241.33,4187.63 4249.75,4179.21 4301.31,4179.21 4335,4179.21 4361.02,4179.21 4391.19,4209.37 4460.63,4209.37 v1(4475,4195) v1@4469.23,4195 ; v1@777.41,4304.49 cw(c786.8,4295.1) 786.8,4308.37 cw(c786.8,4321.65) v1@777.41,4312.26 ; v1@780.24,4301.66 cw(c796.46,4285.44) 796.46,4308.37 cw(c796.46,4331.31) v1@780.24,4315.09
PBIO.D49: EXTHDR1.100 U8.V6 | length 6799.6
  Top Layer w4: EXTHDR1.100@582.36,2808.48 cw(c568.7,2794.82) 588.01,2794.82 cw(c607.33,2794.82) EXTHDR1.100@593.67,2808.48 ; EXTHDR1.100@588.01,2859.25 588.01,2793.88 v1(598.52,2783.37) ; v3(5035.67,4032.52) U8.V6@5055.35,4052.2 ; U8.V6@5048.01,4052.2 cw(c5030.29,4052.2) 5042.82,4039.67 cw(c5055.35,4027.14) U8.V6@5055.35,4044.86 ; 5048.47,4045.32 cw(c5035.67,4058.13) 5035.67,4040.02 ccw(c5035.67,4058.13) 5048.47,4045.32 ; 5048.47,4045.32 ccw(c5061.28,4032.52) 5043.17,4032.52 cw(c5061.28,4032.52) 5048.47,4045.32
  MidLayer1 w4: v1(3015.19,2641.71) 3131.86,2758.37 3131.86,3025.04 3465.19,3358.37 3465.19,3778.02 3528.88,3841.71 3701.5,3841.71 3748.19,3888.39 3748.19,4141.37 3765.19,4158.37 3781.86,4175.04 3890.19,4175.04 3906.86,4158.37 3906.86,4081.55 3839.5,4014.19 3839.5,3957.34 3859.96,3936.87 3962.13,3936.87 3972.75,3947.5 4018.98,3947.5 4082.94,3883.54 4103.54,3883.54 4157.19,3937.19 4157.19,3950.73 4183.33,3976.87 4214.36,3976.87 4263.13,4025.63 4263.13,4057.33 4318.01,4112.21 4408.26,4112.21 4414.87,4118.81 4484.87,4118.81 ; v1@3015.19,2647.21 ccw(c3015.19,2660.49) 3024.58,2651.1 ccw(c3033.97,2641.71) v1@3020.69,2641.71 ; v1@3015.19,2651.21 ccw(c3015.19,2674.14) 3031.41,2657.93 ccw(c3047.63,2641.71) v1@3024.69,2641.71 ; 4499.43,4133.37 4484.87,4118.81 ; 4958.86,4008.66 4972.79,4008.66 ; v3@5028.2,4033.17 cw(c5010.16,4034.75) 5021.8,4020.88 ; v3@5035.02,4025.05 ccw(c5033.44,4007.01) 5021.8,4020.88 ; 4484.87,4118.81 4516.1,4150.04 4548.52,4150.04 4556.36,4142.2 4556.36,4129.89 4604.75,4081.5 4662.19,4081.5 4729.69,4014 4761,4014 4766.34,4008.66 4830.82,4008.66 4838.82,4008.66 4879.25,4008.66 4898.67,4008.66 4972.79,4008.66 ; 4972.79,4008.66 4992.29,4008.66 ccw(c4992.29,4050.39) 5021.8,4020.88
  MidLayer2 w4: v1@598.52,2773.87 cw(c598.52,2750.94) 614.74,2767.16 cw(c630.96,2783.37) v1@608.02,2783.37 ; v1@598.52,2777.87 cw(c598.52,2764.6) 607.91,2773.99 cw(c617.3,2783.37) v1@604.02,2783.37 ; v1(598.52,2783.37) 623.52,2758.37 715.19,2758.37 723.52,2766.71 v1(797.52,2766.71) ; v1@790.81,2759.99 ccw(c774.59,2743.77) 774.59,2766.71 ccw(c774.59,2789.64) v1@790.81,2773.43 ; v1@793.64,2762.82 ccw(c784.25,2753.43) 784.25,2766.71 ccw(c784.25,2779.99) v1@793.64,2770.6
  Bottom Layer w4: v1(797.52,2766.71) 1046.54,2766.71 1058.75,2754.5 1073.25,2754.5 1077.12,2758.37 1098.37,2758.37 1115.5,2741.25 1115.5,2735.79 1125.92,2725.37 1523.54,2725.37 1565.21,2683.71 2168,2683.71 2210,2641.71 v1(3015.19,2641.71) ; v1@801.41,2762.82 cw(c810.8,2753.43) 810.8,2766.71 cw(c810.8,2779.99) v1@801.41,2770.6 ; v1@804.24,2759.99 cw(c820.46,2743.77) 820.46,2766.71 cw(c820.46,2789.64) v1@804.24,2773.43 ; v1@3008.47,2634.99 ccw(c2992.26,2618.77) 2992.26,2641.71 ccw(c2992.26,2664.64) v1@3008.47,2648.43 ; v1@3011.3,2637.82 ccw(c3001.91,2628.43) 3001.91,2641.71 ccw(c3001.91,2654.99) v1@3011.3,2645.6
PORT1.DMINUS: J36.2 U61.18 U62.6 | length 3391.8
  Top Layer w7: 5323.5,1226.34 5313.69,1236.15 5313.69,1620 5313.69,2094.62 5389.18,2170.11 5389.18,2170.82 5411.36,2193
  Top Layer w8: J36.2@5184.65,538.97 ccw(c5156.45,545.56) 5176.93,566.04 ; J36.2@5192.44,537.15 ccw(c5172.94,541.7) 5187.1,555.86 ccw(c5201.26,570.02) J36.2@5205.82,550.52 ; J36.2@5204,558.31 cw(c5197.41,586.52) 5176.93,566.04 ; J36.2@5209.9,533.07 5176.93,566.04 ; 5323.5,1226.34 5435,1114.84 5435,880 ; 5411.36,2193 5913,2193 5913,2207 5904.65,2215.35 U61.18@5904.65,2240 ; 5435,841.82 5435,880 ; 5176.93,566.04 5176.93,593.07 5155,615 5155,710 5235,790 5400,790 5435,825 5435,880
  Bottom Layer w8: J36.2@5184.65,538.97 ccw(c5156.45,545.56) 5176.93,566.04 ; J36.2@5192.44,537.15 ccw(c5172.94,541.7) 5187.1,555.86 ccw(c5201.26,570.02) J36.2@5205.82,550.52 ; J36.2@5204,558.31 cw(c5197.41,586.52) 5176.93,566.04 ; J36.2@5209.9,533.07 5176.93,566.04 ; U62.6@5297.76,972.4 5337.6,972.4 5340,970 5340,895 5155,710 5155,615 5176.93,593.07 5176.93,566.04 ; U62.6@5310.58,965.49 cw(c5327.27,948.79) 5327.27,972.4 cw(c5327.27,996.01) U62.6@5310.58,979.32
PORT1.DPLUS: J36.3 U61.20 U62.1 | length 3089.2
  Top Layer w8: J36.3@5185.05,604.43 ccw(c5175.16,601.5) 5175.16,611.81 ; J36.3@5185.05,619.19 cw(c5175.16,622.12) 5175.16,611.81 ; J36.3@5209.9,611.81 5175.16,611.81 ; U61.20@5944.01,2240 5944.01,2195.68 5929.33,2181 5416.33,2181 5325.19,2089.86 5325.19,1602.73 5325.19,1241.62 5447,1119.81 5447,820.03 5404.97,778 5239.97,778 5167,705.03 5167,619.97 5175.16,611.81
  Bottom Layer w8: J36.3@5185.05,604.43 ccw(c5175.16,601.5) 5175.16,611.81 ; J36.3@5185.05,619.19 cw(c5175.16,622.12) 5175.16,611.81 ; J36.3@5209.9,611.81 5175.16,611.81 ; U62.1@5379.42,965.49 ccw(c5362.73,948.79) 5362.73,972.4 ccw(c5362.73,996.01) U62.1@5379.42,979.32 ; U62.1@5392.24,972.4 5356.4,972.4 5352,968 5352,890.03 5167,705.03 5167,619.97 5175.16,611.81
PORT1.VBUS: F2.1 J36.1 J37.1 J38.1 R261.2 R262.2 R263.2 | length 7825.7
  MidLayer1 w4: v1(5081.86,2094.37) 5160.63,2094.37 5168.4,2086.6 5168.4,1888.47 5116.02,1836.09 5116.02,1396.23 5273.42,1238.83 5273.42,1098.42 5260,1085 5140,1085 v1(5115,1060) ; v1@5085.75,2090.49 cw(c5095.14,2081.1) 5095.14,2094.37 cw(c5095.14,2107.65) v1@5085.75,2098.26 ; v1@5088.57,2087.66 cw(c5104.79,2071.44) 5104.79,2094.37 cw(c5104.79,2117.31) v1@5088.57,2101.09 ; v1@5115,1065.5 ccw(c5115,1078.78) 5124.39,1069.39 ccw(c5133.78,1060) v1@5120.5,1060 ; v1@5115,1069.5 ccw(c5115,1092.43) 5131.22,1076.22 ccw(c5147.43,1060) v1@5124.5,1060
  MidLayer2 w4: v1(5115,1060) 5130.37,1075.37 5264.25,1075.37 5274.19,1065.43 5274.19,864.19 5260,850 5065,850 5038,823 5038,523 5061,500 5115,500 5160.67,454.33 ; J36.1@5185.93,440 ccw(c5160.67,424.9) 5160.67,454.33 ; J36.1@5185.93,468.66 cw(c5160.67,483.76) 5160.67,454.33 ; J36.1@5189.36,442.06 ccw(c5167.72,429.12) 5167.72,454.33 ccw(c5167.72,479.54) J36.1@5189.36,466.61 ; J36.1@5192.8,444.11 ccw(c5174.78,433.33) 5174.78,454.33 ccw(c5174.78,475.33) J36.1@5192.8,464.55 ; J36.1@5209.9,454.33 5160.67,454.33
  Bottom Layer w4: R263.2@5012.23,2152.92 cw(c4996.32,2137.01) 5018.82,2137.01 cw(c5041.32,2137.01) R263.2@5025.41,2152.92 ; R263.2@5012.23,2167.08 ccw(c4996.32,2182.99) 5018.82,2182.99 ccw(c5041.32,2182.99) R263.2@5025.41,2167.08 ; R262.2@5012.23,2208.83 cw(c4996.32,2192.92) 5018.82,2192.92 cw(c5041.32,2192.92) R262.2@5025.41,2208.83 ; R262.2@5012.23,2222.99 ccw(c4996.32,2238.9) 5018.82,2238.9 ccw(c5041.32,2238.9) R262.2@5025.41,2222.99 ; R261.2@5012.23,2264.74 cw(c4996.32,2248.83) 5018.82,2248.83 cw(c5041.32,2248.83) R261.2@5025.41,2264.74 ; R263.2@5015.06,2155.75 cw(c5005.98,2146.67) 5018.82,2146.67 cw(c5031.66,2146.67) R263.2@5022.58,2155.75 ; R263.2@5015.06,2164.25 ccw(c5005.98,2173.33) 5018.82,2173.33 ccw(c5031.66,2173.33) R263.2@5022.58,2164.25 ; R262.2@5015.06,2211.66 cw(c5005.98,2202.58) 5018.82,2202.58 cw(c5031.66,2202.58) R262.2@5022.58,2211.66 ; R262.2@5015.06,2220.16 ccw(c5005.98,2229.24) 5018.82,2229.24 ccw(c5031.66,2229.24) R262.2@5022.58,2220.16 ; R261.2@5015.06,2267.56 cw(c5005.98,2258.48) 5018.82,2258.48 cw(c5031.66,2258.48) R261.2@5022.58,2267.56 ; R261.2@5018.82,2271.82 R262.2@5018.82,2215.91 R263.2@5018.82,2160 5018.82,2121.18 5045.63,2094.37 v1(5081.86,2094.37) ; v1@5075.14,2087.66 ccw(c5058.92,2071.44) 5058.92,2094.37 ccw(c5058.92,2117.31) v1@5075.14,2101.09 ; v1@5077.97,2090.49 ccw(c5068.58,2081.1) 5068.58,2094.37 ccw(c5068.58,2107.65) v1@5077.97,2098.26
  Bottom Layer w20: F2.1@2531.46,1123.58 2658.32,1123.58 2690.19,1091.71 2690.19,775.04 2831.86,633.37 3716.63,633.37 4003.19,346.81 4688.19,346.81 4723.81,311.19 5086.19,311.19 5136,361 5176,361 5209.9,394.9 ; F2.1@2556.4,1098.63 cw(c2616.62,1038.41) 2616.62,1123.58 cw(c2616.62,1208.74) F2.1@2556.4,1148.52 ; J36.1@5195.81,440.24 cw(c5161.8,406.24) 5209.9,406.24 cw(c5257.99,406.24) J36.1@5223.98,440.24 ; J36.1@5209.9,454.33 5209.9,394.9 ; J37.1@5515.81,440.64 cw(c5481.8,406.63) 5529.9,406.63 cw(c5577.99,406.63) J37.1@5543.98,440.64 ; J37.1@5529.9,454.72 5529.9,344.9 5501.04,316.04 5288.75,316.04 5209.9,394.9 ; 5530,343.58 5757.77,343.58 5789.19,375 5835,375 5849.9,389.9 J38.1@5849.9,454.33 ; J38.1@5835.81,440.24 cw(c5801.8,406.24) 5849.9,406.24 cw(c5897.99,406.24) J38.1@5863.98,440.24
PORT2.DMINUS: J37.2 U61.25 U63.6 | length 3213.9
  Top Layer w8: J37.2@5504.65,539.36 ccw(c5476.45,545.95) 5496.93,566.43 ; J37.2@5512.44,537.54 ccw(c5492.94,542.1) 5507.1,556.26 ccw(c5521.26,570.42) J37.2@5525.82,550.92 ; J37.2@5524,558.71 cw(c5517.41,586.91) 5496.93,566.43 ; J37.2@5529.9,533.46 5496.93,566.43 ; U61.25@6042.44,2240 6042.44,2215.35 6053.12,2204.67 6053.12,2190 6023.12,2160 5425.03,2160 5346.19,2081.16 5346.19,1250.32 5367.77,1228.74 5468,1128.51 5468,758.54 5466.3,756.83 5466.3,622.08 5492.92,595.46 5493.01,595.46 5496.93,591.54 5496.93,566.43
  Bottom Layer w8: J37.2@5504.65,539.36 ccw(c5476.45,545.95) 5496.93,566.43 ; J37.2@5512.44,537.54 ccw(c5492.94,542.1) 5507.1,556.26 ccw(c5521.26,570.42) J37.2@5525.82,550.92 ; J37.2@5524,558.71 cw(c5517.41,586.91) 5496.93,566.43 ; J37.2@5529.9,533.46 5496.93,566.43 ; U63.6@5547.76,972.4 5583.6,972.4 5588,968 5588,843 5475,730 5475,613.38 5492.92,595.46 5493.01,595.46 5496.93,591.54 5496.93,566.43 ; U63.6@5560.58,965.49 cw(c5577.27,948.79) 5577.27,972.4 cw(c5577.27,996.01) U63.6@5560.58,979.32
PORT2.DPLUS: J37.3 U61.27 U63.1 | length 2943.8
  Top Layer w8: J37.3@5505.05,604.83 ccw(c5495.16,601.89) 5495.16,612.2 ; J37.3@5505.05,619.58 cw(c5495.16,622.52) 5495.16,612.2 ; J37.3@5529.9,612.2 5495.16,612.2 ; U61.27@6081.81,2240 6081.81,2201.71 6028.1,2148 5430,2148 5358.19,2076.19 5358.19,1255.3 5368.5,1244.99 5480,1133.48 5480,753.57 5478.3,751.86 5478.3,629.07 5495.16,612.2
  Bottom Layer w8: J37.3@5505.05,604.83 ccw(c5495.16,601.89) 5495.16,612.2 ; J37.3@5505.05,619.58 cw(c5495.16,622.52) 5495.16,612.2 ; J37.3@5529.9,612.2 5495.16,612.2 ; U63.1@5629.42,965.49 ccw(c5612.73,948.79) 5612.73,972.4 ccw(c5612.73,996.01) U63.1@5629.42,979.32 ; U63.1@5642.24,972.4 5607.4,972.4 5600,965 5600,838.03 5487,725.03 5487,620.36 5495.16,612.2
PORT3.DMINUS: J38.2 U61.32 U64.6 | length 3543
  Top Layer w8: J38.2@5824.65,538.97 ccw(c5796.45,545.56) 5816.93,566.04 ; J38.2@5832.44,537.15 ccw(c5812.94,541.7) 5827.1,555.86 ccw(c5841.26,570.02) J38.2@5845.82,550.52 ; J38.2@5844,558.31 cw(c5837.41,586.52) 5816.93,566.04 ; J38.2@5849.9,533.07 5816.93,566.04 ; U61.32@6180.24,2240 6180.24,2178.98 6128.25,2127 5438.7,2127 5379.19,2067.49 5379.19,1264 5389.5,1253.69 5501,1142.18 5501,794 5515,780 5775,780 5795,760 5795,612.98 5812.92,595.06 5813.01,595.06 5816.93,591.15 5816.93,566.04
  Bottom Layer w8: U64.6@5797.76,972.4 5832.6,972.4 5838,967 5838,805.03 5795,762.03 5795,612.98 5812.92,595.06 5813.01,595.06 5816.93,591.15 5816.93,566.04 ; U64.6@5810.58,965.49 cw(c5827.27,948.79) 5827.27,972.4 cw(c5827.27,996.01) U64.6@5810.58,979.32 ; J38.2@5824.65,538.97 ccw(c5796.45,545.56) 5816.93,566.04 ; J38.2@5832.44,537.15 ccw(c5812.94,541.7) 5827.1,555.86 ccw(c5841.26,570.02) J38.2@5845.82,550.52 ; J38.2@5844,558.31 cw(c5837.41,586.52) 5816.93,566.04 ; J38.2@5849.9,533.07 5816.93,566.04
PORT3.DPLUS: J38.3 U61.34 U64.1 | length 3295.9
  Top Layer w8: J38.3@5825.05,604.43 ccw(c5815.16,601.5) 5815.16,611.81 ; J38.3@5825.05,619.19 cw(c5815.16,622.12) 5815.16,611.81 ; J38.3@5849.9,611.81 5815.16,611.81 ; U61.34@6219.6,2240 6219.6,2200.35 6134.25,2115 5443.67,2115 5391.19,2062.52 5391.19,1268.97 5401.5,1258.66 5513,1147.15 5513,798.97 5519.97,792 5780,792 5807,765 5807,619.97 5815.16,611.81
  Bottom Layer w8: J38.3@5825.05,604.43 ccw(c5815.16,601.5) 5815.16,611.81 ; J38.3@5825.05,619.19 cw(c5815.16,622.12) 5815.16,611.81 ; J38.3@5849.9,611.81 5815.16,611.81 ; 5850,810 5850,820 ; U64.1@5879.42,965.49 ccw(c5862.73,948.79) 5862.73,972.4 ccw(c5862.73,996.01) U64.1@5879.42,979.32 ; U64.1@5892.24,972.4 5852.4,972.4 5850,970 5850,820 ; 5815.16,611.81 5807,619.97 5807,757.06 5850,800.06 5850,820
PWFBIN: C42.2 L1.2 U5.8 | length 1353.8
  MidLayer2 w12: v2(2320,5410) 2443.88,5410 2454.42,5420.54 2820,5420.54 3005.54,5235 v2(3140,5235) ; v2@2324.11,5405.89 cw(c2334.03,5395.97) 2334.03,5410 cw(c2334.03,5424.03) v2@2324.11,5414.11 ; v2@3135.89,5230.89 ccw(c3125.97,5220.97) 3125.97,5235 ccw(c3125.97,5249.03) v2@3135.89,5239.11
  Bottom Layer w12: v2@2315.89,5405.89 cw(c2305.97,5395.97) 2320,5395.97 cw(c2334.03,5395.97) v2@2324.11,5405.89 ; v2(2320,5410) 2320,5365 2331.34,5353.66 U5.8@2331.34,5322.68 ; 2326.07,5358.93 cw(c2313.34,5346.2) U5.8@2331.34,5346.2 ; L1.2@3115.32,5185.62 ccw(c3091.96,5208.98) 3125,5208.98 ccw(c3158.04,5208.98) L1.2@3134.68,5185.62 ; v2(3140,5235) 3125,5220 L1.2@3125,5175.94 3145.67,5155.28 C42.2@3145.67,5120 ; C42.2@3141.56,5124.11 ccw(c3131.64,5134.03) 3145.67,5134.03 ccw(c3159.7,5134.03) C42.2@3149.78,5124.11 ; C42.2@3145.67,5121.52 cw(c3208.95,5121.52) L1.2@3164.2,5166.27 ; 3145.67,5150.49 cw(c3179.98,5150.49) L1.2@3155.72,5174.75
PWM.PWM0: LED12.1 R123.1 U8.F8 U22.1 U22.3 U22.4 U22.5 U22.6 | length 4482.4
  Top Layer w4: U22.3@3866.99,5380.85 ccw(c3856.96,5370.82) 3856.96,5385 ccw(c3856.96,5399.18) U22.3@3866.99,5389.15 ; U22.1@3866.99,5432.03 ccw(c3856.96,5422) 3856.96,5436.18 ccw(c3856.96,5450.36) U22.1@3866.99,5440.33 ; U22.3@3880,5385 3839.23,5385 3823.52,5400.71 3823.52,5425.04 3834.66,5436.18 U22.1@3880,5436.18 3936.02,5436.18 ; U22.1@3893.01,5432.03 cw(c3903.04,5422) 3903.04,5436.18 cw(c3903.04,5450.36) U22.1@3893.01,5440.33 ; 3936.02,5383.79 cw(c3963.03,5383.79) U22.5@3947.38,5405.8 ; 3936.02,5388.38 ccw(c3946.19,5388.38) U22.4@3940.62,5379.88 ; 3936.02,5391.55 cw(c3957.52,5391.55) U22.5@3945.06,5409.06 ; 3936.02,5395.78 ccw(c3951.04,5395.78) U22.4@3942.81,5383.22 ; 3936.02,5399.3 cw(c3952.01,5399.3) U22.5@3942.74,5412.32 ; 3936.02,5403.19 ccw(c3955.89,5403.19) U22.4@3945,5386.57 ; 3936.02,5407.05 cw(c3946.49,5407.05) U22.5@3940.43,5415.58 ; 3936.02,5409.38 cw(c3963.03,5409.38) U22.6@3947.38,5431.39 ; 3936.02,5413.97 ccw(c3946.19,5413.97) U22.5@3940.62,5405.47 ; 3936.02,5417.14 cw(c3957.52,5417.14) U22.6@3945.06,5434.65 ; 3936.02,5421.37 ccw(c3951.04,5421.37) U22.5@3942.81,5408.81 ; 3936.02,5424.89 cw(c3952.01,5424.89) U22.6@3942.74,5437.91 ; 3936.02,5428.78 ccw(c3955.89,5428.78) U22.5@3945,5412.16 ; 3936.02,5432.64 cw(c3946.49,5432.64) U22.6@3940.43,5441.17 ; U22.4@3938.36,5383.27 ccw(c3936.02,5382.55) 3936.02,5385 ; U22.4@3938.36,5386.73 cw(c3936.02,5387.45) 3936.02,5385 ; U22.5@3938.36,5408.86 ccw(c3936.02,5408.14) 3936.02,5410.59 ; U22.5@3938.36,5412.32 cw(c3936.02,5413.03) 3936.02,5410.59 ; U22.6@3939.82,5432.03 ccw(c3929.8,5422) 3929.8,5436.18 ccw(c3929.79,5450.36) U22.6@3939.82,5440.33 ; U22.4@3947.2,5389.91 cw(c3960.74,5410.59) 3936.02,5410.59 ; U22.5@3947.2,5415.5 cw(c3960.74,5436.18) 3936.02,5436.18 ; U22.6@3948.68,5440.33 ccw(c3938.65,5450.36) 3952.84,5450.36 ccw(c3967.01,5450.36) U22.6@3956.99,5440.33 ; U22.4@3952.83,5385 3936.02,5385 ; U22.5@3952.83,5410.59 3936.02,5410.59 ; 3952.84,5451.31 U22.6@3952.83,5436.18 3936.02,5436.18 ; 3952.86,5451.31 3961.52,5459.98 v1(3961.52,5466.71) 4127.11,5466.71 R123.1@4133.82,5460 ; v1@3965.41,5462.82 cw(c3974.8,5453.43) 3974.8,5466.71 cw(c3974.8,5479.99) v1@3965.41,5470.6 ; v1@3968.24,5459.99 cw(c3984.46,5443.77) 3984.46,5466.71 cw(c3984.46,5489.64) v1@3968.24,5473.43 ; 4096.31,5466.71 cw(c4096.31,5422.99) R123.1@4127.23,5453.9 ; 4105.97,5466.71 cw(c4105.97,5432.64) R123.1@4130.06,5456.73 ; 4115.63,5466.71 cw(c4115.63,5442.3) R123.1@4132.89,5459.56 ; LED12.1@4594.26,5788.44 cw(c4610.8,5771.91) 4610.8,5795.29 cw(c4610.8,5818.67) LED12.1@4594.26,5802.14 ; LED12.1@4597.09,5785.61 cw(c4620.45,5762.25) 4620.45,5795.29 cw(c4620.45,5828.33) LED12.1@4597.09,5804.97 ; LED12.1@4599.54,5788.95 cw(c4610,5783.49) 4610,5795.29 cw(c4610,5807.09) LED12.1@4599.54,5801.63 ; LED12.1@4599.92,5782.79 cw(c4630.11,5752.6) 4630.11,5795.29 cw(c4630.11,5837.99) LED12.1@4599.92,5807.8 ; LED12.1@4603.09,5787.1 cw(c4616.61,5780.04) 4616.61,5795.29 ; LED12.1@4603.09,5803.48 ccw(c4616.61,5810.54) 4616.61,5795.29 ; v1@4770.5,5740 ccw(c4747.56,5740) 4763.78,5756.22 ccw(c4780,5772.43) v1@4780,5749.5 ; v1@4774.5,5740 ccw(c4761.22,5740) 4770.61,5749.39 ccw(c4780,5758.78) v1@4780,5745.5 ; v1(4780,5740) 4724.71,5795.29 LED12.1@4587.42,5795.29 4616.61,5795.29 ; v3(5114.41,4544.33) U8.F8@5134.09,4524.65 ; U8.F8@5126.75,4524.65 ccw(c5109.03,4524.65) 5121.56,4537.18 ccw(c5134.09,4549.71) U8.F8@5134.09,4531.99 ; 3936.02,5385 3936.02,5410.59 ; 3936.02,5410.59 3936.02,5436.18 ; 3936.02,5436.18 ccw(c3936.02,5438.63) 3938.36,5437.91 cw(c3936.02,5438.63) 3936.02,5436.18 ; 3936.02,5436.18 cw(c3936.02,5433.74) 3938.36,5434.45 ccw(c3936.02,5433.74) 3936.02,5436.18 ; 5127.21,4531.53 cw(c5140.02,4544.33) 5121.91,4544.33 ccw(c5140.02,4544.33) 5127.21,4531.53 ; 5127.21,4531.53 ccw(c5114.41,4518.72) 5114.41,4536.83 cw(c5114.41,4518.72) 5127.21,4531.53
  MidLayer1 w4: v1@4780,5730.5 cw(c4780,5707.56) 4796.22,5723.78 cw(c4812.43,5740) v1@4789.5,5740 ; v1@4780,5734.5 cw(c4780,5721.22) 4789.39,5730.61 cw(c4798.78,5740) v1@4785.5,5740 ; v1(4780,5740) 4819.63,5700.37 4953.54,5700.37 4965.52,5688.39 4965.52,5392.35 4921.52,5348.35 4921.52,5027.63 4982.11,4967.04 5025.13,4967.04 5085.5,4906.67 5085.5,4852.02 5075,4841.52 5075,4795 5090.55,4779.45 5090.55,4749.18 5090.55,4741.18 5090.55,4700.75 5090.55,4681.33 5090.55,4607.21 ; 5090.55,4621.14 5090.55,4607.21 ; v3@5106.94,4544.98 ccw(c5088.9,4546.56) 5102.77,4558.2 ; v3@5115.06,4551.8 cw(c5116.64,4569.84) 5102.77,4558.2 ; 5090.55,4607.21 5090.55,4587.71 ccw(c5132.28,4587.71) 5102.77,4558.2
  Bottom Layer w4: v1(3961.52,5466.71) 4326.17,5466.71 4334.83,5458.04 4433.04,5458.04 4445,5470 4445,5721.71 4490,5766.71 4753.29,5766.71 v1(4780,5740) ; v1@3965.41,5462.82 cw(c3974.8,5453.43) 3974.8,5466.71 cw(c3974.8,5479.99) v1@3965.41,5470.6 ; v1@3968.24,5459.99 cw(c3984.46,5443.77) 3984.46,5466.71 cw(c3984.46,5489.64) v1@3968.24,5473.43 ; v1@4770.5,5740 ccw(c4747.56,5740) 4763.78,5756.22 ccw(c4780,5772.43) v1@4780,5749.5 ; v1@4774.5,5740 ccw(c4761.22,5740) 4770.61,5749.39 ccw(c4780,5758.78) v1@4780,5745.5
PWM.PWM1: LED8.1 R90.1 U8.B7 U9.1 U9.3 U9.4 U9.5 U9.6 | length 3721.9
  Top Layer w4: U9.3@3725,5385 3746.86,5385 ; U9.1@3725,5436.18 3746.86,5436.18 ; U9.3@3738.27,5381.12 cw(c3746.86,5373.56) 3746.86,5385 ; U9.3@3738.27,5388.88 ccw(c3746.86,5396.44) 3746.86,5385 ; U9.1@3738.27,5432.3 cw(c3746.86,5424.74) 3746.86,5436.18 ; U9.1@3738.27,5440.06 ccw(c3746.86,5447.62) 3746.86,5436.18 ; 3748.48,5437.8 cw(c3758.11,5428.17) v1@3764.19,5440.37 ; 3752.41,5441.74 cw(c3760.73,5433.42) v1@3765.97,5443.95 ; v1@3765.99,5442.69 ccw(c3780.28,5455.11) 3780.28,5436.18 ; v1@3769.01,5445.32 ccw(c3789.06,5462.75) U9.6@3789.06,5436.18 ; v1@3772.03,5447.94 ccw(c3797.83,5470.38) U9.6@3797.83,5436.18 ; U9.4@3793.68,5389.15 ccw(c3783.65,5399.18) 3797.84,5399.18 ccw(c3812.01,5399.18) U9.4@3801.99,5389.15 ; U9.5@3793.68,5406.44 cw(c3783.65,5396.41) 3797.84,5396.41 cw(c3812.01,5396.41) U9.5@3801.99,5406.44 ; U9.5@3793.68,5414.74 ccw(c3783.65,5424.77) 3797.84,5424.77 ccw(c3812.01,5424.77) U9.5@3801.99,5414.74 ; U9.6@3793.68,5432.03 cw(c3783.65,5422) 3797.84,5422 ; U9.4@3797.83,5385 U9.5@3797.83,5410.59 U9.6@3797.83,5436.18 ; 3797.84,5422 cw(c3812.01,5422) U9.6@3801.99,5432.03 ; v1(4099.19,5391.37) 4115.19,5391.37 ; v1@4107.53,5386.83 cw(c4115.19,5382.65) 4115.19,5391.37 ; v1@4107.53,5395.92 ccw(c4115.19,5400.1) 4115.19,5391.37 ; R90.1@4126.27,5385.71 ccw(c4115.19,5377.71) 4115.19,5391.37 ; R90.1@4126.29,5386.17 ccw(c4115.48,5378.29) 4115.48,5391.67 ; R90.1@4126.29,5397.16 cw(c4115.48,5405.05) 4115.48,5391.67 ; R90.1@4126.46,5396.89 cw(c4115.19,5405.64) 4115.19,5391.37 ; LED8.1@4587.42,5624.9 4671.52,5624.9 ; LED8.1@4594.26,5618.06 cw(c4610.8,5601.52) 4610.8,5624.9 cw(c4610.8,5648.29) LED8.1@4594.26,5631.75 ; LED8.1@4597.09,5615.23 cw(c4620.45,5591.87) 4620.45,5624.9 cw(c4620.45,5657.94) LED8.1@4597.09,5634.58 ; LED8.1@4599.92,5612.4 cw(c4630.11,5582.21) 4630.11,5624.9 cw(c4630.11,5667.6) LED8.1@4599.92,5637.41 ; v1@4683.47,5515.09 ccw(c4667.26,5531.31) 4690.19,5531.31 ccw(c4713.13,5531.31) v1@4696.91,5515.09 ; v1@4686.3,5512.26 ccw(c4676.91,5521.65) 4690.19,5521.65 ccw(c4703.47,5521.65) v1@4694.08,5512.26 ; v1(4690.19,5508.37) 4690.19,5606.24 4671.52,5624.9 ; 3746.86,5385 3748.52,5386.67 3748.52,5434.51 3746.86,5436.18 ; 3746.86,5436.18 3752.38,5441.71 v1(3764.86,5441.71) 3764.86,5441.51 3770.19,5436.18 U9.6@3797.83,5436.18 ; 4115.19,5391.37 4115.48,5391.67 ; 4115.19,5391.37 4133.53,5391.37 R90.1@4133.82,5391.67 4115.48,5391.67 ; 4671.52,5624.9 4701.86,5655.24 4701.86,5675.04 4710.19,5683.37 4773.52,5683.37 4839.69,5617.2 4856.86,5600.04 4975.52,5600.04 4998,5577.56 4998,5381.69 4986,5369.69 4986,5310.19 4997.86,5298.34 4997.86,5238 5032.35,5203.5 5032.35,5172.56 5017.5,5157.7 5017.5,5125 ; 5017.5,5114.04 5017.5,5125 ; 5017.5,5114.04 5056.7,5074.85 5056.7,4914.99 5077.5,4894.19 5077.5,4867.75 5073.52,4863.78 5073.52,4818.63 5079.22,4812.93 5079.22,4751.18 5079.22,4741.18 ; 5017.5,5114.04 5017.5,5125 ; 5079.22,4701.84 ccw(c5089.37,4701.84) 5082.19,4694.66 ; 5079.22,4701.84 ccw(c5089.37,4701.84) 5082.19,4694.66 ; 5079.22,4701.84 5079.22,4741.18 ; 5079.22,4701.84 5079.22,4741.18 ; 5082.19,4694.66 ccw(c5094.72,4707.19) 5094.72,4689.47 cw(c5094.72,4707.19) 5082.19,4694.66 ; 5082.19,4694.66 cw(c5069.66,4682.13) 5087.38,4682.13 ccw(c5069.66,4682.13) 5082.19,4694.66
  MidLayer2 w4: v1@3764.86,5432.21 cw(c3764.86,5409.27) 3781.07,5425.49 cw(c3797.29,5441.71) v1@3774.36,5441.71 ; v1@3764.86,5436.21 cw(c3764.86,5422.93) 3774.25,5432.32 cw(c3783.64,5441.71) v1@3770.36,5441.71 ; v1(3764.86,5441.71) 3848.19,5358.37 4031.86,5358.37 ; v1@4089.69,5391.37 cw(c4066.76,5391.37) 4082.97,5375.16 cw(c4099.19,5358.94) v1@4099.19,5381.87 ; v1@4093.69,5391.37 cw(c4080.41,5391.37) 4089.8,5381.99 cw(c4099.19,5372.6) v1@4099.19,5385.87 ; v1(4099.19,5391.37) 4066.19,5358.37 ; 4031.86,5358.37 4066.19,5358.37 ; 4031.86,5358.37 4066.19,5358.37
  Bottom Layer w4: v1(4099.19,5391.37) 4438.52,5391.37 4480.52,5433.37 4615.19,5433.37 v1(4690.19,5508.37) ; v1@4103.08,5387.49 cw(c4112.47,5378.1) 4112.47,5391.37 cw(c4112.47,5404.65) v1@4103.08,5395.26 ; v1@4105.91,5384.66 cw(c4122.13,5368.44) 4122.13,5391.37 cw(c4122.13,5414.31) v1@4105.91,5398.09 ; v1@4680.69,5508.37 cw(c4657.76,5508.37) 4673.97,5492.16 cw(c4690.19,5475.94) v1@4690.19,5498.87 ; v1@4684.69,5508.37 cw(c4671.41,5508.37) 4680.8,5498.99 cw(c4690.19,5489.6) v1@4690.19,5502.87
PWM.PWM2: LED9.1 R92.1 U8.C6 U10.1 U10.3 U10.4 U10.5 U10.6 | length 3771.9
  Top Layer w4: U10.3@3725,5248.82 3748.52,5248.82 ; U10.1@3725,5300 3746.86,5300 ; U10.3@3738.01,5244.67 cw(c3748.04,5234.64) 3748.04,5248.82 cw(c3748.04,5263) U10.3@3738.01,5252.97 ; U10.1@3738.27,5296.12 cw(c3746.86,5288.56) 3746.86,5300 ; U10.1@3738.27,5303.88 ccw(c3746.86,5311.44) 3746.86,5300 ; 3780.19,5247.35 cw(c3806.61,5247.35) U10.5@3792.18,5269.49 ; 3780.19,5248.82 3780.19,5274.41 ; 3780.19,5253.46 ccw(c3791.7,5253.46) U10.4@3785.88,5243.53 ; 3780.19,5254.74 cw(c3801.8,5254.74) U10.5@3790,5272.84 ; 3780.19,5260.44 ccw(c3795.79,5260.44) U10.4@3787.9,5246.98 ; 3780.19,5262.12 cw(c3796.99,5262.12) U10.5@3787.82,5276.19 ; 3780.19,5267.43 ccw(c3799.88,5267.43) U10.4@3789.92,5250.44 ; 3780.19,5269.5 cw(c3792.18,5269.5) U10.5@3785.63,5279.54 ; 3780.19,5272.94 cw(c3806.61,5272.94) U10.6@3792.18,5295.08 ; 3780.19,5279.05 ccw(c3791.7,5279.05) U10.5@3785.88,5269.12 ; 3780.19,5280.33 cw(c3801.8,5280.33) U10.6@3790,5298.43 ; 3780.19,5286.03 ccw(c3795.79,5286.03) U10.5@3787.9,5272.58 ; 3780.19,5287.71 cw(c3796.99,5287.71) U10.6@3787.82,5301.78 ; 3780.19,5293.02 ccw(c3799.89,5293.02) U10.5@3789.92,5276.03 ; 3780.19,5295.09 cw(c3792.18,5295.09) U10.6@3785.63,5305.13 ; 3780.19,5300 ccw(c3803.98,5300) U10.5@3791.95,5279.48 ; U10.5@3783.55,5272.16 ccw(c3780.19,5270.77) 3780.19,5274.41 ; U10.5@3783.55,5276.65 cw(c3780.19,5278.04) 3780.19,5274.41 ; U10.6@3783.55,5297.75 ccw(c3780.19,5296.37) 3780.19,5300 ; U10.6@3783.55,5302.24 cw(c3780.19,5303.63) 3780.19,5300 ; U10.4@3784.82,5244.67 ccw(c3774.8,5234.64) 3774.8,5248.82 ccw(c3774.79,5263) U10.4@3784.82,5252.97 ; U10.4@3791.95,5253.89 cw(c3803.98,5274.41) 3780.19,5274.41 ; U10.6@3793.68,5304.15 ccw(c3783.65,5314.18) 3797.84,5314.18 ccw(c3812.01,5314.18) U10.6@3801.99,5304.15 ; U10.4@3797.83,5248.82 3748.52,5248.82 ; U10.5@3797.83,5274.41 3780.19,5274.41 ; R92.1@4133.02,5321.79 cw(c4121.89,5307.27) 4140.19,5307.27 ; v1@4133.47,5284.99 ccw(c4117.26,5268.77) 4117.26,5291.71 ccw(c4117.26,5314.64) 4133.47,5298.43 ccw(c4117.26,5314.64) 4140.19,5314.64 ccw(c4163.13,5314.64) v1@4146.91,5298.43 ; v1@4136.3,5287.82 ccw(c4126.91,5278.43) 4126.91,5291.71 ccw(c4126.91,5304.99) 4136.3,5295.6 ccw(c4126.91,5304.99) 4140.19,5304.99 ccw(c4153.47,5304.99) v1@4144.08,5295.6 ; R92.1@4140.19,5316.96 v1(4140.19,5291.71) 4073.29,5291.71 4070,5295 ; LED9.1@4574.91,5442.01 cw(c4544.72,5411.82) 4587.42,5411.82 cw(c4630.11,5411.82) LED9.1@4599.92,5442.01 ; LED9.1@4577.74,5444.84 cw(c4554.38,5421.48) 4587.42,5421.48 cw(c4620.45,5421.48) LED9.1@4597.09,5444.84 ; LED9.1@4580.57,5447.67 cw(c4564.03,5431.14) 4587.42,5431.14 cw(c4610.8,5431.14) LED9.1@4594.26,5447.67 ; LED9.1@4587.42,5454.52 4587.42,5382.42 4579.71,5374.71 4418.46,5374.71 4393.17,5400 4299.71,5400 4290,5409.71 4092.77,5409.71 4070,5386.93 4070,5295 ; v1@4798.52,5123.87 cw(c4798.52,5100.94) 4814.74,5117.16 cw(c4830.96,5133.37) v1@4808.02,5133.37 ; v1@4798.52,5127.87 cw(c4798.52,5114.6) 4807.91,5123.99 cw(c4817.3,5133.37) v1@4804.02,5133.37 ; v1(4798.52,5133.37) 4826.9,5105 4895,5105 4907.19,5092.81 4907.19,4963.02 4906.36,4962.19 4906.36,4957.22 5010.32,4853.26 5031.49,4832.09 5031.49,4749.18 5031.49,4741.18 ; 3746.86,5300 3748.52,5298.33 3748.52,5248.82 ; 3780.19,5274.41 3780.19,5300 ; 3780.19,5300 U10.6@3797.83,5300 3797.84,5314.35 3816.86,5333.37 4031.63,5333.37 4070,5295 ; 5031.49,4682.64 ccw(c5070.17,4682.64) 5042.82,4655.29 ; 5031.49,4682.64 ccw(c5070.17,4682.64) 5042.82,4655.29 ; 5031.49,4682.64 5031.49,4741.18 ; 5031.49,4682.64 5031.49,4741.18 ; 5042.82,4655.29 cw(c5030.29,4642.76) 5048.01,4642.76 ccw(c5030.29,4642.76) 5042.82,4655.29 ; 5042.82,4655.29 ccw(c5055.35,4667.82) 5055.35,4650.1 cw(c5055.35,4667.82) 5042.82,4655.29
  Bottom Layer w4: v1@4140.19,5282.21 cw(c4140.19,5259.27) 4156.41,5275.49 cw(c4172.63,5291.71) v1@4149.69,5291.71 ; v1@4140.19,5286.21 cw(c4140.19,5272.93) 4149.58,5282.32 cw(c4158.97,5291.71) v1@4145.69,5291.71 ; v1(4140.19,5291.71) 4167,5264.9 4167,5173 4189.81,5150.19 4530.19,5150.19 4557.81,5177.81 4701.09,5177.81 4714.49,5164.41 4745.52,5133.37 v1(4798.52,5133.37) ; v1@4791.81,5126.66 ccw(c4775.59,5110.44) 4775.59,5133.37 ccw(c4775.59,5156.31) v1@4791.81,5140.09 ; v1@4794.64,5129.49 ccw(c4785.25,5120.1) 4785.25,5133.37 ccw(c4785.25,5146.65) v1@4794.64,5137.26