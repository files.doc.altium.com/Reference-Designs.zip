# Altium PCB NB3000AL.PcbDoc (part 53 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
HOST_SRAM.A17: U30.N15 U47.44 | length 3362.9
  Top Layer w4: 7419.58,1655.61 cw(c7393.98,1630) v2@7430.19,1630 ; 7426.41,1648.78 cw(c7407.63,1630) v2@7434.19,1630 ; 7432.11,1643.08 ccw(c7440,1650.97) v2@7440,1639.81 ; 7433.24,1641.95 cw(c7421.29,1630) v2@7438.19,1630 ; v2(7440,1630) 7440,1635.19 7411.38,1663.81 7392.62,1663.81 7392.24,1664.19 7391.31,1664.19 7389.5,1666 7383.51,1671.99 7372.01,1671.99 7359,1671.99 7285.95,1671.99 7285.62,1672.33 ; v1@7808.28,2064.28 cw(c7792.06,2048.06) 7815,2048.06 cw(c7837.94,2048.06) v1@7821.72,2064.28 ; v1@7811.11,2067.11 cw(c7801.72,2057.72) 7815,2057.72 cw(c7828.28,2057.72) v1@7818.89,2067.11 ; v1(7815,2071) 7815,2022.81 7817.81,2020 7817.81,1937.19 7864.3,1890.7 7864.3,1765.7 7878,1752 v2(7878,1750) ; v1(7959.52,3368.37) 7962.19,3365.71 U47.44@8004.41,3365.71 ; v1@7963.41,3372.26 ccw(c7979.24,3388.09) U47.44@7979.24,3365.71 ; v1@7966.24,3361.66 cw(c7976.02,3351.88) 7976.02,3365.71 ; v1@7966.24,3375.09 ccw(c7988.9,3397.75) U47.44@7988.9,3365.71 ; 7278.44,1675.3 ccw(c7285.62,1682.48) 7285.62,1672.33 ; 7278.44,1675.3 ccw(c7285.62,1682.48) 7285.62,1672.33 ; 7278.44,1675.3 cw(c7290.97,1687.83) 7273.25,1687.83 ccw(c7290.97,1687.83) 7278.44,1675.3 ; 7278.44,1675.3 ccw(c7265.91,1662.77) 7265.91,1680.49 cw(c7265.91,1662.77) 7278.44,1675.3
  MidLayer1 w4: v1@7808.28,2077.72 ccw(c7792.06,2093.93) 7815,2093.93 ccw(c7837.94,2093.93) v1@7821.72,2077.72 ; v1@7811.11,2074.89 ccw(c7801.72,2084.28) 7815,2084.28 ccw(c7828.28,2084.28) v1@7818.89,2074.89 ; v1(7815,2071) 7815,2169.7 7782.61,2202.09 ; 7766.19,2456 7766.19,2484 ; 7766.19,2456 7766.19,2426.85 7782.61,2410.43 ; 7766.19,2456 7766.19,2484 ; 7766.19,2484 7766.19,2521.19 v1@7768.19,2523.19 ; v1@7768.19,2523.19 v1(7775,2530) v1@7768.19,2523.19 ; 7782.61,2202.09 7782.61,2245 ; 7782.61,2202.09 7782.61,2245 ; 7782.61,2245 7782.61,2380 ; 7782.61,2380 7782.61,2410.43 ; 7782.61,2380 7782.61,2410.43
  MidLayer2 w4: v1@7769.47,2537.72 ccw(c7761.74,2548.5) 7775,2548.5 ; v1(7775,2530) 7775,2548.5 ; v1@7780.53,2537.72 cw(c7788.26,2548.5) 7775,2548.5 ; v1@7950.02,3368.37 cw(c7927.09,3368.37) 7943.31,3352.16 cw(c7959.52,3335.94) v1@7959.52,3358.87 ; v1@7954.02,3368.37 cw(c7940.75,3368.37) 7950.14,3358.99 cw(c7959.52,3349.6) v1@7959.52,3362.87 ; v1(7959.52,3368.37) 7774.81,3183.66 7774.81,2693.62 7754.19,2673 7754.19,2569.31 ; 7754.19,2569.31 7765.19,2558.31 ; 7754.19,2569.31 7765.19,2558.31 ; 7765.19,2558.31 7775,2548.5
  Bottom Layer w4: v2@7433.06,1623.06 cw(c7416.31,1606.31) 7440,1606.31 cw(c7463.69,1606.31) v2@7446.94,1623.06 ; v2@7435.89,1625.89 cw(c7425.97,1615.97) 7440,1615.97 cw(c7454.03,1615.97) v2@7444.11,1625.89 ; v2(7440,1630) 7440,1605 7447,1598 7447,1530 7464,1513 ; v2@7871.06,1743.06 ccw(c7854.31,1726.31) 7854.31,1750 ccw(c7854.31,1773.69) v2@7871.06,1756.94 ; v2@7873.89,1745.89 ccw(c7863.97,1735.97) 7863.97,1750 ccw(c7863.97,1764.03) v2@7873.89,1754.11 ; v2(7878,1750) 7838.47,1750 7750.67,1662.2 7750.67,1564.25 7738.42,1552 7733.69,1547.27 7628.63,1547.27 7594.36,1513 7510,1513 ; 7464,1513 7510,1513 ; 7464,1513 7510,1513
HOST_SRAM.A18: U30.J15 U47.28 | length 2395.2
  Top Layer w4: 7351.04,1829.47 ccw(c7351.04,1854.96) v2@7369.06,1836.94 ; 7353.59,1829.47 cw(c7353.59,1807.59) v2@7369.06,1823.06 ; 7360.7,1829.47 ccw(c7360.7,1845.3) v2@7371.89,1834.11 ; 7363.24,1829.47 cw(c7363.24,1817.24) v2@7371.89,1825.89 ; v2(7376,1830) 7380,1830 v2@7380.53,1829.47 ; v2@7380.19,1829.81 v2@7380.53,1829.47 ; v1@7876.19,1958.37 v1@7877.82,1960 ; v1@7882.5,1955 cw(c7905.88,1955) 7889.35,1971.53 ; v1(7885,1955) 7880,1960 v1@7877.82,1960 ; v1@7886.5,1955 cw(c7919.54,1955) 7896.18,1978.36 ; v1@7890.5,1955 cw(c7933.19,1955) 7903,1985.19 ; v1@7894.5,1955 cw(c7946.85,1955) 7909.83,1992.02 ; 7953,2562 7953,2540 ; U47.28@7980.23,2857.29 ccw(c7971.77,2851.56) 7971.77,2861.77 ; U47.28@7980.23,2866.26 cw(c7971.77,2871.98) 7971.77,2861.77 ; U47.28@8004.41,2861.77 7971.77,2861.77 ; 7278.44,1832.78 ccw(c7285.62,1839.96) 7285.62,1829.81 ; 7278.44,1832.78 ccw(c7285.62,1839.96) 7285.62,1829.81 ; 7278.44,1832.78 cw(c7290.97,1845.31) 7273.25,1845.31 ccw(c7290.97,1845.31) 7278.44,1832.78 ; 7278.44,1832.78 ccw(c7265.91,1820.25) 7265.91,1837.97 cw(c7265.91,1820.25) 7278.44,1832.78 ; 7285.62,1829.81 7285.95,1829.47 v2@7380.53,1829.47 ; v1@7877.82,1960 7991.1,2073.28 7991.1,2317.42 7978.52,2330 7957.88,2330 7953,2334.88 7953,2540 ; 7953,2540 7953,2565.21 7907.19,2611.02 7907.19,2844.38 7917.81,2855 7965,2855 7971.77,2861.77
  Bottom Layer w4: v2@7380.11,1825.89 cw(c7390.03,1815.97) 7390.03,1830 cw(c7390.03,1844.03) v2@7380.11,1834.11 ; v2@7382.94,1823.06 cw(c7399.69,1806.31) 7399.69,1830 cw(c7399.69,1853.69) v2@7382.94,1836.94 ; 7388,1830 v2(7376,1830) 7402.81,1830 7414.62,1818.19 7420,1818.19 7436.19,1802 7436.19,1768.62 7446.62,1758.19 7461.38,1758.19 7471.81,1768.62 7471.81,1783.38 7464.19,1791 7464.19,1884.69 7464.19,1900 7464.19,1979.38 7474.62,1989.81 7489.38,1989.81 7538.67,1940.51 7563.23,1940.51 7571.24,1932.5 7642.25,1932.5 7650.75,1924 7815.56,1924 7831.56,1940 7870,1940 v1(7885,1955) 7880,1960 v1@7877.82,1960
HOST_SRAM.D0: U30.A15 U47.7 | length 1598.8
  Top Layer w4: U30.A15@7260.71,2165.47 ccw(c7248.18,2178) 7265.91,2178 ccw(c7283.63,2178) U30.A15@7271.1,2165.47 ; U30.A15@7265.91,2160.28 7265.91,2218 ; 7265.91,2219.3 7265.91,2218 ; v2(7299.35,2265.35) 7299.35,2262.05 7265.91,2228.6 7265.91,2218 ; U47.7@7555.59,3176.73 7589.52,3176.73 ; U47.7@7579.46,3171.82 cw(c7589.52,3163.97) 7589.52,3176.73 ; U47.7@7579.46,3181.65 ccw(c7589.52,3189.49) 7589.52,3176.73 ; v1@7633.47,3151.66 ccw(c7617.26,3135.44) 7617.26,3158.37 ccw(c7617.26,3181.31) v1@7633.47,3165.09 ; v1@7636.3,3154.49 ccw(c7626.91,3145.1) 7626.91,3158.37 ccw(c7626.91,3171.65) v1@7636.3,3162.26 ; v1(7640.19,3158.37) 7607.88,3158.37 7589.52,3176.73
  MidLayer1 w4: v2@7292.41,2272.29 ccw(c7275.67,2289.04) 7299.35,2289.04 ccw(c7323.04,2289.04) v2@7306.29,2272.29 ; v2@7295.24,2269.46 ccw(c7285.32,2279.38) 7299.35,2279.38 ccw(c7313.38,2279.38) v2@7303.46,2269.46 ; v2(7299.35,2265.35) 7299.35,2323.2 7299.35,2400.87 v1(7315.19,2416.71)
  MidLayer2 w4: v1@7308.47,2423.43 ccw(c7292.26,2439.64) 7315.19,2439.64 ccw(c7338.13,2439.64) v1@7321.91,2423.43 ; v1@7311.3,2420.6 ccw(c7301.91,2429.99) 7315.19,2429.99 ccw(c7328.47,2429.99) v1@7319.08,2420.6 ; v1(7315.19,2416.71) 7315.19,2456.06 7415.19,2556.06 7415.19,2737.71 7599.52,2922.04 7662.19,2922.04 7681.86,2941.71 7681.86,3116.71 v1(7640.19,3158.37) ; v1@7640.19,3148.87 cw(c7640.19,3125.94) 7656.41,3142.16 cw(c7672.63,3158.37) v1@7649.69,3158.37 ; v1@7640.19,3152.87 cw(c7640.19,3139.6) 7649.58,3148.99 cw(c7658.97,3158.37) v1@7645.69,3158.37
HOST_SRAM.D1: U30.L11 U47.8 | length 3681.4
  Top Layer w4: v2(7044,1414) 7069.5,1414 7074,1409.5 7083.31,1400.19 7107.75,1400.19 7143.44,1364.5 7169.56,1364.5 7196.87,1337.19 7206.81,1337.19 v2(7234,1310) ; v2@7048.11,1409.89 cw(c7058.03,1399.97) 7058.03,1414 cw(c7058.03,1428.03) v2@7048.11,1418.11 ; v2@7050.94,1407.06 cw(c7067.69,1390.31) 7067.69,1414 cw(c7067.69,1437.69) v2@7050.94,1420.94 ; U30.L11@7108.43,1759.23 cw(c7108.43,1741.51) 7120.96,1754.04 cw(c7133.49,1766.57) U30.L11@7115.77,1766.57 ; U30.L11@7108.43,1766.57 v3(7128.11,1746.89) ; v2@7224.19,1310 ccw(c7200.5,1310) 7217.25,1326.75 ccw(c7234,1343.5) v2@7234,1319.81 ; v2@7228.19,1310 ccw(c7214.16,1310) 7224.08,1319.92 ccw(c7234,1329.84) v2@7234,1315.81 ; v2(7384,1328) 7384,1365.44 7387.86,1369.3 7444,1425.44 7444,1597.5 7454.24,1607.74 7471.93,1625.43 7471.93,1676.88 ; v2@7436,2194.19 cw(c7436,2170.5) 7452.75,2187.25 cw(c7469.5,2204) v2@7445.81,2204 ; v2@7436,2198.19 cw(c7436,2184.16) 7445.92,2194.08 cw(c7455.84,2204) v2@7441.81,2204 ; v2(7436,2204) 7453.81,2186.19 7453.81,2177.38 7453.81,2165 7453.81,2142.94 7438.19,2127.32 7438.19,2092.68 7446.18,2084.7 7446.18,1995.3 7440.19,1989.32 7440.19,1935.37 7462,1913.56 7462,1891.82 7454.19,1884 7454.19,1812.31 7479.81,1786.69 7479.81,1763.81 7471.93,1755.93 7471.93,1660 ; U47.8@7555.59,3145.24 7620,3145.24 7631.86,3133.37 v1(7631.86,3098.04) ; U47.8@7578.81,3139.58 cw(c7592.46,3125.92) 7592.46,3145.24 cw(c7592.46,3164.55) U47.8@7578.81,3150.89 ; v1@7625.14,3104.76 ccw(c7608.92,3120.98) 7631.86,3120.98 ccw(c7654.79,3120.98) v1@7638.57,3104.76 ; v1@7627.97,3101.93 ccw(c7618.58,3111.32) 7631.86,3111.32 ccw(c7645.14,3111.32) v1@7635.75,3101.93 ; 7115.31,1759.69 cw(c7102.5,1746.89) 7120.61,1746.89 ccw(c7102.5,1746.89) 7115.31,1759.69 ; 7115.31,1759.69 ccw(c7128.11,1772.5) 7128.11,1754.39 cw(c7128.11,1772.5) 7115.31,1759.69
  MidLayer1 w4: v1@7528.28,2681.72 ccw(c7512.06,2697.93) 7535,2697.93 ccw(c7557.94,2697.93) v1@7541.72,2681.72 ; v1@7531.11,2678.89 ccw(c7521.72,2688.28) 7535,2688.28 ccw(c7548.28,2688.28) v1@7538.89,2678.89 ; v1(7535,2675) 7535,2730 7535,2804.95 7564.86,2834.81 7564.86,2930 7564.86,2950 7564.86,3031.04 v1(7631.86,3098.04) ; v1@7622.36,3098.04 cw(c7599.42,3098.04) 7615.64,3081.82 cw(c7631.86,3065.61) v1@7631.86,3088.54 ; v1@7626.36,3098.04 cw(c7613.08,3098.04) 7622.47,3088.65 cw(c7631.86,3079.26) v1@7631.86,3092.54
  MidLayer2 w4: v2(7044,1414) 7074.19,1414 7080,1408.19 7101.38,1408.19 7124.19,1431 7124.19,1491.38 7151.97,1519.16 7151.97,1590.47 7151.97,1609.89 7151.97,1684.01 7151.97,1707.26 ccw(c7128.2,1707.26) 7145.58,1723.48 7138.5,1732.06 ; v2@7048.11,1409.89 cw(c7058.03,1399.97) 7058.03,1414 cw(c7058.03,1428.03) v2@7048.11,1418.11 ; v2@7050.94,1407.06 cw(c7067.69,1390.31) 7067.69,1414 cw(c7067.69,1437.69) v2@7050.94,1420.94 ; v3@7126.81,1739.5 cw(c7123.66,1721.67) 7138.5,1732.06 ; v3@7135.5,1745.59 ccw(c7153.33,1742.44) 7138.5,1732.06 ; v2(7234,1310) 7259,1335 7345.03,1335 7352.03,1328 v2(7384,1328) ; v2@7234,1315.81 ccw(c7234,1329.84) 7243.92,1319.92 ccw(c7253.84,1310) v2@7239.81,1310 ; v2@7234,1319.81 ccw(c7234,1343.5) 7250.75,1326.75 ccw(c7267.5,1310) v2@7243.81,1310 ; v2@7377.06,1321.06 ccw(c7360.31,1304.31) 7360.31,1328 ccw(c7360.31,1351.69) v2@7377.06,1334.94 ; v2@7379.89,1323.89 ccw(c7369.97,1313.97) 7369.97,1328 ccw(c7369.97,1342.03) v2@7379.89,1332.11 ; v2@7429.06,2210.94 ccw(c7412.31,2227.69) 7436,2227.69 ccw(c7459.69,2227.69) v2@7442.94,2210.94 ; v2@7431.89,2208.11 ccw(c7421.97,2218.03) 7436,2218.03 ccw(c7450.03,2218.03) v2@7440.11,2208.11 ; v2@7435.91,2204.09 v2@7436,2204.18 ; v2(7436,2204) v2@7436,2204.18 ; 7516.23,2657.72 cw(c7535,2638.95) v1@7535,2665.5 ; 7519.84,2661.34 ccw(c7506.18,2675) v1@7525.5,2675 ; 7523.05,2664.55 cw(c7535,2652.61) v1@7535,2669.5 ; v1@7531.86,2673.35 7506,2647.5 7506,2574.19 7507.81,2572.38 7507.81,2431.81 7430.19,2354.19 7430.19,2298.98 7436,2293.17 v2@7436,2204.18
HOST_SRAM.D2: U30.T15 U47.9 | length 3200.1
  Top Layer w4: U30.T15@7260.71,1564.53 cw(c7248.18,1552) 7265.91,1552 cw(c7283.63,1552) U30.T15@7271.1,1564.53 ; U30.T15@7265.91,1569.72 7265.91,1497.59 v2@7320,1443.5 ; 7302.19,1461.31 cw(c7282.88,1442) v2@7310.19,1442 ; 7305.81,1457.69 ccw(c7320,1471.88) v2@7320,1451.81 ; 7309.02,1454.48 cw(c7296.54,1442) v2@7314.19,1442 ; v2@7532,2462.19 cw(c7532,2438.5) 7548.75,2455.25 cw(c7565.5,2472) v2@7541.81,2472 ; v2@7532,2466.19 cw(c7532,2452.16) 7541.92,2462.08 cw(c7551.84,2472) v2@7537.81,2472 ; v2(7532,2472) 7565.5,2438.5 7565.5,2432.5 7565.5,2425 7565.5,2152.71 7598.19,2120.02 7598.19,2046.01 7574.19,2022 7574.19,2000.25 7562.5,1988.56 7562.5,1967.44 7608.5,1921.44 7608.5,1905.44 7624.44,1889.5 7645.56,1889.5 7660.5,1904.44 7681.56,1925.5 7806.87,1925.5 7848.19,1884.18 v2@7848.19,1562 ; U47.9@7555.59,3113.74 7595.56,3113.74 v1(7606.86,3125.04) ; U47.9@7578.81,3108.08 cw(c7592.46,3094.43) 7592.46,3113.74 cw(c7592.46,3133.05) U47.9@7578.81,3119.4
  MidLayer1 w4: v2(7490,1458) 7504.19,1458 7566,1458 7670,1562 v2(7848,1562) ; 7512.19,2514.94 7512.19,2510 7512.19,2491.81 v2(7532,2472) ; 7512.5,2515.25 7543.02,2545.77 7543.02,2582.23 7537.5,2587.75 7537.5,2602.25 7543.02,2607.77 7543.02,2640.79 7515.81,2668.01 7515.81,2797.07 7556.86,2838.12 7556.86,3075.04 v1(7606.86,3125.04) ; v2@7522.19,2472 ccw(c7498.5,2472) 7515.25,2488.75 ccw(c7532,2505.5) v2@7532,2481.81 ; v2@7526.19,2472 ccw(c7512.16,2472) 7522.08,2481.92 ccw(c7532,2491.84) v2@7532,2477.81 ; v1@7597.36,3125.04 cw(c7574.42,3125.04) 7590.64,3108.82 cw(c7606.86,3092.61) v1@7606.86,3115.54 ; v1@7601.36,3125.04 cw(c7588.08,3125.04) 7597.47,3115.65 cw(c7606.86,3106.26) v1@7606.86,3119.54 ; v2@7841.06,1555.06 ccw(c7824.31,1538.31) 7824.31,1562 ccw(c7824.31,1585.69) v2@7841.06,1568.94 ; v2@7843.89,1557.89 ccw(c7833.97,1547.97) 7833.97,1562 ccw(c7833.97,1576.03) v2@7843.89,1566.11
  MidLayer2 w4: v2(7320,1442) 7389,1442 7405,1458 v2(7490,1458) ; v2@7324.11,1437.89 cw(c7334.03,1427.97) 7334.03,1442 cw(c7334.03,1456.03) v2@7324.11,1446.11 ; v2@7326.94,1435.06 cw(c7343.69,1418.31) 7343.69,1442 cw(c7343.69,1465.69) v2@7326.94,1448.94 ; v2@7483.06,1451.06 ccw(c7466.31,1434.31) 7466.31,1458 ccw(c7466.31,1481.69) v2@7483.06,1464.94 ; v2@7485.89,1453.89 ccw(c7475.97,1443.97) 7475.97,1458 ccw(c7475.97,1472.03) v2@7485.89,1462.11
HOST_SRAM.D3: U30.R12 U47.10 | length 4116.3
  Top Layer w4: 7163.3,1589.37 7163.3,1502.7 7167.81,1498.19 7167.81,1453.69 7176,1445.5 v2(7176,1410) ; v2@7169.06,1416.94 ccw(c7152.31,1433.69) 7176,1433.69 ccw(c7199.69,1433.69) v2@7182.94,1416.94 ; v2@7171.89,1414.11 ccw(c7161.97,1424.03) 7176,1424.03 ccw(c7190.03,1424.03) v2@7180.11,1414.11 ; 7520.76,2401.47 ccw(c7540,2420.71) v1@7540,2393.5 ; 7525.03,2397.2 cw(c7511.84,2384) v1@7530.5,2384 ; 7527.59,2394.64 ccw(c7540,2407.05) v1@7540,2389.5 ; U47.10@7531.35,3077.85 ccw(c7523.19,3072.48) 7523.19,3082.24 ; U47.10@7531.35,3086.64 cw(c7523.19,3092.01) 7523.19,3082.24 ; v1@7539.12,2383.12 7498.52,2423.71 7498.52,2518.45 7454.19,2562.78 7454.19,2630.69 7459.19,2635.69 7459.19,2856.04 ; U47.10@7555.59,3082.24 7523.19,3082.24 ; 7160.33,1596.56 ccw(c7147.8,1584.03) 7147.8,1601.75 cw(c7147.8,1584.03) 7160.33,1596.56 ; 7160.33,1596.56 cw(c7172.86,1609.09) 7155.14,1609.09 ccw(c7172.86,1609.09) 7160.33,1596.56 ; 7160.33,1596.56 cw(c7153.15,1589.38) 7163.3,1589.38 ccw(c7153.15,1589.38) 7160.33,1596.56 ; 7451.86,2863.37 7450.05,2865.18 7431.86,2883.37 7431.86,2933.37 7440.19,2941.71 7506.86,2941.71 7515.19,2950.04 7515.19,3074.24 7523.19,3082.24 ; 7451.86,2863.37 7459.19,2856.04 ; 7451.86,2863.37 7459.19,2856.04
  MidLayer1 w4: v2@7169.06,1403.06 cw(c7152.31,1386.31) 7176,1386.31 cw(c7199.69,1386.31) v2@7182.94,1403.06 ; v2@7171.89,1405.89 cw(c7161.97,1395.97) 7176,1395.97 cw(c7190.03,1395.97) v2@7180.11,1405.89 ; v2(7176,1410) 7176,1364.75 7216.19,1324.56 7216.19,1302.62 7227.31,1291.5 7251.25,1291.5 7261.5,1281.25 7261.5,1270 7282.5,1249 7408.55,1249 7457.36,1297.81 7457.36,1420.2 7438,1439.56 7438,1479.94 7466.06,1508 7488.06,1508 7512,1531.94 7512,1547.37 7575.92,1611.29 7581.42,1611.29 7712.62,1742.49 7712.62,1785.4 7770.81,1843.59 7770.81,1953.62 7793.81,1976.62 7793.81,1993 7782.19,2004.62 7782.19,2019.38 7782.19,2032.69 7787,2037.5 7828.88,2037.5 ; v2@7817,2345.19 cw(c7817,2321.5) 7833.75,2338.25 cw(c7850.5,2355) v2@7826.81,2355 ; v2@7817,2349.19 cw(c7817,2335.16) 7826.92,2345.08 cw(c7836.84,2355) v2@7822.81,2355 ; v2(7817,2355) 7849.36,2322.64 7849.36,2298.96 ; 7828.88,2037.5 7848.5,2057.12 ; 7828.88,2037.5 7848.5,2057.12 ; 7848.5,2057.12 7848.5,2202.02 7839.36,2211.16 7839.36,2238.92 7849.36,2248.92 ; 7849.36,2248.92 7849.36,2298.96 ; 7849.36,2248.92 7849.36,2298.96
  MidLayer2 w4: v2@7800,2460.19 cw(c7800,2436.5) 7816.75,2453.25 cw(c7833.5,2470) v2@7809.81,2470 ; v2@7800,2464.19 cw(c7800,2450.16) 7809.92,2460.08 cw(c7819.84,2470) v2@7805.81,2470 ; v2(7800,2470) 7817,2453 v2(7817,2355) ; v2@7810.06,2361.94 ccw(c7793.31,2378.69) 7817,2378.69 ccw(c7840.69,2378.69) v2@7823.94,2361.94 ; v2@7812.89,2359.11 ccw(c7802.97,2369.03) 7817,2369.03 ccw(c7831.03,2369.03) v2@7821.11,2359.11
  Bottom Layer w4: v1@7533.28,2390.72 ccw(c7516.61,2407.39) 7540.19,2407.39 ; v1@7536.11,2387.89 ccw(c7526.26,2397.74) 7540.19,2397.74 ; v1@7540.19,2384.08 7540.19,2414.19 7559.87,2433.87 7643.62,2433.87 7723.94,2514.19 7730.69,2514.19 7747.69,2531.19 7747.69,2538.96 7762.92,2554.19 7798.19,2554.19 7808,2564 7861.07,2564 7864.61,2567.54 7879.11,2567.54 7889.36,2557.29 7889.36,2541.13 7880.77,2532.54 7837.35,2532.54 7802,2497.19 ; 7540.19,2396.82 ccw(c7552.82,2396.82) v1@7543.89,2387.89 ; 7540.19,2406.48 ccw(c7562.48,2406.48) v1@7546.72,2390.72 ; v2@7793.3,2477.17 ccw(c7774.62,2497.19) 7802,2497.19 ; v2@7796.03,2474.25 ccw(c7783.21,2487.98) 7802,2487.98 ; v2@7802,2472 7802,2497.19 ; 7802,2488.86 ccw(c7818.86,2488.86) v2@7806.94,2476.94
  other v1: 7540,2384
HOST_SRAM.D4: U30.A13 U47.13 | length 1325.6
  Top Layer w4: U30.A13@7181.97,2165.47 ccw(c7169.44,2178) 7187.17,2178 ccw(c7204.89,2178) U30.A13@7192.36,2165.47 ; U30.A13@7187.17,2160.28 7187.17,2221.17 7192.19,2226.19 7197.38,2226.19 7207.81,2236.62 v2@7207.81,2277.81 ; v2@7201.06,2271.06 cw(c7184.77,2254.77) 7207.81,2254.77 ; v2@7203.89,2273.89 cw(c7194.43,2264.43) 7207.81,2264.43 ; 7207.81,2253.86 cw(c7232.14,2253.86) v2@7214.94,2271.06 ; 7207.81,2263.51 cw(c7222.49,2263.51) v2@7212.11,2273.89 ; U47.13@7555.59,2987.76 7589.52,2987.76 ; U47.13@7579.46,2982.84 cw(c7589.52,2975) 7589.52,2987.76 ; U47.13@7579.46,2992.67 ccw(c7589.52,3000.51) 7589.52,2987.76 ; v1(7606,2986) 7606.15,2986 7606.86,2986.71 7590.57,2986.71 7589.52,2987.76
  MidLayer2 w4: v2(7208,2278) 7208,2382.81 7366.19,2541 7366.19,2768.19 7420.81,2822.81 7428.81,2822.81 7592.71,2986.71 7605.44,2986.71 7606,2986.15 v1(7606,2986) ; 7565.88,2959.88 cw(c7606,2919.77) v1@7606,2976.5 ; 7572.71,2966.71 cw(c7606,2933.42) v1@7606,2980.5 ; 7579.54,2973.54 cw(c7606,2947.08) v1@7606,2984.5 ; 7586.37,2980.37 cw(c7606,2960.74) v1@7606,2988.5 ; 7593.2,2987.2 cw(c7606,2974.39) v1@7606,2992.5
HOST_SRAM.D5: U30.R13 U47.14 | length 3264
  Top Layer w4: v2@7193.06,1468.94 ccw(c7169.86,1492.14) 7202.67,1492.14 ; v2@7195.89,1466.11 ccw(c7179.52,1482.48) 7202.67,1482.48 ; v2@7202.67,1462 7202.67,1589.38 ; 7202.67,1479.23 ccw(c7217.23,1479.23) v2@7206.94,1468.94 ; U47.14@7555.59,2956.26 7588.82,2956.26 ; U47.14@7579.63,2951.57 cw(c7588.82,2944.92) 7588.82,2956.26 ; U47.14@7579.63,2960.95 ccw(c7588.82,2967.6) 7588.82,2956.26 ; v2@7694.19,2795 ccw(c7670.5,2795) 7687.25,2811.75 ccw(c7704,2828.5) v2@7704,2804.81 ; v2@7698.19,2795 ccw(c7684.16,2795) 7694.08,2804.92 ccw(c7704,2814.84) v2@7704,2800.81 ; v2(7704,2795) 7669.62,2829.38 7661.86,2837.14 7661.86,2883.22 7588.82,2956.26 ; 7199.7,1596.56 cw(c7192.52,1589.38) 7202.67,1589.38 ; 7199.7,1596.56 cw(c7192.52,1589.38) 7202.67,1589.38 ; 7199.7,1596.56 ccw(c7187.17,1584.03) 7187.17,1601.75 cw(c7187.17,1584.03) 7199.7,1596.56 ; 7199.7,1596.56 cw(c7212.23,1609.09) 7194.51,1609.09 ccw(c7212.23,1609.09) 7199.7,1596.56
  MidLayer1 w4: v2@7200,1452.19 cw(c7200,1428.5) 7216.75,1445.25 cw(c7233.5,1462) v2@7209.81,1462 ; v2@7200,1456.19 cw(c7200,1442.16) 7209.92,1452.08 cw(c7219.84,1462) v2@7205.81,1462 ; v2(7200,1462) 7221.81,1440.19 7221.81,1418.62 7221.44,1418.25 7221.44,1359.06 7259.81,1320.69 7259.81,1307 7272.62,1294.19 7287.38,1294.19 7317,1323.81 7351.87,1323.81 7422,1393.94 7422,1486.57 7459.43,1524 7480.5,1524 7496,1539.5 7496,1554 7569.29,1627.29 7574.79,1627.29 7696.62,1749.12 7696.62,1792.03 7712.5,1807.9 7727.19,1822.6 7729.81,1825.22 7729.81,1910 7729.81,1975 7729.81,2017.83 7727.75,2019.9 v2(7726.9,2019.9)
  MidLayer2 w4: v2@7860.11,2386.4 ccw(c7836.42,2386.4) 7853.17,2403.15 ccw(c7869.92,2419.89) v2@7869.92,2396.21 ; v2@7864.11,2386.4 ccw(c7850.08,2386.4) 7860,2396.32 ccw(c7869.92,2406.24) v2@7869.92,2392.21 ; v2@7868.8,2386.4 v2(7869.92,2386.4) 7848.73,2407.59 7848.73,2441.27 7894,2486.55 7894,2806 v2(7925,2837) ; v2@7915.19,2837 cw(c7891.5,2837) 7908.25,2820.25 cw(c7925,2803.5) v2@7925,2827.19 ; v2@7919.19,2837 cw(c7905.16,2837) 7915.08,2827.08 cw(c7925,2817.16) v2@7925,2831.19
  Bottom Layer w4: v2(7704,2795) 7706,2797 7885,2797 v2(7925,2837) ; v2@7708.11,2790.89 cw(c7722.86,2776.14) 7722.86,2797 cw(c7722.86,2813.86) v2@7710.94,2801.94 ; v2@7710.94,2788.06 cw(c7732.51,2766.49) 7732.51,2797 ; v2@7719.96,2026.84 ccw(c7704.93,2041.87) 7726.19,2041.87 ; v2@7722.79,2024.01 ccw(c7714.59,2032.21) 7726.19,2032.21 ; 7726.19,2034.95 ccw(c7741.01,2034.95) v2@7730.87,2024.14 ; v2(7726.9,2019.9) 7726.09,2020.71 7726.09,2026 7726.19,2026.1 7726.19,2044.19 ; v2@7733.61,2027.06 cw(c7749.67,2044.19) 7726.19,2044.19 ; v2(7869.92,2386.4) 7869.6,2386.4 7855.36,2372.16 7855.36,2170.29 7789.5,2104.44 7789.5,2069.44 7774.56,2054.5 7736.5,2054.5 7726.19,2044.19 ; v2@7915.19,2837 cw(c7891.5,2837) 7908.25,2820.25 cw(c7925,2803.5) v2@7925,2827.19 ; v2@7919.19,2837 cw(c7905.16,2837) 7915.08,2827.08 cw(c7925,2817.16) v2@7925,2831.19
HOST_SRAM.D6: U30.C14 U47.15 | length 2108
  Top Layer w4: U30.C14@7226.54,2081.54 v3(7246.22,2101.22) ; U30.C14@7226.54,2088.88 ccw(c7226.54,2106.6) 7239.07,2094.07 ccw(c7251.6,2081.54) U30.C14@7233.88,2081.54 ; U47.15@7555.59,2924.76 7600.24,2924.76 7606.86,2918.14 v1(7606.86,2902.71) ; U47.15@7578.81,2919.11 cw(c7592.46,2905.45) 7592.46,2924.76 cw(c7592.46,2944.08) U47.15@7578.81,2930.42 ; 7233.42,2088.42 cw(c7246.22,2075.61) 7246.22,2093.72 ccw(c7246.22,2075.61) 7233.42,2088.42 ; 7233.42,2088.42 ccw(c7220.61,2101.22) 7238.72,2101.22 cw(c7220.61,2101.22) 7233.42,2088.42
  MidLayer1 w4: v3@7244.92,2108.61 ccw(c7241.77,2126.44) 7256.61,2116.05 ; v3@7253.61,2102.52 cw(c7271.44,2105.67) 7256.61,2116.05 ; v1(7606.86,2902.71) 7665.19,2902.71 7681.86,2919.37 7681.86,3016.71 7665.19,3033.37 7665.19,3250.04 7648.52,3266.71 7565.19,3266.71 7540.19,3241.71 7540.19,2844.08 7466.19,2770.08 7466.19,2728.69 7459.19,2721.69 7459.19,2694.31 7459.19,2623 7459.19,2615.62 7459.19,2589.19 7266.52,2396.52 7266.52,2279.6 7253.75,2266.82 7253.75,2252.07 7261.73,2244.08 7261.73,2218.27 7261.73,2133.9 cw(c7228.6,2133.73) 7256.64,2116.08 ; v1@7610.75,2898.82 cw(c7620.14,2889.43) 7620.14,2902.71 cw(c7620.14,2915.99) v1@7610.75,2906.6 ; v1@7613.57,2895.99 cw(c7629.79,2879.77) 7629.79,2902.71 cw(c7629.79,2925.64) v1@7613.57,2909.43
HOST_SRAM.D7: U30.T14 U47.16 | length 3327.5
  Top Layer w4: U30.T14@7221.34,1564.53 cw(c7208.81,1552) 7226.54,1552 cw(c7244.26,1552) U30.T14@7231.73,1564.53 ; U30.T14@7226.54,1569.72 7226.6,1569.66 7226.6,1498.79 7225.19,1497.38 7225.19,1474.63 v2(7237.44,1462.38) ; U47.16@7555.59,2893.27 7587.15,2893.27 ; U47.16@7580.04,2889.21 cw(c7587.15,2885.02) 7587.15,2893.27 ; U47.16@7580.04,2897.33 ccw(c7587.15,2901.52) 7587.15,2893.27 ; v2@7725.19,2665 ccw(c7701.5,2665) 7718.25,2681.75 ccw(c7735,2698.5) v2@7735,2674.81 ; v2@7729.19,2665 ccw(c7715.16,2665) 7725.08,2674.92 ccw(c7735,2684.84) v2@7735,2670.81 ; v2(7735,2665) 7718,2682 7718,2731.31 7630.38,2818.94 7630.38,2850.04 7587.15,2893.27
  MidLayer1 w4: v2@7237.81,1462.01 7237.81,1412 7237.44,1411.62 7237.44,1372.81 7278.44,1331.81 7348.56,1331.81 7414,1397.25 7414,1489.88 7456.12,1532 7477.19,1532 7487.81,1542.62 7487.81,1557.81 7565.29,1635.29 7571.48,1635.29 7688.62,1752.43 7688.62,1795.34 7710,1816.72 7710,1994 v2(7711.8,1995.8)
  MidLayer2 w4: v2(7813,2226) 7864.36,2277.36 7864.36,2292.96 7908.4,2337 7935.69,2337 8082,2483.31 8082,2808.94 v2(8061.47,2829.47) ; v2@7813,2231.81 ccw(c7813,2245.84) 7822.92,2235.92 ccw(c7832.84,2226) v2@7818.81,2226 ; v2@7813,2235.81 ccw(c7813,2259.5) 7829.75,2242.75 ccw(c7846.5,2226) v2@7822.81,2226 ; v2@8061.47,2819.66 cw(c8061.47,2795.97) 8078.22,2812.72 cw(c8094.97,2829.47) v2@8071.28,2829.47 ; v2@8061.47,2823.66 cw(c8061.47,2809.63) 8071.39,2819.55 cw(c8081.31,2829.47) v2@8067.28,2829.47
  Bottom Layer w4: v2(7711.8,1995.8) 7708.19,1999.41 7708.19,2047.6 7723.08,2062.5 7771.25,2062.5 7781.5,2072.75 7781.5,2107.75 7813,2139.25 v2(7813,2226) v2@7819,2220 ; v2(7735,2665) 7883.13,2665 8030.98,2812.85 8044.85,2812.85 ; v2@7739.11,2660.89 cw(c7749.03,2650.97) 7749.03,2665 cw(c7749.03,2679.03) v2@7739.11,2669.11 ; v2@7741.94,2658.06 cw(c7758.69,2641.31) 7758.69,2665 cw(c7758.69,2688.69) v2@7741.94,2671.94 ; v2@7806.06,2219.06 cw(c7789.31,2202.31) 7813,2202.31 cw(c7836.69,2202.31) v2@7819.94,2219.06 ; v2@7808.89,2221.89 cw(c7798.97,2211.97) 7813,2211.97 cw(c7827.03,2211.97) v2@7817.11,2221.89 ; v2@8051.66,2829.41 cw(c8028.41,2829.29) 8044.85,2812.85 ; v2@8055.66,2829.44 cw(c8041.89,2829.36) 8051.63,2819.62 cw(c8061.37,2809.89) v2@8061.44,2823.66 ; v2@8061.42,2819.66 ccw(c8061.29,2796.41) 8044.85,2812.85 ; v2(8061.47,2829.47) 8044.85,2812.85
HOST_SRAM.D8: U30.F16 U47.29 | length 2287.1
  Top Layer w4: U30.F16@7305.28,1963.43 v2@7383.42,1963.42 ; U30.F16@7310.47,1958.23 cw(c7323,1945.7) 7323,1963.42 cw(c7323,1981.15) U30.F16@7310.47,1968.62 ; 7356.05,1963.42 cw(c7356.05,1928.05) v2@7381.06,1953.06 ; 7365.7,1963.42 cw(c7365.7,1937.7) v2@7383.89,1955.89 ; 7372.58,1963.42 ccw(c7372.58,1975.42) v2@7381.06,1966.94 ; 7375.36,1963.42 cw(c7375.36,1947.36) v2@7386.72,1958.72 ; U47.29@8004.41,2893.27 8113.63,2893.27 8306.86,2700.04 8306.86,2473.56 v1(8275,2441.71) ; U47.29@8027.63,2887.61 cw(c8041.28,2873.95) 8041.28,2893.27 cw(c8041.28,2912.58) U47.29@8027.63,2898.92 ; v1@8275,2447.21 ccw(c8275,2460.49) 8284.39,2451.1 ccw(c8293.78,2441.71) v1@8280.5,2441.71 ; v1@8275,2451.21 ccw(c8275,2474.14) 8291.22,2457.93 ccw(c8307.44,2441.71) v1@8284.5,2441.71
  Bottom Layer w4: v2@7388.85,1958 7402.55,1958 7403.04,1958.49 7428.55,1958.49 7431.84,1961.78 7431.84,1993.78 7486.87,2048.81 7592.38,2048.81 7683,1958.19 7786.69,1958.19 7801.81,1973.31 7844.31,2015.81 ; v1@8268.28,2434.99 ccw(c8252.06,2418.77) 8252.06,2441.71 ccw(c8252.06,2464.64) v1@8268.28,2448.43 ; v1@8271.11,2437.82 ccw(c8261.72,2428.43) 8261.72,2441.71 ccw(c8261.72,2454.99) v1@8271.11,2445.6 ; v1(8275,2441.71) 8192.21,2441.71 8015.19,2264.69 8015.19,2095.04 7927.65,2007.5 7905.98,2007.5 7879,2007.5 7870.69,2015.81 ; 7844.31,2015.81 7870.69,2015.81 ; 7844.31,2015.81 7850,2015.81 7870.69,2015.81
  other v2: 7388,1960
HOST_SRAM.D9: U30.L14 U47.30 | length 2462.5
  Top Layer w4: U30.L14@7226.54,1759.23 cw(c7226.54,1741.51) 7239.07,1754.04 cw(c7251.6,1766.57) U30.L14@7233.88,1766.57 ; U30.L14@7226.54,1766.57 v3(7246.22,1746.89) ; v1@7950.14,2881.76 ccw(c7933.92,2897.98) 7956.86,2897.98 ccw(c7979.79,2897.98) v1@7963.57,2881.76 ; v1@7952.97,2878.93 ccw(c7943.58,2888.32) 7956.86,2888.32 ccw(c7970.14,2888.32) v1@7960.75,2878.93 ; v1(7956.86,2875.04) 7956.86,2916.43 7965.19,2924.76 U47.30@8004.41,2924.76 ; U47.30@7981.19,2919.11 ccw(c7967.54,2905.45) 7967.54,2924.76 ccw(c7967.54,2944.08) U47.30@7981.19,2930.42 ; 7233.42,1759.69 cw(c7220.61,1746.89) 7238.72,1746.89 ccw(c7220.61,1746.89) 7233.42,1759.69 ; 7233.42,1759.69 ccw(c7246.22,1772.5) 7246.22,1754.39 cw(c7246.22,1772.5) 7233.42,1759.69
  MidLayer1 w4: v3@7247.52,1739.5 cw(c7250.67,1721.67) 7261.05,1736.5 cw(c7271.44,1751.34) v3@7253.61,1748.19 ; 7261.08,1736.47 ccw(c7278.73,1764.51) 7278.9,1731.38 7369.43,1731.38 7386.81,1714 7409.71,1714 7413.21,1717.5 7437.25,1717.5 7447.5,1707.25 7447.5,1692.75 7428.31,1673.56 7428.31,1657.88 7434,1652.19 ; 7434,1652 7437.63,1648.37 7490,1648.37 7530.34,1648.37 7626.82,1744.86 7702,1820.03 7702,1980.41 7693.99,1988.42 7693.99,2012.18 7725.62,2043.81 7746.19,2043.81 7755,2035 v2@7755,2020
  MidLayer2 w4: v1@7956.86,2865.54 cw(c7956.86,2842.61) 7973.07,2858.82 cw(c7989.29,2875.04) v1@7966.36,2875.04 ; v1@7956.86,2869.54 cw(c7956.86,2856.26) 7966.25,2865.65 cw(c7975.64,2875.04) v1@7962.36,2875.04 ; v1(7956.86,2875.04) 7998.52,2833.37 v1(7998.52,2575.04) ; v1@7991.81,2581.76 ccw(c7975.59,2597.98) 7998.52,2597.98 ccw(c8021.46,2597.98) v1@8005.24,2581.76 ; v1@7994.64,2578.93 ccw(c7985.25,2588.32) 7998.52,2588.32 ccw(c8011.8,2588.32) v1@8002.41,2578.93
  Bottom Layer w4: v2(7754.6,2020) 7784.6,2050 7786,2050 7818.75,2050 7832.5,2063.75 7832.5,2100.68 7931.86,2200.04 7931.86,2251.37 7948.52,2268.04 7948.52,2485.71 7954.52,2491.71 7995.86,2491.71 7998.52,2494.37 v1(7998.52,2575.04) ; v2@7754.6,2025.81 ccw(c7754.6,2039.84) 7764.52,2029.92 ccw(c7774.44,2020) v2@7760.41,2020 ; v2@7754.6,2029.81 ccw(c7754.6,2053.5) 7771.35,2036.75 ccw(c7788.1,2020) v2@7764.41,2020 ; v1@7991.81,2568.32 cw(c7975.59,2552.11) 7998.52,2552.11 cw(c8021.46,2552.11) v1@8005.24,2568.32 ; v1@7994.64,2571.15 cw(c7985.25,2561.76) 7998.52,2561.76 cw(c8011.8,2561.76) v1@8002.41,2571.15
HOST_SRAM.D10: U30.G11 U47.31 | length 2508.9
  Top Layer w4: U30.G11@7108.43,1924.05 v3(7128.11,1943.74) ; U30.G11@7108.43,1931.4 ccw(c7108.42,1949.12) 7120.96,1936.59 ccw(c7133.49,1924.05) U30.G11@7115.77,1924.05 ; v1(7923.52,2933.37) 7945.97,2933.37 ; v1@7927.47,2929.55 cw(c7936.52,2920.78) 7936.52,2933.37 cw(c7936.52,2945.97) v1@7927.47,2937.2 ; v1@7930.35,2926.76 cw(c7945.96,2911.62) 7945.96,2933.37 ; v1@7930.35,2939.99 ccw(c7945.96,2955.13) 7945.96,2933.37 ; U47.31@7980.91,2950.9 ccw(c7968.85,2940.01) 7968.85,2956.26 ; U47.31@7980.91,2961.62 cw(c7968.85,2972.51) 7968.85,2956.26 ; U47.31@8004.41,2956.26 7968.85,2956.26 ; 7115.31,1930.94 cw(c7128.11,1918.13) 7128.11,1936.24 ccw(c7128.11,1918.13) 7115.31,1930.94 ; 7115.31,1930.94 ccw(c7102.5,1943.74) 7120.61,1943.74 cw(c7102.5,1943.74) 7115.31,1930.94 ; 7945.97,2933.37 7968.85,2956.26
  MidLayer1 w4: 7907.05,2917.05 cw(c7923.52,2900.58) v1@7923.52,2923.87 ; 7907.41,2917.41 ccw(c7891.45,2933.37) v1@7914.02,2933.37 ; 7913.88,2923.88 cw(c7923.52,2914.24) v1@7923.52,2927.87 ; 7914.24,2924.24 ccw(c7905.11,2933.37) v1@7918.02,2933.37 ; v1(7923.52,2933.37) 7923.37,2933.37 7851.39,2861.39 ; v1@7946.6,2254.72 ccw(c7936.59,2267.21) 7952.6,2267.21 ; v1@7949.1,2251.6 ccw(c7943.27,2258.88) 7952.6,2258.88 ; v1(7952.54,2247.31) 7952.6,2247.37 7952.6,2267.22 ; v1@7958.55,2254.67 cw(c7968.8,2267.21) 7952.6,2267.21 ; 7830.5,2840.5 7830.5,2731.88 7830.5,2720 7830.5,2663.49 7830.5,2599.19 7824.5,2593.19 7824.5,2503.32 7835,2492.82 7835,2396.13 7881.36,2349.77 7881.36,2338.46 7891.06,2328.76 7952.6,2267.22 ; 7830.5,2840.5 7851.39,2861.39 ; 7830.5,2840.5 7851.39,2861.39
  MidLayer2 w4: v3@7128.76,1951.21 ccw(c7130.34,1969.25) 7141.98,1955.38 ; v3@7135.58,1943.09 cw(c7153.62,1941.51) 7141.98,1955.38 ; v1@7952.54,2237.81 cw(c7952.54,2210.66) 7971.74,2229.86 ; v1@7952.54,2241.81 cw(c7952.54,2224.32) 7964.91,2236.69 ; v1(7952.54,2247.31) 7954.29,2247.31 7986,2215.6 7986,2026 7956,1996 7879.19,1996 7829.38,2045.81 7677.69,2045.81 7659.69,2027.81 7527.81,2027.81 7511.02,2011.02 7511.02,1934.1 7496.91,1920 7460.69,1920 7402.88,1977.81 7380.62,1977.81 7370.41,1967.6 7284.53,1967.6 7265.11,1967.6 7190.99,1967.6 7171.49,1967.6 ccw(c7171.49,1925.87) 7141.98,1955.38 ; v1@7962.04,2247.31 ccw(c7980.76,2247.31) 7967.53,2234.07
HOST_SRAM.D11: U30.D15 U47.32 | length 1766.8
  Top Layer w4: 7361.89,2058.01 cw(c7361.89,2025.23) v2@7385.06,2048.41 ; 7371.54,2058.01 cw(c7371.54,2034.89) v2@7387.89,2051.24 ; 7374.74,2058.01 ccw(c7374.74,2072.6) v2@7385.06,2062.28 ; v2@7389.34,2058.01 7285.95,2058.01 7285.62,2057.67 ; v1(7948.52,2972.04) 7948.52,2974.37 7961.91,2987.76 U47.32@8004.41,2987.76 ; U47.32@7981.19,2982.1 ccw(c7967.54,2968.44) 7967.54,2987.76 ccw(c7967.54,3007.07) U47.32@7981.19,2993.41 ; 7278.44,2054.7 cw(c7285.62,2047.52) 7285.62,2057.67 ; 7278.44,2054.7 cw(c7285.62,2047.52) 7285.62,2057.67 ; 7278.44,2054.7 ccw(c7290.97,2042.16) 7273.25,2042.16 cw(c7290.97,2042.16) 7278.44,2054.7 ; 7278.44,2054.7 cw(c7265.91,2067.23) 7265.91,2049.51 ccw(c7265.91,2067.23) 7278.44,2054.7
  MidLayer2 w4: v2@7394.65,2055.35 7411.65,2055.35 ; v2@7399.84,2049.45 cw(c7411.65,2040.57) 7411.65,2055.35 ; v2@7399.84,2061.24 ccw(c7411.65,2070.13) 7411.65,2055.35 ; 7438,2062 7437.85,2061.85 ; 7765,2150 7765,2140.37 7749.67,2125.04 7730.15,2125.04 7723.38,2131.81 7702.62,2131.81 7695.85,2125.04 7657.29,2125.04 7642.5,2110.25 7642.5,2092.5 7616,2066 7442,2066 7437.85,2061.85 ; 7765.19,2150 7765.19,2483.01 7778.68,2496.5 7788.88,2496.5 7822.5,2530.12 7822.5,2637.7 7814.7,2645.5 7814.7,2791.21 7815.19,2791.71 7948.52,2925.04 v1(7948.52,2972.04) ; v1@7941.81,2965.32 cw(c7925.59,2949.11) 7948.52,2949.11 cw(c7971.46,2949.11) v1@7955.24,2965.32 ; v1@7944.64,2968.15 cw(c7935.25,2958.76) 7948.52,2958.76 cw(c7961.8,2958.76) v1@7952.41,2968.15 ; 7411.65,2055.35 7415,2052 ; 7415,2052 7428,2052 ; 7415,2052 7428,2052 ; 7428,2052 7437.85,2061.85
  other v2: 7392,2055.35
HOST_SRAM.D12: U30.K11 U47.35 | length 2862.2
  Top Layer w4: U30.K11@7108.43,1798.6 cw(c7108.42,1780.88) 7120.96,1793.41 cw(c7133.49,1805.94) U30.K11@7115.77,1805.94 ; U30.K11@7108.43,1805.94 v3(7128.11,1786.26) ; v1@7964.02,2303.04 ccw(c7941.09,2303.04) 7957.31,2319.26 ccw(c7973.52,2335.48) v1@7973.52,2312.54 ; v1@7968.02,2303.04 ccw(c7954.75,2303.04) 7964.14,2312.43 ccw(c7973.52,2321.82) v1@7973.52,2308.54 ; v1(7973.52,2303.04) 7945,2331.56 7945,2561.9 7898.12,2608.78 7898.12,2904.32 7890.19,2912.25 7890.19,3058.37 7914.06,3082.24 U47.35@8004.41,3082.24 ; U47.35@7981.19,3076.59 ccw(c7967.54,3062.93) 7967.54,3082.24 ccw(c7967.54,3101.56) U47.35@7981.19,3087.9 ; 7115.31,1799.06 cw(c7102.5,1786.26) 7120.61,1786.26 ccw(c7102.5,1786.26) 7115.31,1799.06 ; 7115.31,1799.06 ccw(c7128.11,1811.87) 7128.11,1793.76 cw(c7128.11,1811.87) 7115.31,1799.06
  MidLayer2 w4: v3@7128.76,1778.79 cw(c7130.34,1760.75) 7141.98,1774.62 ; v3@7135.58,1786.91 ccw(c7153.62,1788.49) 7141.98,1774.62 ; v2(7972,1954) 7989.37,1954 ; v1@7973.52,2293.54 cw(c7973.52,2270.61) 7989.74,2286.82 cw(c8005.96,2303.04) v1@7983.02,2303.04 ; v1@7973.52,2297.54 cw(c7973.52,2284.26) 7982.91,2293.65 cw(c7992.3,2303.04) v1@7979.02,2303.04 ; v1(7973.52,2303.04) 7999.19,2277.37 7999.19,1963.82 7989.37,1954 ; v2@7976.45,1767.88 cw(c7952.76,1767.88) 7969.51,1751.13 cw(c7986.26,1734.39) v2@7986.26,1758.07 ; v2@7980.4,1948.93 cw(c7989.37,1943.53) 7989.37,1954 ; v2@7980.4,1959.07 ccw(c7989.37,1964.47) 7989.37,1954 ; v2@7980.45,1767.88 cw(c7966.42,1767.88) 7976.34,1757.96 cw(c7986.26,1748.04) v2@7986.26,1762.07 ; v2(7986.26,1767.88) 7942.57,1724.19 7775.38,1724.19 7767.38,1716.19 7752.62,1716.19 7744.62,1724.19 7660.38,1724.19 7652.38,1716.19 7611.08,1716.19 7590.16,1737.11 7508.8,1737.11 7497.69,1726 7488.73,1726 7409.19,1726 7399.38,1716.19 7383.81,1716.19 7337.6,1762.4 7284.53,1762.4 7265.11,1762.4 7190.99,1762.4 7171.49,1762.4 cw(c7171.49,1804.13) 7141.98,1774.62
  Bottom Layer w4: v2(7972,1954) 7991,1954 ; v2@7980,1948.32 cw(c7991,1940.51) 7991,1954 ; v2@7980,1959.68 ccw(c7991,1967.49) 7991,1954 ; v2(7986.26,1767.88) 7986.26,1771.71 8002.5,1787.95 ; v2@7986.26,1777.69 ccw(c7986.26,1792.15) 7996.48,1781.93 ; v2@7992.03,1768.59 cw(c8008.26,1770.58) 7996.7,1782.14 ; v2@7996,1769.08 cw(c8018.6,1771.84) 8002.5,1787.94 ; 7991,1954 8002.5,1942.5 8002.5,1909.3 8002.5,1905 8002.5,1787.95
HOST_SRAM.D13: U30.T13 U47.36 | length 3761.9
  Top Layer w4: U30.T13@7181.97,1564.53 cw(c7169.44,1552) 7187.17,1552 cw(c7204.89,1552) U30.T13@7192.36,1564.53 ; 7182.19,1460 7182.19,1450.62 ; 7185.26,1447.55 cw(c7163.72,1426) v2@7194.19,1426 ; U30.T13@7187.2,1569.69 7187.2,1474.39 7182.19,1469.38 7182.19,1450.62 ; 7192.09,1440.72 cw(c7177.37,1426) v2@7198.19,1426 ; 7192.05,1440.76 ccw(c7204,1452.71) v2@7204,1435.81 ; v2@7203.69,1429.13 7203.69,1426 7203.69,1421.38 7204,1421.69 v2(7204,1426) 7204,1428.81 7182.19,1450.62 ; v2@7773.06,2573.06 cw(c7756.31,2556.31) 7780,2556.31 cw(c7803.69,2556.31) v2@7786.94,2573.06 ; v2@7775.89,2575.89 cw(c7765.97,2565.97) 7780,2565.97 cw(c7794.03,2565.97) v2@7784.11,2575.89 ; v2(7776,1984) 7774.19,1985.81 7774.19,2054.13 7789.5,2069.44 7789.5,2090.56 7774.61,2105.45 7774.61,2436.26 7758.19,2452.68 7758.19,2493.32 7770.64,2505.77 7775.52,2505.77 7792.5,2522.75 7792.5,2537.25 7780,2549.75 v2(7780,2580) ; U47.36@8004.41,3113.74 8097.55,3113.74 8110.83,3127.02 8171.88,3127.02 v1(8207.19,3091.71) ; U47.36@8027.63,3108.08 cw(c8041.28,3094.43) 8041.28,3113.74 cw(c8041.28,3133.05) U47.36@8027.63,3119.4 ; v1@8197.69,3091.71 ccw(c8174.76,3091.71) 8190.97,3107.93 ccw(c8207.19,3124.14) v1@8207.19,3101.21 ; v1@8201.69,3091.71 ccw(c8188.41,3091.71) 8197.8,3101.1 ccw(c8207.19,3110.49) v1@8207.19,3097.21
  MidLayer1 w4: v2@7197.06,1419.06 cw(c7180.31,1402.31) 7204,1402.31 cw(c7227.69,1402.31) v2@7210.94,1419.06 ; v2@7199.89,1421.89 cw(c7189.97,1411.97) 7204,1411.97 cw(c7218.03,1411.97) v2@7208.11,1421.89 ; v2(7204,1426) 7204,1365.19 7251.81,1317.38 7251.81,1302.25 7269.5,1284.56 7269.5,1273.31 7285.81,1257 7405.23,1257 7449.36,1301.13 7449.36,1416.89 7430,1436.24 7430,1483.25 7462.75,1516 7483.82,1516 7504,1536.18 7504,1550.69 7572.6,1619.29 7578.1,1619.29 7704.62,1745.81 7704.62,1788.72 7731.29,1815.38 7754.69,1838.78 7754.69,1916.5 7754.69,1962.69 v2(7776,1984) ; v2@7766.19,1984 cw(c7742.5,1984) 7759.25,1967.25 cw(c7776,1950.5) v2@7776,1974.19 ; v2@7770.19,1984 cw(c7756.16,1984) 7766.08,1974.08 cw(c7776,1964.16) v2@7776,1978.19
  Bottom Layer w4: v2(7780,2580) 7854.44,2580 7857.98,2583.54 7865,2583.54 7977.69,2583.54 7994.19,2600.04 8004.86,2600.04 8014.9,2600.04 8031.23,2583.71 8282.19,2583.71 8295,2596.52 8295,3036.9 8240.19,3091.71 v1(8207.19,3091.71) ; v1@8211.08,3087.82 cw(c8220.47,3078.43) 8220.47,3091.71 cw(c8220.47,3104.99) v1@8211.08,3095.6 ; v1@8213.91,3084.99 cw(c8230.13,3068.77) 8230.13,3091.71 cw(c8230.13,3114.64) v1@8213.91,3098.43
HOST_SRAM.D14: U30.C15 U47.37 | length 2114.7
  Top Layer w4: 7346.8,2097.38 ccw(c7346.8,2147.37) v2@7382.14,2112.02 ; 7356.45,2097.38 ccw(c7356.45,2137.71) v2@7384.97,2109.19 ; 7366.11,2097.38 ccw(c7366.11,2128.05) v2@7387.8,2106.36 ; 7375.77,2097.38 ccw(c7375.77,2118.4) v2@7390.63,2103.53 ; v2(7389.08,2105.08) 7381.04,2097.04 7380.71,2097.38 7285.95,2097.38 7285.62,2097.04 ; v1(7960.52,3141.71) 7964.05,3145.24 U47.37@8004.41,3145.24 ; v1@7961.58,3140.65 cw(c7972.66,3129.57) 7972.66,3145.24 ; v1@7964.41,3137.82 cw(c7982.32,3119.91) U47.37@7982.32,3145.24 ; v1@7967.24,3134.99 cw(c7991.98,3110.26) U47.37@7991.98,3145.24 ; v1@7967.24,3148.43 ccw(c7974.94,3156.13) 7974.94,3145.24 ; 7278.44,2094.07 cw(c7285.62,2086.89) 7285.62,2097.04 ; 7278.44,2094.07 cw(c7285.62,2086.89) 7285.62,2097.04 ; 7278.44,2094.07 ccw(c7290.97,2081.53) 7273.25,2081.53 cw(c7290.97,2081.53) 7278.44,2094.07 ; 7278.44,2094.07 cw(c7265.91,2106.6) 7265.91,2088.88 ccw(c7265.91,2106.6) 7278.44,2094.07
  MidLayer2 w4: v2(7389.08,2105.08) 7459.73,2105.08 7472.62,2092.19 7507.34,2092.19 7562.96,2147.81 7730,2147.81 7736.44,2141.37 7741.35,2141.37 7748.86,2148.88 7748.86,2489.3 7772.06,2512.5 7782.25,2512.5 7792.5,2522.75 ; v2@7393.19,2100.97 cw(c7403.11,2091.05) 7403.11,2105.08 cw(c7403.11,2119.11) v2@7393.19,2109.19 ; v2@7396.02,2098.14 cw(c7412.77,2081.4) 7412.77,2105.08 cw(c7412.77,2128.77) v2@7396.02,2112.02 ; v1@7953.81,3134.99 ccw(c7937.59,3118.77) 7937.59,3141.71 ccw(c7937.59,3164.64) v1@7953.81,3148.43 ; v1@7956.64,3137.82 ccw(c7947.25,3128.43) 7947.25,3141.71 ccw(c7947.25,3154.99) v1@7956.64,3145.6 ; v1(7960.52,3141.71) 7915.19,3141.71 7798.52,3025.04 7784,3010.52 7784,2688.69 7762.19,2666.88 7762.19,2572.62 ; 7762.19,2572.62 7772.62,2562.19 ; 7762.19,2572.62 7772.62,2562.19 ; 7772.62,2562.19 7792.5,2542.31 ; 7772.62,2562.19 7773,2562.19 7792.5,2542.69 7792.5,2542.31 ; 7792.5,2522.75 7792.5,2542.31 ; 7792.5,2522.75 7792.5,2542.31
HOST_SRAM.D15: U30.G16 U47.38 | length 2332.8
  Top Layer w4: U30.G16@7305.28,1924.05 7354.33,1924.05 7379.95,1924.05 v2@7390,1914 ; U30.G16@7310.47,1918.86 cw(c7323,1906.33) 7323,1924.05 cw(c7323,1941.78) U30.G16@7310.47,1929.25 ; v1(7954.86,3175.04) 7956.55,3176.73 U47.38@8004.41,3176.73 ; v1@7958.75,3171.15 cw(c7972.22,3157.68) 7972.22,3176.73 ; v1@7961.57,3168.32 cw(c7981.87,3148.02) U47.38@7981.87,3176.73 ; v1@7961.57,3181.76 ccw(c7973.71,3193.89) 7973.71,3176.73
  MidLayer1 w4: v2@7388.19,1911.81 7417,1911.81 7429.81,1924.62 ; v2@7392.11,1907.89 cw(c7401.57,1898.43) 7401.57,1911.81 ; v2@7392.11,1916.11 ccw(c7402.49,1926.49) 7402.49,1911.81 ; v2@7394.94,1905.06 cw(c7411.23,1888.77) 7411.23,1911.81 ; v2@7394.94,1918.94 ccw(c7412.14,1936.14) 7412.14,1911.81 ; 7429.59,1939.59 7429.81,1939.38 ; 7655,2635 7667.19,2647.19 ; v1@7785.69,3175.04 cw(c7762.76,3175.04) 7778.97,3158.82 cw(c7795.19,3142.61) v1@7795.19,3165.54 ; v1@7789.69,3175.04 cw(c7776.41,3175.04) 7785.8,3165.65 cw(c7795.19,3156.26) v1@7795.19,3169.54 ; v1(7795.19,3175.04) 7764.67,3144.52 7764.67,2993.78 7764.67,2909.09 ; 7429.81,1924.62 7429.81,1939.38 ; 7429.81,1924.62 7429.81,1939.38 ; 7429.81,1939.38 7429.81,1961.81 7429.81,1970.01 7467.8,2008 7476,2008 7507.5,2008 7509.5,2010 7518.19,2018.69 7535.31,2035.81 7550,2035.81 7556.69,2035.81 7570.68,2035.81 7579.36,2044.48 7674.68,2139.81 7713.78,2139.81 7742.61,2168.64 7742.61,2185.52 7742.61,2393.86 7726.19,2410.28 7726.19,2497.48 7689.17,2534.5 7680.75,2534.5 7657,2558.25 7657,2602.81 7647.19,2612.62 7647.19,2627.38 ; 7647.19,2627.38 7654.91,2635.09 7667,2647.19 ; 7647.19,2627.38 7667,2647.19 ; 7667,2647.19 7667.19,2647.19 ; 7667.19,2647.19 7747.38,2647.19 7766,2665.81 7777,2676.81 7782.5,2682.31 ; 7764.67,2909.09 7765.69,2908.07 ; 7764.67,2909.09 7765.69,2908.07 ; 7765.69,2908.07 7767.81,2905.95 7767.81,2757.19 7782.5,2742.5 7782.5,2682.31 ; 7782.5,2682.31 7782.5,2683.37 7782.5,2682.31
  MidLayer2 w4: v1(7795.19,3175.04) v1(7954.86,3175.04) ; v1@7799.08,3171.15 cw(c7808.47,3161.76) 7808.47,3175.04 cw(c7808.47,3188.32) v1@7799.08,3178.93 ; v1@7801.91,3168.32 cw(c7818.13,3152.11) 7818.13,3175.04 cw(c7818.13,3197.98) v1@7801.91,3181.76 ; v1@7948.14,3168.32 ccw(c7931.92,3152.11) 7931.92,3175.04 ccw(c7931.92,3197.98) v1@7948.14,3181.76 ; v1@7950.97,3171.15 ccw(c7941.58,3161.76) 7941.58,3175.04 ccw(c7941.58,3188.32) v1@7950.97,3178.93
  other v2: 7388,1912
HOST_SRAM.NBHE: U30.D14 U47.40 | length 2179.8
  Top Layer w4: U30.D14@7226.54,2042.17 v3(7246.22,2061.85) ; U30.D14@7226.54,2049.51 ccw(c7226.54,2067.23) 7239.07,2054.7 ccw(c7251.6,2042.17) U30.D14@7233.88,2042.17 ; v1(7961.19,3241.71) 7971.52,3241.71 7973.51,3239.72 U47.40@8004.41,3239.72 ; v1@7965.08,3245.6 ccw(c7979.26,3259.78) U47.40@7979.26,3239.72 ; v1@7967.91,3234.99 cw(c7979.34,3223.56) U47.40@7979.34,3239.72 ; v1@7967.91,3248.43 ccw(c7988.91,3269.43) U47.40@7988.91,3239.72 ; 7233.42,2049.05 cw(c7246.22,2036.24) 7246.22,2054.35 ccw(c7246.22,2036.24) 7233.42,2049.05 ; 7233.42,2049.05 ccw(c7220.61,2061.85) 7238.72,2061.85 cw(c7220.61,2061.85) 7233.42,2049.05
  MidLayer1 w4: v3@7247.52,2069.24 ccw(c7250.67,2087.07) 7261.05,2072.24 ; v3@7253.61,2060.55 cw(c7271.44,2057.4) 7261.05,2072.24 ; 7323.03,2085.71 7309.1,2085.71 ; v1@7558.47,2101.99 ccw(c7542.26,2085.77) 7542.26,2108.71 ccw(c7542.26,2131.64) v1@7558.47,2115.43 ; v1@7561.3,2104.82 ccw(c7551.91,2095.43) 7551.91,2108.71 ccw(c7551.91,2121.99) v1@7561.3,2112.6 ; v1(7565.19,2108.71) 7518.71,2108.71 7495,2085 7480.4,2085 7470.4,2095 7417.15,2095 7407.86,2085.71 7354.33,2085.71 7309.1,2085.71 ; 7261.05,2072.24 7269.63,2079.32 cw(c7285.85,2061.94) 7285.85,2085.71 7309.1,2085.71
  MidLayer2 w4: v1(7565.19,2108.71) 7589.86,2133.37 7692.87,2133.37 7699.31,2139.81 7726.69,2139.81 7733.13,2133.37 7745,2133.37 7745,2133.71 7756.86,2145.56 7756.86,2485.99 7775.37,2504.5 7785.56,2504.5 7806.52,2525.46 7806.52,2593.73 7787.5,2612.75 7787.5,2627.25 7806.52,2646.27 7806.52,2789.06 7806.36,2789.22 7806.36,2899.55 7981.86,3075.04 7981.86,3221.04 v1(7961.19,3241.71) ; v1@7565.19,2114.21 ccw(c7565.19,2127.49) 7574.58,2118.1 ccw(c7583.97,2108.71) v1@7570.69,2108.71 ; v1@7565.19,2118.21 ccw(c7565.19,2141.14) 7581.41,2124.93 ccw(c7597.63,2108.71) v1@7574.69,2108.71 ; v1@7961.19,3232.21 cw(c7961.19,3209.27) 7977.41,3225.49 cw(c7993.63,3241.71) v1@7970.69,3241.71 ; v1@7961.19,3236.21 cw(c7961.19,3222.93) 7970.58,3232.32 cw(c7979.97,3241.71) v1@7966.69,3241.71
HOST_SRAM.NBLE: U30.P15 U47.39 | length 3232.8
  Top Layer w4: v2@7393.19,1583 ccw(c7369.5,1583) 7386.25,1599.75 ccw(c7403,1616.5) v2@7403,1592.81 ; v2@7397.19,1583 ccw(c7383.16,1583) 7393.08,1592.92 ccw(c7403,1602.84) v2@7403,1588.81 ; v2(7403,1583) 7383.29,1602.71 7383.29,1624.71 7375.04,1632.96 7285.62,1632.96 ; v2@7550.05,1904.45 v2(7550.05,1908.7) ; 7618.9,1735 cw(c7618.9,1707.9) v2@7638.06,1727.06 ; 7623.73,1735 ccw(c7623.73,1755.27) v2@7638.06,1740.94 ; 7628.56,1735 cw(c7628.56,1717.56) v2@7640.89,1729.89 ; v1@7866.81,2420.43 ccw(c7850.59,2436.64) 7873.52,2436.64 ccw(c7896.46,2436.64) v1@7880.24,2420.43 ; v1@7869.64,2417.6 ccw(c7860.25,2426.99) 7873.52,2426.99 ccw(c7886.8,2426.99) v1@7877.41,2417.6 ; v1(7873.52,2413.71) 7873.52,2474.04 7891.52,2492.04 7891.52,2575 7891.52,2604.25 7890.12,2605.65 7890.12,2610.68 7890.12,2901.01 7881.86,2909.27 7881.86,3198.23 7891.86,3208.23 U47.39@8004.41,3208.23 ; U47.39@7981.19,3202.57 ccw(c7967.54,3188.91) 7967.54,3208.23 ccw(c7967.54,3227.54) U47.39@7981.19,3213.88 ; 7278.44,1635.93 cw(c7290.97,1648.46) 7273.25,1648.46 ccw(c7290.97,1648.46) 7278.44,1635.93 ; 7278.44,1635.93 ccw(c7265.91,1623.4) 7265.91,1641.12 cw(c7265.91,1623.4) 7278.44,1635.93 ; 7278.44,1635.93 ccw(c7285.62,1643.11) 7285.62,1632.96 ; 7278.44,1635.93 ccw(c7285.62,1643.11) 7285.62,1632.96 ; v2(7550.05,1908.7) 7552.86,1911.51 v2(7550.05,1908.7) ; v2(7550.05,1908.7) 7583.81,1874.94 7583.81,1870.69 7583.81,1855 ; 7583.81,1795.19 7583.81,1855 ; 7583.81,1795.19 7583.81,1766.19 7615,1735 v2@7644,1735 ; 7583.81,1795.19 7583.81,1855 ; v2@7644,1735 v2(7645,1734) v2@7644,1735
  MidLayer1 w4: v2(7403,1583) 7451.09,1583 7500.09,1632 7507.89,1639.8 7550.8,1639.8 v2(7645,1734) v2@7645,1728.5 ; v2@7407.11,1578.89 cw(c7417.03,1568.97) 7417.03,1583 cw(c7417.03,1597.03) v2@7407.11,1587.11 ; v2@7409.94,1576.06 cw(c7426.69,1559.31) 7426.69,1583 cw(c7426.69,1606.69) v2@7409.94,1589.94 ; v2@7552.86,1911.51 v2(7550.05,1908.7) 7578.89,1908.7 7581.7,1911.51 ; v2@7554.16,1904.59 cw(c7564.08,1894.67) 7564.08,1908.7 cw(c7564.08,1922.73) v2@7554.16,1912.81 ; v2@7556.99,1901.77 cw(c7573.74,1885.02) 7573.74,1908.7 cw(c7573.74,1932.39) v2@7556.99,1915.64 ; v2@7635.19,1734 cw(c7611.5,1734) 7628.25,1717.25 cw(c7645,1700.5) v2@7645,1724.19 ; v2@7639.19,1734 cw(c7625.16,1734) 7635.08,1724.08 cw(c7645,1714.16) v2@7645,1728.19 ; v2@7707.59,2105.24 cw(c7703.98,2098.07) 7712,2098.07 ; v2@7716.41,2105.24 ccw(c7720.02,2098.07) 7712,2098.07 ; 7581.7,1911.51 7624.87,1954.68 ; 7581.7,1911.51 7637.81,1967.62 ; 7624.87,1954.68 7636,1965.81 ; 7624.87,1954.68 7636,1965.81 ; 7636,1965.81 7637.81,1967.62 ; 7637.81,1967.62 7637.81,2009.89 ; 7637.81,2009.89 7637.81,2020 ; 7637.81,2009.89 7637.81,2020 ; 7637.81,2020 7637.81,2026 7620.19,2043.63 7620.19,2051.38 7638.91,2070.09 ; 7638.91,2070.09 7677.16,2070.09 ; 7638.91,2070.09 7677.16,2070.09 ; 7677.16,2070.09 7684.02,2070.09 7712,2098.07 ; 7712,2098.07 v2@7712,2111.44 ; v2@7712,2111.44 v2(7712,2114) v2@7712,2111.44
  Bottom Layer w4: v2(7712,2114) 7741.69,2114 7765,2137.31 7765,2370 ; v2@7716.11,2109.89 cw(c7726.03,2099.97) 7726.03,2114 cw(c7726.03,2128.03) v2@7716.11,2118.11 ; v2@7718.94,2107.06 cw(c7735.69,2090.31) 7735.69,2114 cw(c7735.69,2137.69) v2@7718.94,2120.94 ; v1@7866.81,2406.99 ccw(c7850.59,2390.77) 7850.59,2413.71 ccw(c7850.59,2436.64) v1@7866.81,2420.43 ; v1@7869.64,2409.82 ccw(c7860.25,2400.43) 7860.25,2413.71 ccw(c7860.25,2426.99) v1@7869.64,2417.6 ; v1(7873.52,2413.71) 7808.71,2413.71 ; 7765,2370 7808.71,2413.71 ; 7765,2370 7808.71,2413.71