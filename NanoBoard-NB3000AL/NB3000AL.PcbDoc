# Altium PCB NB3000AL.PcbDoc (part 29 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_A11: U7.C6 U8.L26 U12.34 U13.34 U16.22 U17.22 U61.97 | length 8439
  Top Layer w4: U61.97@5665.6,2821.32 cw(c5658.77,2814.49) 5668.43,2814.49 cw(c5678.08,2814.49) U61.97@5671.25,2821.32 ; U61.97@5668.42,2837.34 5668.42,2806.57 5738,2737 v1(5802,2737) ; v1@5795.28,2730.28 ccw(c5779.06,2714.06) 5779.06,2737 ccw(c5779.06,2759.93) v1@5795.28,2743.72 ; v1@5798.11,2733.11 ccw(c5788.72,2723.72) 5788.72,2737 ccw(c5788.72,2750.28) v1@5798.11,2740.89 ; U8.L26@5842.76,4335.14 ccw(c5842.76,4352.86) 5855.29,4340.33 ; U8.L26@5850.1,4327.79 cw(c5867.82,4327.79) 5855.29,4340.33 ; U17.22@6164.93,4303.64 cw(c6151.28,4289.98) 6170.59,4289.98 cw(c6189.9,4289.98) U17.22@6176.25,4303.64 ; U17.22@6170.59,4309.29 6170.59,4275.71 ; v1@6248.47,4279.99 ccw(c6232.26,4263.77) 6232.26,4286.71 ccw(c6232.26,4309.64) v1@6248.47,4293.43 ; v1@6251.3,4282.82 ccw(c6241.91,4273.43) 6241.91,4286.71 ccw(c6241.91,4299.99) v1@6251.3,4290.6 ; v1(6255.19,4286.71) 6181.59,4286.71 6170.59,4275.71 ; U13.34@6619.41,3544.53 6653.71,3544.53 ; U13.34@6643.19,3539.5 cw(c6653.7,3531.02) 6653.7,3544.53 ; U13.34@6643.19,3549.55 ccw(c6653.7,3558.03) 6653.7,3544.53 ; v1@6666.85,3535.6 ccw(c6657.52,3529.65) 6657.52,3540.71 ; v1@6666.85,3545.82 cw(c6657.52,3551.77) 6657.52,3540.71 ; v1(6674.86,3540.71) 6657.52,3540.71 ; v1@6805.55,4288.76 ccw(c6795.4,4301.29) 6811.52,4301.29 ; v1@6808.06,4285.65 ccw(c6802.19,4292.9) 6811.52,4292.9 ccw(c6820.86,4292.9) v1@6814.99,4285.65 ; v1(6811.52,4281.37) 6811.52,4301.29 ; 6811.98,4301.75 cw(c6822.52,4291.21) U16.22@6826.86,4305.47 ; 6816.69,4306.46 cw(c6824.72,4298.43) U16.22@6828.03,4309.29 ; v1@6817.5,4288.76 cw(c6827.65,4301.29) 6811.52,4301.29 ; U16.22@6845.59,4309.29 6819.52,4309.29 6811.52,4301.29 ; v1(7223.52,3533.37) 7234.68,3544.53 U12.34@7294.41,3544.53 ; U12.34@7271.19,3538.87 ccw(c7257.54,3525.22) 7257.54,3544.53 ccw(c7257.54,3563.84) U12.34@7271.19,3550.18 ; 5855.29,4340.33 cw(c5882.64,4312.98) 5882.64,4351.66 5941.18,4351.66 5949.18,4351.66 5978.66,4351.66 6002.57,4327.74 6025.57,4327.74 6037.31,4316 6054,4316 6103.13,4266.87 6161.76,4266.87 6170.59,4275.71 ; 6653.71,3544.53 6657.52,3540.71
  Top Layer w8: U7.C6@7909.06,4425.94 v5(7928.74,4406.26) ; v5@7919.74,4406.26 ccw(c7898.01,4406.26) 7913.38,4421.62 ccw(c7928.74,4436.99) v5@7928.74,4415.26
  MidLayer1 w4: v1(6255.19,4286.71) 6306.67,4286.71 6318.67,4274.71 6689.86,4274.71 6715.65,4300.5 6792.4,4300.5 v1(6811.52,4281.37) ; v1@6259.08,4282.82 cw(c6268.47,4273.43) 6268.47,4286.71 cw(c6268.47,4299.99) v1@6259.08,4290.6 ; v1@6261.91,4279.99 cw(c6278.13,4263.77) 6278.13,4286.71 cw(c6278.13,4309.64) v1@6261.91,4293.43 ; v1@6668.14,3547.43 ccw(c6651.92,3563.64) 6674.86,3563.64 ccw(c6697.79,3563.64) v1@6681.57,3547.43 ; v1@6670.97,3544.6 ccw(c6661.58,3553.99) 6674.86,3553.99 ccw(c6688.14,3553.99) v1@6678.75,3544.6 ; v1(6674.86,3540.71) 6674.86,3590.33 6665.19,3600 6665.19,3611.37 6681.86,3628.04 6711.88,3628.04 6744,3595.92 6744,3496.66 6743.95,3496.61 v1(6767.52,3473.04) ; v1@6750.14,2740.09 ccw(c6733.92,2756.31) 6756.86,2756.31 ccw(c6779.79,2756.31) v1@6763.57,2740.09 ; v1@6752.97,2737.26 ccw(c6743.58,2746.65) 6756.86,2746.65 ccw(c6770.14,2746.65) v1@6760.75,2737.26 ; v1(6756.86,2733.37) 6756.86,2777.67 7139.86,3160.67 7139.86,3449.71 7159.95,3469.8 ; v1@6758.02,3473.04 ccw(c6735.09,3473.04) 6751.31,3489.26 ccw(c6767.52,3505.48) v1@6767.52,3482.54 ; v1@6762.02,3473.04 ccw(c6748.75,3473.04) 6758.14,3482.43 ccw(c6767.52,3491.82) v1@6767.52,3478.54 ; v1@6802.02,4281.37 ccw(c6779.09,4281.37) 6795.31,4297.59 ccw(c6811.52,4313.81) v1@6811.52,4290.87 ; v1@6806.02,4281.37 ccw(c6792.75,4281.37) 6802.14,4290.76 ccw(c6811.52,4300.15) v1@6811.52,4286.87 ; v1@6955.47,4286.32 cw(c6939.26,4270.11) 6962.19,4270.11 cw(c6985.13,4270.11) v1@6968.91,4286.32 ; v1@6958.3,4289.15 cw(c6948.91,4279.76) 6962.19,4279.76 cw(c6975.47,4279.76) v1@6966.08,4289.15 ; v1(6962.19,4293.04) 6962.19,4251.37 v1(7005.19,4208.37) ; v1@6995.69,4208.37 ccw(c6972.76,4208.37) 6988.97,4224.59 ccw(c7005.19,4240.81) v1@7005.19,4217.87 ; v1@6999.69,4208.37 ccw(c6986.41,4208.37) 6995.8,4217.76 ccw(c7005.19,4227.15) v1@7005.19,4213.87 ; 7148.52,3458.37 v1(7223.52,3533.37) ; v1@7214.02,3533.37 cw(c7191.09,3533.37) 7207.31,3517.16 cw(c7223.52,3500.94) v1@7223.52,3523.87 ; v1@7218.02,3533.37 cw(c7204.75,3533.37) 7214.14,3523.99 cw(c7223.52,3514.6) v1@7223.52,3527.87 ; v5@7928.74,4395.26 cw(c7928.74,4368.7) 7947.52,4387.48 cw(c7966.3,4406.26) v5@7939.74,4406.26 ; v5@7928.74,4399.26 cw(c7928.74,4382.36) 7940.69,4394.31 cw(c7952.64,4406.26) v5@7935.74,4406.26 ; v5(7928.74,4406.26) 7948.52,4386.48 v1(7948.52,4209.71) ; v1@7941.81,4216.43 ccw(c7925.59,4232.64) 7948.52,4232.64 ccw(c7971.46,4232.64) v1@7955.24,4216.43 ; v1@7944.64,4213.6 ccw(c7935.25,4222.99) 7948.52,4222.99 ccw(c7961.8,4222.99) v1@7952.41,4213.6
  MidLayer2 w4: v1(6811.52,4281.37) 6831.19,4301.04 6890.19,4301.04 ; v1@6811.52,4286.87 ccw(c6811.52,4300.15) 6820.91,4290.76 ccw(c6830.3,4281.37) v1@6817.02,4281.37 ; v1@6811.52,4290.87 ccw(c6811.52,4313.81) 6827.74,4297.59 ccw(c6843.96,4281.37) v1@6821.02,4281.37 ; v1@6955.47,4286.32 ccw(c6939.26,4270.11) 6939.26,4293.04 ccw(c6939.26,4315.98) v1@6955.47,4299.76 ; v1@6958.3,4289.15 ccw(c6948.91,4279.76) 6948.91,4293.04 ccw(c6948.91,4306.32) v1@6958.3,4296.93 ; v1(6962.19,4293.04) 6898.19,4293.04 ; v1(7223.52,3533.37) 7273.52,3583.37 7273.52,3875.04 7415.19,4016.71 7709.84,4016.71 7873.55,4180.42 7919.23,4180.42 v1(7948.52,4209.71) ; v1@7223.52,3538.87 ccw(c7223.52,3552.15) 7232.91,3542.76 ccw(c7242.3,3533.37) v1@7229.02,3533.37 ; v1@7223.52,3542.87 ccw(c7223.52,3565.81) 7239.74,3549.59 ccw(c7255.96,3533.37) v1@7233.02,3533.37 ; v1@7939.02,4209.71 cw(c7916.09,4209.71) 7932.31,4193.49 cw(c7948.52,4177.27) v1@7948.52,4200.21 ; v1@7943.02,4209.71 cw(c7929.75,4209.71) 7939.14,4200.32 cw(c7948.52,4190.93) v1@7948.52,4204.21 ; 6890.19,4301.04 6898.19,4293.04 ; 6890.19,4301.04 6898.19,4293.04
  Bottom Layer w4: v1@5795.28,2730.28 cw(c5779.06,2714.06) 5802,2714.06 cw(c5824.93,2714.06) v1@5808.72,2730.28 ; v1@5798.11,2733.11 cw(c5788.72,2723.72) 5802,2723.72 cw(c5815.28,2723.72) v1@5805.89,2733.11 ; v1(5802,2737) 5802,2678 5845.96,2634.04 6051.9,2634.04 6052.07,2634.21 6160,2634.21 6199.21,2634.21 6363.58,2634.21 6403.92,2674.55 6425.88,2696.5 6457.25,2696.5 6482.96,2722.21 6661.64,2722.21 6670.47,2731.04 6726.04,2731.04 6728.37,2733.37 v1(6756.86,2733.37) ; v1@6750.14,2726.66 ccw(c6733.92,2710.44) 6733.92,2733.37 ccw(c6733.92,2756.31) v1@6750.14,2740.09 ; v1@6752.97,2729.49 ccw(c6743.58,2720.1) 6743.58,2733.37 ccw(c6743.58,2746.65) v1@6752.97,2737.26 ; v1(6767.52,3473.04) 6825.52,3473.04 6866.19,3432.37 7122.52,3432.37 v1(7223.52,3533.37) ; v1@6771.41,3469.15 cw(c6780.8,3459.76) 6780.8,3473.04 cw(c6780.8,3486.32) v1@6771.41,3476.93 ; v1@6774.24,3466.32 cw(c6790.46,3450.11) 6790.46,3473.04 cw(c6790.46,3495.98) v1@6774.24,3479.76 ; v1(7005.19,4208.37) 7019.56,4194 7364.48,4194 7370.52,4200.04 7394.86,4224.37 7535.67,4224.37 7560,4200.04 7920.33,4200.04 7930,4209.71 ; v1@7214.02,3533.37 cw(c7191.09,3533.37) 7207.31,3517.16 cw(c7223.52,3500.94) v1@7223.52,3523.87 ; v1@7218.02,3533.37 cw(c7204.75,3533.37) 7214.14,3523.99 cw(c7223.52,3514.6) v1@7223.52,3527.87 ; v1@7940.81,4204.16 ccw(c7930,4196.4) 7930,4209.71 ; v1@7940.81,4215.25 cw(c7930,4223.02) 7930,4209.71 ; v1(7948.52,4209.71) 7930,4209.71
DB_MEM.BUS_A12: U7.D6 U8.AE26 U12.22 U13.22 U16.23 U17.23 U61.98 | length 7748.2
  Top Layer w4: U61.98@5645.91,2821.32 cw(c5639.08,2814.49) 5648.74,2814.49 cw(c5658.4,2814.49) U61.98@5651.57,2821.32 ; 5734.25,2483.37 5727.31,2490.31 ; 5946.54,2483.37 5953.51,2490.34 ; U13.22@6147.37,3507.37 ccw(c6133.72,3493.72) 6133.72,3513.03 ccw(c6133.72,3532.35) U13.22@6147.37,3518.69 ; U13.22@6193.81,3507.37 cw(c6207.46,3493.72) 6207.46,3513.03 cw(c6207.46,3532.35) U13.22@6193.81,3518.69 ; v1(6281.86,3375.04) 6298.52,3391.71 6298.52,3475.04 6269.74,3503.82 6260.53,3513.03 U13.22@6170.59,3513.03 6091.97,3513.03 6030,3575 6030,3606.31 5993.12,3643.2 5993.12,3706.24 5969,3730.35 5969,3746 5965,3750 5962.25,3752.75 5949.18,3752.75 5941.18,3752.75 5882.64,3752.75 ; v1@6281.86,3380.54 ccw(c6281.86,3393.82) 6291.25,3384.43 ccw(c6300.64,3375.04) v1@6287.36,3375.04 ; v1@6281.86,3384.54 ccw(c6281.86,3407.48) 6298.07,3391.26 ccw(c6314.29,3375.04) v1@6291.36,3375.04 ; v1(6331.86,3143.04) 6381.86,3143.04 6398.52,3159.71 6398.52,3360 6389.19,3369.33 v1(6389.19,3408.37) ; v1@6335.75,3139.15 cw(c6345.14,3129.76) 6345.14,3143.04 cw(c6345.14,3156.32) v1@6335.75,3146.93 ; v1@6338.57,3136.32 cw(c6354.79,3120.11) 6354.79,3143.04 cw(c6354.79,3165.98) v1@6338.57,3149.76 ; v1(6348.52,2941.71) 6368.86,2941.71 ; v1@6352.74,2938.18 cw(c6360.3,2931.86) 6360.3,2941.71 cw(c6360.3,2951.55) v1@6352.74,2945.24 ; v1@6355.81,2935.61 cw(c6368.86,2924.7) 6368.86,2941.71 ; v1@6355.81,2947.8 ccw(c6368.86,2958.72) 6368.86,2941.71 ; v1@6382.47,3401.66 cw(c6366.26,3385.44) 6389.19,3385.44 cw(c6412.13,3385.44) v1@6395.91,3401.66 ; v1@6385.3,3404.49 cw(c6375.91,3395.1) 6389.19,3395.1 cw(c6402.47,3395.1) v1@6393.08,3404.49 ; U17.23@6619.41,4309.29 6651.61,4309.29 ; U17.23@6643.7,4304.97 cw(c6651.61,4299.9) 6651.61,4309.29 ; U17.23@6643.7,4313.61 ccw(c6651.61,4318.68) 6651.61,4309.29 ; v1(6665.19,4295.71) 6651.61,4309.29 ; v1(6734.86,3355.37) 6788.52,3409.04 6806.86,3427.37 6806.86,3504.7 6815.19,3513.03 ; v1@6734.86,3360.87 ccw(c6734.86,3374.16) 6744.25,3364.76 ccw(c6753.63,3355.37) v1@6740.36,3355.37 ; v1@6734.86,3364.87 ccw(c6734.86,3387.81) 6751.08,3371.59 ccw(c6767.29,3355.37) v1@6744.36,3355.37 ; U12.22@6820.85,3509.5 ccw(c6815.19,3506.72) 6815.19,3513.03 ; U12.22@6820.85,3516.56 cw(c6815.19,3519.34) 6815.19,3513.03 ; U12.22@6845.59,3513.03 6815.19,3513.03 ; v1(7186.19,4285.37) 7202.19,4285.37 ; v1@7194.53,4280.83 cw(c7202.19,4276.65) 7202.19,4285.37 ; v1@7194.53,4289.92 ccw(c7202.19,4294.1) 7202.19,4285.37 ; U16.23@7271.19,4303.64 ccw(c7257.54,4289.98) 7257.54,4309.29 ccw(c7257.54,4328.61) U16.23@7271.19,4314.95 ; U16.23@7294.41,4309.29 7226.11,4309.29 7202.19,4285.37 ; U61.98@5648.74,2836.46 5648.74,2812.95 5661.5,2800.19 5661.5,2775 5661.5,2752.75 5661.5,2715.05 5701,2675.55 5701,2516.63 5727.31,2490.31 ; U61.98@5648.74,2836.46 U61.98@5648.74,2837.34 U61.98@5648.74,2836.46 ; 5727.31,2490.31 5734.75,2482.87 5946.04,2482.87 5953.51,2490.34 ; 5855.29,3764.08 ccw(c5882.64,3791.43) 5882.64,3752.75 ; 5855.29,3764.08 ccw(c5882.64,3791.43) 5882.64,3752.75 ; 5855.29,3764.08 ccw(c5842.76,3751.55) 5842.76,3769.27 cw(c5842.76,3751.55) 5855.29,3764.08 ; 5855.29,3764.08 cw(c5867.82,3776.61) 5850.1,3776.61 ccw(c5867.82,3776.61) 5855.29,3764.08 ; 5953.51,2490.34 6125.92,2662.75 6125.92,2676.19 6168.23,2718.5 6189.88,2718.5 6197.88,2726.5 6258.32,2726.5 6336.82,2805 6365,2805 6389,2829 6389,2921.56 6368.86,2941.71
  Top Layer w8: U7.D6@7869.69,4425.94 v5(7889.37,4406.26) ; v5@7880.37,4406.26 ccw(c7858.64,4406.26) 7874.01,4421.62 ccw(c7889.37,4436.99) v5@7889.37,4415.26
  MidLayer1 w4: v1@6325.14,3136.32 cw(c6308.92,3120.11) 6331.86,3120.11 cw(c6354.79,3120.11) v1@6338.57,3136.32 ; v1@6327.97,3139.15 cw(c6318.58,3129.76) 6331.86,3129.76 cw(c6345.14,3129.76) v1@6335.75,3139.15 ; v1(6331.86,3143.04) 6331.86,3086.14 6345.52,3072.48 ; v1@6341.81,2948.43 ccw(c6332.83,2957.4) 6345.52,2957.4 ; 6345.52,2962.23 ccw(c6369.04,2962.23) v1@6352.41,2945.6 ; 6345.52,2971.89 ccw(c6378.7,2971.89) v1@6355.24,2948.43 ; v1(6348.52,2941.71) 6345.52,2944.71 6345.52,3070 ; v1(6734.86,3355.37) 6797.9,3355.37 6865.19,3422.67 6865.19,3485.71 6865.19,3550.04 6890.19,3575.04 6915.08,3575.04 7075.02,3734.98 ; v1@6738.75,3351.49 cw(c6748.14,3342.1) 6748.14,3355.37 cw(c6748.14,3368.65) v1@6738.75,3359.26 ; v1@6741.57,3348.66 cw(c6757.79,3332.44) 6757.79,3355.37 cw(c6757.79,3378.31) v1@6741.57,3362.09 ; 7075,3735 7081.86,3741.86 7081.86,3803.02 7081.86,3820 7081.86,4119.08 7186.19,4223.41 v1(7186.19,4285.37) ; v1@7179.47,4278.66 cw(c7163.26,4262.44) 7186.19,4262.44 cw(c7209.13,4262.44) v1@7192.91,4278.66 ; v1@7182.3,4281.49 cw(c7172.91,4272.1) 7186.19,4272.1 cw(c7199.47,4272.1) v1@7190.08,4281.49 ; 6345.52,3070 6345.52,3072.48 ; 6345.52,3070 6345.52,3072.48
  MidLayer2 w4: v1(6665.19,4295.71) 6691.21,4295.71 6696.88,4301.37 6703.5,4301.37 6715,4301.37 6765,4301.37 6770.88,4301.37 6777.51,4301.37 6786.84,4310.71 6973.52,4310.71 7000.86,4283.37 7124.25,4283.37 7140.92,4266.71 7167.52,4266.71 v1(7186.19,4285.37) ; v1@6669.08,4291.82 cw(c6678.47,4282.43) 6678.47,4295.71 cw(c6678.47,4308.99) v1@6669.08,4299.6 ; v1@6671.91,4288.99 cw(c6688.13,4272.77) 6688.13,4295.71 cw(c6688.13,4318.64) v1@6671.91,4302.43 ; v1@7176.69,4285.37 cw(c7153.76,4285.37) 7169.97,4269.16 cw(c7186.19,4252.94) v1@7186.19,4275.87 ; v1@7180.69,4285.37 cw(c7167.41,4285.37) 7176.8,4275.99 cw(c7186.19,4266.6) v1@7186.19,4279.87
  Bottom Layer w4: v1(6281.86,3375.04) 6315.19,3408.37 ; v1@6281.86,3380.54 ccw(c6281.86,3393.82) 6291.25,3384.43 ccw(c6300.64,3375.04) v1@6287.36,3375.04 ; v1@6281.86,3384.54 ccw(c6281.86,3407.48) 6298.07,3391.26 ccw(c6314.29,3375.04) v1@6291.36,3375.04 ; v1@6382.47,3401.66 ccw(c6366.26,3385.44) 6366.26,3408.37 ccw(c6366.26,3431.31) v1@6382.47,3415.09 ; v1@6385.3,3404.49 ccw(c6375.91,3395.1) 6375.91,3408.37 ccw(c6375.91,3421.65) v1@6385.3,3412.26 ; v1@6389.19,3413.87 ccw(c6389.19,3427.15) 6398.58,3417.76 ccw(c6407.97,3408.37) v1@6394.69,3408.37 ; v1@6389.19,3417.87 ccw(c6389.19,3440.81) 6405.41,3424.59 ccw(c6421.63,3408.37) v1@6398.69,3408.37 ; v1(6734.86,3355.37) 6673.52,3416.71 6660.13,3416.71 6651.46,3425.37 6406.19,3425.37 v1(6389.19,3408.37) 6340,3408.37 ; v1@7179.47,4292.09 ccw(c7163.26,4308.31) 7186.19,4308.31 ccw(c7209.13,4308.31) v1@7192.91,4292.09 ; v1@7182.3,4289.26 ccw(c7172.91,4298.65) 7186.19,4298.65 ccw(c7199.47,4298.65) v1@7190.08,4289.26 ; v1(7186.19,4285.37) 7186.19,4308.37 7177.86,4316.71 7153.19,4316.71 7131.86,4295.37 7131.86,4258.71 7148.86,4241.71 7373.52,4241.71 7406.86,4275.04 7600.04,4275.04 7608.37,4283.37 7960,4283.37 7962.86,4283.37 8023.37,4283.37 8031.86,4291.86 8031.86,4363.37 8031.86,4370.37 8031.86,4405 8031.86,4418.4 8025,4425.26 7979.31,4425.26 7945.63,4425.26 7945,4425.89 7909,4425.89 v5(7889.37,4406.26) ; 6315.19,3408.37 6340,3408.37 ; 6315.19,3408.37 6340,3408.37
DB_MEM.BUS_A13: U7.B7 U8.L28 U12.35 U13.35 U16.24 U17.24 U61.100 | length 8581.8
  Top Layer w4: v1@5594.14,2781.76 ccw(c5566.26,2809.64) 5605.69,2809.64 ; v1@5596.97,2778.93 ccw(c5575.92,2799.98) 5605.69,2799.98 ; v1@5599.8,2776.1 ccw(c5585.57,2790.33) 5605.69,2790.33 ; v1(5600.86,2775.04) 5605.69,2779.87 5605.69,2833.66 U61.100@5609.37,2837.34 ; 5605.69,2786.31 ccw(c5612.13,2786.31) v1@5607.57,2781.76 ; 5605.69,2805.6 cw(c5627.91,2805.6) U61.100@5612.2,2821.32 ; 5605.69,2815.26 cw(c5618.26,2815.26) U61.100@5609.37,2824.14 ; U8.L28@5921.5,4327.8 5941.18,4327.79 5949.18,4327.79 5978.08,4327.79 5995.88,4310 6015,4310 6030,4295 6030,4284.25 6055.38,4258.87 6165.07,4258.87 6181.2,4275 6237,4275 v1(6281,4231) ; U8.L28@5926.69,4322.6 cw(c5939.22,4310.07) 5939.22,4327.79 cw(c5939.22,4345.52) U8.L28@5926.69,4332.99 ; v1@6271.5,4231 ccw(c6248.56,4231) 6264.78,4247.22 ccw(c6281,4263.43) v1@6281,4240.5 ; v1@6275.5,4231 ccw(c6262.22,4231) 6271.61,4240.39 ccw(c6281,4249.78) v1@6281,4236.5 ; v1(6473.52,2465.04) 6500.19,2491.71 6550.23,2491.71 6573.52,2515 6573.52,2766.71 v1(6648.52,2841.71) ; v1@6473.52,2470.54 ccw(c6473.52,2483.82) 6482.91,2474.43 ccw(c6492.3,2465.04) v1@6479.02,2465.04 ; v1@6473.52,2474.54 ccw(c6473.52,2497.48) 6489.74,2481.26 ccw(c6505.96,2465.04) v1@6483.02,2465.04 ; v1@6566.81,4231.76 ccw(c6550.59,4247.98) 6573.52,4247.98 ccw(c6596.46,4247.98) v1@6580.24,4231.76 ; v1@6569.64,4228.93 ccw(c6560.25,4238.32) 6573.52,4238.32 ccw(c6586.8,4238.32) v1@6577.41,4228.93 ; v1(6573.52,4225.04) 6573.52,4265 6580,4271.48 6580,4335 6585.79,4340.79 ; U17.24@6595.47,4335.97 ccw(c6585.79,4328.66) 6585.79,4340.79 ; U17.24@6595.47,4345.61 cw(c6585.79,4352.91) 6585.79,4340.79 ; U13.35@6619.41,3576.02 6656.17,3576.02 ; U17.24@6619.41,4340.79 6585.79,4340.79 ; v1@6639.02,2841.71 cw(c6616.09,2841.71) 6632.31,2825.49 cw(c6648.52,2809.27) v1@6648.52,2832.21 ; U13.35@6642.65,3570.39 cw(c6656.17,3556.98) 6656.17,3576.02 ; U13.35@6642.65,3581.66 ccw(c6656.17,3595.07) 6656.17,3576.02 ; v1@6643.02,2841.71 cw(c6629.75,2841.71) 6639.14,2832.32 cw(c6648.52,2822.93) v1@6648.52,2836.21 ; v1@6680.69,3610.04 cw(c6657.76,3610.04) 6673.97,3593.82 cw(c6690.19,3577.61) v1@6690.19,3600.54 ; v1@6684.69,3610.04 cw(c6671.41,3610.04) 6680.8,3600.65 cw(c6690.19,3591.26) v1@6690.19,3604.54 ; v1(6690.19,3610.04) 6656.17,3576.02 ; v1(7125.52,3677.04) 7144.77,3696.28 7182.61,3696.28 7248.52,3630.37 7248.52,3584.02 7256.52,3576.02 U12.35@7294.41,3576.02 ; v1@7125.52,3682.54 ccw(c7125.52,3695.82) 7134.91,3686.43 ccw(c7144.3,3677.04) v1@7131.02,3677.04 ; v1@7125.52,3686.54 ccw(c7125.52,3709.48) 7141.74,3693.26 ccw(c7157.96,3677.04) v1@7135.02,3677.04 ; v1@7145.81,3892.09 ccw(c7129.59,3908.31) 7152.52,3908.31 ccw(c7175.46,3908.31) v1@7159.24,3892.09 ; v1@7148.64,3889.26 ccw(c7139.25,3898.65) 7152.52,3898.65 ccw(c7165.8,3898.65) v1@7156.41,3889.26 ; v1(7152.52,3885.37) 7152.52,3929.04 7181.86,3958.37 7181.86,4121.86 7310,4250 7370,4250 7385.19,4265.19 v1(7385.19,4291.71) 7385.19,4329.81 7374.21,4340.79 U16.24@7294.41,4340.79 ; U12.35@7271.19,3570.37 ccw(c7257.54,3556.71) 7257.54,3576.02 ccw(c7257.54,3595.34) U12.35@7271.19,3581.68 ; U16.24@7317.63,4335.13 cw(c7331.28,4321.47) 7331.28,4340.79 cw(c7331.28,4360.1) U16.24@7317.63,4346.44 ; v1@7378.47,4284.99 cw(c7362.26,4268.77) 7385.19,4268.77 cw(c7408.13,4268.77) v1@7391.91,4284.99 ; v1@7378.47,4298.43 ccw(c7362.26,4314.64) 7385.19,4314.64 ccw(c7408.13,4314.64) v1@7391.91,4298.43 ; v1@7381.3,4287.82 cw(c7371.91,4278.43) 7385.19,4278.43 cw(c7398.47,4278.43) v1@7389.08,4287.82 ; v1@7381.3,4295.6 ccw(c7371.91,4304.99) 7385.19,4304.99 ccw(c7398.47,4304.99) v1@7389.08,4295.6
  Top Layer w8: U7.B7@7948.43,4386.57 v5(7968.11,4366.89) ; v5@7959.11,4366.89 ccw(c7937.38,4366.89) 7952.75,4382.25 ccw(c7968.11,4397.62) v5@7968.11,4375.89
  MidLayer1 w4: v1(6648.52,2841.71) 6680.83,2874.02 6682,2875.18 6682,2905.79 6701.09,2924.87 6701.34,2924.87 6715.19,2938.73 6715.19,3333.37 ; v1@6648.52,2847.21 ccw(c6648.52,2860.49) 6657.91,2851.1 ccw(c6667.3,2841.71) v1@6654.02,2841.71 ; v1@6648.52,2851.21 ccw(c6648.52,2874.14) 6664.74,2857.93 ccw(c6680.96,2841.71) v1@6658.02,2841.71 ; v1@6683.47,3603.32 cw(c6667.26,3587.11) 6690.19,3587.11 cw(c6713.13,3587.11) v1@6696.91,3603.32 ; v1@6686.3,3606.15 cw(c6676.91,3596.76) 6690.19,3596.76 cw(c6703.47,3596.76) v1@6694.08,3606.15 ; v1(6690.19,3610.04) 6690.19,3557 6731.86,3515.33 6731.86,3463.73 6707.86,3439.73 6707.86,3394.69 6715.19,3387.36 6715.19,3333.37 ; v1@7116.02,3677.04 cw(c7093.09,3677.04) 7109.31,3660.82 cw(c7125.52,3644.61) v1@7125.52,3667.54 ; v1@7120.02,3677.04 cw(c7106.75,3677.04) 7116.14,3667.65 cw(c7125.52,3658.26) v1@7125.52,3671.54 ; v1(7125.52,3677.04) 6965.19,3516.71 6965.19,3450.04 6940.19,3425.04 6878.88,3425.04 6787.21,3333.37 6715.19,3333.37
  MidLayer2 w4: v1@5594.61,2767.88 cw(c5582.62,2754.14) 5600.86,2754.14 ; v1@5597.24,2770.9 cw(c5590.3,2762.94) 5600.86,2762.94 cw(c5611.41,2762.94) v1@5604.47,2770.9 ; v1(5600.86,2775.04) 5600.86,2754.14 ; v1@5607.1,2767.88 ccw(c5619.09,2754.14) 5600.86,2754.14 ; v1@6289.02,2425.04 ccw(c6266.09,2425.04) 6282.31,2441.26 ccw(c6298.52,2457.48) v1@6298.52,2434.54 ; v1@6293.02,2425.04 ccw(c6279.75,2425.04) 6289.14,2434.43 ccw(c6298.52,2443.82) v1@6298.52,2430.54 ; v1(6298.52,2425.04) 6256.86,2466.71 6222.53,2466.71 6214.7,2458.87 5869.51,2458.87 5806.86,2521.52 5806.86,2663.45 5730.31,2740 5615,2740 5600.86,2754.14 ; v1(6573.52,4225.04) 6596.54,4225.04 6605.54,4234.04 6886.86,4234.04 6901.52,4248.71 6988.86,4248.71 6998.52,4258.37 7115.31,4258.37 7133.69,4240 7218.69,4240 7278.73,4300.04 7325,4300.04 7333.33,4291.71 v1(7385.19,4291.71) ; v1@6577.41,4221.15 cw(c6586.8,4211.76) 6586.8,4225.04 cw(c6586.8,4238.32) v1@6577.41,4228.93 ; v1@6580.24,4218.32 cw(c6596.46,4202.11) 6596.46,4225.04 cw(c6596.46,4247.98) v1@6580.24,4231.76 ; v1@7378.47,4284.99 ccw(c7362.26,4268.77) 7362.26,4291.71 ccw(c7362.26,4314.64) v1@7378.47,4298.43 ; v1@7381.3,4287.82 ccw(c7371.91,4278.43) 7371.91,4291.71 ccw(c7371.91,4304.99) v1@7381.3,4295.6
  Bottom Layer w4: v1(6281,4231) 6281.15,4231 6300.19,4250.04 6548.52,4250.04 v1(6573.52,4225.04) ; v1@6281,4236.5 ccw(c6281,4250.14) 6290.64,4240.49 ; v1@6281,4240.5 ccw(c6281,4263.8) 6297.47,4247.32 ; v1@6286.5,4231 cw(c6299.42,4231) 6290.28,4240.13 ; v1@6290.5,4231 cw(c6313.07,4231) 6297.11,4246.96 ; v1(6298.52,2425.04) 6317.98,2444.5 6452.98,2444.5 v1(6473.52,2465.04) v1@6473.52,2462.78 ; v1@6298.52,2430.54 ccw(c6298.52,2443.82) 6307.91,2434.43 ccw(c6317.3,2425.04) v1@6304.02,2425.04 ; v1@6298.52,2434.54 ccw(c6298.52,2457.48) 6314.74,2441.26 ccw(c6330.96,2425.04) v1@6308.02,2425.04 ; v1@6464.02,2465.04 cw(c6441.09,2465.04) 6457.31,2448.82 cw(c6473.52,2432.61) v1@6473.52,2455.54 ; v1@6468.02,2465.04 cw(c6454.75,2465.04) 6464.14,2455.65 cw(c6473.52,2446.26) v1@6473.52,2459.54 ; v1@6564.02,4225.04 ccw(c6541.09,4225.04) 6557.31,4241.26 ccw(c6573.52,4257.48) v1@6573.52,4234.54 ; v1@6568.02,4225.04 ccw(c6554.75,4225.04) 6564.14,4234.43 ccw(c6573.52,4243.82) v1@6573.52,4230.54 ; v1@7125.52,3667.54 cw(c7125.52,3644.61) 7141.74,3660.82 cw(c7157.96,3677.04) v1@7135.02,3677.04 ; v1@7125.52,3671.54 cw(c7125.52,3658.26) 7134.91,3667.65 cw(c7144.3,3677.04) v1@7131.02,3677.04 ; v1(7125.52,3677.04) 7152.56,3650 7195,3650 7202.5,3657.5 7202.5,3823.29 7207.36,3828.15 7207.36,3849.27 7202.5,3854.13 7202.5,3862.6 7207.69,3867.79 7207.69,3887.31 7202.46,3892.54 7182.94,3892.54 7175.78,3885.37 v1(7152.52,3885.37) ; v1@7156.41,3881.49 cw(c7165.8,3872.1) 7165.8,3885.37 cw(c7165.8,3898.65) v1@7156.41,3889.26 ; v1@7159.24,3878.66 cw(c7175.46,3862.44) 7175.46,3885.37 cw(c7175.46,3908.31) v1@7159.24,3892.09 ; v1(7385.19,4291.71) 7448.52,4291.71 7473.52,4316.71 7589.52,4316.71 7614.52,4291.71 7941.71,4291.71 7949.11,4299.11 7949.11,4347.89 v5(7968.11,4366.89) ; v1@7389.08,4287.82 cw(c7398.47,4278.43) 7398.47,4291.71 cw(c7398.47,4304.99) v1@7389.08,4295.6 ; v1@7391.91,4284.99 cw(c7408.13,4268.77) 7408.13,4291.71 cw(c7408.13,4314.64) v1@7391.91,4298.43 ; v5@7957.11,4366.89 cw(c7930.55,4366.89) 7949.33,4348.11 cw(c7968.11,4329.33) v5@7968.11,4355.89 ; v5@7961.11,4366.89 cw(c7944.21,4366.89) 7956.16,4354.94 cw(c7968.11,4342.99) v5@7968.11,4359.89
DB_MEM.BUS_A14: U7.A7 U8.K28 U12.36 U13.36 U16.25 U17.25 U61.101 | length 7615.1
  Top Layer w4: U61.101@5586.86,2853.36 ccw(c5580.03,2860.19) 5589.69,2860.19 ccw(c5599.34,2860.19) U61.101@5592.51,2853.36 ; U61.101@5589.68,2837.34 5589.69,2866.2 5598.52,2875.04 v1(5606.86,2875.04) ; 5589.98,2866.5 cw(c5600.15,2856.33) v1@5605,2869.86 ; 5594.44,2870.96 cw(c5602.5,2862.9) v1@5606.35,2873.63 ; U8.K28@5921.5,4367.17 5941.18,4367.16 5949.18,4367.16 5974.46,4367.16 6005.89,4335.74 6028.89,4335.74 6040.63,4324 6071.43,4324 v1@6102.29,4293.14 ; 6086.71,4308.72 ccw(c6104.86,4326.87) v1@6104.86,4301.21 ; 6089.44,4306 cw(c6075.15,4291.71) v1@6095.36,4291.71 ; 6093.54,4301.9 ccw(c6104.86,4313.21) v1@6104.86,4297.21 ; v1(6461.86,3391.71) 6548.52,3478.37 6548.52,3568.52 6587.52,3607.52 ; v1@6461.86,3397.21 ccw(c6461.86,3410.49) 6471.25,3401.1 ccw(c6480.64,3391.71) v1@6467.36,3391.71 ; v1@6461.86,3401.21 ccw(c6461.86,3424.14) 6478.07,3407.93 ccw(c6494.29,3391.71) v1@6471.36,3391.71 ; U13.36@6595.04,3603.32 ccw(c6587.52,3598.69) 6587.52,3607.52 ; U13.36@6595.04,3611.72 cw(c6587.52,3616.35) 6587.52,3607.52 ; U17.25@6619.41,4372.28 6650.95,4372.28 ; U13.36@6642.91,3602.16 cw(c6654.97,3591.27) 6654.97,3607.52 ; U13.36@6642.91,3612.88 ccw(c6654.97,3623.77) 6654.97,3607.52 ; U17.25@6643.87,4368.23 cw(c6650.95,4364.07) 6650.95,4372.28 ; U17.25@6643.87,4376.34 ccw(c6650.95,4380.5) 6650.95,4372.28 ; v1@6666.81,3647.66 cw(c6650.59,3631.44) 6673.52,3631.44 cw(c6696.46,3631.44) v1@6680.24,3647.66 ; v1@6667.37,4366 ccw(c6651.35,4350.13) 6651.35,4372.68 ccw(c6651.35,4395.24) v1@6667.37,4379.37 ; v1@6669.64,3650.49 cw(c6660.25,3641.1) 6673.52,3641.1 cw(c6686.8,3641.1) v1@6677.41,3650.49 ; v1@6670.22,4368.81 ccw(c6660.94,4359.63) 6660.94,4372.68 ccw(c6660.94,4385.74) v1@6670.22,4376.55 ; v1(6673.52,3654.37) 6673.52,3626.07 6654.97,3607.52 ; v1(6674.13,4372.68) 6651.35,4372.68 6650.95,4372.28 ; v1(7138.52,3750.04) 7165.19,3750.04 7256.86,3658.37 7256.86,3615.52 7264.86,3607.52 ; v1@7142.41,3746.15 cw(c7151.8,3736.76) 7151.8,3750.04 cw(c7151.8,3763.32) v1@7142.41,3753.93 ; v1@7145.24,3743.32 cw(c7161.46,3727.11) 7161.46,3750.04 cw(c7161.46,3772.98) v1@7145.24,3756.76 ; v1(7174.19,4344.37) 7200,4344.37 7227.91,4372.28 U16.25@7294.41,4372.28 U16.25@7298.52,4372.28 ; v1@7178.08,4340.49 cw(c7187.47,4331.1) 7187.47,4344.37 cw(c7187.47,4357.65) v1@7178.08,4348.26 ; v1@7180.91,4337.66 cw(c7197.13,4321.44) 7197.13,4344.37 cw(c7197.13,4367.31) v1@7180.91,4351.09 ; U12.36@7269.46,3604.45 ccw(c7264.86,3602.53) 7264.86,3607.52 ; U12.36@7269.46,3610.59 cw(c7264.86,3612.51) 7264.86,3607.52 ; U16.25@7271.19,4366.63 ccw(c7257.54,4352.97) 7257.54,4372.28 ccw(c7257.54,4391.6) U16.25@7271.19,4377.94 ; U12.36@7294.41,3607.52 7264.86,3607.52 ; U16.25@7298.52,4366.71 U16.25@7298.52,4372.28 ; U16.25@7319.2,4368.86 cw(c7324.61,4366.29) 7324.61,4372.28 ; U16.25@7319.2,4375.71 ccw(c7324.61,4378.28) 7324.61,4372.28 ; v1@7337.85,4362.16 ccw(c7330.19,4357.98) 7330.19,4366.71 ; v1@7337.85,4371.26 cw(c7330.19,4375.43) 7330.19,4366.71 ; v1(7346.19,4366.71) 7330.19,4366.71 ; 5939.22,4367.16 cw(c5939.22,4384.89) 5926.69,4372.36 ccw(c5939.22,4384.89) 5939.22,4367.16 ; 5939.22,4367.16 ccw(c5939.22,4349.44) 5926.69,4361.97 cw(c5939.22,4349.44) 5939.22,4367.16 ; 6587.52,3607.52 6654.97,3607.52 ; U16.25@7298.52,4372.28 7324.62,4372.28 ; 7324.62,4372.28 7330.19,4366.71
  Top Layer w8: U7.A7@7987.8,4386.57 v5(8007.48,4366.89) ; v5@7998.48,4366.89 ccw(c7976.75,4366.89) 7992.12,4382.25 ccw(c8007.48,4397.62) v5@8007.48,4375.89
  MidLayer1 w4: v1@6104.86,4297.21 ccw(c6104.86,4314.95) 6117.41,4302.41 ; v1@6104.86,4301.21 ccw(c6104.86,4328.61) 6124.23,4309.23 ; v1@6106,4291 6131.71,4316.71 6146.15,4316.71 6220.48,4391.04 6276.58,4391.04 6288.12,4379.5 6363.4,4379.5 ; v1@6114.36,4291.71 cw(c6132.82,4291.71) 6119.77,4304.77 ; v1(6270.46,2774.71) 6295.21,2774.71 6306.86,2786.35 6306.86,2942.06 6337.52,2972.73 6337.52,3069.16 6313.19,3093.5 6313.19,3226.25 6346.86,3259.92 6346.86,3318.41 6359.19,3330.75 6359.19,3409.02 6350.86,3417.35 v1(6350.86,3466.71) ; v1@6274.35,2770.82 cw(c6283.74,2761.43) 6283.74,2774.71 cw(c6283.74,2787.99) v1@6274.35,2778.6 ; v1@6277.18,2767.99 cw(c6293.4,2751.77) 6293.4,2774.71 cw(c6293.4,2797.64) v1@6277.18,2781.43 ; v1@6344.14,3459.99 cw(c6327.92,3443.77) 6350.86,3443.77 cw(c6373.79,3443.77) v1@6357.57,3459.99 ; v1@6346.97,3462.82 cw(c6337.58,3453.43) 6350.86,3453.43 cw(c6364.14,3453.43) v1@6354.75,3462.82 ; 6363.4,4379.5 6372.52,4370.37 6436.23,4370.37 6474.66,4408.81 6498.7,4408.81 6532.47,4375.04 v1@6671.77,4375.04 ; 6645.5,4375.04 cw(c6645.5,4344.06) v1@6667.41,4365.97 ; 6655.16,4375.04 cw(c6655.16,4353.71) v1@6670.24,4368.79 ; 6656.88,4375.04 ccw(c6656.88,4389.93) v1@6667.41,4379.4 ; v1@7129.02,3750.04 ccw(c7106.09,3750.04) 7122.31,3766.26 ccw(c7138.52,3782.48) v1@7138.52,3759.54 ; v1@7133.02,3750.04 ccw(c7119.75,3750.04) 7129.14,3759.43 ccw(c7138.52,3768.82) v1@7138.52,3755.54 ; 7136,4065 7136,4043.37 ; v1(7138.52,3750.04) 7105.86,3782.71 7105.86,4013.23 7136,4043.37 ; v1(7174.19,4344.37) 7160,4358.56 7160,4400 7175,4415 7205,4415 7223.25,4396.75 7223.25,4226.53 7136,4139.28 7136,4043.37
  MidLayer2 w4: v1@5606.86,2865.54 cw(c5606.86,2842.61) 5623.07,2858.82 cw(c5639.29,2875.04) v1@5616.36,2875.04 ; v1@5606.86,2869.54 cw(c5606.86,2856.26) 5616.25,2865.65 cw(c5625.64,2875.04) v1@5612.36,2875.04 ; v1(5606.86,2875.04) 5639.9,2842 5763,2842 5796.63,2808.37 5959.94,2808.37 6034.94,2733.37 6085.31,2733.37 6160.31,2658.37 6275,2658.37 6285,2668.37 6285,2760.83 6270.79,2775.04 v1(6270.46,2774.71) ; v1(6350.86,3466.71) 6386.86,3466.71 v1(6461.86,3391.71) ; v1@6354.75,3462.82 cw(c6364.14,3453.43) 6364.14,3466.71 cw(c6364.14,3479.99) v1@6354.75,3470.6 ; v1@6357.57,3459.99 cw(c6373.79,3443.77) 6373.79,3466.71 cw(c6373.79,3489.64) v1@6357.57,3473.43 ; v1@6452.36,3391.71 ccw(c6429.42,3391.71) 6445.64,3407.93 ccw(c6461.86,3424.14) v1@6461.86,3401.21 ; v1@6456.36,3391.71 ccw(c6443.08,3391.71) 6452.47,3401.1 ccw(c6461.86,3410.49) v1@6461.86,3397.21 ; v1(6674.13,4372.68) 6752.18,4372.68 6789.98,4334.87 7025.69,4334.87 7145.5,4334.87 7155,4344.37 ; v1@6678.01,4368.79 cw(c6687.4,4359.41) 6687.4,4372.68 cw(c6687.4,4385.96) v1@6678.01,4376.57 ; v1@6680.84,4365.97 cw(c6697.06,4349.75) 6697.06,4372.68 cw(c6697.06,4395.62) v1@6680.84,4379.4 ; v1@7166.64,4338.61 ccw(c7155,4329.74) 7155,4344.37 ; v1@7166.64,4350.13 cw(c7155,4359.01) 7155,4344.37 ; v1(7174.19,4344.37) 7155,4344.37 ; v5(8007.48,4366.89) v5@8009.97,4369.37
  Bottom Layer w4: v1(6673.52,3654.37) 6722.33,3654.37 6735,3641.71 7030.19,3641.71 v1(7138.52,3750.04) ; v1@6677.41,3650.49 cw(c6686.8,3641.1) 6686.8,3654.37 cw(c6686.8,3667.65) v1@6677.41,3658.26 ; v1@6680.24,3647.66 cw(c6696.46,3631.44) 6696.46,3654.37 cw(c6696.46,3677.31) v1@6680.24,3661.09 ; v1@7129.02,3750.04 cw(c7106.09,3750.04) 7122.31,3733.82 cw(c7138.52,3717.61) v1@7138.52,3740.54 ; v1@7133.02,3750.04 cw(c7119.75,3750.04) 7129.14,3740.65 cw(c7138.52,3731.26) v1@7138.52,3744.54 ; v1@7346.19,4357.21 cw(c7346.19,4334.27) 7362.41,4350.49 cw(c7378.63,4366.71) v1@7355.69,4366.71 ; v1@7346.19,4361.21 cw(c7346.19,4347.93) 7355.58,4357.32 cw(c7364.97,4366.71) v1@7351.69,4366.71 ; v1(7346.19,4366.71) 7379.52,4333.37 7453.9,4333.37 7462.23,4341.71 7598.47,4341.71 7619.8,4320.37 7655.52,4320.37 7682.86,4347.71 7740.86,4347.71 7751.52,4358.37 7751.52,4375.04 7763.52,4387.04 7987.33,4387.04 v5(8007.48,4366.89) ; v5@7996.48,4366.89 ccw(c7969.93,4366.89) 7988.7,4385.67 ccw(c8007.48,4404.45) v5@8007.48,4377.89 ; v5@8000.48,4366.89 ccw(c7983.58,4366.89) 7995.53,4378.84 ccw(c8007.48,4390.79) v5@8007.48,4373.89
  other v1: 6104.86,4291.71
DB_MEM.BUS_A15: U7.C7 U8.AE27 U12.20 U13.20 U16.26 U17.26 U61.102 | length 7051.8
  Top Layer w4: U61.102@5567.17,2821.32 cw(c5560.34,2814.49) 5570,2814.49 cw(c5579.66,2814.49) U61.102@5572.83,2821.32 ; U61.102@5570,2837.34 5570,2795.23 5573.52,2791.71 5573.52,2766.71 5590.19,2750.04 5615.19,2750.04 5664.47,2700.76 5693,2672.23 5693,2513.31 5731.44,2474.87 5949.36,2474.87 v1(6174.52,2700.04) ; U13.20@6147.37,3570.37 ccw(c6133.72,3556.71) 6133.72,3576.02 ccw(c6133.72,3595.34) U13.20@6147.37,3581.68 ; v1@6165.02,2700.04 cw(c6142.09,2700.04) 6158.31,2683.82 cw(c6174.52,2667.61) v1@6174.52,2690.54 ; v1@6169.02,2700.04 cw(c6155.75,2700.04) 6165.14,2690.65 cw(c6174.52,2681.26) v1@6174.52,2694.54 ; U13.20@6170.59,3576.02 6058.74,3576.02 6038,3596.76 6038,3609.63 6001.12,3646.51 6001.12,3709.55 5977,3733.67 5977,3749.31 5965.21,3761.11 5901.84,3761.11 ; U13.20@6180.08,3576.04 cw(c6180.08,3532.57) v1@6211.25,3562.87 ; U13.20@6189.55,3576.04 cw(c6189.55,3541.77) v1@6214.11,3565.66 ; 6199.02,3576.04 cw(c6199.02,3550.98) v1@6216.98,3568.45 ; v1@6208.38,3560.09 ccw(c6170.61,3523.36) 6170.61,3576.04 6205.86,3576.04 v1(6215.19,3566.71) ; v1@6552.81,4335.76 ccw(c6536.59,4351.98) 6559.52,4351.98 ccw(c6582.46,4351.98) v1@6566.24,4335.76 ; v1@6555.64,4332.93 ccw(c6546.25,4342.32) 6559.52,4342.32 ccw(c6572.8,4342.32) v1@6563.41,4332.93 ; v1(6559.52,4329.04) 6559.52,4399.52 6563.78,4403.78 U17.26@6619.41,4403.78 ; U17.26@6596.19,4398.12 ccw(c6582.54,4384.47) 6582.54,4403.78 ccw(c6582.54,4423.09) U17.26@6596.19,4409.44 ; U12.20@6845.59,3576.02 6891.02,3576.02 6896.19,3581.19 ; U12.20@6868.81,3570.37 cw(c6882.46,3556.71) 6882.46,3576.02 cw(c6882.46,3595.34) U12.20@6868.81,3581.68 ; v1@6890.04,3594.46 cw(c6878.79,3581.19) 6896.19,3581.19 ; v1@6892.63,3597.51 cw(c6886.11,3589.83) 6896.19,3589.83 cw(c6906.27,3589.83) v1@6899.75,3597.51 ; v1(6896.19,3601.71) 6896.19,3581.19 ; v1@6902.34,3594.46 ccw(c6913.59,3581.19) 6896.19,3581.19 ; v1@7149.47,4298.43 ccw(c7133.26,4314.64) 7156.19,4314.64 ccw(c7179.13,4314.64) v1@7162.91,4298.43 ; v1@7152.3,4295.6 ccw(c7142.91,4304.99) 7156.19,4304.99 ccw(c7169.47,4304.99) v1@7160.08,4295.6 ; v1(7156.19,4291.71) 7156.19,4386.19 7173.78,4403.78 U16.26@7294.41,4403.78 ; U16.26@7271.19,4398.12 ccw(c7257.54,4384.47) 7257.54,4403.78 ccw(c7257.54,4423.09) U16.26@7271.19,4409.44 ; 5894.66,3764.08 ccw(c5901.84,3771.26) 5901.84,3761.11 ; 5894.66,3764.08 ccw(c5901.84,3771.26) 5901.84,3761.11 ; 5894.66,3764.08 cw(c5907.19,3776.61) 5889.47,3776.61 ccw(c5907.19,3776.61) 5894.66,3764.08 ; 5894.66,3764.08 ccw(c5882.13,3751.55) 5882.13,3769.27 cw(c5882.13,3751.55) 5894.66,3764.08
  Top Layer w8: U7.C7@7909.06,4386.57 v5(7928.74,4366.89) ; v5@7919.74,4366.89 ccw(c7898.01,4366.89) 7913.38,4382.25 ccw(c7928.74,4397.62) v5@7928.74,4375.89
  MidLayer1 w4: v1(6174.52,2700.04) 6236.86,2762.37 6236.86,2913.04 6223.52,2926.37 6223.52,2985 6223.52,3001.31 6247.5,3025.29 6247.5,3204.68 6247.5,3222.25 6237.25,3232.5 6190.19,3279.56 6190.19,3310 6190.19,3372.06 6181.36,3380.89 6181.36,3532.88 v1(6215.19,3566.71) ; v1@6174.52,2705.54 ccw(c6174.52,2718.82) 6183.91,2709.43 ccw(c6193.3,2700.04) v1@6180.02,2700.04 ; v1@6174.52,2709.54 ccw(c6174.52,2732.48) 6190.74,2716.26 ccw(c6206.96,2700.04) v1@6184.02,2700.04 ; v1@6205.69,3566.71 cw(c6182.76,3566.71) 6198.97,3550.49 cw(c6215.19,3534.27) v1@6215.19,3557.21 ; v1@6209.69,3566.71 cw(c6196.41,3566.71) 6205.8,3557.32 cw(c6215.19,3547.93) v1@6215.19,3561.21 ; v1@6889.92,3608.84 ccw(c6877.73,3622.71) 6896.19,3622.71 ; v1@6892.56,3605.84 ccw(c6885.5,3613.87) 6896.19,3613.87 ccw(c6906.88,3613.87) v1@6899.82,3605.84 ; v1(6896.19,3601.71) 6896.19,3622.71 ; v1@6902.46,3608.84 cw(c6914.65,3622.71) 6896.19,3622.71 ; v1@7149.47,4284.99 cw(c7133.26,4268.77) 7156.19,4268.77 cw(c7179.13,4268.77) v1@7162.91,4284.99 ; v1@7152.3,4287.82 cw(c7142.91,4278.43) 7156.19,4278.43 cw(c7169.47,4278.43) v1@7160.08,4287.82 ; v1(7156.19,4291.71) 7156.19,4204.73 7155,4203.54 7150,4198.54 7073.52,4122.06 7073.52,3800.04 6896.19,3622.71
  MidLayer2 w4: v1(6559.52,4329.04) 6591.54,4329.04 6598.04,4322.55 6605,4322.55 6687.02,4322.55 ; v1@6563.41,4325.15 cw(c6572.8,4315.76) 6572.8,4329.04 cw(c6572.8,4342.32) v1@6563.41,4332.93 ; v1@6566.24,4322.32 cw(c6582.46,4306.11) 6582.46,4329.04 cw(c6582.46,4351.98) v1@6566.24,4335.76 ; v1@7146.69,4291.71 ccw(c7123.76,4291.71) 7139.97,4307.93 ccw(c7156.19,4324.14) v1@7156.19,4301.21 ; v1@7150.69,4291.71 ccw(c7137.41,4291.71) 7146.8,4301.1 ccw(c7156.19,4310.49) v1@7156.19,4297.21 ; v1(7156.19,4291.71) 7121.02,4326.87 6786.67,4326.87 6780.38,4326.87 ; 6687.02,4322.55 6691.36,4318.2 ; 6687.02,4322.55 6691.36,4318.2 ; 6691.36,4318.2 6692.19,4317.37 6710.13,4317.37 6725,4317.37 6770.88,4317.37 ; 6770.88,4317.37 6780.38,4326.87 ; 6770.88,4317.37 6780.38,4326.87
  Bottom Layer w4: v1(6215.19,3566.71) 6287.52,3566.71 6298.52,3555.71 6331.86,3555.71 6342.86,3566.71 6696.86,3566.71 6705.19,3558.37 6705.19,3541.71 6713.52,3533.37 6731.48,3533.37 6739.82,3525.04 6819.52,3525.04 v1(6896.19,3601.71) ; v1@6219.08,3562.82 cw(c6228.47,3553.43) 6228.47,3566.71 cw(c6228.47,3579.99) v1@6219.08,3570.6 ; v1@6221.91,3559.99 cw(c6238.13,3543.77) 6238.13,3566.71 cw(c6238.13,3589.64) v1@6221.91,3573.43 ; v1@6886.69,3601.71 cw(c6863.76,3601.71) 6879.97,3585.49 cw(c6896.19,3569.27) v1@6896.19,3592.21 ; v1@6890.69,3601.71 cw(c6877.41,3601.71) 6886.8,3592.32 cw(c6896.19,3582.93) v1@6896.19,3596.21 ; v1@7151.35,4283.53 cw(c7146.32,4275.04) 7156.19,4275.04 ; v1(7156.19,4291.71) 7156.19,4275.04 ; v1@7161.03,4283.53 ccw(c7166.06,4275.04) 7156.19,4275.04 ; v5@7917.74,4366.89 cw(c7891.18,4366.89) 7909.96,4348.11 cw(c7928.74,4329.33) v5@7928.74,4355.89 ; v5@7921.74,4366.89 cw(c7904.84,4366.89) 7916.79,4354.94 cw(c7928.74,4342.99) v5@7928.74,4359.89 ; v5(7928.74,4366.89) 7908.37,4346.52 7908.37,4303.37 7905.04,4300.04 7823.52,4300.04 7617.51,4300.04 7592.55,4325 7575,4325 7468.19,4325.04 7459.86,4316.71 7375.19,4316.71 7308.52,4250.04 7181.19,4250.04 7156.19,4275.04
DB_MEM.BUS_A16: U7.D7 U8.AH25 U12.21 U13.21 U16.27 U17.27 U61.103 | length 6901.4
  Top Layer w4: v1@5482,2784.1 U61.103@5516.83,2784.1 ; v1@5483.06,2778.94 cw(c5495.52,2766.48) 5495.52,2784.1 ; v1@5485.89,2776.11 cw(c5505.18,2756.82) U61.103@5505.18,2784.1 ; v1@5488.72,2773.28 cw(c5514.83,2747.16) U61.103@5514.83,2784.1 ; v1@5488.72,2786.72 ccw(c5495.04,2793.04) 5495.04,2784.1 ; v1@5794.29,3612.59 ccw(c5780.58,3630.82) 5803.39,3630.82 ; v1@5796.69,3609.4 ccw(c5786.61,3622.8) 5803.39,3622.8 ; U8.AH25@5798.19,3653.31 cw(c5785.66,3640.78) 5803.39,3640.78 cw(c5821.11,3640.78) U8.AH25@5808.58,3653.31 ; v1(5800,3605) v1@5800,3611.2 ; v1@5800.5,3611.71 5801.71,3611.71 5803.39,3613.39 5803.39,3630.82 ; 5803.39,3619.76 ccw(c5814.76,3619.76) v1@5806.72,3611.72 ; U8.AH25@5803.39,3658.5 5803.39,3638.82 5803.39,3630.82 ; v1@5931.28,3448.72 ccw(c5915.06,3464.93) 5938,3464.93 ccw(c5960.93,3464.93) v1@5944.72,3448.72 ; v1@5934.11,3445.89 ccw(c5924.72,3455.28) 5938,3455.28 ccw(c5951.28,3455.28) v1@5941.89,3445.89 ; v1@5935.28,3549.28 cw(c5919.06,3533.06) 5942,3533.06 cw(c5964.93,3533.06) v1@5948.72,3549.28 ; v1(5938,3442) 5938,3486 5942,3490 v1(5942,3556) ; v1@5938.11,3552.11 cw(c5928.72,3542.72) 5942,3542.72 cw(c5955.28,3542.72) v1@5945.89,3552.11 ; v1(6123.52,3541.71) 6170.59,3541.71 6173.52,3541.71 U13.21@6173.52,3544.53 ; v1@6127.41,3537.82 cw(c6136.8,3528.43) 6136.8,3541.71 cw(c6136.8,3554.99) v1@6127.41,3545.6 ; v1@6130.24,3534.99 cw(c6146.46,3518.77) 6146.46,3541.71 cw(c6146.46,3564.64) v1@6130.24,3548.43 ; 6140.53,3541.71 cw(c6140.53,3532.02) U13.21@6147.37,3538.87 ; U13.21@6170.59,3544.53 6179.53,3544.53 U13.21@6180,3545 ; U13.21@6180,3544.53 6266.47,3544.53 v1@6286.96,3524.04 ; U13.21@6193.81,3538.87 cw(c6207.46,3525.22) 6207.46,3544.53 cw(c6207.47,3563.84) U13.21@6193.81,3550.18 ; 6270.11,3540.89 ccw(c6287.86,3558.64) v1@6287.86,3533.54 ; 6272.27,3538.73 cw(c6257.59,3524.04) v1@6278.36,3524.04 ; 6276.94,3534.06 ccw(c6287.86,3544.99) v1@6287.86,3529.54 ; 6279.1,3531.9 cw(c6271.25,3524.04) v1@6282.36,3524.04 ; U17.27@6619.41,4435.28 6655.62,4435.28 ; U17.27@6642.76,4429.76 cw(c6655.62,4417.53) 6655.62,4435.28 ; U17.27@6642.76,4440.79 ccw(c6655.62,4453.02) 6655.62,4435.28 ; 6654.68,4436.22 cw(c6635.78,4417.33) v1@6662.5,4417.09 ; 6659.02,4431.88 ccw(c6672,4444.85) v1@6672,4426.5 ; 6661.42,4429.48 cw(c6649.14,4417.21) v1@6666.5,4417.05 ; v1@6672.95,4417.95 6655.62,4435.28 ; U12.21@6845.59,3544.53 6880,3544.53 ; U12.21@6869.35,3539.47 cw(c6880,3530.78) 6880,3544.53 ; U12.21@6869.35,3549.58 ccw(c6880,3558.27) 6880,3544.53 ; v1@6905.5,3551.37 ccw(c6892.85,3541.05) 6892.85,3557.37 ccw(c6892.85,3573.69) v1@6905.5,3563.38 ; v1@6908.6,3553.9 ccw(c6901.27,3547.93) 6901.27,3557.37 ccw(c6901.27,3566.82) v1@6908.6,3560.85 ; v1(6912.86,3557.37) 6892.85,3557.37 6880,3544.53 ; U16.27@7294.41,4435.28 7323.97,4435.28 ; U16.27@7311.97,4439.28 cw(c7311.97,4419.96) 7325.63,4433.62 ; U16.27@7314.71,4432.37 cw(c7320.79,4425.92) 7327.06,4432.19 ; U16.27@7317.46,4429.46 cw(c7323.62,4422.93) 7329.97,4429.28 ; U16.27@7319.35,4432.2 cw(c7323.97,4430.28) 7323.97,4435.28 ; U16.27@7319.35,4438.35 ccw(c7323.97,4440.27) 7323.97,4435.28 ; 7324.14,4435.1 ccw(c7317.97,4428.92) 7311.97,4435.28 cw(c7311.97,4406.31) 7332.45,4426.79 ; 7327.55,4431.69 cw(c7307.9,4412.04) v1@7335.69,4412.04 ; 7332.41,4426.84 ccw(c7345.19,4439.62) v1@7345.19,4421.54 ; 7334.38,4424.86 cw(c7321.55,4412.04) v1@7339.69,4412.04 ; v1(7345.19,4412.04) 7345.19,4414.05 7323.97,4435.28
  Top Layer w8: U7.D7@7869.69,4386.57 v5(7889.37,4366.89) ; v5@7880.37,4366.89 ccw(c7858.64,4366.89) 7874.01,4382.25 ccw(c7889.37,4397.62) v5@7889.37,4375.89
  MidLayer1 w4: v1@5426,3406.5 cw(c5426,3383.56) 5442.22,3399.78 cw(c5458.43,3416) v1@5435.5,3416 ; v1@5426,3410.5 cw(c5426,3397.22) 5435.39,3406.61 cw(c5444.78,3416) v1@5431.5,3416 ; v1(5426,3416) 5482.39,3359.61 ; v1@5481.13,2784.1 5498.12,2801.09 ; v1@5482,2789.5 ccw(c5482,2800.44) 5489.73,2792.7 ; v1@5487.45,2780.73 cw(c5504.73,2783.05) 5492.4,2795.37 ; v1@5491.42,2781.26 cw(c5514.81,2784.4) 5498.12,2801.09 ; v1(6912.86,3557.37) 7055.52,3700.04 7081.31,3725.83 ; v1@6912.86,3562.87 ccw(c6912.86,3576.15) 6922.25,3566.76 ccw(c6931.64,3557.37) v1@6918.36,3557.37 ; v1@6912.86,3566.87 ccw(c6912.86,3589.81) 6929.07,3573.59 ccw(c6945.29,3557.37) v1@6922.36,3557.37 ; v1(7190,4385) 7205,4370 7206.86,4368.14 7206.86,4345 7206.86,4232.77 7123.52,4149.43 7120,4145.91 7120,4050 7089.86,4019.86 7089.86,3999.86 7089.86,3980 7089.86,3830 7089.86,3805.3 7089.86,3734.37 ; 5482.39,3340 5482.39,3345 5482.39,3359.61 ; 5482.39,3340 5482.39,3265.01 5503.62,3243.78 5507.35,3240.05 5507.35,3180.24 5503.62,3176.5 5501.72,3174.61 5501.72,3154.49 5501.72,3129.97 5497,3125.25 5497,3043.19 5527.81,3012.38 5527.81,2974.31 5498.12,2944.62 5498.12,2801.09 ; 5482.39,3340 5482.39,3359.61 ; 7081.31,3725.83 7089.86,3734.37 ; 7081.31,3725.83 7089.86,3734.37
  MidLayer2 w4: v1@5800,3602 5824.81,3577.19 5837,3565 5876.73,3565 5888.92,3577.19 5904.28,3592.54 5918.77,3592.54 5929.02,3582.29 5929.02,3568.98 v1(5942,3556) 5942,3547.81 5942,3518 5948.19,3511.81 5978,3511.81 6036.81,3511.81 6066.71,3541.71 v1(6123.52,3541.71) ; v1@5935.28,3549.28 cw(c5919.06,3533.06) 5942,3533.06 cw(c5964.93,3533.06) v1@5948.72,3549.28 ; v1@5938.11,3552.11 cw(c5928.72,3542.72) 5942,3542.72 cw(c5955.28,3542.72) v1@5945.89,3552.11 ; v1@6116.81,3534.99 ccw(c6100.59,3518.77) 6100.59,3541.71 ccw(c6100.59,3564.64) v1@6116.81,3548.43 ; v1@6119.64,3537.82 ccw(c6110.25,3528.43) 6110.25,3541.71 ccw(c6110.25,3554.99) v1@6119.64,3545.6 ; v1(6672,4417) 6724.9,4417 6766.86,4375.04 6951.19,4375.04 6976.19,4350.04 7005,4350.04 7015.19,4350.04 7040.19,4350.04 7048.52,4358.37 7051.23,4361.08 7090.19,4400.04 7156.86,4400.04 7174.96,4400.04 v1(7190,4385) 7205.04,4400.04 7222,4400.04 7333.19,4400.04 v1(7345.19,4412.04) ; v1@6675.89,4413.11 cw(c6685.28,4403.72) 6685.28,4417 cw(c6685.28,4430.28) v1@6675.89,4420.89 ; v1@6678.72,4410.28 cw(c6694.93,4394.06) 6694.93,4417 cw(c6694.93,4439.93) v1@6678.72,4423.72
  Bottom Layer w4: v1@5426,3406.5 cw(c5426,3383.56) 5442.22,3399.78 cw(c5458.43,3416) v1@5435.5,3416 ; v1@5426,3410.5 cw(c5426,3397.22) 5435.39,3406.61 cw(c5444.78,3416) v1@5431.5,3416 ; v1(5426,3416) 5443.5,3398.5 5455.67,3398.5 5464.49,3389.68 5561.67,3292.5 5603.25,3292.5 5613.5,3302.75 5613.5,3306.56 5638.94,3332 5670,3332 5738.15,3332 5741.28,3328.87 5818.02,3328.87 5838.44,3349.29 5874.79,3349.29 5935.51,3410.02 5938,3412.5 v1(5938,3442) ; v1@5931.28,3435.28 cw(c5915.06,3419.06) 5938,3419.06 cw(c5960.93,3419.06) v1@5944.72,3435.28 ; v1@5934.11,3438.11 cw(c5924.72,3428.72) 5938,3428.72 cw(c5951.28,3428.72) v1@5941.89,3438.11 ; v1(6287.86,3524.04) 6311.52,3547.71 6335.17,3547.71 6345.84,3558.37 6690.52,3558.37 6697.19,3551.71 6697.19,3533.37 6705.52,3525.04 6728.51,3525.04 6736.84,3516.71 6872.19,3516.71 v1(6912.86,3557.37) ; v1@6287.86,3529.54 ccw(c6287.86,3542.82) 6297.25,3533.43 ccw(c6306.64,3524.04) v1@6293.36,3524.04 ; v1@6287.86,3533.54 ccw(c6287.86,3556.48) 6304.07,3540.26 ccw(c6320.29,3524.04) v1@6297.36,3524.04 ; v1@6903.36,3557.37 cw(c6880.42,3557.37) 6896.64,3541.16 cw(c6912.86,3524.94) v1@6912.86,3547.87 ; v1@6907.36,3557.37 cw(c6894.08,3557.37) 6903.47,3547.99 cw(c6912.86,3538.6) v1@6912.86,3551.87 ; v1@7335.69,4412.04 cw(c7312.76,4412.04) 7328.97,4395.82 cw(c7345.19,4379.61) v1@7345.19,4402.54 ; v1@7339.69,4412.04 cw(c7326.41,4412.04) 7335.8,4402.65 cw(c7345.19,4393.26) v1@7345.19,4406.54 ; v1(7345.19,4412.04) 7328.19,4395.04 7328.19,4354.71 7357.86,4325.04 7420,4325.04 7456.84,4325 7465.21,4333.37 7595.48,4333.37 7620.48,4308.37 7705,4308.37 7705.14,4308.52 7743.34,4308.52 7815,4308.52 7818.5,4308.52 7858.52,4308.52 7865,4315 7865,4342.52 v5(7889.37,4366.89) ; v5@7878.37,4366.89 cw(c7851.81,4366.89) 7870.59,4348.11 cw(c7889.37,4329.33) v5@7889.37,4355.89 ; v5@7882.37,4366.89 cw(c7865.47,4366.89) 7877.42,4354.94 cw(c7889.37,4342.99) v5@7889.37,4359.89
  other v1: 5482,2780