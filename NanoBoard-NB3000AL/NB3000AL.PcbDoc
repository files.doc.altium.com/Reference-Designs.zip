# Altium PCB NB3000AL.PcbDoc (part 7 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
1V2: (continued)
  Bottom Layer w4: 4838.82,4048.03 4861.95,4048.03 4920.21,4048.03 4978.47,4048.03 5036.73,4048.03 5056.15,4048.03 5130.27,4048.03 5149.77,4048.03 ccw(c5149.77,4089.76) 5179.28,4060.25 ; 4838.82,4244.88 4861.95,4244.88 4920.21,4244.88 4978.47,4244.88 5036.73,4244.88 5056.15,4244.88 5116.34,4244.88 5130.27,4244.88 cw(c5130.27,4230.83) 5140.2,4240.76 ; 4838.82,4292.6 4861.95,4292.6 4920.21,4292.6 4978.47,4292.6 5036.73,4292.6 5056.15,4292.6 5130.27,4292.6 5149.77,4292.6 cw(c5149.77,4250.87) 5179.28,4280.38 ; 4838.82,4371.34 4861.95,4371.34 4920.21,4371.34 4978.47,4371.34 5036.73,4371.34 5056.15,4371.34 5130.27,4371.34 5149.77,4371.34 cw(c5149.77,4329.61) 5179.28,4359.12 ; 5130.01,3638.82 5130.01,3640.41 5130.01,3698.67 5130.01,3914.41 cw(c5153.78,3914.41) 5136.97,3931.22 5143.39,3938.95 ; 5130.01,4741.18 5130.01,4739.59 5130.01,4681.33 5130.01,4465.59 ccw(c5153.78,4465.59) 5136.97,4448.78 5143.39,4441.05 ; v3@5146.31,4228.72 ccw(c5128.27,4227.14) 5139.91,4241.01 ccw(c5151.55,4254.88) v3@5153.13,4236.84 ; v3@5146.39,3952.48 cw(c5128.56,3949.33) 5143.39,3938.95 ; v3@5146.39,4427.52 ccw(c5128.56,4430.67) 5143.39,4441.05 ; v3@5155.08,3946.39 ccw(c5158.23,3928.56) 5143.39,3938.95 ; v3@5155.08,4433.61 cw(c5158.23,4451.44) 5143.39,4441.05 ; v3@5185.68,4072.54 cw(c5167.64,4074.12) 5179.28,4060.25 ; v3@5185.68,4268.09 ccw(c5167.64,4266.51) 5179.28,4280.38 ; v3@5185.68,4346.83 ccw(c5167.64,4345.25) 5179.28,4359.12 ; v3@5192.5,4064.42 ccw(c5190.92,4046.38) 5179.28,4060.25 ; v3@5192.5,4276.21 cw(c5190.92,4294.25) 5179.28,4280.38 ; v3@5192.5,4354.95 cw(c5190.92,4372.99) 5179.28,4359.12 ; 5208.66,4741.18 5208.66,4718.05 5208.66,4659.79 5208.66,4601.53 5208.66,4543.27 5208.66,4523.85 5208.66,4449.73 5208.66,4430.23 ccw(c5250.39,4430.23) 5220.88,4400.72 ; v3@5225.05,4387.5 ccw(c5207.01,4389.08) 5220.88,4400.72 ; v3@5233.17,4394.32 cw(c5234.75,4412.36) 5220.88,4400.72 ; v1@5237.45,5047.45 v1@5234.9,5050 ; v1(5240,5050) v1@5234.9,5050 ; 5248.03,3638.82 5248.03,3661.95 5248.03,3720.21 5248.03,3778.47 5248.03,3836.73 5248.03,3856.15 5248.03,3930.27 5248.03,3949.77 cw(c5289.76,3949.77) 5260.25,3979.28 ; v3@5264.42,3992.5 cw(c5246.38,3990.92) 5260.25,3979.28 ; v3@5272.54,3985.68 ccw(c5274.12,3967.64) 5260.25,3979.28 ; v1(5273.52,3253.37) v1@5277.52,3257.37 ; v1@5492.6,4872.6 v1(5495,4875) ; v3@5507.46,4394.32 ccw(c5505.88,4412.36) 5519.75,4400.72 ; v3@5515.58,4387.5 cw(c5533.62,4389.08) 5519.75,4400.72 ; 5531.97,4741.18 5531.97,4718.05 5531.97,4659.79 5531.97,4601.53 5531.97,4543.27 5531.97,4523.85 5531.97,4449.73 5531.97,4430.23 cw(c5490.24,4430.23) 5519.75,4400.72 ; v3@5546.83,3985.68 cw(c5545.25,3967.64) 5559.12,3979.28 ; v3@5554.95,3992.5 ccw(c5572.99,3990.92) 5559.12,3979.28 ; 5571.34,3638.82 5571.34,3661.95 5571.34,3720.21 5571.34,3778.47 5571.34,3836.73 5571.34,3856.15 5571.34,3930.27 5571.34,3949.77 ccw(c5529.61,3949.77) 5559.12,3979.28 ; v3@5585.55,4394.24 ccw(c5582.4,4412.07) 5597.24,4401.68 ccw(c5612.07,4391.3) v3@5594.24,4388.15 ; v3@5587.5,4103.79 cw(c5589.08,4085.75) 5600.72,4099.62 ; v3@5587.5,4315.58 ccw(c5589.08,4333.62) 5600.72,4319.75 ; v3@5594.32,4111.91 ccw(c5612.36,4113.49) 5600.72,4099.62 ; v3@5594.32,4307.46 cw(c5612.36,4305.88) 5600.72,4319.75 ; 5597.28,4401.65 ccw(c5578.68,4416.44) 5602.4,4418.05 ; 5602.45,4418.1 5602.45,4426.22 cw(c5626.22,4426.22) 5626.22,4449.99 ccw(c5626.22,4465.59) 5641.82,4465.59 5641.82,4681.33 5641.82,4739.59 5641.82,4741.18 ; v3@5624.92,3946.39 cw(c5621.77,3928.56) 5636.61,3938.95 ; v3@5624.92,4433.61 ccw(c5621.77,4451.44) 5636.61,4441.05 ; v3@5626.87,4143.16 cw(c5628.45,4125.12) 5640.09,4138.99 cw(c5651.73,4152.86) v3@5633.69,4151.28 ; v3@5626.87,4276.21 ccw(c5628.45,4294.25) 5640.09,4280.38 ccw(c5651.73,4266.51) v3@5633.69,4268.09 ; v3@5633.61,3952.48 ccw(c5651.44,3949.33) 5636.61,3938.95 ; v3@5633.61,4427.52 cw(c5651.44,4430.67) 5636.61,4441.05 ; 5639.8,4139.24 ccw(c5649.73,4149.17) 5649.73,4135.12 5663.66,4135.12 5723.85,4135.12 5743.27,4135.12 5801.53,4135.12 5859.79,4135.12 5918.05,4135.12 5941.18,4135.12 ; 5639.8,4280.13 cw(c5649.73,4270.2) 5649.73,4284.25 5663.66,4284.25 5723.85,4284.25 5743.27,4284.25 5801.53,4284.25 5859.79,4284.25 5918.05,4284.25 5941.18,4284.25 ; 5649.99,3638.82 5649.99,3640.41 5649.99,3698.67 5649.99,3914.41 ccw(c5626.22,3914.41) 5643.03,3931.22 5636.61,3938.95 ; 5649.99,4741.18 5649.99,4739.59 5649.99,4681.33 5649.99,4465.59 cw(c5626.22,4465.59) 5643.03,4448.78 5636.61,4441.05 ; 5941.18,4087.4 5918.05,4087.4 5859.79,4087.4 5801.53,4087.4 5743.27,4087.4 5723.85,4087.4 5649.73,4087.4 5630.23,4087.4 cw(c5630.23,4129.13) 5600.72,4099.62 ; 5941.18,4331.97 5918.05,4331.97 5859.79,4331.97 5801.53,4331.97 5743.27,4331.97 5723.85,4331.97 5649.73,4331.97 5630.23,4331.97 ccw(c5630.23,4290.24) 5600.72,4319.75 ; 6915.75,1510.67 6915.75,1552.69 6915.75,1610.95 6915.75,1669.21 6915.75,1688.63 6915.75,1748.82 6915.75,1753.58 cw(c6948.88,1753.75) 6920.84,1771.4 ; 6915.75,2219.33 6915.75,2177.31 6915.75,2119.05 6915.75,2060.79 6915.75,2041.37 6915.75,1981.18 6915.75,1976.42 ccw(c6948.88,1976.25) 6920.84,1958.6 ; v3@6923.87,1784.96 cw(c6906.04,1781.81) 6920.87,1771.43 cw(c6935.71,1761.04) v3@6932.56,1778.87 ; v3@6923.87,1945.04 ccw(c6906.04,1948.19) 6920.87,1958.57 ccw(c6935.71,1968.96) v3@6932.56,1951.13 ; 6955.12,2219.33 6955.12,2177.31 6955.12,2119.05 6955.12,2060.79 6955.12,2041.37 6955.12,1981.18 6955.12,1976.42 ccw(c6988.25,1976.25) 6960.21,1958.6 ; v3@6963.24,1945.04 ccw(c6945.41,1948.19) 6960.24,1958.57 ccw(c6975.08,1968.96) v3@6971.93,1951.13 ; v3@7048.07,1951.13 ccw(c7044.92,1968.96) 7059.76,1958.57 ccw(c7074.59,1948.19) v3@7056.76,1945.04 ; 7059.79,1958.6 ccw(c7031.75,1976.25) 7064.88,1976.42 7064.88,1981.18 7064.88,2041.37 7064.88,2060.79 7064.88,2119.05 7064.88,2177.31 7064.88,2219.33 ; v3@7087.44,1951.13 ccw(c7084.29,1968.96) 7099.13,1958.57 ccw(c7113.96,1948.19) v3@7096.13,1945.04 ; 7099.16,1958.6 ccw(c7071.12,1976.25) 7104.25,1976.42 7104.25,1981.18 7104.25,2041.37 7104.25,2060.79 7104.25,2119.05 7104.25,2177.31 7104.25,2219.33 ; v1@5234.86,5050.04 v1@5234.9,5050
  Bottom Layer w12: R207.2@3303.82,1635 3303.82,1620 3313.82,1610 3395,1610 3406.93,1598.07 3406.93,1570 v1(3435,1541.93) ; v1@3429.5,1541.93 ccw(c3416.22,1541.93) 3425.61,1551.32 ccw(c3435,1560.71) v1@3435,1547.43 ; v1(4460.11,1806) 4485.72,1806 4491.72,1800 C239.1@4491.72,1776.18 ; v1(4460.11,1856.35) 4485.72,1856.35 4491.72,1862.35 C221.1@4491.72,1886.18 ; v1@4464,1802.11 cw(c4473.39,1792.72) 4473.39,1806 cw(c4473.39,1819.28) v1@4464,1809.89 ; v1@4464,1852.46 cw(c4473.39,1843.08) 4473.39,1856.35 cw(c4473.39,1869.63) v1@4464,1860.24 ; C239.1@4487.62,1780.29 ccw(c4477.7,1790.21) 4491.72,1790.21 ccw(c4505.75,1790.21) C239.1@4495.83,1780.29 ; C221.1@4487.62,1882.07 cw(c4477.7,1872.15) 4491.72,1872.15 cw(c4505.75,1872.15) C221.1@4495.83,1882.07 ; v1(4570,1825) 4615,1825 4631.72,1808.28 C224.1@4631.72,1776.18 ; v1@4573.89,1821.11 cw(c4583.28,1811.72) 4583.28,1825 cw(c4583.28,1838.28) v1@4573.89,1828.89 ; C224.1@4627.62,1780.29 ccw(c4617.7,1790.21) 4631.72,1790.21 ccw(c4645.75,1790.21) C224.1@4635.83,1780.29 ; C192.1@4627.62,1882.07 cw(c4617.7,1872.15) 4631.72,1872.15 cw(c4645.75,1872.15) C192.1@4635.83,1882.07 ; v1@4630,1852 4631,1853 4631.72,1853.72 C192.1@4631.72,1886.18 ; 4631.72,1867.36 ccw(c4649.36,1867.36) v1@4636.89,1854.89 ; C226.1@5902.62,5512.07 cw(c5892.7,5502.15) 5906.73,5502.15 cw(c5920.75,5502.15) C226.1@5910.83,5512.07 ; C226.1@5902.62,5520.29 ccw(c5892.7,5530.21) 5906.72,5530.21 ccw(c5920.75,5530.21) C226.1@5910.83,5520.29 ; C225.1@5902.62,5622.07 cw(c5892.7,5612.15) 5906.72,5612.15 cw(c5920.75,5612.15) 5910.83,5622.07 cw(c5920.75,5612.15) 5920.75,5626.18 cw(c5920.75,5640.21) C225.1@5910.83,5630.29 ; v1@5902.84,5479.12 ccw(c5893.45,5488.51) 5906.73,5488.51 ccw(c5920,5488.51) v1@5910.61,5479.12 ; v1@5906.73,5475.04 v1(5906.73,5475.23) C226.1@5906.72,5516.18 C225.1@5906.72,5626.18 v1(5959.72,5626.18) ; v1@5955.83,5622.29 ccw(c5946.44,5612.9) 5946.44,5626.18 ccw(c5946.44,5639.45) v1@5955.83,5630.07 ; v2(7480,2110) v2@7481.86,2110 ; 3303.82,1621.67 ccw(c3290.98,1621.67) 3300.06,1630.75 cw(c3290.98,1621.67) 3303.82,1621.67 ; 3303.82,1621.67 cw(c3316.66,1621.67) 3307.58,1630.75 ccw(c3316.66,1621.67) 3303.82,1621.67
  Bottom Layer w19: v3(5193.15,4150.63) C314.1@5193.15,4169.33 ; C302.1@5232.52,4210.67 v3(5232.52,4229.37) ; C297.1@5267.14,4312.86 ccw(c5255.66,4324.34) C297.1@5271.89,4324.34 ; v3(5271.89,4150.63) C268.1@5271.89,4169.33 ; C297.1@5271.89,4314.35 v3(5271.89,4347.48) ; C296.1@5298,4098 v3(5311.26,4111.26) ; C274.1@5311.26,4210.67 v3(5311.26,4229.37) ; v3(5350.63,4071.89) C318.1@5369.33,4071.89 ; C275.1@5350.63,4169.33 v3(5350.63,4150.63) C273.1@5369.33,4150.63 ; v3(5350.63,4268.74) C301.1@5369.33,4268.74 ; v3(5350.63,4347.48) C299.1@5369.33,4347.48 ; C298.1@5410.15,4227.12 cw(c5404.53,4202.92) C270.1@5429.37,4202.92 ; C317.1@5410.67,4032.52 v3(5429.37,4032.52) ; C316.1@5410.67,4111.26 v3(5429.37,4111.26) ; C298.1@5410.67,4229.37 v3(5429.37,4229.37) C270.1@5429.37,4210.67 ; C300.1@5410.67,4308.11 v3(5429.37,4308.11) ; v3(5468.74,4150.63) C269.1@5468.74,4169.33 ; v3(5468.74,4268.74) C313.1@5482,4282 ; v3(5508.11,4032.52) C295.1@5508.11,4065.65 ; C295.1@5508.11,4057.27 cw(c5522.73,4057.27) C295.1@5512.39,4067.61 ; C272.1@5508.11,4210.67 v3(5508.11,4229.37) ; v3(5547.48,4150.63) C271.1@5547.48,4169.33 ; C315.1@5586.85,4210.67 v3(5586.85,4229.37)
  other v1: 3435,1438.07 3457.5,1438.07 3480,1438.07 3555,1438 3577.5,1438 3600,1438 3622.5,1438 3645,1438 3667.5,1438 3457.5,1541.93 3480,1541.93 3348.7,1750.67 3470.75,1750.67 3348.7,1773.17 3470.75,1773.17 3348.7,1795.67 3470.75,1795.67 4633,1851 997.62,3003.81 997.31,3143.04 4884,4804
1V2SET: R207.1 R208.1 U42.5 | length 432.8
  Bottom Layer w12: R207.1@3346.18,1635 R208.1@3438.82,1635 3438.82,1598.01 3438.82,1581.18 3445,1575 3505,1575 3595,1575 3636.14,1533.86 U42.5@3636.14,1525 ; R207.1@3349.94,1631.24 cw(c3359.02,1622.16) 3359.02,1635 cw(c3359.02,1647.84) R207.1@3349.94,1638.76 ; R208.1@3435.06,1630.75 cw(c3425.98,1621.67) 3438.82,1621.67 cw(c3451.66,1621.67) R208.1@3442.58,1630.75 ; R208.1@3435.06,1631.24 ccw(c3425.98,1622.16) 3425.98,1635 ccw(c3425.98,1647.84) R208.1@3435.06,1638.76
1V8: C128.1 C129.1 EXTHDR1.77 EXTHDR1.79 PROTOTYPE1.4 R201.2 TP6.1 U39.2 | length 2492.1
  Top Layer w12: v1@902.98,3142.02 EXTHDR1.79@902.97,3071.85 v1@902.98,3142.88 ; v1@930.43,3139.15 cw(c920.66,3129.38) 934.47,3129.38 ; EXTHDR1.77@934.47,3071.85 v1@934.47,3142.88 ; 934.47,3130.14 cw(c947.21,3130.14) v1@938.2,3139.15 ; v1@898.93,3139.15 cw(c889.16,3129.38) 902.98,3129.38 ccw(c889.16,3129.38) v1@898.93,3139.15 ; 902.98,3130.14 cw(c915.72,3130.14) 906.71,3139.15 ccw(c915.72,3130.14) 902.98,3130.14
  MidLayer1 w20: TP6.1@56.12,3708.23 cw(c7.84,3708.23) 41.98,3674.09 cw(c76.12,3639.95) TP6.1@76.12,3688.23 ; TP6.1@76.12,3708.23 0,3632.11 0,3310 25,3285 452.89,3285 PROTOTYPE1.4@576.12,3408.23 ; PROTOTYPE1.4@555.12,3408.23 cw(c504.42,3408.23) 540.27,3372.39 cw(c576.12,3336.54) PROTOTYPE1.4@576.12,3387.23
  MidLayer2 w20: PROTOTYPE1.4@576.12,3387.23 cw(c576.12,3336.54) 611.97,3372.39 cw(c647.82,3408.23) PROTOTYPE1.4@597.12,3408.23 ; PROTOTYPE1.4@576.12,3408.23 639.36,3345 925,3345 955,3315 955,3210 934.31,3189.31 v1(934.31,3143.04)
  Bottom Layer w20: 2860.6,1684.26 cw(c2902.01,1642.85) v1@2902.01,1701.41 ; R201.2@2868.82,1625 2868.82,1692.48 C129.1@2940.28,1763.94 ; 2883.51,1702.91 cw(c2893.78,1702.91) 2886.52,1710.18 ; C129.1@2894.74,1718.4 cw(c2902.01,1711.14) C129.1@2902.01,1721.41 ; v1@2903.51,1702.91 cw(c2962.07,1702.91) C129.1@2920.66,1744.32 ; C129.1@2904.12,1727.78 cw(c2940.28,1691.62) C129.1@2940.28,1742.76
  other v1: 2358,1438.01 2383,1438.01 2408,1438.01 2580,1450 2358,1464.01 2383,1464.01 2408,1464.01 2358,1490 2383,1490 2408,1490 2545,1490 2615,1490 2358,1516 2383,1516 2408,1516 2545,1516.67 2615,1516.67 2358,1542 2383,1542 2408,1542 2545,1543.33 2615,1543.33 2545,1570 2615,1570 2356.01,1584.87 2382,1584.87 2408,1584.87 2515,1605 2540.99,1605 2615,1605 2640.99,1605 2335,1617.01 2820,1629 2846,1629 2515,1630 2540.99,1630 2615,1630 2640.99,1630 2335,1643.01 2515,1655 2540.99,1655 2615,1655 2640.99,1655 2820,1655 2846,1655 2335,1669 2206.02,1670.99 2232.01,1670.99 2258.01,1670.99 2284,1671 2310,1671 2820,1681 2335,1695 2232.01,1695.99 2258.01,1695.99 2284,1696 2310,1696 2902.01,1702.91 2924.51,1702.91 2947.01,1702.91 3003,1711 3029,1711 3055,1711 3080.99,1711 3106.99,1711 3003,1736 3029,1736 3055,1736 3080.99,1736 3106.99,1736 2879.25,1740.67 2820,1760 2844,1760 3003,1761 3029,1761 3055,1761 3080.99,1761 3106.99,1761 2879.25,1763.17 2335,1768.01 2206.02,1770 2232.01,1770 2258.01,1770 2284,1770 2310,1770 2820,1785 2844,1785 2879.25,1785.67 2335,1794 2232.01,1795 2258.01,1795 2284,1795 2310,1795 2258.01,1820 2284,1820 2310,1820 2335,1820 2820,1871.99 2845,1871.99 2870,1871.99 2191.14,1885 2295,1885 3019.98,1887 3045.98,1887 3071.98,1887 3097.97,1887.01 2335,1894 2820,1897.99 2845,1897.99 2191.14,1907.5 2295,1907.5 2993.99,1912 3019.98,1912 3045.98,1912 3071.98,1912 3097.97,1912.01 2335,1920 2820,1923.98 2191.14,1930 2295,1930 2967.99,1937 2993.99,1937 3019.98,1937 3045.98,1937 3071.98,1937 3097.97,1937.01 2335,2010.02 2335,2036.01 2106,2040 2131.99,2040 2869.99,2053.96 2335,2062.01 2106,2065 2131.99,2065 2231.02,2088 2257.01,2088 2283.01,2088 2309,2088 2335,2088 2106,2090 2131.99,2090 2231.02,2114 2257.01,2114 2283.01,2114 2309,2114 2335,2114 2106,2115 2131.99,2115 2156.99,2115 2181.99,2115 2106,2140 2131.99,2140 2156.99,2141 2181.99,2141 2106,2165 2131.99,2165 2106,2190 2131.99,2190 2362.01,2191.99 2388.01,2191.99 2414,2191.99 2440,2191.99 2362.01,2216.99 2388.01,2216.99 2414,2216.99 2440,2216.99 2336.01,2241.99 2362.01,2241.99 2388.01,2241.99 2414,2241.99 2440,2241.99 902.82,3143.04
1V8SET: R201.1 R202.1 U39.1 | length 450.7
  Bottom Layer w12: U39.1@2680,1525 2715,1560 2880,1560 2911.18,1591.18 R201.1@2911.18,1625 ; R201.1@2906.09,1625 R201.1@2911.18,1625 ; R201.1@2907.42,1620.75 cw(c2898.34,1611.67) 2911.18,1611.67 cw(c2924.02,1611.67) R201.1@2914.94,1620.75 ; R201.1@2914.94,1621.24 cw(c2924.02,1612.16) 2924.02,1625 cw(c2924.02,1637.84) R201.1@2914.94,1628.76 ; R202.1@3000.06,1621.24 ccw(c2990.98,1612.16) 2990.98,1625 ccw(c2990.98,1637.84) R202.1@3000.06,1628.76 ; R202.1@3003.82,1625 R201.1@2911.18,1625
2V5: C132.1 C133.1 C138.1 C139.1 EXTHDR1.81 EXTHDR1.83 L4.1 L5.1 L6.1 L7.1 L8.1 L9.1 PROTOTYPE1.6 R203.2 TP5.1 U40.2 U42.1 U42.2 | length 4165.4
  Top Layer w12: v1@835.94,3139.15 cw(c826.17,3129.38) 839.98,3129.38 ; EXTHDR1.83@839.98,3071.85 v1@839.98,3142.88 ; 839.98,3130.14 cw(c852.73,3130.14) v1@843.72,3139.15 ; v1@867.43,3139.15 cw(c857.66,3129.38) 871.48,3129.38 ; EXTHDR1.81@871.48,3071.85 v1@871.48,3142.88 ; 871.48,3130.14 cw(c884.22,3130.14) v1@875.21,3139.15
  MidLayer2 w19: v8(4838.82,4190) v8(5941.18,4190) ; v8@5390,3638.82 v8(5390,4741.18)
  MidLayer2 w20: TP5.1@76.12,3788.23 cw(c76.12,3739.95) 110.26,3774.09 cw(c144.41,3808.23) TP5.1@96.12,3808.23 ; TP5.1@76.12,3808.23 124.36,3760 710,3760 725,3745 725,3459.36 PROTOTYPE1.6@776.12,3408.23 ; PROTOTYPE1.6@755.12,3408.23 ccw(c704.42,3408.23) 740.27,3444.08 ccw(c776.12,3479.93) PROTOTYPE1.6@776.12,3429.23
  Bottom Layer w12: R203.2@1780.06,1629.25 ccw(c1770.98,1638.33) 1783.82,1638.33 ccw(c1796.66,1638.33) R203.2@1787.58,1629.25 ; R203.2@1783.82,1625 1783.82,1654.72 v1@1832.01,1702.91 ; 1809.82,1680.72 ccw(c1787.62,1702.91) v1@1819.01,1702.91 ; 1812.01,1682.92 cw(c1847.01,1647.92) v1@1847.01,1697.41 ; v1@1832.5,1703.4 cw(c1847.01,1688.89) v1@1847.01,1709.41
  Bottom Layer w19: v8(4838.82,4190) L4.1@4877.2,4190 ; v8@5390,3638.82 L7.1@5390,3677.2 ; L6.1@5390,4702.8 v8(5390,4741.18) ; L5.1@5902.8,4190 v8(5941.18,4190) ; v2(7548,1710) 7550,1712 7570.33,1712 L9.1@7571.33,1713 7571.33,1695.78 7583.31,1683.8 7583.31,1681.69 7585.31,1679.69 7699.5,1679.69 7709.52,1689.71 ; L9.1@7573.2,1711.64 ccw(c7585.19,1702.9) 7574.7,1692.41 ; 7709.71,1689.71 7711.67,1691.67 L8.1@7711.67,1713
  other v1: 1273,1438.01 1298,1438.01 1323,1438.01 4054.02,1438.07 4076.52,1438.07 4099.02,1438.07 1495,1450 1273,1464.01 1298,1464.01 1323,1464.01 1273,1490 1298,1490 1323,1490 1460,1490 1530,1490 1273,1516 1298,1516 1323,1516 1460,1516.67 1530,1516.67 1273,1542 1298,1542 1323,1542 4054.02,1541.93 4076.52,1541.93 4099.02,1541.93 1460,1543.33 1530,1543.33 1460,1570 1530,1570 1271,1585 1297,1585 1322.99,1585 1637.01,1585 1663.01,1585 1689,1585 1715,1585 1430,1605 1456,1605 1530,1605 1556,1605 1735,1607.01 1760.01,1608.05 1255,1609 1430,1630 1456,1630 1530,1630 1556,1630 1735,1633.01 1760.01,1634.04 1255,1635 1430,1655 1456,1655 1530,1655 1556,1655 1735,1659 1760.01,1660.04 1255,1661 1923,1668.01 1948,1668.01 1973,1668.01 1998,1668.01 2023,1668.01 1735,1685 1760.01,1686.04 1255,1686.99 1923,1694.01 1948,1694.01 1973,1694.01 1998,1694.01 2023,1694.01 1106.02,1700 1132.01,1700 1158.01,1700 1184,1700 1210,1700 1802.01,1702.91 1824.51,1702.91 1847.01,1702.91 4107.01,1702.91 4129.51,1702.91 4152.01,1702.91 1735,1711 1760.01,1712.03 1255,1712.99 1923,1720 1948,1720 1973,1720 1998,1720 2023,1720 1106.02,1725 1132.01,1725 1158.01,1725 1184,1725 1210,1725 1735,1736.99 1760.01,1738.03 1255,1738.98 1923,1746 1948,1746 1973,1746 1998,1746 2023,1746 1106.02,1750 1132.01,1750 1158.01,1750 1184,1750 1210,1750 1735,1762.99 1760,1764.02 1255,1764.98 1923,1772 1948,1772 1973,1772 1998,1772 1106.02,1775 1132.01,1775 1158.01,1775 1184,1775 1210,1775 1735,1788.98 1760,1790.02 1255,1790.98 1735,1814.98 1760,1816.02 1802.01,1824.96 1824.51,1824.96 1847.01,1824.96 4107.01,1824.96 4129.51,1824.96 4152.01,1824.96 1735,1840.98 1760,1842.01 1250.77,1856.04 1250.77,1882.03 1106.14,1885 1210,1885 1106.14,1907.5 1210,1907.5 1250.77,1908.03 1734.99,1926.97 1760,1928.01 1106.14,1930 1210,1930 1250.77,1934.03 1734.99,1952.97 1760,1954 1734.99,1978.96 1760,1980 1250,2010 1735,2025 1250,2036 1735,2074 1735,2100 1735,2126 1331,2145 1356.99,2145 1426,2145 1451.99,2145 1477.99,2145 1503.98,2145 1529.98,2145 1555.98,2145 1581.97,2145.01 1607.97,2145.01 1633.96,2145.01 1659.96,2145.01 1685.96,2145.01 1711.95,2145.01 1829,2172 1855,2172 1880.99,2172 1906.99,2172 1803,2197 1829,2197 1855,2197 1880.99,2197 1906.99,2197 1803,2222 1829,2222 1855,2222 1880.99,2222 1906.99,2222 1803,2247 1829,2247 1855,2247 1880.99,2247 1906.99,2247 839.83,3143.04 871.32,3143.04
  other v2: 7528.1,1711.3
  other v6: 5390.5,3625.82
  other v8: 5390,3639.82
2V5SET: R203.1 R204.1 U40.1 | length 445.6
  Bottom Layer w12: U40.1@1595,1520 1630,1555 1795,1555 1826.18,1586.18 R203.1@1826.18,1620 ; R203.1@1822.42,1620.75 cw(c1813.34,1611.67) 1826.18,1611.67 cw(c1839.02,1611.67) R203.1@1829.94,1620.75 ; R203.1@1826.18,1625 R204.1@1918.82,1625 ; R203.1@1829.94,1621.24 cw(c1839.02,1612.16) 1839.02,1625 cw(c1839.02,1637.84) R203.1@1829.94,1628.76 ; R204.1@1915.06,1621.24 ccw(c1905.98,1612.16) 1905.98,1625 ccw(c1905.98,1637.84) R204.1@1915.06,1628.76