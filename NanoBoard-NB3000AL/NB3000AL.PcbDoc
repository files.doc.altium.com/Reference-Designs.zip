# Altium PCB NB3000AL.PcbDoc (part 30 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_A17: U7.E7 U8.AD12 U16.42 U17.42 U61.105 | length 9747.7
  Top Layer w4: v3(5271.89,3796.3) U8.AD12@5291.57,3815.98 ; U8.AD12@5284.23,3815.98 cw(c5266.51,3815.98) 5279.04,3803.45 cw(c5291.57,3790.92) U8.AD12@5291.57,3808.64 ; v1@5429.28,2823.28 cw(c5413.06,2807.06) 5436,2807.06 cw(c5458.93,2807.06) v1@5442.72,2823.28 ; v1@5432.11,2826.11 cw(c5422.72,2816.72) 5436,2816.72 cw(c5449.28,2816.72) v1@5439.89,2826.11 ; v1(5436,2830) 5436,2799 5450,2785 5450,2753.81 5469.62,2734.19 5494.05,2734.19 5504.6,2744.73 U61.105@5516.83,2744.73 5545.08,2744.73 5559.62,2730.19 5576.71,2730.19 v1(5594.52,2712.37) ; 5496.13,2736.27 ccw(c5487.67,2744.73) U61.105@5499.64,2744.73 ; 5498.44,2738.58 cw(c5503.64,2733.38) U61.105@5503.64,2740.73 ; U61.105@5532.85,2741.9 cw(c5539.68,2735.07) 5539.68,2744.73 cw(c5539.68,2754.39) U61.105@5532.85,2747.56 ; v1@5585.02,2712.37 ccw(c5562.09,2712.37) 5578.31,2728.59 ccw(c5594.52,2744.81) v1@5594.52,2721.87 ; v1@5589.02,2712.37 ccw(c5575.75,2712.37) 5585.14,2721.76 ccw(c5594.52,2731.15) v1@5594.52,2717.87 ; v1@6553.81,5031.32 cw(c6537.59,5015.11) 6560.52,5015.11 cw(c6583.46,5015.11) v1@6567.24,5031.32 ; v1@6556.64,5034.15 cw(c6547.25,5024.76) 6560.52,5024.76 cw(c6573.8,5024.76) v1@6564.41,5034.15 ; v1(6560.52,5038.04) 6560.52,4983.33 6552.19,4975 6552.19,4915.72 6560.19,4907.72 U17.42@6619.41,4907.72 ; U17.42@6596.19,4902.06 ccw(c6582.54,4888.4) 6582.54,4907.72 ccw(c6582.54,4927.03) U17.42@6596.19,4913.37 ; U16.42@7294.41,4907.72 v1@7345.53,4907.72 ; U16.42@7317.63,4902.06 cw(c7331.28,4888.4) 7331.28,4907.72 cw(c7331.28,4927.03) U16.42@7317.63,4913.37 ; 7329.81,4907.72 ccw(c7329.81,4931.76) v1@7346.81,4914.76 ; 7331.37,4907.72 cw(c7331.37,4885.89) v1@7346.81,4901.32 ; 7339.47,4907.72 ccw(c7339.47,4922.1) v1@7349.64,4911.93 ; 7341.03,4907.72 cw(c7341.03,4895.54) v1@7349.64,4904.15 ; v1@7345.86,4908.04 v1(7353.52,4908.04) ; v1@7790.19,4250.54 cw(c7790.19,4227.61) 7806.41,4243.82 cw(c7822.63,4260.04) v1@7799.69,4260.04 ; v1@7790.19,4254.54 cw(c7790.19,4241.26) 7799.58,4250.65 cw(c7808.97,4260.04) v1@7795.69,4260.04 ; v1(7790.19,4260.04) 7807.19,4243.04 7807.19,3658.71 7798.52,3650.04 7763.45,3614.97 7763.45,3516.55 7805,3475 7805,3348.38 7832.69,3320.69 7832.69,3031.87 v1(7825.86,3025.04) ; v1@7819.14,3031.76 ccw(c7786.43,3064.47) 7832.69,3064.47 ; v1@7821.97,3028.93 ccw(c7796.08,3054.82) 7832.69,3054.82 ; v1@7824.8,3026.1 ccw(c7805.74,3045.16) 7832.69,3045.16 ; v1@7827.62,3023.27 ccw(c7815.4,3035.5) 7832.69,3035.5 ; 5284.69,3809.1 cw(c5271.89,3821.91) 5271.89,3803.8 ccw(c5271.89,3821.91) 5284.69,3809.1 ; 5284.69,3809.1 ccw(c5297.5,3796.3) 5279.39,3796.3 cw(c5297.5,3796.3) 5284.69,3809.1
  Top Layer w8: v5(7810.63,4366.89) U7.E7@7830.32,4386.57 ; v5@7810.63,4375.89 ccw(c7810.63,4397.62) 7825.99,4382.25 ccw(c7841.36,4366.89) v5@7819.63,4366.89
  MidLayer1 w4: v1@5223.28,3001.72 ccw(c5207.06,3017.93) 5230,3017.93 ccw(c5252.93,3017.93) v1@5236.72,3001.72 ; v1@5226.11,2998.89 ccw(c5216.72,3008.28) 5230,3008.28 ccw(c5243.28,3008.28) v1@5233.89,2998.89 ; v1@5231.86,2995 5231.86,2991.71 5230,2993.56 v1(5230,2995) 5230,3047.5 5227.5,3050 5227.5,3067.25 5237.75,3077.5 5256.44,3077.5 5267.47,3066.47 5311.47,3066.47 5318.02,3073.02 5318.02,3199.21 5317.19,3200.04 5308.86,3208.37 5262.19,3208.37 5247.86,3222.71 5247.86,3500.16 5281.25,3533.56 5281.25,3590.06 5256.38,3614.93 5256.38,3630.82 5256.38,3638.82 5256.38,3679.25 5256.38,3772.79 ; 5256.38,3758.86 5256.38,3772.79 ; 5260.5,3782.72 ccw(c5270.43,3772.79) 5256.38,3772.79 ; v3@5264.42,3795.65 cw(c5246.38,3794.07) 5260.25,3782.43 cw(c5274.12,3770.79) v3@5272.54,3788.83 ; v1(6560.52,5038.04) 6702.19,5038.04 6740.19,5000.04 6757.86,5000.04 6791.52,5033.71 6828.54,5033.71 6862.54,4999.71 6951.86,4999.71 6955.86,5003.71 7023.52,5003.71 7102.19,4925.04 7107.21,4920.02 7135.52,4891.71 7337.19,4891.71 v1(7353.52,4908.04) ; v1@7344.02,4908.04 cw(c7321.09,4908.04) 7337.31,4891.82 cw(c7353.52,4875.61) v1@7353.52,4898.54 ; v1@7348.02,4908.04 cw(c7334.75,4908.04) 7344.13,4898.65 cw(c7353.52,4889.26) v1@7353.52,4902.54 ; v1(7790.19,4260.04) 7831.86,4301.71 7831.86,4345.66 v5(7810.63,4366.89) ; v1@7790.19,4265.54 ccw(c7790.19,4278.82) 7799.58,4269.43 ccw(c7808.97,4260.04) v1@7795.69,4260.04 ; v1@7790.19,4269.54 ccw(c7790.19,4292.48) 7806.41,4276.26 ccw(c7822.63,4260.04) v1@7799.69,4260.04 ; v5@7810.63,4355.89 cw(c7810.63,4329.33) 7829.41,4348.11 cw(c7848.19,4366.89) v5@7821.63,4366.89 ; v5@7810.63,4359.89 cw(c7810.63,4342.99) 7822.58,4354.94 cw(c7834.53,4366.89) v5@7817.63,4366.89
  MidLayer2 w4: v1@5230,2985.5 cw(c5230,2962.56) 5246.22,2978.78 cw(c5262.43,2995) v1@5239.5,2995 ; v1@5230,2989.5 cw(c5230,2976.22) 5239.39,2985.61 cw(c5248.78,2995) v1@5235.5,2995 ; v1(5230,2995) 5270,2955 5270,2924.71 5328.5,2866.21 5399.79,2866.21 v1(5436,2830) ; v1@5426.5,2830 ccw(c5403.56,2830) 5419.78,2846.22 ccw(c5436,2862.43) v1@5436,2839.5 ; v1@5430.5,2830 ccw(c5417.22,2830) 5426.61,2839.39 ccw(c5436,2848.78) v1@5436,2835.5 ; v1(5594.52,2712.37) 5724,2712.37 5776.98,2659.39 5776.98,2621.98 5768,2613 v1(5740,2613) ; v1@5743.89,2609.11 cw(c5753.28,2599.72) 5753.28,2613 cw(c5753.28,2626.28) v1@5743.89,2616.89 ; v1@5746.72,2606.28 cw(c5762.93,2590.06) 5762.93,2613 cw(c5762.93,2635.93) v1@5746.72,2619.72 ; v1(7353.52,4908.04) 7433.04,4908.04 7482,4957 7613.58,4957 7623.03,4947.56 7646.04,4924.55 7835.45,4924.55 7920.3,4839.7 v1(7920.3,4813.1) ; v1@7357.41,4904.15 cw(c7366.8,4894.76) 7366.8,4908.04 cw(c7366.8,4921.32) v1@7357.41,4911.93 ; v1@7360.24,4901.32 cw(c7376.46,4885.11) 7376.46,4908.04 cw(c7376.46,4930.98) v1@7360.24,4914.76 ; v1@7913.58,4819.82 ccw(c7897.37,4836.03) 7920.3,4836.03 ccw(c7943.23,4836.03) v1@7927.02,4819.82 ; v1@7916.41,4816.99 ccw(c7907.02,4826.38) 7920.3,4826.38 ccw(c7933.58,4826.38) v1@7924.19,4816.99
  Bottom Layer w4: v1@5742.37,2615.37 5771.31,2615.37 5816.98,2569.71 ; v1@5743.89,2609.11 cw(c5759.01,2593.99) 5759.01,2615.37 ; v1@5746.72,2606.28 cw(c5768.67,2584.33) 5768.67,2615.37 ; v1@5746.72,2619.72 ccw(c5757.2,2630.2) 5757.2,2615.37 ; 5817.31,2569.37 6375.94,2569.37 6404.81,2540.5 6481.3,2540.5 6498.76,2523.04 6548.9,2523.04 6606.4,2580.54 6766.78,2580.54 6772.05,2585.81 6832.75,2585.81 6879.44,2632.5 6900.56,2632.5 6922.69,2610.37 6954.87,2610.37 6979.37,2634.87 7027.01,2634.87 7035.01,2626.87 7128.34,2626.87 7385.17,2883.71 7483.79,2883.71 7485.96,2885.87 7597.5,2885.87 7600,2883.37 7684.19,2883.37 v1(7825.86,3025.04) ; v1@7790.19,4250.54 cw(c7790.19,4227.61) 7806.41,4243.82 cw(c7822.63,4260.04) v1@7799.69,4260.04 ; v1@7790.19,4254.54 cw(c7790.19,4241.26) 7799.58,4250.65 cw(c7808.97,4260.04) v1@7795.69,4260.04 ; v1(7790.19,4260.04) 7808.52,4241.71 8024.39,4241.71 8098.86,4316.17 8098.86,4634.54 v1(7920.3,4813.1) ; v1@7816.36,3025.04 cw(c7793.42,3025.04) 7809.64,3008.82 cw(c7825.86,2992.61) v1@7825.86,3015.54 ; v1@7820.36,3025.04 cw(c7807.08,3025.04) 7816.47,3015.65 cw(c7825.86,3006.26) v1@7825.86,3019.54 ; v1@7920.3,4803.6 cw(c7920.3,4780.66) 7936.52,4796.88 cw(c7952.73,4813.1) v1@7929.8,4813.1 ; v1@7920.3,4807.6 cw(c7920.3,4794.32) 7929.69,4803.71 cw(c7939.08,4813.1) v1@7925.8,4813.1
DB_MEM.BUS_A18: U7.B3 U8.C18 U16.43 U17.43 | length 4322.6
  Top Layer w4: U8.C18@5527.79,4650.1 ccw(c5527.79,4667.82) 5540.33,4655.29 ; U8.C18@5535.14,4642.76 cw(c5552.86,4642.76) 5540.33,4655.29 ; v1@5559.93,4885.56 cw(c5547.87,4871.77) 5566.19,4871.77 ; v1@5562.57,4888.57 cw(c5555.58,4880.59) 5566.19,4880.59 cw(c5576.8,4880.59) v1@5569.81,4888.57 ; 5562.69,4868.27 5551.66,4857.24 ; v1(5566.19,4892.71) 5566.19,4871.77 ; v1@5572.45,4885.56 ccw(c5584.51,4871.77) 5566.19,4871.77 ; v1(6506.86,5168.71) 6638.71,5168.71 6656.86,5150.56 6656.86,4947.21 ; v1@6510.75,5164.82 cw(c6520.14,5155.43) 6520.14,5168.71 cw(c6520.14,5181.99) v1@6510.75,5172.6 ; v1@6513.57,5161.99 cw(c6529.79,5145.77) 6529.79,5168.71 cw(c6529.79,5191.64) v1@6513.57,5175.43 ; U17.43@6619.41,4939.21 6648.86,4939.21 ; U17.43@6636.97,4939.21 ccw(c6642.79,4947.68) 6650.06,4940.41 ; U17.43@6639.24,4942.51 ccw(c6645.56,4951.71) 6653.46,4943.81 ; U17.43@6641.5,4945.8 ccw(c6648.33,4955.74) 6656.86,4947.21 ; U17.43@6644.38,4936.2 cw(c6648.86,4934.38) 6648.86,4939.21 ; U17.43@6644.38,4942.23 ccw(c6648.86,4944.05) 6648.86,4939.21 ; U16.43@7294.41,4939.21 7342.7,4939.21 v1(7353.52,4950.04) ; U16.43@7317.63,4933.56 cw(c7331.28,4919.9) 7331.28,4939.21 cw(c7331.28,4958.53) U16.43@7317.63,4944.87 ; 5540.33,4655.29 ccw(c5512.98,4682.64) 5551.66,4682.64 5551.66,4741.18 5551.66,4748.34 5551.66,4857.24 ; 5551.66,4857.24 5566.19,4871.77 ; 6648.86,4939.21 6656.86,4947.21
  Top Layer w8: U7.B3@7948.43,4544.06 v5(7968.11,4563.74) ; v5@7959.11,4563.74 cw(c7937.38,4563.74) 7952.75,4548.38 cw(c7968.11,4533.01) v5@7968.11,4554.74
  MidLayer1 w4: v1@5559.47,4899.43 ccw(c5548.89,4910.01) 5563.86,4910.01 ; v1@5563.86,4895.04 5563.86,4948.1 5616.64,5000.88 5640.8,5025.04 5758.8,5025.04 5858.47,5124.71 5889.86,5124.71 5925,5124.71 6462.86,5124.71 v1(6506.86,5168.71) ; 5563.86,4911.62 ccw(c5585.1,4911.62) v1@5570.08,4896.6 ; 5563.86,4921.28 ccw(c5594.76,4921.28) v1@5572.91,4899.43 ; v1@6497.36,5168.71 cw(c6474.42,5168.71) 6490.64,5152.49 cw(c6506.86,5136.27) v1@6506.86,5159.21 ; v1@6501.36,5168.71 cw(c6488.08,5168.71) 6497.47,5159.32 cw(c6506.86,5149.93) v1@6506.86,5163.21
  MidLayer2 w4: v1(7353.52,4950.04) 7395.19,4991.71 7798.52,4991.71 7965.19,4825.04 7988,4802.23 7988,4595 7980,4587 7980,4575.63 v5(7968.11,4563.74) ; v1@7353.52,4955.54 ccw(c7353.52,4968.82) 7362.91,4959.43 ccw(c7372.3,4950.04) v1@7359.02,4950.04 ; v1@7353.52,4959.54 ccw(c7353.52,4982.48) 7369.74,4966.26 ccw(c7385.96,4950.04) v1@7363.02,4950.04
  Bottom Layer w4: v1(6506.86,5168.71) 6555.88,5168.71 6571.21,5184.04 6600,5184.04 6833.21,5184.04 6858.54,5158.71 7133.9,5158.71 7234.39,5058.21 7245.99,5058.21 ; v1@6510.75,5164.82 cw(c6520.14,5155.43) 6520.14,5168.71 cw(c6520.14,5181.99) v1@6510.75,5172.6 ; v1@6513.57,5161.99 cw(c6529.79,5145.77) 6529.79,5168.71 cw(c6529.79,5191.64) v1@6513.57,5175.43 ; 7246.15,5058.37 7273.52,5058.37 7353.52,4978.37 v1(7353.52,4950.04) ; v1@7346.81,4956.76 ccw(c7330.59,4972.98) 7353.52,4972.98 ccw(c7376.46,4972.98) v1@7360.24,4956.76 ; v1@7349.64,4953.93 ccw(c7340.25,4963.32) 7353.52,4963.32 ccw(c7366.8,4963.32) v1@7357.41,4953.93
DB_MEM.BUS_A19: U7.C4 U8.B18 U16.44 U17.44 | length 5885.2
  Top Layer w4: U8.B18@5527.79,4689.47 ccw(c5527.79,4707.19) 5540.33,4694.66 ; U8.B18@5535.14,4682.13 cw(c5552.86,4682.13) 5540.33,4694.66 ; v1@5567.81,5194.32 cw(c5551.59,5178.11) 5574.52,5178.11 cw(c5597.46,5178.11) v1@5581.24,5194.32 ; v1@5570.64,5197.15 cw(c5561.25,5187.76) 5574.52,5187.76 cw(c5587.8,5187.76) v1@5578.41,5197.15 ; v1(5574.52,5201.04) 5574.52,5097.67 5548.52,5071.67 5548.52,4865.42 5511.36,4828.25 5511.36,4786.07 5543.3,4754.13 5543.3,4748.7 5543.3,4741.18 5543.3,4701.84 cw(c5533.15,4701.84) 5540.33,4694.66 ; v1@6600.59,5009.57 cw(c6588.4,4995.71) 6606.86,4995.71 ; v1@6603.23,5012.58 cw(c6596.17,5004.55) 6606.86,5004.55 cw(c6617.54,5004.55) v1@6610.49,5012.58 ; v1(6606.86,5016.71) 6606.86,4995.71 ; v1@6613.13,5009.57 ccw(c6625.32,4995.71) 6606.86,4995.71 ; U17.44@6616.09,4977.99 ccw(c6613.73,4983.16) 6619.41,4983.16 ; U17.44@6619.41,4970.71 6619.41,4983.16 ; U17.44@6622.73,4977.99 cw(c6625.09,4983.16) 6619.41,4983.16 ; U16.44@7294.41,4970.71 7328.86,4970.71 ; U16.44@7318.16,4965.64 cw(c7328.86,4956.88) 7328.86,4970.71 ; U16.44@7318.16,4975.78 ccw(c7328.86,4984.53) 7328.86,4970.71 ; v1@7330.14,5031.66 cw(c7313.92,5015.44) 7336.86,5015.44 cw(c7359.79,5015.44) v1@7343.57,5031.66 ; v1@7332.97,5034.49 cw(c7323.58,5025.1) 7336.86,5025.1 cw(c7350.14,5025.1) v1@7340.75,5034.49 ; v1(7336.86,5038.37) 7336.86,4978.71 7328.86,4970.71 ; 6606.86,4995.71 6619.41,4983.16
  Top Layer w8: U7.C4@7909.06,4504.69 v5(7928.74,4524.37) ; v5@7919.74,4524.37 cw(c7898.01,4524.37) 7913.38,4509.01 cw(c7928.74,4493.64) v5@7928.74,4515.37
  MidLayer1 w4: v1(6606.86,5016.71) 6708.29,5016.71 6741.63,4983.37 6952.86,4983.37 6965.19,4995.71 7020.21,4995.71 7094.01,4921.91 ; v1@6610.75,5012.82 cw(c6620.14,5003.43) 6620.14,5016.71 cw(c6620.14,5029.99) v1@6610.75,5020.6 ; v1@6613.57,5009.99 cw(c6629.79,4993.77) 6629.79,5016.71 cw(c6629.79,5039.64) v1@6613.57,5023.43 ; v1@7336.86,5028.87 cw(c7336.86,5005.94) 7353.07,5022.16 cw(c7369.29,5038.37) v1@7346.36,5038.37 ; v1@7336.86,5032.87 cw(c7336.86,5019.6) 7346.25,5028.99 cw(c7355.64,5038.37) v1@7342.36,5038.37 ; v1@7340.75,5034.49 cw(c7350.14,5025.1) 7350.14,5038.37 cw(c7350.14,5051.65) v1@7340.75,5042.26 ; v1@7343.57,5031.66 cw(c7359.79,5015.44) 7359.79,5038.37 cw(c7359.79,5061.31) v1@7343.57,5045.09 ; v1@7377.81,5090.66 cw(c7361.59,5074.44) 7384.52,5074.44 cw(c7407.46,5074.44) v1@7391.24,5090.66 ; v1@7380.64,5093.49 cw(c7371.25,5084.1) 7384.52,5084.1 cw(c7397.8,5084.1) v1@7388.41,5093.49 ; v1(7384.52,5097.37) 7384.52,5044.52 7378.37,5038.37 v1(7336.86,5038.37) 7373.52,5001.71 7373.52,4891.71 7365.19,4883.37 7155,4883.37 ; 7094.01,4921.91 7099.21,4916.71 ; 7094.01,4921.91 7099.21,4916.71 ; 7099.21,4916.71 7132.54,4883.37 7143.52,4883.37 ; 7143.52,4883.37 7155,4883.37 ; 7143.52,4883.37 7155,4883.37
  MidLayer2 w4: v1(6070,5290) 6480,5290 6512.5,5322.5 6520,5330 6700,5330 6712,5318 6755,5275 7195,5275 7206.9,5275 7367.18,5114.72 ; v1@6073.89,5286.11 cw(c6083.28,5276.72) 6083.28,5290 cw(c6083.28,5303.28) v1@6073.89,5293.89 ; v1@6076.72,5283.28 cw(c6092.93,5267.06) 6092.93,5290 cw(c6092.93,5312.93) v1@6076.72,5296.72 ; v1@7336.86,5028.87 cw(c7336.86,5005.94) 7353.07,5022.16 cw(c7369.29,5038.37) v1@7346.36,5038.37 ; v1@7336.86,5032.87 cw(c7336.86,5019.6) 7346.25,5028.99 cw(c7355.64,5038.37) v1@7342.36,5038.37 ; v1(7336.86,5038.37) 7365.23,5010 7802.86,5010 8040,4772.86 8040,4608.56 8040.19,4608.37 8015.19,4583.37 7993.37,4583.37 7988,4578 7988,4551 7981,4544 7948.37,4544 ; v1@7377.77,5097.37 v1(7384.52,5097.37) ; v1@7384.52,5101.37 v1(7384.52,5097.37) ; v5(7928.74,4524.37) 7948.37,4544 ; v5@7928.74,4531.37 ccw(c7928.74,4548.27) 7940.69,4536.32 ccw(c7952.64,4524.37) v5@7935.74,4524.37 ; v5@7928.74,4535.37 ccw(c7928.74,4561.93) 7947.52,4543.15 ccw(c7966.3,4524.37) v5@7939.74,4524.37 ; 7948.52,4544.15 7948.37,4544 ; 7367.18,5114.72 v1(7384.52,5097.37) ; 7367.18,5114.72 v1(7384.52,5097.37) ; 7368.31,5113.59 cw(c7352.09,5097.37) 7375.02,5097.37 ccw(c7352.09,5097.37) 7368.31,5113.59 ; 7368.31,5113.59 ccw(c7384.52,5129.81) 7384.52,5106.87 cw(c7384.52,5129.81) 7368.31,5113.59 ; 7375.14,5106.76 cw(c7365.75,5097.37) 7379.02,5097.37 ccw(c7365.75,5097.37) 7375.14,5106.76 ; 7375.14,5106.76 ccw(c7384.52,5116.15) 7384.52,5102.87 cw(c7384.52,5116.15) 7375.14,5106.76
  Bottom Layer w4: v1(5574.52,5201.04) 5639.86,5266.37 6046.37,5266.37 v1(6070,5290) ; v1@5574.52,5206.54 ccw(c5574.52,5219.82) 5583.91,5210.43 ccw(c5593.3,5201.04) v1@5580.02,5201.04 ; v1@5574.52,5210.54 ccw(c5574.52,5233.48) 5590.74,5217.26 ccw(c5606.96,5201.04) v1@5584.02,5201.04 ; v1@6060.5,5290 cw(c6037.56,5290) 6053.78,5273.78 cw(c6070,5257.56) v1@6070,5280.5 ; v1@6064.5,5290 cw(c6051.22,5290) 6060.61,5280.61 cw(c6070,5271.22) v1@6070,5284.5
DB_MEM.BUS_A20: U7.D5 U8.J26 U16.28 U17.28 | length 3653.8
  Top Layer w4: U8.J26@5842.76,4413.88 ccw(c5842.76,4431.6) 5855.29,4419.07 ; U8.J26@5850.1,4406.54 cw(c5867.82,4406.54) 5855.29,4419.07 ; v1@6112.85,4380.46 ccw(c6089.91,4380.46) 6106.13,4396.68 ccw(c6122.35,4412.9) v1@6122.35,4389.96 ; v1@6116.85,4380.46 ccw(c6103.57,4380.46) 6112.96,4389.85 ccw(c6122.35,4399.24) v1@6122.35,4385.96 ; v1(6122.35,4380.46) 6102.31,4400.5 6036.5,4400.5 6028,4409 5999.69,4409 5978.29,4430.4 5949.18,4430.4 5941.18,4430.4 5882.64,4430.4 ccw(c5882.64,4391.72) 5855.29,4419.07 ; v1@6571.09,4460.14 cw(c6587.09,4444.14) 6587.09,4466.77 ; v1(6572.86,4458.37) 6581.25,4466.77 U17.28@6619.41,4466.77 ; v1@6573.92,4457.31 cw(c6596.75,4434.48) U17.28@6596.75,4466.77 ; v1@6576.75,4454.49 cw(c6606.41,4424.82) U17.28@6606.41,4466.77 ; v1@6579.57,4451.66 cw(c6616.06,4415.17) U17.28@6616.06,4466.77 ; U16.28@7294.41,4466.77 7337.19,4466.77 7345.19,4458.77 ; U16.28@7317.63,4461.12 cw(c7331.28,4447.46) 7331.28,4466.77 cw(c7331.28,4486.09) U16.28@7317.63,4472.43 ; v1@7340.19,4449.78 ccw(c7334.62,4458.77) 7345.19,4458.77 ; v1(7345.19,4441.71) 7345.19,4458.77 ; v1@7350.19,4449.78 cw(c7355.76,4458.77) 7345.19,4458.77
  Top Layer w8: U7.D5@7869.69,4465.32 v5(7889.37,4445.63) ; v5@7880.37,4445.63 ccw(c7858.64,4445.63) 7874.01,4460.99 ccw(c7889.37,4476.36) v5@7889.37,4454.63
  MidLayer2 w4: v1@6126,4379.74 6136.56,4379.74 6164.82,4408 6253.96,4408 6284.46,4377.5 6443.35,4377.5 6524.23,4458.37 v1(6572.86,4458.37) 6636.67,4458.37 6645,4450.04 6748.52,4450.04 6781.86,4416.71 6823.52,4416.71 6840.19,4400.04 7015.19,4400.04 7023.52,4391.71 7048.52,4391.71 7065.19,4408.37 7311.86,4408.37 v1(7345.19,4441.71) ; v1@6566.14,4451.66 ccw(c6549.92,4435.44) 6549.92,4458.37 ccw(c6549.92,4481.31) v1@6566.14,4465.09 ; v1@6568.97,4454.49 ccw(c6559.58,4445.1) 6559.58,4458.37 ccw(c6559.58,4471.65) v1@6568.97,4462.26 ; v1@6576.75,4454.49 cw(c6586.14,4445.1) 6586.14,4458.37 cw(c6586.14,4471.65) v1@6576.75,4462.26 ; v1@6579.57,4451.66 cw(c6595.79,4435.44) 6595.79,4458.37 cw(c6595.79,4481.31) v1@6579.57,4465.09 ; v1@7335.69,4441.71 cw(c7312.76,4441.71) 7328.97,4425.49 cw(c7345.19,4409.27) v1@7345.19,4432.21 ; v1@7339.69,4441.71 cw(c7326.41,4441.71) 7335.8,4432.32 cw(c7345.19,4422.93) v1@7345.19,4436.21
  Bottom Layer w4: v1@7345.19,4432.21 cw(c7345.19,4409.27) 7361.41,4425.49 cw(c7377.63,4441.71) v1@7354.69,4441.71 ; v1@7345.19,4436.21 cw(c7345.19,4422.93) 7354.58,4432.32 cw(c7363.97,4441.71) v1@7350.69,4441.71 ; v1(7345.19,4441.71) 7365.19,4421.71 7365.19,4383.37 7407.19,4341.37 7426.37,4341.37 ; v5@7878.37,4445.63 ccw(c7851.81,4445.63) 7870.59,4464.41 ccw(c7889.37,4483.19) v5@7889.37,4456.63 ; v5@7882.37,4445.63 ccw(c7865.47,4445.63) 7877.42,4457.58 ccw(c7889.37,4469.53) v5@7889.37,4452.63 ; v5(7889.37,4445.63) 7868.52,4466.48 7860,4475 7653.21,4475 7648.19,4480.02 7648.19,4675.37 ; 7426.37,4341.37 7440.19,4341.37 ; 7426.37,4341.37 7440.19,4341.37 ; 7440.19,4341.37 7446.37,4341.37 7454.71,4349.71 7534.71,4349.71 7556.86,4371.86 7556.86,4458.04 ; 7556.86,4458.04 7556.86,4490 ; 7556.86,4458.04 7556.86,4490 ; 7556.86,4490 7556.86,4566.71 7540.19,4583.37 7540.19,4691.71 7565.19,4716.71 7606.86,4716.71 ; 7606.86,4716.71 7648.19,4675.37 ; 7606.86,4716.71 7648.19,4675.37
DB_MEM.BUS_A21: U7.D4 U8.H25 | length 2754.3
  Top Layer w4: U8.H25@5803.39,4445.91 v3(5823.07,4465.59) ; U8.H25@5803.39,4453.25 ccw(c5803.39,4470.97) 5815.92,4458.44 ccw(c5828.45,4445.91) U8.H25@5810.73,4445.91 ; 5810.27,4452.79 cw(c5823.07,4439.98) 5823.07,4458.09 ccw(c5823.07,4439.98) 5810.27,4452.79 ; 5810.27,4452.79 ccw(c5797.46,4465.59) 5815.57,4465.59 cw(c5797.46,4465.59) 5810.27,4452.79
  Top Layer w8: U7.D4@7869.69,4504.69 v5(7889.37,4524.37) ; v5@7880.37,4524.37 cw(c7858.64,4524.37) 7874.01,4509.01 cw(c7889.37,4493.64) v5@7889.37,4515.37
  MidLayer1 w4: v3(5823.07,4465.59) 5881.33,4465.59 5900.75,4465.59 5941.18,4465.59 5949.18,4465.59 5996.53,4465.59 6011.44,4480.5 6063.31,4480.5 6098.35,4515.54 6122.36,4515.54 6207.36,4600.54 6284.35,4600.54 6304.31,4620.5 6528.06,4620.5 6590.02,4558.54 6690,4558.54 6707.02,4558.54 6846.83,4558.54 6880,4591.71 6906.61,4591.71 6924.36,4609.46 v1@6924.36,4649.21 ; v3@5828.26,4460.4 cw(c5840.8,4447.86) 5840.8,4465.59 cw(c5840.8,4483.32) v3@5828.26,4470.78 ; v3@5828.37,4460.29 cw(c5841.18,4447.48) 5841.18,4465.59 cw(c5841.18,4483.7) v3@5828.37,4470.89 ; v1@6914.47,4645.66 cw(c6890.61,4621.79) 6924.36,4621.79 ; v1@6917.3,4648.49 cw(c6900.27,4631.45) 6924.36,4631.45 ; v1@6920.13,4651.31 cw(c6909.92,4641.11) 6924.36,4641.11 ; 6924.36,4637.09 cw(c6936.48,4637.09) v1@6927.91,4645.66
  MidLayer2 w4: v1(6921.19,4652.37) 7031.31,4652.37 7045.65,4638.04 7194.35,4638.04 7265.69,4709.37 7268.31,4712 7579.23,4712 7581.86,4709.37 7616.19,4675.04 7774.86,4675.04 7791.52,4658.37 7791.52,4546.04 7793.52,4544.04 7869.86,4544.04 7873.52,4540.37 7873.52,4540.22 v5(7889.37,4524.37) ; v1@6925.08,4648.49 cw(c6934.47,4639.1) 6934.47,4652.37 cw(c6934.47,4665.65) v1@6925.08,4656.26 ; v1@6927.91,4645.66 cw(c6944.13,4629.44) 6944.13,4652.37 cw(c6944.13,4675.31) v1@6927.91,4659.09
DB_MEM.BUS_A22: U7.C5 U8.M23 | length 2796
  Top Layer w4: U8.M23@5724.65,4288.42 v3(5744.33,4308.11) ; U8.M23@5724.65,4295.77 ccw(c5724.65,4313.49) 5737.18,4300.96 ccw(c5749.71,4288.42) U8.M23@5731.99,4288.42 ; 5731.53,4295.31 cw(c5744.33,4282.5) 5744.33,4300.61 ccw(c5744.33,4282.5) 5731.53,4295.31 ; 5731.53,4295.31 ccw(c5718.72,4308.11) 5736.83,4308.11 cw(c5718.72,4308.11) 5731.53,4295.31
  Top Layer w8: U7.C5@7909.06,4465.32 v5(7928.74,4445.63) ; v5@7919.74,4445.63 ccw(c7898.01,4445.63) 7913.38,4460.99 ccw(c7928.74,4476.36) v5@7928.74,4454.63
  MidLayer1 w4: v3@5744.98,4315.58 ccw(c5746.56,4333.62) 5758.2,4319.75 ; v3@5751.8,4307.46 cw(c5769.84,4305.88) 5758.2,4319.75 ; 5821.14,4331.97 5807.21,4331.97 ; v1@6403.28,4393.28 ccw(c6387.06,4377.06) 6387.06,4400 ccw(c6387.06,4422.93) v1@6403.28,4406.72 ; v1@6406.11,4396.11 ccw(c6396.72,4386.72) 6396.72,4400 ccw(c6396.72,4413.28) v1@6406.11,4403.89 ; v1(6410,4400) 6355,4400 6352.04,4397.04 6350.5,4395.5 6309.25,4395.5 6300,4395.5 6294.75,4395.5 6283.21,4407.04 6213.86,4407.04 6140.19,4333.37 6021.25,4333.37 6019.85,4331.97 5998.97,4331.97 5990,4331.97 5949.18,4331.97 5941.18,4331.97 5900.75,4331.97 5881.33,4331.97 5807.21,4331.97 ; 5758.2,4319.75 cw(c5787.71,4290.24) 5787.71,4331.97 5807.21,4331.97
  MidLayer2 w4: v1@6410,4397.04 6451.58,4397.04 6530.58,4476.04 6630.86,4476.04 6648.52,4458.37 6831.86,4458.37 6865.19,4425.04 6965.19,4425.04 6981.86,4441.71 6981.86,4519.08 6988.15,4525.37 7100.07,4525.37 7107.94,4517.5 7122.44,4517.5 7130.31,4525.37 7149.88,4525.37 7208.54,4466.71 7272.17,4466.71 7281.5,4476.04 7898.33,4476.04 v5(7928.74,4445.63) ; v1@6413.89,4403.89 ccw(c6430.42,4420.42) 6430.42,4397.04 ; v1@6416.72,4393.28 cw(c6425.79,4384.21) 6425.79,4397.04 ; v1@6416.72,4406.72 ccw(c6440.08,4430.08) 6440.08,4397.04 ; v5@7917.74,4445.63 ccw(c7891.18,4445.63) 7909.96,4464.41 ccw(c7928.74,4483.19) v5@7928.74,4456.63 ; v5@7921.74,4445.63 ccw(c7904.84,4445.63) 7916.79,4457.58 ccw(c7928.74,4469.53) v5@7928.74,4452.63
DB_MEM.BUS_A23: U7.B8 U8.T22 | length 2890.7
  Top Layer w4: U8.T22@5685.28,4123.6 cw(c5685.28,4105.88) 5697.81,4118.41 cw(c5710.34,4130.94) U8.T22@5692.62,4130.94 ; U8.T22@5685.28,4130.94 v3(5704.96,4111.26) ; 5692.16,4124.06 cw(c5679.35,4111.26) 5697.46,4111.26 ccw(c5679.35,4111.26) 5692.16,4124.06 ; 5692.16,4124.06 ccw(c5704.96,4136.87) 5704.96,4118.76 cw(c5704.96,4136.87) 5692.16,4124.06
  Top Layer w8: U7.B8@7948.43,4347.2 v5(7968.11,4327.52) ; v5@7959.11,4327.52 ccw(c7937.38,4327.52) 7952.75,4342.88 ccw(c7968.11,4358.25) v5@7968.11,4336.52
  MidLayer2 w4: v3@5705.61,4103.79 cw(c5707.19,4085.75) 5718.83,4099.62 cw(c5730.47,4113.49) v3@5712.43,4111.91 ; 5718.54,4099.87 ccw(c5728.47,4109.8) 5728.47,4095.75 5742.4,4095.75 5802.59,4095.75 5822.01,4095.75 5969.75,4095.75 5972,4098 5972,4137.56 6035.94,4201.5 6040.25,4201.5 6053.75,4215 6137.23,4215 6168.86,4183.37 6218.86,4183.37 6248.52,4213.04 6262.9,4213.04 6270.44,4205.5 6305.57,4205.5 6351.07,4251 6494.27,4251 6554.72,4190.55 6585,4190.55 6595.99,4190.55 6666.35,4190.55 6711.9,4145 6842.82,4145 6851.82,4136 7035.5,4136 7045.5,4126 7182.82,4126 7206.86,4150.04 7273.52,4150.04 7315.52,4108.04 7436.88,4108.04 7463.84,4135 7782.87,4135 7818,4170.12 7868,4220.12 7868,4341.18 7873.52,4346.71 7943.52,4346.71 7962.71,4327.52 v5(7968.11,4327.52) ; 7946.22,4344.01 ccw(c7961.25,4359.04) v5@7965.77,4338.27 ; 7951.4,4338.83 ccw(c7963.1,4350.53) v5@7966.62,4334.36 ; 7953.15,4337.08 cw(c7943.59,4327.52) v5@7957.11,4327.52 ; 7956.58,4333.65 ccw(c7964.96,4342.02) v5@7967.47,4330.45
DB_MEM.BUS_A24: U7.C8 U8.M27 | length 2742.2
  Top Layer w4: U8.M27@5882.13,4295.77 ccw(c5882.13,4313.49) 5894.66,4300.96 ; U8.M27@5889.47,4288.42 cw(c5907.19,4288.42) 5894.66,4300.96 ; v1@6241.81,4190.09 ccw(c6225.59,4206.31) 6248.52,4206.31 ccw(c6271.46,4206.31) v1@6255.24,4190.09 ; v1@6244.64,4187.26 ccw(c6235.25,4196.65) 6248.52,4196.65 ccw(c6261.8,4196.65) v1@6252.41,4187.26 ; v1(6248.52,4183.37) 6248.52,4246.48 6228,4267 6184.51,4267 6168.39,4250.87 6048.5,4250.87 6030.88,4268.5 6004.75,4268.5 5982,4291.25 5982,4301.25 5979.32,4303.93 5949.18,4303.93 5941.18,4303.93 5901.84,4303.93 ccw(c5901.84,4293.78) 5894.66,4300.96
  Top Layer w8: U7.C8@7909.06,4347.2 v5(7928.74,4327.52) ; v5@7919.74,4327.52 ccw(c7898.01,4327.52) 7913.38,4342.88 ccw(c7928.74,4358.25) v5@7928.74,4336.52
  MidLayer2 w4: v1@6248.52,4173.87 cw(c6248.52,4150.94) 6264.74,4167.16 cw(c6280.96,4183.37) v1@6258.02,4183.37 ; v1@6248.52,4177.87 cw(c6248.52,4164.6) 6257.91,4173.99 cw(c6267.3,4183.37) v1@6254.02,4183.37 ; v1(6248.52,4183.37) 6266.02,4165.87 6271.28,4165.87 ; v5@7920.96,4319.74 cw(c7902.18,4300.96) 7928.74,4300.96 cw(c7955.3,4300.96) v5@7936.52,4319.74 ; v5@7923.79,4322.57 cw(c7911.84,4310.62) 7928.74,4310.62 cw(c7945.64,4310.62) v5@7933.69,4322.57 ; 6271.28,4165.87 6295,4165.87 ; 6271.28,4165.87 6295,4165.87 ; 6295,4165.87 6389.13,4165.87 6404.96,4150.04 6483.88,4150.04 6488.84,4155 6510,4155 6533,4132 6533,4098.57 6565.57,4066 6698.37,4066 6767.37,4135 6841.5,4135 6848.5,4128 7032.19,4128 7042.19,4118 7180.56,4118 7198.52,4100.04 7440.19,4100.04 7467.15,4127 7700,4127 ; 7700,4127 7716.61,4127 ; 7700,4127 7716.61,4127 ; 7716.61,4127 7786.19,4127 7792.56,4133.37 ; 7792.56,4133.37 7815.04,4155.85 ; 7792.56,4133.37 7815.04,4155.85 ; 7815.04,4155.85 7928.74,4269.55 7928.74,4313.92 ; 7928.74,4313.92 7928.86,4314.04 7928.86,4327.4 v5(7928.74,4327.52) 7928.74,4313.92
DB_MEM.BUS_D0: U7.E3 U8.N26 U12.2 U16.7 U61.37 | length 7266.4
  Top Layer w4: U8.N26@5842.76,4256.4 ccw(c5842.76,4274.12) 5855.29,4261.59 ; U8.N26@5850.1,4249.05 cw(c5867.82,4249.05) 5855.29,4261.59 ; v1@6218.81,4226.66 ccw(c6202.59,4210.44) 6202.59,4233.37 ccw(c6202.59,4256.31) v1@6218.81,4240.09 ; v1@6221.64,4229.49 ccw(c6212.25,4220.1) 6212.25,4233.37 ccw(c6212.25,4246.65) v1@6221.64,4237.26 ; v1(6225.52,4233.37) 6198.52,4233.37 6173.52,4208.37 6141.52,4208.37 6124.52,4225.37 6051.37,4225.37 6024.25,4252.5 5997.25,4252.5 5976.83,4272.92 5941.18,4272.92 5882.64,4272.92 ccw(c5882.64,4234.24) 5855.29,4261.59 ; v1@6234,2172.36 ccw(c6223.7,2185) 6240,2185 ccw(c6256.3,2185) v1@6246,2172.36 ; v1@6236.53,2169.26 ccw(c6230.56,2176.58) 6240,2176.58 ccw(c6249.44,2176.58) v1@6243.47,2169.26 ; v1(6240,2165) 6240,2185 6251.19,2196.19 6265,2196.19 6278.66,2209.85 6278.66,2217.15 ; U61.37@6276.01,2223.81 cw(c6270.8,2217.93) 6278.66,2217.93 ; U61.37@6278.66,2240 6278.66,2217.93 ; U61.37@6281.31,2223.81 ccw(c6286.52,2217.93) 6278.66,2217.93 ; v1@6778.47,4176.66 cw(c6762.26,4160.44) 6785.19,4160.44 cw(c6808.13,4160.44) v1@6791.91,4176.66 ; v1@6781.3,4179.49 cw(c6771.91,4170.1) 6785.19,4170.1 cw(c6798.47,4170.1) v1@6789.08,4179.49 ; v1@6789.11,4179.52 cw(c6798.31,4170.47) 6798.31,4183.37 cw(c6798.31,4196.28) v1@6789.11,4187.23 ; v1@6791.96,4176.71 cw(c6807.86,4161.09) 6807.86,4183.37 ; v1@6791.96,4190.04 ccw(c6807.86,4205.66) 6807.86,4183.37 ; U12.2@6822.37,4137.3 ccw(c6808.72,4123.64) 6808.72,4142.95 ccw(c6808.72,4162.27) U12.2@6822.37,4148.61 ; U12.2@6825.61,4142.95 U12.2@6845.59,4142.95 6796.05,4142.95 6785.19,4153.81 v1(6785.19,4183.37) 6807.86,4183.37 ; U16.7@6845.59,4781.73 6975.17,4781.73 v1(6998.52,4758.37) ; U16.7@6868.81,4776.08 cw(c6882.46,4762.42) 6882.46,4781.73 cw(c6882.46,4801.05) U16.7@6868.81,4787.39 ; v1@6891.81,4345.66 cw(c6875.59,4329.44) 6898.52,4329.44 cw(c6921.46,4329.44) v1@6905.24,4345.66 ; v1@6894.64,4348.49 cw(c6885.25,4339.1) 6898.52,4339.1 cw(c6911.8,4339.1) v1@6902.41,4348.49 ; v1(6898.52,4352.37) 6898.52,4274.04 6807.86,4183.37 ; v1@6989.02,4758.37 ccw(c6966.09,4758.37) 6982.31,4774.59 ccw(c6998.52,4790.81) v1@6998.52,4767.87 ; v1@6993.02,4758.37 ccw(c6979.75,4758.37) 6989.14,4767.76 ccw(c6998.52,4777.15) v1@6998.52,4763.87
  Top Layer w8: v5@7810.63,4554.74 cw(c7810.63,4533.01) 7825.99,4548.38 cw(c7841.36,4563.74) v5@7819.63,4563.74 ; v5(7810.63,4563.74) U7.E3@7830.32,4544.06
  MidLayer1 w4: v1(6448.52,2666.71) 6498.52,2716.71 6498.52,2822.67 6507.19,2831.34 6507.19,3241.19 6523.52,3257.52 6523.52,3654.79 6531.86,3663.12 6531.86,3930.36 6671.5,4070 6685.15,4070 6737.87,4122.72 6737.87,4136.06 v1(6785.19,4183.37) ; v1@6448.52,2672.21 ccw(c6448.52,2685.49) 6457.91,2676.1 ccw(c6467.3,2666.71) v1@6454.02,2666.71 ; v1@6448.52,2676.21 ccw(c6448.52,2699.14) 6464.74,2682.93 ccw(c6480.96,2666.71) v1@6458.02,2666.71 ; v1@6775.69,4183.37 cw(c6752.76,4183.37) 6768.97,4167.16 cw(c6785.19,4150.94) v1@6785.19,4173.87 ; v1@6779.69,4183.37 cw(c6766.41,4183.37) 6775.8,4173.99 cw(c6785.19,4164.6) v1@6785.19,4177.87 ; v1(6898.52,4352.37) 6965.02,4418.87 6965.02,4447.25 6978,4460.23 6978,4513 6990.04,4525.04 7056.35,4525.04 7166.52,4635.21 7166.52,4735.37 7143.52,4758.37 v1(6998.52,4758.37) ; v1@6898.52,4357.87 ccw(c6898.52,4371.15) 6907.91,4361.76 ccw(c6917.3,4352.37) v1@6904.02,4352.37 ; v1@6898.52,4361.87 ccw(c6898.52,4384.81) 6914.74,4368.59 ccw(c6930.96,4352.37) v1@6908.02,4352.37 ; v1@7002.41,4754.49 cw(c7011.8,4745.1) 7011.8,4758.37 cw(c7011.8,4771.65) v1@7002.41,4762.26 ; v1@7005.24,4751.66 cw(c7021.46,4735.44) 7021.46,4758.37 cw(c7021.46,4781.31) v1@7005.24,4765.09
  MidLayer2 w4: v1(6225.52,4233.37) 6253.88,4233.37 6273.75,4213.5 6302.25,4213.5 6347.75,4259 6497.59,4259 6558.04,4198.55 6592.68,4198.55 6612.17,4218.04 6698.52,4218.04 6706.86,4209.71 6706.86,4191.71 6715.19,4183.37 v1(6785.19,4183.37) ; v1@6229.41,4229.49 cw(c6238.8,4220.1) 6238.8,4233.37 cw(c6238.8,4246.65) v1@6229.41,4237.26 ; v1@6232.24,4226.66 cw(c6248.46,4210.44) 6248.46,4233.37 cw(c6248.46,4256.31) v1@6232.24,4240.09 ; v1@6448.52,2657.21 cw(c6448.52,2634.27) 6464.74,2650.49 cw(c6480.96,2666.71) v1@6458.02,2666.71 ; v1@6448.52,2661.21 cw(c6448.52,2647.93) 6457.91,2657.32 cw(c6467.3,2666.71) v1@6454.02,2666.71 ; v1(6448.52,2666.71) 6506.86,2608.37 v1(6506.86,2458.37) ; v1@6500.14,2465.09 ccw(c6483.92,2481.31) 6506.86,2481.31 ccw(c6529.79,2481.31) v1@6513.57,2465.09 ; v1@6502.97,2462.26 ccw(c6493.58,2471.65) 6506.86,2471.65 ccw(c6520.14,2471.65) v1@6510.75,2462.26 ; v1@6778.47,4176.66 ccw(c6762.26,4160.44) 6762.26,4183.37 ccw(c6762.26,4206.31) v1@6778.47,4190.09 ; v1@6781.3,4179.49 ccw(c6771.91,4170.1) 6771.91,4183.37 ccw(c6771.91,4196.65) v1@6781.3,4187.26 ; v1@6991.81,4751.66 cw(c6975.59,4735.44) 6998.52,4735.44 cw(c7021.46,4735.44) v1@7005.24,4751.66 ; v1@6994.64,4754.49 cw(c6985.25,4745.1) 6998.52,4745.1 cw(c7011.8,4745.1) v1@7002.41,4754.49 ; v1(6998.52,4758.37) 6998.52,4696.48 7048.96,4646.04 7191.04,4646.04 7265,4720 7582.54,4720 7619.17,4683.37 7798.52,4683.37 7831.86,4650.04 7831.86,4584.97 7818.27,4571.37 7810.63,4571.37 v5(7810.63,4563.74) ; v5@7810.63,4570.74 ccw(c7810.63,4587.64) 7822.58,4575.69 ccw(c7834.53,4563.74) v5@7817.63,4563.74 ; v5@7810.63,4574.74 ccw(c7810.63,4601.3) 7829.41,4582.52 ccw(c7848.19,4563.74) v5@7821.63,4563.74
  Bottom Layer w4: v1@6233.28,2158.28 ccw(c6217.06,2142.06) 6217.06,2165 ccw(c6217.06,2187.93) v1@6233.28,2171.72 ; v1@6235,2170 v1(6240,2165) 6209.02,2165 6204.02,2170 6194.02,2180 6194.02,2230 6194.02,2340.6 6147.86,2386.77 6147.86,2452.86 6161.71,2466.71 6250,2466.71 6264.21,2452.5 6278.79,2452.5 6434.32,2452.5 6464.36,2482.54 6480.77,2482.54 6504.94,2458.37 v1(6506.86,2458.37) ; v1@6236.11,2161.11 ccw(c6226.72,2151.72) 6226.72,2165 ccw(c6226.72,2178.28) v1@6236.11,2168.89 ; 6487.36,2475.95 ccw(c6506.86,2495.44) v1@6506.86,2467.87 ; 6492,2471.32 cw(c6479.05,2458.37) v1@6497.36,2458.37 ; 6494.19,2469.12 ccw(c6506.86,2481.78) v1@6506.86,2463.87
DB_MEM.BUS_D1: U7.H3 U8.R26 U12.4 U16.8 U61.38 | length 8396.5
  Top Layer w4: U8.R26@5842.76,4162.97 cw(c5842.76,4145.25) 5855.29,4157.78 ; U8.R26@5850.1,4170.32 ccw(c5867.82,4170.32) 5855.29,4157.78 ; v1@5999.92,4118.55 ccw(c5984.96,4104.55) 5984.96,4125.04 ; v1@5999.92,4131.53 cw(c5984.96,4145.53) 5984.96,4125.04 ; v1@6002.84,4121.28 ccw(c5994.18,4113.18) 5994.18,4125.04 ccw(c5994.18,4136.9) v1@6002.84,4128.8 ; v1(6006.86,4125.04) 5984.96,4125.04 ; U61.38@6295.52,2223.98 cw(c6288.69,2217.15) 6298.35,2217.15 ; U61.38@6298.34,2240 6298.35,2217.15 ; U61.38@6301.17,2223.98 ccw(c6308,2217.15) 6298.35,2217.15 ; v1@6321.28,2205.28 ccw(c6305.06,2189.06) 6305.06,2212 ccw(c6305.06,2234.93) v1@6321.28,2218.72 ; v1@6324.11,2208.11 ccw(c6314.72,2198.72) 6314.72,2212 ccw(c6314.72,2225.28) v1@6324.11,2215.89 ; v1(6328,2212) 6303.5,2212 6298.35,2217.15 ; U12.4@6845.59,4079.96 6882.6,4079.96 6900.02,4097.37 v1(6929.52,4097.37) ; U16.8@6845.59,4750.24 6981.66,4750.24 7004.29,4727.61 7068.86,4663.04 7068.86,4433.37 7065.19,4429.71 7065.19,4257.37 v1(7048.52,4240.71) ; U12.4@6868.81,4074.3 cw(c6882.46,4060.65) 6882.46,4079.96 cw(c6882.46,4099.27) U12.4@6868.81,4085.62 ; U16.8@6868.81,4744.58 cw(c6882.46,4730.92) 6882.46,4750.24 cw(c6882.46,4769.55) U16.8@6868.81,4755.89 ; v1@6922.81,4090.66 ccw(c6906.59,4074.44) 6906.59,4097.37 ccw(c6906.59,4120.31) v1@6922.81,4104.09 ; v1@6925.64,4093.49 ccw(c6916.25,4084.1) 6916.25,4097.37 ccw(c6916.25,4110.65) v1@6925.64,4101.26 ; v1@7048.52,4246.21 ccw(c7048.52,4259.49) 7057.91,4250.1 ccw(c7067.3,4240.71) v1@7054.02,4240.71 ; v1@7048.52,4250.21 ccw(c7048.52,4273.14) 7064.74,4256.93 ccw(c7080.96,4240.71) v1@7058.02,4240.71 ; v1(7965.19,3705.37) 8015.19,3755.37 8015.19,3858.37 7968.48,3905.08 7968.48,4176.33 v1(7990.19,4198.04) ; v1@7965.19,3710.87 ccw(c7965.19,3724.15) 7974.58,3714.76 ccw(c7983.97,3705.37) v1@7970.69,3705.37 ; v1@7965.19,3714.87 ccw(c7965.19,3737.81) 7981.41,3721.59 ccw(c7997.63,3705.37) v1@7974.69,3705.37 ; v1@7980.69,4198.04 cw(c7957.76,4198.04) 7973.97,4181.82 cw(c7990.19,4165.61) v1@7990.19,4188.54 ; v1@7984.69,4198.04 cw(c7971.41,4198.04) 7980.8,4188.65 cw(c7990.19,4179.26) v1@7990.19,4192.54 ; 5855.29,4157.78 ccw(c5882.64,4185.13) 5882.64,4146.45 5941.18,4146.45 5951.45,4146.45 5963.55,4146.45 5984.96,4125.04
  Top Layer w8: v5@7692.52,4554.74 cw(c7692.52,4533.01) 7707.88,4548.38 cw(c7723.25,4563.74) v5@7701.52,4563.74 ; v5(7692.52,4563.74) U7.H3@7712.2,4544.06
  MidLayer1 w4: v1@6922.81,4104.09 ccw(c6906.59,4120.31) 6929.52,4120.31 ccw(c6952.46,4120.31) v1@6936.24,4104.09 ; v1@6925.64,4101.26 ccw(c6916.25,4110.65) 6929.52,4110.65 ccw(c6942.8,4110.65) v1@6933.41,4101.26 ; v1(6929.52,4097.37) 6929.52,4139.52 6940,4150 ; v1@6933.47,4169.99 cw(c6917.26,4153.77) 6940.19,4153.77 cw(c6963.13,4153.77) v1@6946.91,4169.99 ; v1@6936.3,4172.82 cw(c6926.91,4163.43) 6940.19,4163.43 cw(c6953.47,4163.43) v1@6944.08,4172.82 ; 6940.19,4150 v1(6940.19,4176.71) ; v1@7616.81,4224.43 ccw(c7600.59,4240.64) 7623.52,4240.64 ccw(c7646.46,4240.64) v1@7630.24,4224.43 ; v1@7619.64,4221.6 ccw(c7610.25,4230.99) 7623.52,4230.99 ccw(c7636.8,4230.99) v1@7627.41,4221.6 ; v1(7623.52,4217.71) 7623.52,4405.39 7648.52,4430.39 7648.52,4519.74 v5(7692.52,4563.74) ; v5@7681.52,4563.74 cw(c7654.96,4563.74) 7673.74,4544.96 cw(c7692.52,4526.19) v5@7692.52,4552.74 ; v5@7685.52,4563.74 cw(c7668.62,4563.74) 7680.57,4551.79 cw(c7692.52,4539.84) v5@7692.52,4556.74
  MidLayer2 w4: v1@6004.37,4124.75 cw(c6025.15,4127.18) 6010.36,4141.98 ; v1@6006.86,4131.61 v1(6006.86,4125.04) 6006.86,4138.48 6027.88,4159.5 6104.98,4159.5 6114.48,4169 6139.23,4169 6188.52,4119.71 6225.54,4119.71 6237.75,4107.5 6287.68,4107.5 6300,4119.81 6479.01,4119.81 6498.82,4100 6508.94,4100 6558.94,4050 6705,4050 6738.37,4083.37 6753.37,4083.37 ; v1@6008.35,4125.22 cw(c6035.61,4128.41) 6016.2,4147.82 ; v1@6012.32,4125.68 cw(c6046.06,4129.63) 6022.04,4153.66 ; v1@6016.29,4126.15 cw(c6056.52,4130.86) 6027.88,4159.5 ; 6753.71,4083.71 6753.37,4083.37 ; v1(6929.52,4097.37) 6915.52,4083.37 6753.37,4083.37 ; v1@6933.47,4183.43 ccw(c6917.26,4199.64) 6940.19,4199.64 ccw(c6963.13,4199.64) v1@6946.91,4183.43 ; v1@6936.3,4180.6 ccw(c6926.91,4189.99) 6940.19,4189.99 ccw(c6953.47,4189.99) v1@6944.08,4180.6 ; v1(6940.19,4176.71) 6940.19,4225.19 6955.71,4240.71 v1(7048.52,4240.71) ; v1@7041.81,4233.99 ccw(c7025.59,4217.77) 7025.59,4240.71 ccw(c7025.59,4263.64) v1@7041.81,4247.43 ; v1@7044.64,4236.82 ccw(c7035.25,4227.43) 7035.25,4240.71 ccw(c7035.25,4253.99) v1@7044.64,4244.6
  Bottom Layer w4: v1@6321.28,2218.72 ccw(c6305.06,2234.93) 6328,2234.93 ccw(c6350.93,2234.93) v1@6334.72,2218.72 ; v1@6324.11,2215.89 ccw(c6314.72,2225.28) 6328,2225.28 ccw(c6341.28,2225.28) v1@6331.89,2215.89 ; v1(6328,2212) 6328,2250 6323,2255 6323,2383 6345.5,2405.5 6405,2405.5 6433.42,2433.92 6466.18,2433.92 6478.75,2446.5 6493.25,2446.5 6503.87,2435.87 6562.11,2435.87 6576.18,2449.95 6576.18,2505.07 6619.65,2548.54 6780.04,2548.54 6785.31,2553.81 6859.31,2553.81 6878.31,2572.81 6900.6,2572.81 6902.29,2574.5 6964.25,2574.5 6992.63,2602.87 7013.75,2602.87 7021.75,2594.87 7064.38,2594.87 7094.75,2564.5 7109.25,2564.5 7134.19,2589.44 7134.19,2597.43 7360.76,2824 7620,2824 7705.82,2824 7874,2824 7986.69,2936.69 7986.69,3104.87 7986.69,3377.27 7965.19,3398.77 7965.19,3534.13 7975.5,3544.44 7975.5,3565.56 7965.19,3575.87 7965.19,3630 ; v1@7048.52,4231.21 cw(c7048.52,4208.27) 7064.74,4224.49 cw(c7080.96,4240.71) v1@7058.02,4240.71 ; v1@7048.52,4235.21 cw(c7048.52,4221.93) 7057.91,4231.32 cw(c7067.3,4240.71) v1@7054.02,4240.71 ; v1(7048.52,4240.71) 7087.23,4202 7361.17,4202 7392.37,4233.2 7397.34,4233.2 7398.17,4232.37 7537.33,4232.37 7555,4250.04 7591.19,4250.04 v1(7623.52,4217.71) 7639.19,4233.37 7954.86,4233.37 v1(7990.19,4198.04) ; v1@7614.02,4217.71 ccw(c7591.09,4217.71) 7607.31,4233.93 ccw(c7623.52,4250.14) v1@7623.52,4227.21 ; v1@7618.02,4217.71 ccw(c7604.75,4217.71) 7614.13,4227.1 ccw(c7623.52,4236.49) v1@7623.52,4223.21 ; v1@7958.47,3698.66 cw(c7941.06,3681.24) 7965.69,3681.24 ; v1@7961.3,3701.49 cw(c7950.72,3690.9) 7965.69,3690.9 ; 7965.19,3635.06 7965.19,3630 ; v1(7965.19,3705.37) 7965.69,3704.88 7965.69,3680.89 7965.19,3680.39 7965.19,3630 ; 7965.69,3683.64 cw(c7986.93,3683.64) v1@7971.91,3698.66 ; 7965.69,3693.29 cw(c7977.27,3693.29) v1@7969.08,3701.49 ; v1@7980.69,4198.04 ccw(c7957.76,4198.04) 7973.97,4214.26 ccw(c7990.19,4230.48) v1@7990.19,4207.54 ; v1@7984.69,4198.04 ccw(c7971.41,4198.04) 7980.8,4207.43 ccw(c7990.19,4216.82) v1@7990.19,4203.54
DB_MEM.BUS_D2: U7.E4 U8.P28 U12.5 U16.9 U61.39 | length 6865.1
  Top Layer w4: U8.P28@5921.5,4209.68 5956.63,4209.68 5998.81,4167.5 6097.35,4167.5 6106.06,4167.5 v1(6123.52,4150.04) v1@6114.81,4150.04 ; U8.P28@5926.69,4204.49 cw(c5939.22,4191.96) 5939.22,4209.68 cw(c5939.22,4227.41) U8.P28@5926.69,4214.88 ; v1@6114.02,4150.04 ccw(c6091.09,4150.04) 6107.31,4166.26 ccw(c6123.52,4182.48) v1@6123.52,4159.54 ; v1@6118.02,4150.04 ccw(c6104.75,4150.04) 6114.14,4159.43 ccw(c6123.52,4168.82) v1@6123.52,4155.54 ; U61.39@6351.93,2291.98 6440,2291.98 6451.19,2291.98 6471.98,2291.98 6490,2310 6490,2370 6490,2385 6490,2395 6487,2398 6486,2399 v1(6486,2429) ; U61.39@6367.95,2289.15 cw(c6374.78,2282.32) 6374.78,2291.98 cw(c6374.78,2301.63) U61.39@6367.95,2294.8 ; v1@6479.28,2422.28 cw(c6463.06,2406.06) 6486,2406.06 cw(c6508.93,2406.06) v1@6492.72,2422.28 ; v1@6482.11,2425.11 cw(c6472.72,2415.72) 6486,2415.72 cw(c6499.28,2415.72) v1@6489.89,2425.11 ; v1@6487,2429 v1@6487,2430 ; U12.5@6845.59,4048.46 6885.28,4048.46 v1(6899.19,4062.37) ; U16.9@6845.59,4718.74 6915.52,4718.74 7001.85,4718.74 7050.86,4669.73 7060.86,4659.73 7060.86,4490 7050.86,4480 v1(7050.86,4458.37) ; U12.5@6868.81,4042.81 cw(c6882.46,4029.15) 6882.46,4048.46 cw(c6882.47,4067.78) U12.5@6868.81,4054.12 ; U16.9@6868.81,4713.08 cw(c6882.46,4699.43) 6882.46,4718.74 cw(c6882.46,4738.05) U16.9@6868.81,4724.4 ; v1@7044.43,4465.37 ccw(c7031,4480) 7050.86,4480 ccw(c7070.72,4480) v1@7057.28,4465.37 ; v1@7047.14,4462.43 ccw(c7039.36,4470.89) 7050.86,4470.89 ccw(c7062.36,4470.89) v1@7054.58,4462.43
  Top Layer w8: v5@7810.63,4515.37 cw(c7810.63,4493.64) 7825.99,4509.01 cw(c7841.36,4524.37) v5@7819.63,4524.37 ; v5(7810.63,4524.37) U7.E4@7830.32,4504.69
  MidLayer1 w4: v1(6544.86,2813.04) 6561.71,2829.89 6564.86,2833.04 6564.86,3063 6640.19,3138.33 6640.19,3266.71 ; v1@6544.86,2818.54 ccw(c6544.86,2831.82) 6554.25,2822.43 ccw(c6563.64,2813.04) v1@6550.36,2813.04 ; v1@6544.86,2822.54 ccw(c6544.86,2845.48) 6561.07,2829.26 ccw(c6577.29,2813.04) v1@6554.36,2813.04 ; v1@6892.47,4055.66 cw(c6876.26,4039.44) 6899.19,4039.44 cw(c6922.13,4039.44) v1@6905.91,4055.66 ; v1@6895.3,4058.49 cw(c6885.91,4049.1) 6899.19,4049.1 cw(c6912.47,4049.1) v1@6903.08,4058.49 ; v1(6899.19,4062.37) 6899.19,3999.19 6767,3867 6767,3846.15 6623.7,3702.84 6623.7,3338.56 6624.36,3337.89 6624.36,3305 6624.36,3284.21 6624.36,3282.54 ; v1(6973.52,4039.71) 7031.86,4098.04 7031.86,4233.37 7025.19,4240.04 7025.19,4396.04 7015.19,4406.04 7015.19,4422.71 v1(7050.86,4458.37) ; v1@6973.52,4045.21 ccw(c6973.52,4058.49) 6982.91,4049.1 ccw(c6992.3,4039.71) v1@6979.02,4039.71 ; v1@6973.52,4049.21 ccw(c6973.52,4072.14) 6989.74,4055.93 ccw(c7005.96,4039.71) v1@6983.02,4039.71 ; v1@7041.36,4458.37 cw(c7018.42,4458.37) 7034.64,4442.16 cw(c7050.86,4425.94) v1@7050.86,4448.87 ; v1@7045.36,4458.37 cw(c7032.08,4458.37) 7041.47,4448.99 cw(c7050.86,4439.6) v1@7050.86,4452.87 ; v1@7658.47,4080.09 ccw(c7642.26,4096.31) 7665.19,4096.31 ccw(c7688.13,4096.31) v1@7671.91,4080.09 ; v1@7661.3,4077.26 ccw(c7651.91,4086.65) 7665.19,4086.65 ccw(c7678.47,4086.65) v1@7669.08,4077.26 ; v1(7665.19,4073.37) 7665.19,4129.81 7660,4135 7660,4469.85 7679.97,4489.82 7776.08,4489.82 v5(7810.63,4524.37) ; v5@7799.63,4524.37 cw(c7773.07,4524.37) 7791.85,4505.59 cw(c7810.63,4486.82) v5@7810.63,4513.37 ; v5@7803.63,4524.37 cw(c7786.73,4524.37) 7798.68,4512.42 cw(c7810.63,4500.47) v5@7810.63,4517.37 ; 6624.36,3282.54 6640.19,3266.71 ; 6624.36,3282.54 6640.19,3266.71
  MidLayer2 w4: v1(6123.52,4150.04) 6146.88,4150.04 6185.21,4111.71 6222.23,4111.71 6234.44,4099.5 6291,4099.5 6303.31,4111.81 6475.69,4111.81 6497.5,4090 6507.63,4090 6613.63,3984 6682.69,3984 6772.69,4074 6866,4074 6877.63,4062.37 ; v1@6127.41,4146.15 cw(c6136.8,4136.76) 6136.8,4150.04 cw(c6136.8,4163.32) v1@6127.41,4153.93 ; v1@6130.24,4143.32 cw(c6146.46,4127.11) 6146.46,4150.04 cw(c6146.46,4172.98) v1@6130.24,4156.76 ; v1@6487,2430 6506.73,2430 ; v1@6490.43,2425.75 cw(c6498.83,2419.58) 6498.83,2430 ; v1@6492.72,2435.72 ccw(c6506.52,2449.52) 6506.52,2430 ; v1@6493.66,2423.38 cw(c6506.73,2413.78) 6506.73,2430 ; v1@6538.14,2806.32 cw(c6521.92,2790.11) 6544.86,2790.11 cw(c6567.79,2790.11) v1@6551.57,2806.32 ; v1@6540.97,2809.15 cw(c6531.58,2799.76) 6544.86,2799.76 cw(c6558.14,2799.76) v1@6548.75,2809.15 ; v1(6544.86,2813.04) 6544.86,2468.12 6506.73,2430 ; v1@6892.18,4055.96 ccw(c6877.63,4042.65) 6877.63,4062.37 ; v1@6892.18,4068.79 cw(c6877.63,4082.1) 6877.63,4062.37 ; v1@6895.13,4058.66 ccw(c6886.71,4050.96) 6886.71,4062.37 ccw(c6886.71,4073.79) v1@6895.13,4066.09 ; v1(6899.19,4062.37) 6877.63,4062.37 ; v1@6966.81,4032.99 cw(c6950.59,4016.77) 6973.52,4016.77 cw(c6996.46,4016.77) v1@6980.24,4032.99 ; v1@6969.64,4035.82 cw(c6960.25,4026.43) 6973.52,4026.43 cw(c6986.8,4026.43) v1@6977.41,4035.82 ; v1(6973.52,4039.71) 6973.52,4006.48 7035,3945 7052,3928 7140.92,3928 7176.92,3964 7219,3964 7339.04,4084.04 ; v1@7655.69,4073.37 ccw(c7632.76,4073.37) 7648.97,4089.59 ccw(c7665.19,4105.81) v1@7665.19,4082.87 ; v1@7659.69,4073.37 ccw(c7646.41,4073.37) 7655.8,4082.76 ccw(c7665.19,4092.15) v1@7665.19,4078.87 ; v1(7665.19,4073.37) 7627.56,4111 7473.78,4111 7446.82,4084.04 7408,4084.04 7395,4084.04 7363.25,4084.04 ; 7339.04,4084.04 7363.25,4084.04 ; 7339.04,4084.04 7363.25,4084.04
  Bottom Layer w4: v1(6899.19,4062.37) 6950.86,4062.37 v1(6973.52,4039.71) ; v1@6903.08,4058.49 cw(c6912.47,4049.1) 6912.47,4062.37 cw(c6912.47,4075.65) v1@6903.08,4066.26 ; v1@6905.91,4055.66 cw(c6922.13,4039.44) 6922.13,4062.37 cw(c6922.13,4085.31) v1@6905.91,4069.09 ; v1@6964.02,4039.71 ccw(c6941.09,4039.71) 6957.31,4055.93 ccw(c6973.52,4072.14) v1@6973.52,4049.21 ; v1@6968.02,4039.71 ccw(c6954.75,4039.71) 6964.14,4049.1 ccw(c6973.52,4058.49) v1@6973.52,4045.21