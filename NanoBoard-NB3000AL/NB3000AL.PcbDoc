# Altium PCB NB3000AL.PcbDoc (part 56 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
I2C.SDA: EXTHDR1.27 R278.1 U8.V7 | length 5061.8
  Top Layer w4: EXTHDR1.27@1716.22,3122.62 ccw(c1702.56,3136.28) 1721.87,3136.28 ccw(c1741.19,3136.28) EXTHDR1.27@1727.53,3122.62 ; EXTHDR1.27@1721.87,3071.85 1721.87,3136.87 1741.1,3156.1 1741.1,3205.76 1735.41,3211.45 1731.86,3215 1731.86,3258.37 v1(1773.52,3300.04) ; v1@1764.02,3300.04 cw(c1741.09,3300.04) 1757.31,3283.82 cw(c1773.52,3267.61) v1@1773.52,3290.54 ; v1@1768.02,3300.04 cw(c1754.75,3300.04) 1764.13,3290.65 cw(c1773.52,3281.26) v1@1773.52,3294.54 ; v1@1957.62,3288.28 cw(c1941.4,3272.06) 1964.34,3272.06 cw(c1987.27,3272.06) v1@1971.06,3288.28 ; v1@1960.45,3291.11 cw(c1951.06,3281.72) 1964.34,3281.72 cw(c1977.62,3281.72) v1@1968.23,3291.11 ; v1(1964.34,3295) 1964.34,3202.39 R278.1@2006.7,3160.03 ; 1989.95,3176.78 ccw(c2006.7,3193.52) R278.1@2006.7,3169.84 ; 1991.14,3175.59 cw(c1976.07,3160.52) R278.1@1997.38,3160.52 ; R278.1@1996.78,3169.95 ccw(c2006.7,3179.87) R278.1@2006.7,3165.84 ; R278.1@1997.97,3168.76 cw(c1989.73,3160.52) R278.1@2001.38,3160.52 ; v3(5075.04,4032.52) U8.V7@5094.72,4052.2 ; U8.V7@5087.38,4052.2 cw(c5069.66,4052.2) 5082.19,4039.67 cw(c5094.72,4027.14) U8.V7@5094.72,4044.86 ; 5087.84,4045.32 cw(c5075.04,4058.13) 5075.04,4040.02 ccw(c5075.04,4058.13) 5087.84,4045.32 ; 5087.84,4045.32 ccw(c5100.65,4032.52) 5082.54,4032.52 cw(c5100.65,4032.52) 5087.84,4045.32
  MidLayer2 w4: v1(1773.52,3300.04) 1899.96,3300.04 1905,3295 v1(1964.34,3295) 2000,3295 2031.86,3326.86 2031.86,3650.04 2048.52,3666.71 2398.52,3666.71 2415.19,3683.37 2415.19,3833.37 2448.52,3866.71 2598.52,3866.71 2615.19,3883.37 2615.19,3950.04 2631.86,3966.71 3406.86,3966.71 3415.19,3975.04 3415.19,4141.71 3423.52,4150.04 3606.86,4150.04 3640.19,4116.71 3855.92,4116.71 3861.12,4111.5 3888.88,4111.5 3894.08,4116.71 4285.5,4116.71 4323.4,4078.81 4550.87,4078.81 4556.18,4073.5 4622.25,4073.5 4648.5,4047.25 4648.64,4047.11 4648.64,4043.07 4648.64,4034.04 4653.18,4029.5 4688.25,4029.5 ; v1@1777.41,3296.15 cw(c1786.8,3286.76) 1786.8,3300.04 cw(c1786.8,3313.32) v1@1777.41,3303.93 ; v1@1780.24,3293.32 cw(c1796.46,3277.11) 1796.46,3300.04 cw(c1796.46,3322.98) v1@1780.24,3306.76 ; v1@1957.62,3288.28 ccw(c1941.4,3272.06) 1941.4,3295 ccw(c1941.4,3317.93) v1@1957.62,3301.72 ; v1@1960.45,3291.11 ccw(c1951.06,3281.72) 1951.06,3295 ccw(c1951.06,3308.28) v1@1960.45,3298.89 ; v1@1968.23,3291.11 cw(c1977.62,3281.72) 1977.62,3295 cw(c1977.62,3308.28) v1@1968.23,3298.89 ; v1@1971.06,3288.28 cw(c1987.27,3272.06) 1987.27,3295 cw(c1987.27,3317.93) v1@1971.06,3301.72 ; 5061.46,4021.13 cw(c5051.53,4031.06) 5051.53,4017.01 5037.6,4017.01 4957.99,4017.01 4899.73,4017.01 4838.82,4017.01 4828.82,4017.01 4815,4017.01 4804.32,4017.01 4700.74,4017.01 4698.5,4019.25 ; v3@5067.57,4033.17 cw(c5049.53,4034.75) 5061.17,4020.88 cw(c5072.81,4007.01) v3@5074.39,4025.05 ; 4688.25,4029.5 4698.5,4019.25 ; 4688.25,4029.5 4698.5,4019.25
IN.L: R2.2 R5.2 R6.2 R7.2 R137.1 TP9.1 U26.5 | length 4233.5
  Top Layer w4: U26.5@-389.13,5000 -314.44,5000 -294.44,4980 v1(-265,4980) v1@-269.96,4975.04 ; U26.5@-351.56,4995.89 cw(c-341.64,4985.97) -341.64,5000 cw(c-341.64,5014.03) U26.5@-351.56,5004.11 ; TP9.1@76.12,3508.23 125,3557.11 125,4284.85 296.85,4456.7 296.85,4586.85 v1(320,4610) ; v1@315.15,4610 v1(320,4610) ; v1@317.57,4607.57 v1(320,4610)
  MidLayer1 w4: v1@240.19,5008.37 240,5008.56 v1(240,5015) 315,5015 385,4945 385,4635 360,4610 v1(320,4610) 317.76,4612.24 v1@317.76,4612.61
  MidLayer2 w4: v1(-250,3760) -275,3735 -330,3735 -350,3715 -350,3645 -373.44,3621.56 -416.63,3621.56 -442,3596.18 -442,3535 -415.23,3508.23 TP9.1@76.12,3508.23
  Bottom Layer w4: R5.2@-282.58,3744.71 ccw(c-291.66,3753.79) -278.82,3753.79 ccw(c-265.98,3753.79) R5.2@-275.06,3744.71 ; R2.2@-282.58,3791.66 cw(c-291.66,3782.58) -278.82,3782.58 cw(c-265.98,3782.58) R2.2@-275.06,3791.66 ; R5.2@-278.82,3740.45 R5.2@-278.82,3741.71 ; R2.2@-278.82,3795.91 R5.2@-278.82,3741.71 ; R5.2@-275.06,3737.19 cw(c-264.14,3726.27) -264.14,3741.71 ; R5.2@-272.23,3747.54 ccw(c-258.16,3761.61) -258.16,3741.71 ; v1@-263.56,4975.04 -265,4976.48 v1(-265,4980) -134.96,4980 -130,4975.04 -52,4975.04 ; v1@-255.01,3751.93 cw(c-260.62,3742.91) -250,3742.91 ; v1(-250,3760) -250,3742.91 ; v1@-244.99,3751.93 ccw(c-239.38,3742.91) -250,3742.91 ; -243.68,3740.45 ccw(c-243.68,3762.95) R6.2@-227.77,3747.04 ; R7.2@-224.94,3689.25 ccw(c-234.02,3698.33) -221.18,3698.33 ccw(c-208.34,3698.33) R7.2@-217.42,3689.25 ; R6.2@-224.94,3736.2 cw(c-234.02,3727.12) -221.18,3727.12 cw(c-208.34,3727.12) R6.2@-217.42,3736.2 ; R6.2@-224.94,3736.69 ccw(c-234.02,3727.62) -234.02,3740.45 ccw(c-234.02,3753.3) R6.2@-224.94,3744.22 ; R7.2@-221.18,3685 R6.2@-221.18,3740.45 -247.81,3740.45 -248.81,3741.45 -248.81,3741.71 R5.2@-278.82,3741.71 ; R137.1@-160.85,5388.42 -98.42,5388.42 -64.81,5354.81 -64.81,4987.85 -52,4975.04 ; R137.1@-157.09,5384.65 cw(c-148.01,5375.57) -148.01,5388.42 cw(c-148.01,5401.26) R137.1@-157.09,5392.18 ; v1(240,5015) 167.97,5015 126.01,4973.04 90,4973.04 88,4975.04 -52,4975.04
IN.R: R10.2 R11.2 R12.2 R13.2 R15.2 R138.1 TP10.1 U26.6 | length 3517.8
  Top Layer w4: U26.6@-389.09,4950.04 U26.6@-389.13,4950 -335,4950 v1(-320,4935) ; U26.6@-351.17,4946.33 cw(c-343.43,4940.01) -343.43,4950 cw(c-343.43,4959.99) U26.6@-351.17,4953.67
  MidLayer1 w4: v1(-368.14,4308.37) -395,4335.23 -395,4430 -327.12,4497.88 -327.12,4583.19 -403.48,4659.54 -403.48,4766.49 -297.14,4872.82 -297.14,4912.14 v1(-320,4935) -319.83,4935.17 v1@-319.17,4935.17
  MidLayer2 w4: v1(-355,4020) -420,3955 -420,3724.88 -475,3669.88 -475,3505.68 -377.56,3408.23 TP10.1@76.12,3408.23 ; v1(-320,4935) -320,4988.5 -295,5013.5 -236.5,5013.5 -210,5040 -210,5255 -197.96,5267.04 v1(-126.14,5267.04)
  Bottom Layer w0: R12.2@-327.77,4121.55 cw(c-343.68,4105.65) -321.18,4105.65
  Bottom Layer w4: v1(-368.14,4308.37) -368.14,4267.37 -340.31,4239.55 ; v1(-355,4020) -352.73,4017.73 R10.2@-321.18,4017.73 R11.2@-321.18,4073.18 ; R15.2@-328.52,4245.29 cw(c-340.31,4254.52) -340.31,4239.54 ; R10.2@-324.94,4013.97 ccw(c-334.02,4004.89) -334.02,4017.73 ccw(c-334.02,4030.57) R10.2@-324.94,4021.49 ; R10.2@-324.94,4021.98 ccw(c-334.02,4031.06) -321.18,4031.06 ccw(c-308.34,4031.06) R10.2@-317.42,4021.98 ; R11.2@-324.94,4068.93 cw(c-334.02,4059.85) -321.18,4059.85 cw(c-308.34,4059.85) R11.2@-317.42,4068.93 ; R13.2@-324.94,4188.34 ccw(c-334.02,4197.42) -321.18,4197.42 ccw(c-308.34,4197.42) R13.2@-317.42,4188.34 ; R15.2@-324.94,4235.29 cw(c-334.02,4226.21) -321.18,4226.21 cw(c-308.34,4226.21) R15.2@-317.42,4235.29 ; R138.1@-160.85,5276.75 -135.85,5276.75 v1(-126.14,5267.04) ; R138.1@-157.09,5272.99 cw(c-148.01,5263.91) -148.01,5276.75 cw(c-148.01,5289.59) R138.1@-157.09,5280.51 ; R138.1@-154.26,5270.16 cw(c-138.35,5254.25) -138.35,5276.75 ; -340.31,4239.55 R15.2@-321.18,4239.55 R13.2@-321.18,4184.09 ; R11.2@-324.94,4077.43 ccw(c-334.02,4086.52) -321.18,4086.52 ; R11.2@-324.94,4077.43 ccw(c-334.02,4086.51) -321.18,4086.51 ; R11.2@-324.94,4077.43 ccw(c-334.02,4086.51) -321.18,4086.51 ; R12.2@-324.94,4124.38 cw(c-334.02,4115.3) -321.18,4115.3 ; R12.2@-324.94,4124.38 cw(c-334.02,4115.3) -321.18,4115.3 ; R12.2@-324.94,4124.38 cw(c-334.02,4115.3) -321.18,4115.3 ; R12.2@-324.94,4132.89 ccw(c-334.02,4141.97) -321.18,4141.97 ; R12.2@-324.94,4132.89 ccw(c-334.02,4141.97) -321.18,4141.97 ; R12.2@-324.94,4132.89 ccw(c-334.02,4141.97) -321.18,4141.97 ; R13.2@-324.94,4179.84 cw(c-334.02,4170.76) -321.18,4170.76 ; R13.2@-324.94,4179.84 cw(c-334.02,4170.76) -321.18,4170.76 ; R13.2@-324.94,4179.84 cw(c-334.02,4170.76) -321.18,4170.76 ; R11.2@-321.18,4073.18 R12.2@-321.18,4128.64 ; R11.2@-321.18,4073.18 R12.2@-321.18,4128.64 ; R11.2@-321.18,4073.18 R12.2@-321.18,4128.64 ; -321.18,4086.51 ccw(c-308.34,4086.51) R11.2@-317.42,4077.43 ; -321.18,4086.51 ccw(c-308.34,4086.51) R11.2@-317.42,4077.43 ; -321.18,4086.51 ccw(c-308.34,4086.51) R11.2@-317.42,4077.43 ; -321.18,4115.3 cw(c-308.34,4115.3) R12.2@-317.42,4124.38 ; -321.18,4115.3 cw(c-308.34,4115.3) R12.2@-317.42,4124.38 ; -321.18,4115.3 cw(c-308.34,4115.3) R12.2@-317.42,4124.38 ; R12.2@-321.18,4128.64 R13.2@-321.18,4184.09 ; R12.2@-321.18,4128.64 R13.2@-321.18,4184.09 ; R12.2@-321.18,4128.64 R13.2@-321.18,4184.09 ; -321.18,4141.97 ccw(c-308.34,4141.97) R12.2@-317.42,4132.89 ; -321.18,4141.97 ccw(c-308.34,4141.97) R12.2@-317.42,4132.89 ; -321.18,4141.97 ccw(c-308.34,4141.97) R12.2@-317.42,4132.89 ; -321.18,4170.76 cw(c-308.34,4170.76) R13.2@-317.42,4179.84 ; -321.18,4170.76 cw(c-308.34,4170.76) R13.2@-317.42,4179.84 ; -321.18,4170.76 cw(c-308.34,4170.76) R13.2@-317.42,4179.84
ISP176X.BUS_DMA_ACK: U8.AF13 U61.116 | length 1808.1
  Top Layer w4: 5297.02,3525.84 5297.02,3535 ; v1(5312,3499) 5297.02,3513.97 5297.02,3535 ; U8.AF13@5323.6,3737.24 cw(c5305.88,3737.24) 5318.41,3724.71 ; v1@5326.14,2912.32 ccw(c5309.92,2896.11) 5309.92,2919.04 ccw(c5309.92,2941.98) v1@5326.14,2925.76 ; v1@5328.97,2915.15 ccw(c5319.58,2905.76) 5319.58,2919.04 ccw(c5319.58,2932.32) v1@5328.97,2922.93 ; U8.AF13@5330.95,3729.9 ccw(c5330.95,3712.18) 5318.41,3724.71 ; v1(5332.86,2919.04) 5289.04,2919.04 5256.52,2886.52 5256.52,2842.71 5256.52,2840 5256.52,2495.02 5318.5,2433.04 5398.04,2433.04 5425,2460 5425,2474.67 5433.7,2483.37 5456.86,2483.37 5472.93,2499.45 5472.93,2522.93 5478.2,2528.2 U61.116@5516.83,2528.2 ; U61.116@5500.81,2525.37 ccw(c5493.98,2518.54) 5493.98,2528.2 ccw(c5493.98,2537.85) U61.116@5500.81,2531.02 ; 5297.02,3535 5297.02,3562.91 5292.02,3567.91 5292.02,3592.09 5292.07,3592.13 5292.07,3611.73 5307.08,3626.74 5307.08,3638.82 5307.08,3697.36 cw(c5345.76,3697.36) 5318.41,3724.71
  MidLayer1 w4: v1@5304.76,3496.77 v1@5309.77,3496.77 ; v1@5311.41,3496.77 v1@5309.77,3496.77 ; v1(5312,3499) v1@5309.77,3496.77 ; v1@5328.09,2927.26 ccw(c5323.28,2935.54) 5332.86,2935.54 ; v1(5332.86,2919.04) 5332.86,2935.54 ; v1@5337.63,2927.26 cw(c5342.43,2935.54) 5332.86,2935.54 ; v1@5309.77,3496.77 5300.8,3487.8 5300.8,3271.14 5334.02,3237.92 5334.02,3127.19 5334.02,2999.29 5331.36,2996.63 5331.36,2960 5331.36,2937.04 5332.86,2935.54
ISP176X.BUS_DMA_REQ: U8.AH19 U61.114 | length 1739
  Top Layer w4: v1@5473.52,2580.21 cw(c5473.52,2557.27) 5489.74,2573.49 cw(c5505.96,2589.71) v1@5483.02,2589.71 ; v1@5473.52,2584.21 cw(c5473.52,2570.93) 5482.91,2580.32 cw(c5492.3,2589.71) v1@5479.02,2589.71 ; v1(5473.52,2589.71) 5495.67,2567.57 ; 5483.2,2580.03 ccw(c5503.64,2600.47) U61.114@5503.64,2571.57 ; 5490.03,2573.2 ccw(c5503.64,2586.81) U61.114@5503.64,2567.57 ; v1(5490.54,3433.81) 5519.8,3463.07 5519.8,3528.8 5545.59,3554.59 5545.59,3555.84 5566.69,3576.95 5566.69,3630.35 ; v1@5490.54,3439.31 ccw(c5490.54,3452.59) 5499.93,3443.2 ccw(c5509.32,3433.81) v1@5496.04,3433.81 ; v1@5490.54,3443.31 ccw(c5490.54,3466.24) 5506.76,3450.02 ccw(c5522.98,3433.81) v1@5500.04,3433.81 ; 5496.86,2566.37 ccw(c5503.64,2573.16) U61.114@5503.64,2563.57 ; U61.114@5500.43,2565.17 ccw(c5495.67,2561.62) 5495.67,2567.57 ; U61.114@5500.43,2569.96 cw(c5495.67,2573.51) 5495.67,2567.57 ; U61.114@5516.83,2567.57 5495.67,2567.57 ; 5567.17,3630.82 5567.17,3638.82 U8.AH19@5567.17,3658.5 ; 5567.17,3640.78 cw(c5584.89,3640.78) 5572.36,3653.31 ccw(c5584.89,3640.78) 5567.17,3640.78 ; 5567.17,3640.78 ccw(c5549.44,3640.78) 5561.97,3653.31 cw(c5549.44,3640.78) 5567.17,3640.78
  MidLayer1 w4: v1(5454,3017) 5443.5,3006.5 5443.5,2948.25 5427.5,2932.25 5427.5,2917.75 5435,2910.25 5435,2885 5413.52,2863.52 5413.52,2823 5451.52,2785 5451.52,2648.96 5473.52,2626.96 v1(5473.52,2589.71) ; v1@5466.81,2596.43 ccw(c5450.59,2612.64) 5473.52,2612.64 ccw(c5496.46,2612.64) v1@5480.24,2596.43 ; v1@5469.64,2593.6 ccw(c5460.25,2602.99) 5473.52,2602.99 ccw(c5486.8,2602.99) v1@5477.41,2593.6
  MidLayer2 w4: 5400.5,3420 5400.5,3393.19 ; v1@5447.28,3023.72 ccw(c5431.06,3039.93) 5454,3039.93 ccw(c5476.93,3039.93) v1@5460.72,3023.72 ; v1@5450.11,3020.89 ccw(c5440.72,3030.28) 5454,3030.28 ccw(c5467.28,3030.28) v1@5457.89,3020.89 ; v1(5454,3017) 5454,3136.25 5424.4,3165.85 5401.62,3188.63 5401.62,3236.5 5425.5,3260.38 5425.5,3293.24 5416.43,3302.32 5416.43,3330.07 5430.8,3344.44 5430.8,3362.89 5400.5,3393.19 ; v1(5490.54,3433.81) 5456.35,3468 5434.36,3468 5400.5,3434.14 5400.5,3393.19
ISP176X.BUS_NCS: U8.AB14 U61.106 | length 2519.4
  Top Layer w4: v1@5059.47,2919.32 ccw(c5043.26,2903.11) 5043.26,2926.04 ccw(c5043.26,2948.98) v1@5059.47,2932.76 ; v1@5062.3,2922.15 ccw(c5052.91,2912.76) 5052.91,2926.04 ccw(c5052.91,2939.32) v1@5062.3,2929.93 ; v1(5066.19,2926.04) 5031.09,2926.04 5022.52,2917.48 5022.52,2878.61 5056.13,2845 5153.56,2845 5165.19,2833.37 5165.19,2791.71 5173.52,2783.37 5198.86,2783.37 v1(5215.19,2767.04) ; v1@5205.69,2767.04 ccw(c5182.76,2767.04) 5198.97,2783.26 ccw(c5215.19,2799.48) v1@5215.19,2776.54 ; v1@5209.69,2767.04 ccw(c5196.41,2767.04) 5205.8,2776.43 ccw(c5215.19,2785.82) v1@5215.19,2772.54 ; v3(5350.63,3875.04) U8.AB14@5370.31,3894.72 ; U8.AB14@5362.97,3894.72 cw(c5345.25,3894.72) 5357.78,3882.19 cw(c5370.31,3869.66) U8.AB14@5370.31,3887.38 ; U61.106@5523.52,2725.04 5546.19,2725.04 v1(5601.52,2669.71) ; U61.106@5532.85,2722.22 cw(c5539.67,2715.4) 5539.67,2725.04 cw(c5539.69,2734.71) U61.106@5532.85,2727.87 ; v1@5592.02,2669.71 ccw(c5569.09,2669.71) 5585.31,2685.93 ccw(c5601.52,2702.14) v1@5601.52,2679.21 ; v1@5596.02,2669.71 ccw(c5582.75,2669.71) 5592.14,2679.1 ccw(c5601.52,2688.49) v1@5601.52,2675.21 ; 5363.43,3887.84 cw(c5350.63,3900.65) 5350.63,3882.54 ccw(c5350.63,3900.65) 5363.43,3887.84 ; 5363.43,3887.84 ccw(c5376.24,3875.04) 5358.13,3875.04 cw(c5376.24,3875.04) 5363.43,3887.84
  MidLayer2 w4: v1(5066.19,2926.04) 5116,2975.85 5116,3083.75 5240.02,3207.77 5240.02,3270.84 5240.02,3391.22 5239.86,3391.38 5239.86,3428.35 5239.86,3499.86 ; v1@5066.19,2931.54 ccw(c5066.19,2944.82) 5075.58,2935.43 ccw(c5084.97,2926.04) v1@5071.69,2926.04 ; v1@5066.19,2935.54 ccw(c5066.19,2958.48) 5082.41,2942.26 ccw(c5098.63,2926.04) v1@5075.69,2926.04 ; 5339.24,3861.46 ccw(c5349.17,3851.53) 5335.12,3851.53 5335.12,3757.99 5335.12,3638.82 5335.12,3630.82 5335.12,3600.12 5332.5,3597.5 5308.75,3597.5 5292.04,3580.78 5292.04,3550 5292.04,3534.51 5287.53,3530 5274.4,3516.87 5256.87,3516.87 ; v3@5343.16,3874.39 cw(c5325.12,3872.81) 5338.99,3861.17 cw(c5352.86,3849.53) v3@5351.28,3867.57 ; 5239.86,3499.86 5256.87,3516.87 ; 5239.86,3499.86 5256.87,3516.87
  Bottom Layer w4: v1@5215.19,2757.54 cw(c5215.19,2734.61) 5231.41,2750.82 cw(c5247.63,2767.04) v1@5224.69,2767.04 ; v1@5215.19,2761.54 cw(c5215.19,2748.26) 5224.58,2757.65 cw(c5233.97,2767.04) v1@5220.69,2767.04 ; v1(5215.19,2767.04) 5276,2706.23 5276,2698 5357.29,2616.71 5548.52,2616.71 v1(5601.52,2669.71) ; v1@5592.02,2669.71 cw(c5569.09,2669.71) 5585.31,2653.49 cw(c5601.52,2637.27) v1@5601.52,2660.21 ; v1@5596.02,2669.71 cw(c5582.75,2669.71) 5592.14,2660.32 cw(c5601.52,2650.93) v1@5601.52,2664.21
ISP176X.BUS_NIRQ: U8.AF16 U61.112 | length 1958
  Top Layer w4: U8.AF16@5449.05,3729.9 cw(c5449.05,3712.18) 5461.59,3724.71 ; U8.AF16@5456.4,3737.24 ccw(c5474.12,3737.24) 5461.59,3724.71 ; 5492.03,2614.87 ccw(c5501.77,2624.61) U61.112@5503.22,2610.91 ; U61.112@5497.95,2608.95 ccw(c5502.9,2613.9) U61.112@5503.64,2606.94 ; U61.112@5516.83,2608.37 5498.52,2608.37 5490.19,2616.71 5273.29,2616.71 5264.52,2625.48 5264.52,2839.39 5264.52,2883.21 5281.31,2900 5300,2900 5345,2900 5367.5,2900 5410,2942.5 5469.31,2942.5 ; 5461.59,3724.71 cw(c5434.24,3697.36) 5472.92,3697.36 5472.92,3638.82 5472.92,3615.67 5448.2,3590.95 5448.2,3576.45 5453.2,3571.45 5453.2,3553.37 5427.02,3527.19 5416.34,3527.19 5394.8,3505.65 5394.8,3416.51 5436.31,3375 5436.31,3338.64 5423.02,3325.35 5423.02,3307.03 5439.3,3290.76 5439.3,3264.39 5456.69,3247 5500.47,3247 5556.06,3191.4 5599.56,3191.4 5618.86,3172.1 5618.86,3171.63 5633.11,3157.37 5635.05,3157.37 5648.52,3143.9 5648.52,3090.37 5665.19,3073.71 5665.19,3009.19 5624.62,2968.62 5592.1,2968.62 5565.67,2942.19 5474,2942.19 ; 5469.31,2942.5 5469.62,2942.19 5474,2942.19 ; 5469.31,2942.5 5473.69,2942.5 5474,2942.19
ISP176X.ISP176X_NRESET: U8.AH11 U61.122 | length 1964.8
  Top Layer w4: v1@5058.47,3018.32 cw(c5042.26,3002.11) 5065.19,3002.11 cw(c5088.13,3002.11) v1@5071.91,3018.32 ; v1@5061.3,3021.15 cw(c5051.91,3011.76) 5065.19,3011.76 cw(c5078.47,3011.76) v1@5069.08,3021.15 ; v1(5065.19,3025.04) 5065.19,2996.12 5097.52,2963.79 5097.52,2934.37 5111.9,2920 5215,2920 5248.52,2886.48 5248.52,2491.71 5315.19,2425.04 5398.52,2425.04 5413.48,2410.09 U61.122@5516.83,2410.09 ; v1@5200.81,3249.04 ccw(c5190.24,3261.86) 5206.86,3261.86 ; v1@5203.36,3245.95 ccw(c5197.24,3253.37) 5206.86,3253.37 ccw(c5216.48,3253.37) v1@5210.36,3245.95 ; v1@5210,3246.9 5211.02,3245.87 5215.19,3241.71 v1(5206.86,3241.71) 5206.86,3261.86 ; v1@5212.9,3249.04 cw(c5223.47,3261.86) 5206.86,3261.86 ; U8.AH11@5247.01,3653.31 cw(c5234.48,3640.78) 5252.2,3640.78 cw(c5269.93,3640.78) U8.AH11@5257.4,3653.31 ; U8.AH11@5252.2,3658.5 5252.2,3621.81 5260.02,3613.99 5260.02,3585.48 5233.81,3559.27 5233.81,3520.74 5230.02,3516.95 5230.02,3431.34 5224.19,3425.5 5224.19,3410.08 5224.19,3279.19 5206.86,3261.86 ; U61.122@5500.81,2407.26 ccw(c5493.98,2400.43) 5493.98,2410.09 ccw(c5493.98,2419.74) U61.122@5500.81,2412.91
  MidLayer2 w4: v1(5065.19,3025.04) 5100,3059.85 5100,3090.38 5206.86,3197.23 v1(5206.86,3241.71) ; v1@5065.19,3030.54 ccw(c5065.19,3043.82) 5074.58,3034.43 ccw(c5083.97,3025.04) v1@5070.69,3025.04 ; v1@5065.19,3034.54 ccw(c5065.19,3057.48) 5081.41,3041.26 ccw(c5097.63,3025.04) v1@5074.69,3025.04 ; v1@5200.14,3234.99 cw(c5183.92,3218.77) 5206.86,3218.77 cw(c5229.79,3218.77) v1@5213.57,3234.99 ; v1@5202.97,3237.82 cw(c5193.58,3228.43) 5206.86,3228.43 cw(c5220.14,3228.43) v1@5210.75,3237.82
JTAG.DETECT: EXTHDR1.23 R233.2 | length 3073.9
  Top Layer w4: EXTHDR1.23@1779.21,3122.62 ccw(c1765.55,3136.28) 1784.87,3136.28 ccw(c1804.18,3136.28) EXTHDR1.23@1790.52,3122.62 ; EXTHDR1.23@1784.87,3071.85 1784.87,3274.87 1827.04,3317.04 2264.25,3317.04 2370,3211.29 2370,3170 2472,3068 2472,2447 2460,2435 2460,2221.31 2501.31,2180 3125,2180 3165.19,2220.19 3165.19,2322 3145,2342.19 v1(3145,2370) ; v1@3138.28,2363.28 cw(c3122.06,2347.06) 3145,2347.06 cw(c3167.93,2347.06) v1@3151.72,2363.28 ; v1@3141.11,2366.11 cw(c3131.72,2356.72) 3145,2356.72 cw(c3158.28,2356.72) v1@3148.89,2366.11
  Bottom Layer w4: R233.2@3097.23,2442.92 cw(c3083.79,2429.48) 3102.8,2429.48 ; 3102.8,2424.54 cw(c3128.78,2424.54) R233.2@3110.41,2442.92 ; 3102.8,2434.2 cw(c3119.12,2434.2) R233.2@3107.58,2445.75 ; R233.2@3103.82,2450 3102.8,2448.98 3102.8,2412.2 v1(3145,2370) ; v1@3135.5,2370 ccw(c3112.56,2370) 3128.78,2386.22 ccw(c3145,2402.43) v1@3145,2379.5 ; v1@3139.5,2370 ccw(c3126.22,2370) 3135.61,2379.39 ccw(c3145,2388.78) v1@3145,2375.5
JTAG.HARD.TCK: EXTHDR1.11 R223.2 | length 1906.2
  Top Layer w4: EXTHDR1.11@1973.84,3018.73 cw(c1973.84,3004.27) 1984.07,3014.49 ; EXTHDR1.11@1973.84,3071.85 1973.84,3024.72 v1(2006.86,2991.71) ; EXTHDR1.11@1977.84,3026.73 ccw(c1992.35,3026.73) 1982.09,3016.47 ; EXTHDR1.11@1981.84,3026.73 ccw(c2006.01,3026.73) 1988.92,3009.64 ; v1@1997.36,2991.71 ccw(c1974.42,2991.71) 1990.64,3007.93 ccw(c2006.86,3024.14) v1@2006.86,3001.21 ; v1@2001.36,2991.71 ccw(c1988.08,2991.71) 1997.47,3001.1 ccw(c2006.86,3010.49) v1@2006.86,2997.21
  MidLayer1 w4: v1@2000.14,2984.99 cw(c1983.92,2968.77) 2006.86,2968.77 cw(c2029.79,2968.77) v1@2013.57,2984.99 ; v1@2002.97,2987.82 cw(c1993.58,2978.43) 2006.86,2978.43 cw(c2020.14,2978.43) v1@2010.75,2987.82 ; v1(2006.86,2991.71) 2006.86,2817.32 2132.47,2691.71 2920,2691.71 3053.88,2691.71 3106.86,2744.69 v1(3106.86,2841.71) ; v1@3100.14,2834.99 cw(c3083.92,2818.77) 3106.86,2818.77 cw(c3129.79,2818.77) v1@3113.57,2834.99 ; v1@3102.97,2837.82 cw(c3093.58,2828.43) 3106.86,2828.43 cw(c3120.14,2828.43) v1@3110.75,2837.82
  Bottom Layer w4: R223.2@3097.23,2877.92 cw(c3081.32,2862.01) 3103.82,2862.01 cw(c3126.32,2862.01) R223.2@3110.41,2877.92 ; R223.2@3100.06,2880.75 cw(c3090.98,2871.67) 3103.82,2871.67 cw(c3116.66,2871.67) R223.2@3107.58,2880.75 ; v1@3100.14,2848.43 ccw(c3091.26,2857.31) 3103.82,2857.31 ; 3103.82,2862.32 ccw(c3127.47,2862.32) v1@3110.75,2845.6 ; 3103.82,2871.98 ccw(c3137.13,2871.98) v1@3113.57,2848.43 ; R223.2@3103.82,2885 3103.82,2844.75 v1(3106.86,2841.71)
JTAG.HARD.TDI: EXTHDR1.7 R220.2 | length 1443.7
  Top Layer w4: v1@2033.47,3136.32 cw(c2025.36,3128.21) 2036.83,3128.21 ; EXTHDR1.7@2036.83,3071.85 2036.83,3139.68 v1(2040.19,3143.04) ; EXTHDR1.7@2036.83,3112 cw(c2071.23,3112) v1@2046.91,3136.32 ; EXTHDR1.7@2036.83,3121.66 cw(c2061.57,3121.66) v1@2044.08,3139.15 ; 2036.83,3131.32 cw(c2051.91,3131.32) v1@2041.25,3141.98
  Bottom Layer w4: v1(2040.19,3143.04) 2114.19,3217.04 2724.67,3217.04 2934,3007.71 3081.53,3007.71 R220.2@3103.82,3030 R220.2@3103.82,3028.82 ; v1@2040.19,3148.54 ccw(c2040.19,3161.82) 2049.58,3152.43 ccw(c2058.97,3143.04) v1@2045.69,3143.04 ; v1@2040.19,3152.54 ccw(c2040.19,3175.48) 2056.41,3159.26 ccw(c2072.63,3143.04) v1@2049.69,3143.04 ; 3087.07,3013.25 cw(c3103.82,2996.5) R220.2@3103.82,3020.19 ; 3088.26,3014.44 ccw(c3073.19,3029.51) R220.2@3094.5,3029.51 ; R220.2@3093.9,3020.08 cw(c3103.82,3010.16) R220.2@3103.82,3024.19 ; R220.2@3095.09,3021.27 ccw(c3086.85,3029.51) R220.2@3098.5,3029.51
JTAG.HARD.TDO: EXTHDR1.9 R221.2 | length 1432.4
  Top Layer w4: EXTHDR1.9@2005.34,3018.73 cw(c2005.34,3007.07) 2013.58,3015.31 ; EXTHDR1.9@2005.34,3071.85 2005.34,3023.56 v1(2040.19,2988.71) ; EXTHDR1.9@2009.34,3026.73 ccw(c2026.65,3026.73) 2014.41,3014.49 ; EXTHDR1.9@2013.34,3026.73 ccw(c2040.3,3026.73) 2021.24,3007.66 ; v1@2030.69,2988.71 ccw(c2007.76,2988.71) 2023.97,3004.93 ccw(c2040.19,3021.14) v1@2040.19,2998.21 ; v1@2034.69,2988.71 ccw(c2021.41,2988.71) 2030.8,2998.1 ccw(c2040.19,3007.49) v1@2040.19,2994.21
  Bottom Layer w4: v1(2040.19,2988.71) 2077.19,3025.71 2243.54,3025.71 2269.25,3000 2296.31,3000 2313.69,3017.37 2877.63,3017.37 2919.63,2975.37 3057.12,2975.37 3075,2957.5 R221.2@3103.82,2957.5 ; v1@2040.19,2994.21 ccw(c2040.19,3007.49) 2049.58,2998.1 ccw(c2058.97,2988.71) v1@2045.69,2988.71 ; v1@2040.19,2998.21 ccw(c2040.19,3021.14) 2056.41,3004.93 ccw(c2072.63,2988.71) v1@2049.69,2988.71 ; R221.2@3097.23,2950.91 ccw(c3081.32,2935) 3081.32,2957.5 ccw(c3081.32,2980) R221.2@3097.23,2964.09 ; R221.2@3100.06,2953.74 ccw(c3090.98,2944.66) 3090.98,2957.5 ccw(c3090.98,2970.34) R221.2@3100.06,2961.26
JTAG.HARD.TMS: EXTHDR1.13 R222.2 | length 1502
  Top Layer w4: EXTHDR1.13@1936.82,3020.94 cw(c1924.52,3008.04) 1942.35,3008.04 ; EXTHDR1.13@1942.35,3071.85 1942.35,3008.04 ; EXTHDR1.13@1947.87,3020.94 ccw(c1960.18,3008.04) 1942.35,3008.04 ; v1(1965.19,3000.04) 1950.35,3000.04 1942.35,3008.04
  Bottom Layer w4: v1@1958.47,2993.32 cw(c1942.26,2977.11) 1965.19,2977.11 cw(c1988.13,2977.11) v1@1971.91,2993.32 ; v1@1961.3,2996.15 cw(c1951.91,2986.76) 1965.19,2986.76 cw(c1978.47,2986.76) v1@1969.08,2996.15 ; v1(1965.19,3000.04) 1965.19,2958.37 2015.19,2908.37 2767.07,2908.37 2935.44,2740 R222.2@3103.82,2740 ; R222.2@3097.23,2733.41 ccw(c3081.32,2717.5) 3081.32,2740 ccw(c3081.32,2762.5) R222.2@3097.23,2746.59 ; R222.2@3100.06,2736.24 ccw(c3090.98,2727.16) 3090.98,2740 ccw(c3090.98,2752.84) R222.2@3100.06,2743.76
JTAG.SOFT.TCK: EXTHDR1.19 R231.2 | length 2279.3
  Top Layer w4: v1@1841.81,3143.32 cw(c1825.59,3127.11) 1848.52,3127.11 cw(c1871.46,3127.11) v1@1855.24,3143.32 ; v1@1844.64,3146.15 cw(c1835.25,3136.76) 1848.52,3136.76 cw(c1861.8,3136.76) v1@1852.41,3146.15 ; EXTHDR1.19@1845.03,3119.8 ccw(c1836.59,3128.23) 1848.52,3128.23 ; EXTHDR1.19@1847.86,3071.85 1847.86,3091.71 1848.52,3091.71 v1(1848.52,3150.04) ; 1848.52,3134.67 ccw(c1865.56,3134.67) EXTHDR1.19@1853.51,3122.62
  MidLayer1 w4: v1@1841.81,3143.32 ccw(c1825.59,3127.11) 1825.59,3150.04 ccw(c1825.59,3172.98) v1@1841.81,3156.76 ; v1@1844.64,3146.15 ccw(c1835.25,3136.76) 1835.25,3150.04 ccw(c1835.25,3163.32) v1@1844.64,3153.93 ; v1(1848.52,3150.04) 1795.04,3150.04 1781.86,3136.86 1781.86,3008.37 2398.52,2391.71 2440.19,2391.71 2515.19,2466.71 3081.86,2466.71 3115.19,2500.04 v1(3115.19,2558.37) ; v1@3108.47,2551.66 cw(c3092.26,2535.44) 3115.19,2535.44 cw(c3138.13,2535.44) v1@3121.91,2551.66 ; v1@3111.3,2554.49 cw(c3101.91,2545.1) 3115.19,2545.1 cw(c3128.47,2545.1) v1@3119.08,2554.49
  Bottom Layer w4: R231.2@3103.82,2591.71 3103.82,2594.51 R231.2@3103.82,2595 ; R231.2@3103.86,2591.71 3115.19,2580.37 ; R231.2@3104.5,2585.21 cw(c3105.38,2573.33) 3113.81,2581.76 cw(c3119.32,2587.26) R231.2@3112.26,2590.56 ; v1@3108.68,2565.29 ccw(c3094.47,2580.37) 3115.19,2580.37 ; v1@3111.42,2562.38 ccw(c3103.19,2571.11) 3115.19,2571.11 ccw(c3127.19,2571.11) v1@3118.96,2562.38 ; v1(3115.19,2558.37) 3115.19,2580.37 ; v1@3121.7,2565.29 cw(c3135.91,2580.37) 3115.19,2580.37
JTAG.SOFT.TDI: EXTHDR1.15 R228.2 | length 1678.9
  Top Layer w4: v1@1900.14,3006.76 ccw(c1874.28,3032.62) EXTHDR1.15@1910.85,3032.62 ; v1@1902.97,3003.93 ccw(c1883.94,3022.96) EXTHDR1.15@1910.85,3022.96 ; v1@1905.8,3001.1 ccw(c1893.6,3013.3) 1910.85,3013.3 ccw(c1920.15,3013.34) v1@1913.57,3006.76 ; v1(1906.86,3000.04) 1910.85,3004.03 EXTHDR1.15@1910.85,3071.85
  Bottom Layer w4: v1(1906.86,3000.04) 1940.52,3033.71 2246.86,3033.71 2272.19,3008.37 2293.37,3008.37 2310.37,3025.37 2882.39,3025.37 2924.39,2983.37 3113.86,2983.37 3123.52,2973.71 3123.52,2941.71 3081.86,2900.04 3081.86,2820.83 3090.19,2812.5 ; v1@1906.86,3005.54 ccw(c1906.86,3018.82) 1916.25,3009.43 ccw(c1925.64,3000.04) v1@1912.36,3000.04 ; v1@1906.86,3009.54 ccw(c1906.86,3032.48) 1923.07,3016.26 ccw(c1939.29,3000.04) v1@1916.36,3000.04 ; R228.2@3095.13,2809.12 ccw(c3090.19,2807.19) 3090.19,2812.5 ; R228.2@3095.13,2815.88 cw(c3090.19,2817.81) 3090.19,2812.5 ; R228.2@3103.82,2812.5 3090.19,2812.5
JTAG.SOFT.TDO: EXTHDR1.17 R229.2 | length 1716.4
  Top Layer w4: v1(1865.19,3000.04) 1879.35,3014.2 ; EXTHDR1.17@1875.99,3019.47 cw(c1873.55,3014.21) 1879.35,3014.21 ; EXTHDR1.17@1879.35,3071.85 1879.35,3014.2 ; EXTHDR1.17@1882.72,3019.47 ccw(c1885.16,3014.21) 1879.35,3014.21
  MidLayer1 w4: v1@1858.47,2993.32 cw(c1842.26,2977.11) 1865.19,2977.11 cw(c1888.13,2977.11) v1@1871.91,2993.32 ; v1@1861.3,2996.15 cw(c1851.91,2986.76) 1865.19,2986.76 cw(c1878.47,2986.76) v1@1869.08,2996.15 ; v1(1865.19,3000.04) 1865.19,2975 1865.19,2947.67 2146.15,2666.71 v1(2229.86,2666.71) ; v1@2223.14,2659.99 ccw(c2206.92,2643.77) 2206.92,2666.71 ccw(c2206.92,2689.64) v1@2223.14,2673.43 ; v1@2225.97,2662.82 ccw(c2216.58,2653.43) 2216.58,2666.71 ccw(c2216.58,2679.99) v1@2225.97,2670.6
  Bottom Layer w4: v1(2229.86,2666.71) 2230.65,2667.5 R229.2@3103.82,2667.5 ; v1@2233.75,2662.82 cw(c2245.05,2651.52) 2245.05,2667.5 ; v1@2236.57,2659.99 cw(c2254.7,2641.86) 2254.7,2667.5 ; v1@2236.57,2673.43 ccw(c2250.88,2687.73) 2250.88,2667.5 ; R229.2@3097.23,2660.91 ccw(c3081.32,2645) 3081.32,2667.5 ccw(c3081.32,2690) R229.2@3097.23,2674.09 ; R229.2@3100.06,2663.74 ccw(c3090.98,2654.66) 3090.98,2667.5 ccw(c3090.98,2680.34) R229.2@3100.06,2671.26
JTAG.SOFT.TMS: EXTHDR1.21 R230.2 | length 1896.5
  Top Layer w4: v1@1808.47,3007.43 ccw(c1789.43,3026.47) EXTHDR1.21@1816.36,3026.47 ; v1@1811.3,3004.6 ccw(c1799.08,3016.82) EXTHDR1.21@1816.36,3016.82 ; v1(1815.19,3000.71) 1816.36,3001.88 EXTHDR1.21@1816.36,3071.85 ; EXTHDR1.21@1816.36,3020.81 ccw(c1835.3,3020.81) v1@1821.91,3007.43
  MidLayer1 w4: v1(1815.19,3000.71) 1831.33,2984.57 ; v1@1815.22,2991.21 cw(c1815.31,2968.56) 1831.32,2984.57 ; v1@1815.21,2995.21 cw(c1815.26,2982.09) 1824.53,2991.37 cw(c1833.8,3000.64) v1@1820.69,3000.69 ; v1@1824.69,3000.67 ccw(c1847.34,3000.59) 1831.32,2984.57 ; v1@3058.47,2493.32 ccw(c3042.26,2477.11) 3042.26,2500.04 ccw(c3042.26,2522.98) v1@3058.47,2506.76 ; v1@3061.3,2496.15 ccw(c3051.91,2486.76) 3051.91,2500.04 ccw(c3051.91,2513.32) v1@3061.3,2503.93 ; v1(3065.19,2500.04) 3040,2500.04 3023,2483.04 2318.51,2483.04 1831.33,2970.22 1831.33,2984.57
  Bottom Layer w4: v1(3065.19,2500.04) 3075.19,2510.04 ; 3080.57,2510.04 ccw(c3080.57,2529) R230.2@3098.73,2523.54 ; 3085.95,2510.04 ccw(c3085.95,2527.38) R230.2@3102.56,2522.39 ; 3091.33,2510.04 ccw(c3091.33,2525.76) R230.2@3106.39,2521.24 ; R230.2@3094.89,2524.69 cw(c3075.19,2530.62) 3075.19,2510.04 ; 3096.71,2510.04 ccw(c3096.71,2524.15) R230.2@3110.22,2520.08 ; 3102.09,2510.04 ccw(c3102.09,2522.53) R230.2@3114.05,2518.93 ; R230.2@3103.82,2522.5 3103.82,2510.04 3075.19,2510.04
KEYBOARD.CLOCK: R85.1 U8.AE7 | length 5132.7
  Top Layer w4: v3(5075.04,3756.93) U8.AE7@5094.72,3776.61 ; U8.AE7@5087.38,3776.61 cw(c5069.66,3776.61) 5082.19,3764.08 cw(c5094.72,3751.55) U8.AE7@5094.72,3769.27 ; 5087.84,3769.73 cw(c5075.04,3782.54) 5075.04,3764.43 ccw(c5075.04,3782.54) 5087.84,3769.73 ; 5087.84,3769.73 ccw(c5100.65,3756.93) 5082.54,3756.93 cw(c5100.65,3756.93) 5087.84,3769.73
  MidLayer1 w4: v1(4806.86,1658.37) 4823.52,1675.04 4823.52,2198.71 5021.14,2396.33 ; v1@4806.86,1663.87 ccw(c4806.86,1677.15) 4816.25,1667.76 ccw(c4825.64,1658.37) v1@4812.36,1658.37 ; v1@4806.86,1667.87 ccw(c4806.86,1690.81) 4823.08,1674.59 ccw(c4839.29,1658.37) v1@4816.36,1658.37 ; 5020,2395 5033.52,2408.52 5033.52,2740.04 4971.5,2802.06 4971.5,3150.31 4981.19,3160 4981.19,3375 5048.52,3442.33 5048.52,3541.52 5059.53,3552.53 5059.53,3605.85 5075.04,3621.35 5075.04,3630.82 5075.04,3638.82 5075.04,3679.25 v3(5075.04,3756.93) ; v3@5069.85,3751.74 cw(c5057.31,3739.2) 5075.04,3739.2 cw(c5092.77,3739.2) v3@5080.23,3751.74 ; 5075.04,3738.82 cw(c5093.15,3738.82) 5080.34,3751.63 ccw(c5093.15,3738.82) 5075.04,3738.82 ; 5075.04,3738.82 ccw(c5056.93,3738.82) 5069.74,3751.63 cw(c5056.93,3738.82) 5075.04,3738.82
  MidLayer2 w4: v1@2850.14,1048.43 ccw(c2833.92,1064.64) 2856.86,1064.64 ccw(c2879.79,1064.64) v1@2863.57,1048.43 ; v1@2852.97,1045.6 ccw(c2843.58,1054.99) 2856.86,1054.99 ccw(c2870.14,1054.99) v1@2860.75,1045.6 ; v1(2856.86,1041.71) 2856.86,1255 2892.73,1290.87 3210,1290.87 3259.83,1241.04 4083.65,1241.04 4122.33,1279.73 4230.79,1279.73 4506.64,1555.58 4506.64,1610.88 4537.13,1641.37 4789.86,1641.37 v1(4806.86,1658.37) ; v1@4797.36,1658.37 cw(c4774.42,1658.37) 4790.64,1642.16 cw(c4806.86,1625.94) v1@4806.86,1648.87 ; v1@4801.36,1658.37 cw(c4788.08,1658.37) 4797.47,1648.99 cw(c4806.86,1639.6) v1@4806.86,1652.87
  Bottom Layer w4: R85.1@2836.64,1012.08 ccw(c2820.73,1027.99) 2843.23,1027.99 ccw(c2865.73,1027.99) R85.1@2849.82,1012.08 ; R85.1@2839.47,1009.25 ccw(c2830.39,1018.33) 2843.23,1018.33 ccw(c2856.07,1018.33) R85.1@2846.99,1009.25 ; R85.1@2843.23,1005 2843.23,1028.08 v1(2856.86,1041.71)
KEYBOARD.DATA: R84.1 U8.AD8 | length 4935
  Top Layer w4: v3(5114.41,3796.3) U8.AD8@5134.09,3815.98 ; U8.AD8@5126.75,3815.98 cw(c5109.03,3815.98) 5121.56,3803.45 cw(c5134.09,3790.92) U8.AD8@5134.09,3808.64 ; 5127.21,3809.1 cw(c5114.41,3821.91) 5114.41,3803.8 ccw(c5114.41,3821.91) 5127.21,3809.1 ; 5127.21,3809.1 ccw(c5140.02,3796.3) 5121.91,3796.3 cw(c5140.02,3796.3) 5127.21,3809.1
  MidLayer1 w4: v1@4533.47,1615.09 ccw(c4517.26,1631.31) 4540.19,1631.31 ccw(c4563.13,1631.31) v1@4546.91,1615.09 ; v1@4536.3,1612.26 ccw(c4526.91,1621.65) 4540.19,1621.65 ccw(c4553.47,1621.65) v1@4544.08,1612.26 ; v1(4540.19,1608.37) 4540.19,2325.06 4527.5,2337.75 4527.5,2352.25 4540.19,2364.94 4540.19,2583.37 4640.19,2683.37 4640.19,2858.37 4765.19,2983.37 ; v1@4760.35,2991.87 cw(c4755.32,2983.38) 4765.19,2983.38 ; v1(4765.19,3000.04) 4765.19,2983.37 ; v1@4770.03,2991.87 ccw(c4775.06,2983.38) 4765.19,2983.38 ; v1@5058.28,3211.72 ccw(c5042.06,3227.93) 5065,3227.93 ccw(c5087.93,3227.93) v1@5071.72,3211.72 ; v1@5061.11,3208.89 ccw(c5051.72,3218.28) 5065,3218.28 ccw(c5078.28,3218.28) v1@5068.89,3208.89 ; v1(5065,3205) 5065,3240 5098.5,3273.5 ; 5081.86,3256.86 5098.5,3273.5 ; 5103.02,3782.72 ccw(c5112.95,3772.79) 5098.9,3772.79 5098.9,3758.86 5098.9,3698.67 5098.9,3679.25 5098.9,3638.82 5098.9,3630.82 5098.9,3616.1 5110,3605 5110,3585 5095,3570 5095,3499.96 5140.86,3454.1 5140.86,3395.36 5098.5,3353 5098.5,3273.5 ; v3@5106.94,3795.65 cw(c5088.9,3794.07) 5102.77,3782.43 cw(c5116.64,3770.79) v3@5115.06,3788.83
  MidLayer2 w4: v1@3100.14,1040.09 ccw(c3083.92,1056.31) 3106.86,1056.31 ccw(c3129.79,1056.31) v1@3113.57,1040.09 ; v1@3102.97,1037.26 ccw(c3093.58,1046.65) 3106.86,1046.65 ccw(c3120.14,1046.65) v1@3110.75,1037.26 ; v1(3106.86,1033.37) 3106.86,1186.86 3145.04,1225.04 4198.73,1225.04 4522.64,1548.95 4522.64,1590.82 v1(4540.19,1608.37) ; v1@4530.69,1608.37 cw(c4507.76,1608.37) 4523.97,1592.16 cw(c4540.19,1575.94) v1@4540.19,1598.87 ; v1@4534.69,1608.37 cw(c4521.41,1608.37) 4530.8,1598.99 cw(c4540.19,1589.6) v1@4540.19,1602.87 ; v1(4765.19,3000.04) 4847.19,3000.04 4883.59,3036.44 ; v1@4769.08,2996.15 cw(c4778.47,2986.76) 4778.47,3000.04 cw(c4778.47,3013.32) v1@4769.08,3003.93 ; v1@4771.91,2993.32 cw(c4788.13,2977.11) 4788.13,3000.04 cw(c4788.13,3022.98) v1@4771.91,3006.76 ; 4883.82,3036.44 5027.37,3180 5040,3180 v1(5065,3205) ; v1@5055.5,3205 cw(c5032.56,3205) 5048.78,3188.78 cw(c5065,3172.56) v1@5065,3195.5 ; v1@5059.5,3205 cw(c5046.22,3205) 5055.61,3195.61 cw(c5065,3186.22) v1@5065,3199.5
  Bottom Layer w4: R84.1@3099.13,1005 3099.13,1000.04 3106.86,1000.04 3106.86,1005 v1(3106.86,1033.37) ; v1@3100.14,1026.66 cw(c3083.92,1010.44) 3106.86,1010.44 cw(c3129.79,1010.44) v1@3113.57,1026.66 ; v1@3102.97,1029.49 cw(c3093.58,1020.1) 3106.86,1020.1 cw(c3120.14,1020.1) v1@3110.75,1029.49
LED1_BLUE_EXTA: R165.2 U31.4 | length 5977.9
  Top Layer w4: R165.2@-351.93,4595.17 cw(c-361.16,4583.38) -346.18,4583.38 ; R165.2@-346.18,4603 -346.18,4583.37 ; R165.2@-340.44,4595.17 ccw(c-331.2,4583.38) -346.18,4583.38 ; v1@-97.86,3880.43 ccw(c-114.08,3896.64) -91.14,3896.64 ccw(c-68.21,3896.64) v1@-84.43,3880.43 ; v1@-95.03,3877.6 ccw(c-104.42,3886.99) -91.14,3886.99 ccw(c-77.86,3886.99) v1@-87.25,3877.6 ; v1(-91.14,3873.71) -91.14,3902.54 -89,3904.69 -89,3937.16 -45,3981.16 -45,4036.25 -59.81,4051.06 -59.81,4084.13 ; -59.81,4084.81 -59.81,4084.13 ; v1(3869.19,3436.37) 3956.52,3436.37 3967.19,3425.71 3967.19,3408.23 3957.19,3398.23 U31.4@3920,3398.23 ; v1@3873.08,3432.49 cw(c3882.47,3423.1) 3882.47,3436.37 cw(c3882.47,3449.65) v1@3873.08,3440.26 ; v1@3875.91,3429.66 cw(c3892.13,3413.44) 3892.13,3436.37 cw(c3892.13,3459.31) v1@3875.91,3443.09 ; U31.4@3949.31,3395.4 cw(c3956.14,3388.57) 3956.14,3398.23 cw(c3956.14,3407.89) U31.4@3949.31,3401.06 ; -346.18,4583.37 -326.48,4563.67 -326.48,4530 -316.48,4520 -240,4520 -205,4555 -120,4555 -110,4545 -110,4470 -29,4389 -29,4114.94 -59.81,4084.13
  Bottom Layer w4: v1@-91.14,3864.21 cw(c-91.14,3841.27) -74.93,3857.49 cw(c-58.71,3873.71) v1@-81.64,3873.71 ; v1@-91.14,3868.21 cw(c-91.14,3854.93) -81.75,3864.32 cw(c-72.36,3873.71) v1@-85.64,3873.71 ; v1(-91.14,3873.71) -42.48,3825.04 6.86,3825.04 23.52,3808.37 23.52,3586.48 40,3570 108.88,3570 198.52,3480.35 198.52,3400 198.52,3377.98 226.46,3350.04 1181.86,3350.04 1206.86,3325.04 1773.52,3325.04 1781.86,3316.71 3821.71,3316.71 3869.19,3364.19 v1(3869.19,3436.37) ; v1@3862.47,3429.66 cw(c3846.26,3413.44) 3869.19,3413.44 cw(c3892.13,3413.44) v1@3875.91,3429.66 ; v1@3865.3,3432.49 cw(c3855.91,3423.1) 3869.19,3423.1 cw(c3882.47,3423.1) v1@3873.08,3432.49
LED1_GREEN_EXTA: R166.2 U31.6 | length 6519.2
  Top Layer w4: v1(-365,4665) -365,4661.52 v1@-367.52,4659 ; v1@-359.6,4666.05 ccw(c-351.04,4667.73) R166.2@-351.04,4659 ; R166.2@-355.68,4666.82 ccw(c-346.18,4668.67) R166.2@-346.18,4659 v1@-367.52,4659 ; v1@-251.72,3996.43 ccw(c-267.94,4012.64) -245,4012.64 ccw(c-222.07,4012.64) v1@-238.28,3996.43 ; v1@-248.89,3993.6 ccw(c-258.28,4002.99) -245,4002.99 ccw(c-231.72,4002.99) v1@-241.11,3993.6 ; v1(-245,3989.71) -245,4090 -235,4100 v1@-225,4100 ; U31.6@3920,3347.05 v1(3970.19,3347.04) ; U31.6@3947.24,3347.05 cw(c3947.24,3324.09) v1@3963.47,3340.32 ; U31.6@3947.27,3347.05 ccw(c3947.27,3369.96) v1@3963.47,3353.76 ; U31.6@3949.31,3344.22 cw(c3956.14,3337.39) 3956.14,3347.05 cw(c3956.14,3356.71) U31.6@3949.31,3349.88 ; 3956.9,3347.05 cw(c3956.9,3333.75) v1@3966.3,3343.15 ; 3956.93,3347.05 ccw(c3956.93,3360.3) v1@3966.3,3350.93 ; v1@-367.52,4659 -376.48,4650.04 v1@-367.52,4659
  MidLayer1 w4: v1@-370.76,4657.44 cw(c-379.62,4645.82) -365,4645.82 ; v1(-365,4665) -365,4645.81 ; v1@-359.24,4657.44 ccw(c-350.38,4645.82) -365,4645.82 ; v1(-356.73,4099.58) -324.42,4099.58 -319,4105 -319,4349 -362.5,4392.5 -362.5,4437.75 -309.62,4490.63 -309.62,4589.37 -310.16,4589.91 ; v1@-352.84,4095.69 cw(c-343.45,4086.31) -343.45,4099.58 cw(c-343.45,4112.86) v1@-352.84,4103.47 ; v1@-350.01,4092.87 cw(c-333.79,4076.65) -333.79,4099.58 cw(c-333.79,4122.52) v1@-350.01,4106.3 ; -309.62,4590.44 -365,4645.81
  MidLayer2 w4: v1(-356.73,4099.58) -356.31,4100 v1@-220,4100 ; v1@-352.84,4095.69 cw(c-342.44,4085.3) -342.44,4100 ; v1@-352.84,4103.47 ccw(c-344.45,4111.86) -344.45,4100 ; v1@-350.01,4092.87 cw(c-332.79,4075.64) -332.79,4100 ; v1@-350.01,4106.3 ccw(c-334.8,4121.51) -334.8,4100 ; -245.35,4100 ccw(c-245.35,4126.35) v1@-226.72,4107.72 ; v1(-245,3989.71) -71.02,3989.71 -29.19,3947.87 802.36,3947.87 805,3945.23 1704.77,3945.23 1723.52,3926.48 1723.52,3291.71 1748.52,3266.71 2048.52,3266.71 v1(2073.52,3291.71) ; v1@-241.11,3985.82 cw(c-231.72,3976.43) -231.72,3989.71 cw(c-231.72,4002.99) v1@-241.11,3993.6 ; -240.52,4100 cw(c-240.52,4080.48) v1@-226.72,4094.28 ; v1@-238.28,3982.99 cw(c-222.07,3966.77) -222.07,3989.71 cw(c-222.07,4012.64) v1@-238.28,3996.43 ; -235.69,4100 ccw(c-235.69,4116.69) v1@-223.89,4104.89 ; v1@2064.02,3291.71 cw(c2041.09,3291.71) 2057.31,3275.49 cw(c2073.52,3259.27) v1@2073.52,3282.21 ; v1@2068.02,3291.71 cw(c2054.75,3291.71) 2064.14,3282.32 cw(c2073.52,3272.93) v1@2073.52,3286.21
  Bottom Layer w4: v1(2073.52,3291.71) 2090.19,3308.37 3931.52,3308.37 v1(3970.19,3347.04) ; v1@2073.52,3297.21 ccw(c2073.52,3310.49) 2082.91,3301.1 ccw(c2092.3,3291.71) v1@2079.02,3291.71 ; v1@2073.52,3301.21 ccw(c2073.52,3324.14) 2089.74,3307.93 ccw(c2105.96,3291.71) v1@2083.02,3291.71 ; v1@3960.69,3347.04 cw(c3937.76,3347.04) 3953.97,3330.82 cw(c3970.19,3314.61) v1@3970.19,3337.54 ; v1@3964.69,3347.04 cw(c3951.41,3347.04) 3960.8,3337.65 cw(c3970.19,3328.26) v1@3970.19,3341.54
  other v1: -220,4101
LED1_RED_EXTA: R164.2 U31.2 | length 6247.6
  Top Layer w4: v1(-376.48,4708.37) -369.85,4715 R164.2@-346.18,4715 ccw(c-346.18,4687.98) v1@-368.6,4703.07 ; v1@-375.23,4707.54 cw(c-361.21,4698.1) -361.21,4715 ; v1@-371.91,4705.3 cw(c-353.7,4693.04) R164.2@-353.7,4715 ; R164.2@-349.94,4711.24 ccw(c-359.02,4702.16) -359.02,4715 ccw(c-359.02,4727.84) R164.2@-349.94,4718.76 ; v1@3866.81,3493.32 cw(c3850.59,3477.11) 3873.52,3477.11 cw(c3896.46,3477.11) v1@3880.24,3493.32 ; v1@3869.64,3496.15 cw(c3860.25,3486.76) 3873.52,3486.76 cw(c3886.8,3486.76) v1@3877.41,3496.15 ; v1(3873.52,3500.04) 3873.52,3461.4 3885.52,3449.41 ; U31.2@3890.32,3447.01 ccw(c3885.52,3443.41) 3885.52,3449.41 ; U31.2@3890.32,3451.81 cw(c3885.52,3455.41) 3885.52,3449.41 ; U31.2@3920,3449.41 3885.52,3449.41
  MidLayer1 w4: v1@-376.48,4698.87 cw(c-376.48,4675.94) -360.26,4692.16 cw(c-344.04,4708.37) v1@-366.98,4708.37 ; v1@-376.48,4702.87 cw(c-376.48,4689.6) -367.09,4698.99 cw(c-357.7,4708.37) v1@-370.98,4708.37 ; v1(-376.48,4708.37) -345,4676.9 -345,4637.13 -301.62,4593.75 -301.62,4487.31 -354.5,4434.44 -354.5,4395.81 -311,4352.31 -311,3998.61 -309.23,3996.83 -309.23,3887 -316.23,3880 -340,3880 v1(-350,3890)
  MidLayer2 w4: v1(-350,3890) -340,3880 -140,3880 -118.24,3858.24 -110.04,3850.04 v1(-28.14,3850.04) ; v1@-34.86,3843.32 ccw(c-51.08,3827.11) -51.08,3850.04 ccw(c-51.08,3872.98) v1@-34.86,3856.76 ; v1@-32.03,3846.15 ccw(c-41.42,3836.76) -41.42,3850.04 ccw(c-41.42,3863.32) v1@-32.03,3853.93
  Bottom Layer w4: v1(-28.14,3850.04) 11.52,3850.04 31.86,3829.71 31.86,3675.04 48.52,3658.37 98.52,3658.37 115.19,3641.71 115.19,3575 206.86,3483.33 206.86,3380.96 229.78,3358.04 1185.17,3358.04 1210.17,3333.04 1776.84,3333.04 1784.84,3325.04 3818.73,3325.04 3861.19,3367.5 3861.19,3391.19 3845,3407.38 3845,3471.52 v1(3873.52,3500.04) ; v1@-24.25,3846.15 cw(c-14.86,3836.76) -14.86,3850.04 cw(c-14.86,3863.32) v1@-24.25,3853.93 ; v1@-21.43,3843.32 cw(c-5.21,3827.11) -5.21,3850.04 cw(c-5.21,3872.98) v1@-21.43,3856.76 ; v1@3864.02,3500.04 cw(c3841.09,3500.04) 3857.31,3483.82 cw(c3873.52,3467.61) v1@3873.52,3490.54 ; v1@3868.02,3500.04 cw(c3854.75,3500.04) 3864.14,3490.65 cw(c3873.52,3481.26) v1@3873.52,3494.54
LED2_BLUE_EXTA: R168.2 U31.10 | length 6747.9
  Top Layer w4: R168.2@-346.18,4425.19 cw(c-346.18,4401.5) -329.43,4418.25 ; R168.2@-346.18,4429.19 cw(c-346.18,4415.16) R168.2@-336.26,4425.08 ; R168.2@-346.18,4435 -326.18,4415 -66.31,4415 -37,4385.69 -37,4163 -100,4100 -100,4075 -85,4060 v1(-85,4040) v1@-80,4045 ; R168.2@-340.86,4434.51 ccw(c-329.21,4434.51) R168.2@-337.45,4426.27 ; R168.2@-336.86,4434.51 ccw(c-315.55,4434.51) -330.62,4419.44 ; v1@-91,4047.36 ccw(c-101.3,4060) -85,4060 ccw(c-68.7,4060) v1@-79,4047.36 ; v1@-88.47,4044.26 ccw(c-94.44,4051.58) -85,4051.58 ccw(c-75.56,4051.58) v1@-81.53,4044.26 ; v1(4090.19,3394.71) 4090.19,3379.81 4097.36,3372.64 U31.10@4138.5,3372.64 ; U31.10@4109.2,3369.81 ccw(c4102.37,3362.98) 4102.37,3372.64 ccw(c4102.37,3382.29) U31.10@4109.2,3375.47
  MidLayer1 w4: v1@2507.14,4171.99 cw(c2490.92,4155.77) 2513.86,4155.77 cw(c2536.79,4155.77) v1@2520.57,4171.99 ; v1@2509.97,4174.82 cw(c2500.58,4165.43) 2513.86,4165.43 cw(c2527.14,4165.43) v1@2517.75,4174.82 ; v1(2513.86,4178.71) 2513.86,4149.67 2523.52,4140 v1(2523.52,3425.04) ; v1@2516.81,3431.76 ccw(c2500.59,3447.98) 2523.52,3447.98 ccw(c2546.46,3447.98) v1@2530.24,3431.76 ; v1@2519.64,3428.93 ccw(c2510.25,3438.32) 2523.52,3438.32 ccw(c2536.8,3438.32) v1@2527.41,3428.93
  MidLayer2 w4: v1@-83.94,4038.94 cw(c-69.31,4024.31) -69.31,4045 ; v1@-81.52,4045 19.96,4045 25,4050.04 2488.86,4050.04 2513.86,4075.04 v1(2513.86,4178.71) ; v1@-81.11,4036.11 cw(c-59.65,4014.65) -59.65,4045 ; v1@-78.28,4033.28 cw(c-49.99,4004.99) -49.99,4045 ; v1@-78.28,4046.72 ccw(c-74.14,4050.86) -74.14,4045 ; v1@2507.14,4171.99 cw(c2490.92,4155.77) 2513.86,4155.77 cw(c2536.79,4155.77) v1@2520.57,4171.99 ; v1@2509.97,4174.82 cw(c2500.58,4165.43) 2513.86,4165.43 cw(c2527.14,4165.43) v1@2517.75,4174.82 ; v1@2516.81,3418.32 cw(c2500.59,3402.11) 2523.52,3402.11 cw(c2546.46,3402.11) v1@2530.24,3418.32 ; v1@2519.64,3421.15 cw(c2510.25,3411.76) 2523.52,3411.76 cw(c2536.8,3411.76) v1@2527.41,3421.15 ; v1(2523.52,3425.04) 2523.52,3391.71 2498.52,3366.71 2448.52,3366.71 2440.19,3375.04 2405.86,3375.04 2390.19,3359.37 2390.19,3349.04 2405.86,3333.37 2973.52,3333.37 3015.19,3375.04 3015.19,3441.71 3031.86,3458.37 3934.86,3458.37 3998.52,3394.71 v1(4090.19,3394.71) ; v1@4083.47,3387.99 ccw(c4067.26,3371.77) 4067.26,3394.71 ccw(c4067.26,3417.64) v1@4083.47,3401.43 ; v1@4086.3,3390.82 ccw(c4076.91,3381.43) 4076.91,3394.71 ccw(c4076.91,3407.99) v1@4086.3,3398.6
LED2_GREEN_EXTA: R169.2 U31.12 | length 6939.9
  Top Layer w4: v1@-416.53,3659.99 ccw(c-432.74,3643.77) -432.74,3666.71 ccw(c-432.74,3689.64) v1@-416.53,3673.43 ; v1@-413.7,3662.82 ccw(c-423.09,3653.43) -423.09,3666.71 ccw(c-423.09,3679.99) v1@-413.7,3670.6 ; v1(-409.81,3666.71) -451.71,3666.71 -469,3684 -469,4481 -459,4491 R169.2@-346.18,4491 ; R169.2@-352.77,4484.41 ccw(c-368.68,4468.5) -368.68,4491 ccw(c-368.68,4513.5) R169.2@-352.77,4497.59 ; R169.2@-349.94,4487.24 ccw(c-359.02,4478.16) -359.02,4491 ccw(c-359.02,4503.84) R169.2@-349.94,4494.76 ; v1(4011.86,3416.71) 4045.19,3450.04 4078.97,3450.04 4105.19,3423.82 ; v1@4011.86,3422.21 ccw(c4011.86,3435.49) 4021.25,3426.1 ccw(c4030.64,3416.71) v1@4017.36,3416.71 ; v1@4011.86,3426.21 ccw(c4011.86,3449.14) 4028.07,3432.93 ccw(c4044.29,3416.71) v1@4021.36,3416.71 ; 4093.53,3435.48 ccw(c4112.02,3453.97) U31.12@4112.02,3427.82 ; 4100.36,3428.65 ccw(c4112.02,3440.32) U31.12@4112.02,3423.82 ; U31.12@4108.54,3421.86 ccw(c4105.19,3419.98) 4105.19,3423.82 ; U31.12@4108.54,3425.78 cw(c4105.19,3427.66) 4105.19,3423.82 ; U31.12@4138.5,3423.82 4105.19,3423.82
  Bottom Layer w4: v1@-416.53,3659.99 cw(c-432.74,3643.77) -409.81,3643.77 cw(c-386.87,3643.77) v1@-403.09,3659.99 ; v1@-413.7,3662.82 cw(c-423.09,3653.43) -409.81,3653.43 cw(c-396.53,3653.43) v1@-405.92,3662.82 ; v1(-409.81,3666.71) -409.81,3625.19 -434.5,3600.5 -609.1,3600.5 -638.26,3571.34 -638.26,3560.5 -627.5,3549.73 -627.5,3509.65 -602.85,3485 -157.43,3485 -148.22,3494.21 -20.79,3494.21 47,3562 105.56,3562 190.19,3477.37 190.19,3375 223.15,3342.04 1178.54,3342.04 1279.58,3241 1674.94,3241 1683.65,3249.71 2743,3249.71 2760,3266.71 2793.29,3266.71 2868.96,3191.04 3966.04,3191.04 3975,3200 3975,3269.46 3998.52,3292.98 3998.52,3320.96 4011.86,3334.29 v1(4011.86,3416.71) ; v1@4005.14,3409.99 cw(c3988.92,3393.77) 4011.86,3393.77 cw(c4034.79,3393.77) v1@4018.57,3409.99 ; v1@4007.97,3412.82 cw(c3998.58,3403.43) 4011.86,3403.43 cw(c4025.14,3403.43) v1@4015.75,3412.82
LED2_RED_EXTA: R167.2 U31.8 | length 6347.9
  Top Layer w4: v1@-360.33,4525.5 ccw(c-372.02,4539.06) R167.2@-354.12,4539.06 ; v1@-357.72,4522.48 ccw(c-364.49,4530.32) -354.12,4530.32 ccw(c-343.76,4530.32) v1@-350.53,4522.48 ; v1(-354.12,4518.31) R167.2@-354.12,4539.06 ; R167.2@-354.12,4537.58 cw(c-341.24,4537.58) R167.2@-347.48,4548.85 ; v1@-347.92,4525.5 cw(c-336.23,4539.06) R167.2@-354.12,4539.06 ; R167.2@-346.18,4547 R167.2@-354.12,4539.06 ; v1@4058.47,3423.99 cw(c4042.26,3407.77) 4065.19,3407.77 cw(c4088.13,3407.77) v1@4071.91,3423.99 ; v1@4061.3,3426.82 cw(c4051.91,3417.43) 4065.19,3417.43 cw(c4078.47,3417.43) v1@4069.08,3426.82 ; v1(4065.19,3430.71) 4065.19,3321.04 4071.77,3314.46 4100,3314.46 4107,3321.46 U31.8@4138.5,3321.46 ; 4103.86,3318.31 cw(c4111.48,3310.69) U31.8@4112.02,3321.46
  MidLayer1 w4: v1@2908.47,3448.43 ccw(c2892.26,3464.64) 2915.19,3464.64 ccw(c2938.13,3464.64) v1@2921.91,3448.43 ; v1@2911.3,3445.6 ccw(c2901.91,3454.99) 2915.19,3454.99 ccw(c2928.47,3454.99) v1@2919.08,3445.6 ; v1(2915.19,3441.71) 2915.19,3485.19 2923.52,3493.52 v1(2923.52,4175) ; v1@2916.81,4168.28 cw(c2900.59,4152.06) 2923.52,4152.06 cw(c2946.46,4152.06) v1@2930.24,4168.28 ; v1@2919.64,4171.11 cw(c2910.25,4161.72) 2923.52,4161.72 cw(c2936.8,4161.72) v1@2927.41,4171.11
  MidLayer2 w4: v1@-360.84,4511.59 cw(c-377.06,4495.38) -354.12,4495.38 cw(c-331.19,4495.38) v1@-347.41,4511.59 ; v1@-358.01,4514.42 cw(c-367.4,4505.03) -354.12,4505.03 cw(c-340.85,4505.03) v1@-350.24,4514.42 ; v1(-354.12,4518.31) -354.12,4468.69 -218.81,4333.37 462.52,4333.37 520.86,4391.71 1351.51,4391.71 1384.84,4358.37 1510,4358.37 1543.67,4392.04 2556.52,4392.04 2623.52,4325.04 2623.52,4172.06 2637.21,4158.37 2878.86,4158.37 2895.48,4175 v1(2923.52,4175) ; v1(2915.19,3441.71) 2931.86,3458.37 2931.86,3516.71 2965.19,3550.04 3969.96,3550.04 4065.19,3454.81 v1(4065.19,3430.71) ; v1@2915.19,3447.21 ccw(c2915.19,3460.49) 2924.58,3451.1 ccw(c2933.97,3441.71) v1@2920.69,3441.71 ; v1@2915.19,3451.21 ccw(c2915.19,3474.14) 2931.41,3457.93 ccw(c2947.63,3441.71) v1@2924.69,3441.71 ; v1@2916.81,4168.28 ccw(c2900.59,4152.06) 2900.59,4175 ccw(c2900.59,4197.93) v1@2916.81,4181.72 ; v1@2919.64,4171.11 ccw(c2910.25,4161.72) 2910.25,4175 ccw(c2910.25,4188.28) v1@2919.64,4178.89 ; v1@4058.47,3437.43 ccw(c4042.26,3453.64) 4065.19,3453.64 ccw(c4088.13,3453.64) v1@4071.91,3437.43 ; v1@4061.3,3434.6 ccw(c4051.91,3443.99) 4065.19,3443.99 ccw(c4078.47,3443.99) v1@4069.08,3434.6
LED_PGM: LED2.2 R40.2 | length 297.9
  Top Layer w4: v1(7890.19,2116.71) 7903.47,2129.98 ; LED2.2@7892.97,2150.77 cw(c7877.64,2129.98) 7903.47,2129.98 ; LED2.2@7895.34,2153.99 cw(c7883.48,2137.9) 7903.47,2137.9 cw(c7923.45,2137.9) LED2.2@7911.59,2153.99 ; LED2.2@7903.47,2165 7903.47,2129.98 ; LED2.2@7913.96,2150.77 ccw(c7929.29,2129.98) 7903.47,2129.98
  Bottom Layer w4: v1(7890.19,2116.71) 7941.18,2116.71 7951.18,2106.71 ; v1@7894.08,2112.82 cw(c7903.47,2103.43) 7903.47,2116.71 cw(c7903.47,2129.99) v1@7894.08,2120.6 ; v1@7896.91,2109.99 cw(c7913.13,2093.77) 7913.13,2116.71 cw(c7913.13,2139.64) v1@7896.91,2123.43 ; R40.2@7946.49,2098.54 ccw(c7941.73,2106.71) 7951.18,2106.71 ; R40.2@7951.18,2090 7951.18,2106.71 ; R40.2@7955.87,2098.54 cw(c7960.63,2106.71) 7951.18,2106.71