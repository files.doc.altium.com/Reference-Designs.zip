# Altium PCB NB3000AL.PcbDoc (part 33 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_D21: U8.AA26 U13.10 U17.14 U61.66 | length 3371.1
  Top Layer w4: U8.AA26@5842.76,3926.75 cw(c5842.76,3909.03) 5855.29,3921.56 ; U8.AA26@5850.1,3934.09 ccw(c5867.82,3934.09) 5855.29,3921.56 ; 6000.16,3909.6 6027.06,3882.7 ; 6108.25,3864.5 6105,3864.5 ; U17.14@6170.59,4561.26 6215,4561.26 ; U13.10@6188.15,3882.98 cw(c6188.15,3857) 6206.53,3875.37 ; U13.10@6188.15,3886.98 cw(c6188.15,3870.65) 6199.7,3882.2 ; U17.14@6193.81,4555.6 cw(c6207.46,4541.95) 6207.46,4561.26 cw(c6207.46,4580.57) U17.14@6193.81,4566.92 ; U13.10@6196.15,3890.98 ccw(c6208.79,3890.98) 6199.85,3882.05 ; 6274.39,3841.54 ccw(c6274.39,3879.84) v1@6301.47,3852.76 ; v1@6275.14,2878.32 cw(c6266.64,2869.82) 6278.66,2869.82 ; U61.66@6275.83,2853.36 ccw(c6269,2860.19) 6278.66,2860.19 ccw(c6288.32,2860.19) U61.66@6281.49,2853.36 ; U61.66@6278.66,2837.34 v1@6278.66,2881.84 ; U61.66@6278.66,2854.39 cw(c6312.51,2854.39) v1@6288.57,2878.32 ; 6278.66,2864.04 cw(c6302.85,2864.04) v1@6285.75,2881.15 ; 6278.66,2873.7 cw(c6293.2,2873.7) v1@6282.92,2883.98 ; 6284.05,3841.54 ccw(c6284.05,3870.18) v1@6304.3,3849.93 ; 6293.71,3841.54 ccw(c6293.71,3860.53) v1@6307.13,3847.1 ; 6296.12,3841.54 cw(c6296.12,3833.97) v1@6301.47,3839.32 ; v1(6308.19,3846.04) 6303.69,3841.54 6243.97,3841.54 6225.51,3860 6225.51,3863.62 6214.09,3875.04 6206.86,3875.04 6190.91,3890.98 U13.10@6170.59,3890.98 6135.13,3890.98 6108.65,3864.5 6105,3864.5 ; v1@6308.28,4528.28 ccw(c6292.06,4512.06) 6292.06,4535 ccw(c6292.06,4557.93) 6308.28,4541.72 v1(6315,4535) 6265,4535 6258.29,4541.71 6238.74,4561.26 6220.64,4561.26 ; v1@6311.11,4531.11 ccw(c6301.72,4521.72) 6301.72,4535 ccw(c6301.72,4548.28) v1@6311.11,4538.89 ; v1@6352.69,3866.71 ccw(c6329.76,3866.71) 6345.97,3882.93 ccw(c6362.19,3899.14) v1@6362.19,3876.21 ; v1@6356.69,3866.71 ccw(c6343.41,3866.71) 6352.8,3876.1 ccw(c6362.19,3885.49) v1@6362.19,3872.21 ; v1@6356.86,4532.21 cw(c6356.86,4509.27) 6373.07,4525.49 cw(c6389.29,4541.71) v1@6366.36,4541.71 ; v1@6356.86,4536.21 cw(c6356.86,4522.93) 6366.25,4532.32 cw(c6375.64,4541.71) v1@6362.36,4541.71 ; v1(6356.86,4541.71) 6373.36,4525.21 6382.36,4516.2 6382.36,4444.48 6375,4437.12 6375,4405 6375,4377.37 6403.5,4348.87 6403.5,4346.5 6403.5,4335 6403.5,4289.5 6354.5,4240.5 6354.5,4199.5 6356.36,4197.64 6356.36,4064.28 6356.5,4064.14 6356.5,4027.81 6345.91,4017.22 6345.91,3980.09 6339.36,3973.54 6339.36,3934.46 6343.81,3930.01 6343.81,3885.09 v1(6362.19,3866.71) ; 5855.29,3921.56 ccw(c5882.64,3948.91) 5882.64,3910.23 5941.18,3910.23 5949.7,3910.2 5999.56,3910.2 6027.06,3882.7 ; 6027.06,3882.7 6047.36,3882.7 6057.17,3872.89 6079.61,3872.89 6088,3864.5 6105,3864.5 ; 6215,4561.26 6220.64,4561.26 ; 6215,4561.26 6220.64,4561.26
  MidLayer1 w4: v1@6275.14,2891.76 ccw(c6258.92,2907.98) 6281.86,2907.98 ccw(c6304.79,2907.98) v1@6288.57,2891.76 ; v1@6277.97,2888.93 ccw(c6268.58,2898.32) 6281.86,2898.32 ccw(c6295.14,2898.32) v1@6285.75,2888.93 ; v1(6281.86,2885.04) 6281.86,2928.39 6310,2956.54 6329.52,2976.04 6329.52,3065.85 6305.19,3090.18 6305.19,3229.57 6338.86,3263.23 6338.86,3321.73 6351.19,3334.06 6351.19,3405.71 6333.36,3423.54 6333.36,3557.15 6340.69,3564.48 6340.69,3632.81 6314.19,3659.31 6314.19,3753.04 6297.69,3769.54 6297.69,3795 6308.19,3805.5 v1(6308.19,3846.04) ; v1@6301.47,3839.32 cw(c6285.26,3823.11) 6308.19,3823.11 cw(c6331.13,3823.11) v1@6314.91,3839.32 ; v1@6304.3,3842.15 cw(c6294.91,3832.76) 6308.19,3832.76 cw(c6321.47,3832.76) v1@6312.08,3842.15 ; v1@6321.71,4541.71 v1(6315,4535) 6328.29,4535 6335,4541.71 ; v1@6349.91,4535.23 ccw(c6335,4521.32) 6335,4541.71 ; v1@6349.91,4548.19 cw(c6335,4562.1) 6335,4541.71 ; v1@6352.84,4537.96 ccw(c6344.2,4529.9) 6344.2,4541.71 ccw(c6344.2,4553.51) v1@6352.84,4545.46 ; v1(6356.86,4541.71) 6335,4541.71
  MidLayer2 w4: v1(6308.19,3846.04) 6328.86,3866.71 v1(6362.19,3866.71) ; v1@6308.19,3851.54 ccw(c6308.19,3864.82) 6317.58,3855.43 ccw(c6326.97,3846.04) v1@6313.69,3846.04 ; v1@6308.19,3855.54 ccw(c6308.19,3878.48) 6324.41,3862.26 ccw(c6340.63,3846.04) v1@6317.69,3846.04 ; v1@6355.47,3859.99 ccw(c6339.26,3843.77) 6339.26,3866.71 ccw(c6339.26,3889.64) v1@6355.47,3873.43 ; v1@6358.3,3862.82 ccw(c6348.91,3853.43) 6348.91,3866.71 ccw(c6348.91,3879.99) v1@6358.3,3870.6
DB_MEM.BUS_D22: U8.AB28 U13.11 U17.15 U61.68 | length 3266.2
  Top Layer w4: U8.AB28@5921.5,3894.72 5964.72,3894.72 5971.6,3901.6 5996.85,3901.6 6023.75,3874.7 6044.05,3874.7 6054.33,3864.42 6076.77,3864.42 6085.19,3856 6118.7,3856 6122.19,3859.49 ; 6122.19,3859.71 6122.19,3859.49 ; U13.11@6147.37,3853.83 ccw(c6133.72,3840.17) 6133.72,3859.49 ccw(c6133.72,3878.8) U13.11@6147.37,3865.15 ; U17.15@6170.59,4529.76 6238.14,4529.76 v1(6284.52,4483.37) ; U13.11@6177.56,3859.49 cw(c6177.56,3825.92) v1@6201.29,3849.66 ; U13.11@6187.22,3859.49 cw(c6187.22,3835.58) v1@6204.12,3852.49 ; U13.11@6192.59,3859.49 ccw(c6192.59,3871.8) v1@6201.29,3863.09 ; U17.15@6193.81,4524.11 cw(c6207.46,4510.45) 6207.46,4529.76 cw(c6207.46,4549.08) U17.15@6193.81,4535.42 ; U13.11@6196.87,3859.49 cw(c6196.87,3845.24) v1@6206.95,3855.31 ; v1@6204.9,3859.49 U13.11@6170.59,3859.49 6122.19,3859.49 ; U61.68@6236.46,2853.36 ccw(c6229.63,2860.19) 6239.29,2860.19 ccw(c6248.95,2860.19) U61.68@6242.12,2853.36 ; v1@6236.81,2931.99 cw(c6230.81,2925.99) 6239.29,2925.99 ; U61.68@6239.29,2837.34 v1@6239.29,2934.47 ; 6239.29,2905.55 cw(c6276.68,2905.55) v1@6250.24,2931.99 ; 6239.29,2915.21 cw(c6267.02,2915.21) v1@6247.41,2934.82 ; 6239.29,2924.86 cw(c6257.37,2924.86) v1@6244.58,2937.65 ; v1@6275.02,4483.37 ccw(c6252.09,4483.37) 6268.31,4499.59 ccw(c6284.52,4515.81) v1@6284.52,4492.87 ; v1@6279.02,4483.37 ccw(c6265.75,4483.37) 6275.14,4492.76 ccw(c6284.52,4502.15) v1@6284.52,4488.87 ; v1@6352.01,4449.8 cw(c6337.76,4434.69) 6358.52,4434.69 ; v1@6352.69,3836.37 ccw(c6329.76,3836.37) 6345.97,3852.59 ccw(c6362.19,3868.81) v1@6362.19,3845.87 ; v1@6354.75,4452.71 cw(c6346.5,4443.96) 6358.52,4443.96 cw(c6370.55,4443.96) v1@6362.3,4452.71 ; v1@6356.69,3836.37 ccw(c6343.41,3836.37) 6352.8,3845.76 ccw(c6362.19,3855.15) v1@6362.19,3841.87 ; v1(6358.52,4456.71) 6358.52,4434.69 ; v1(6362.19,3836.37) 6333.81,3864.75 6333.81,3928.69 6331.36,3931.15 6331.36,3978.87 6337.91,3985.43 6337.91,4020.53 6348.5,4031.12 6348.5,4060.83 6348.36,4060.97 6348.36,4194.33 6346.5,4196.18 6346.5,4243.82 6395.5,4292.82 6395.5,4305 6395.5,4345.56 6395,4346.06 6367,4374.06 6367,4385 6367,4400 6367,4426.21 6365.36,4427.86 6358.52,4434.69 ; v1@6365.04,4449.8 ccw(c6379.29,4434.69) 6358.52,4434.69 ; 5939.22,3894.72 ccw(c5939.22,3877) 5926.69,3889.53 cw(c5939.22,3877) 5939.22,3894.72 ; 5939.22,3894.72 cw(c5939.22,3912.45) 5926.69,3899.92 ccw(c5939.22,3912.45) 5939.22,3894.72
  MidLayer1 w4: v1@6208.01,3846.87 cw(c6208.01,3823.94) 6224.23,3840.16 cw(c6240.44,3856.38) v1@6217.51,3856.38 ; v1@6208.01,3850.88 cw(c6208.01,3837.6) 6217.4,3846.99 cw(c6226.79,3856.38) v1@6213.51,3856.38 ; v1(6208.01,3856.38) 6226.38,3838 6232.56,3838 6255.13,3815.44 6267.53,3803.03 6267.53,3765.76 6290.19,3743.1 6290.19,3643.77 6292.02,3641.94 6292.02,3618.79 6189.36,3516.13 6189.36,3384.2 6198.52,3375.04 6198.52,3282.54 6255.5,3225.56 6255.5,3021.98 6243.52,3010 v1(6243.52,2938.71) ; v1@6236.81,2945.43 ccw(c6220.59,2961.64) 6243.52,2961.64 ccw(c6266.46,2961.64) v1@6250.24,2945.43 ; v1@6239.64,2942.6 ccw(c6230.25,2951.99) 6243.52,2951.99 ccw(c6256.8,2951.99) v1@6247.41,2942.6
  MidLayer2 w4: v1(6208.01,3856.38) 6228.19,3856.38 ; v1@6212.25,3852.87 cw(c6219.69,3846.71) 6219.69,3856.38 cw(c6219.69,3866.04) v1@6212.25,3859.88 ; v1@6215.33,3850.32 cw(c6228.19,3839.69) 6228.19,3856.38 ; v1@6215.33,3862.43 ccw(c6228.19,3873.06) 6228.19,3856.37 ; v1(6284.52,4483.37) 6331.86,4483.37 v1(6358.52,4456.71) ; v1@6288.41,4479.49 cw(c6297.8,4470.1) 6297.8,4483.37 cw(c6297.8,4496.65) v1@6288.41,4487.26 ; v1@6291.24,4476.66 cw(c6307.46,4460.44) 6307.46,4483.37 cw(c6307.46,4506.31) v1@6291.24,4490.09 ; v1@6349.02,4456.71 ccw(c6326.09,4456.71) 6342.31,4472.93 ccw(c6358.52,4489.14) v1@6358.52,4466.21 ; v1@6353.02,4456.71 ccw(c6339.75,4456.71) 6349.14,4466.1 ccw(c6358.52,4475.49) v1@6358.52,4462.21 ; v1@6355.47,3829.66 ccw(c6339.26,3813.44) 6339.26,3836.37 ccw(c6339.26,3859.31) v1@6355.47,3843.09 ; v1@6358.3,3832.49 ccw(c6348.91,3823.1) 6348.91,3836.37 ccw(c6348.91,3849.65) v1@6358.3,3840.26 ; v1(6362.19,3836.37) 6336.33,3836.37 6328.5,3828.54 6270.4,3828.54 6249.38,3849.57 6235,3849.57 6228.19,3856.38
DB_MEM.BUS_D23: U8.AB26 U13.13 U17.16 U61.69 | length 3348.8
  Top Layer w4: 6135.16,3787.16 cw(c6148.92,3773.39) U13.13@6152.33,3792.56 ; 6140.58,3792.58 cw(c6150.56,3782.6) U13.13@6153.03,3796.5 ; U13.13@6156.86,3796.5 U13.13@6170.59,3796.5 ; U17.16@6170.59,4498.27 6245.05,4498.27 6267.02,4476.29 6267.02,4476.13 6277.28,4465.87 6277.44,4465.87 6341.36,4401.96 6343,4400.31 6343,4344.52 6342.52,4344.04 ; U17.16@6193.81,4492.61 cw(c6207.46,4478.95) 6207.46,4498.27 cw(c6207.46,4517.58) U17.16@6193.81,4503.92 ; U13.13@6195.06,3792.47 cw(c6202.07,3788.39) 6202.07,3796.5 ; U13.13@6195.06,3800.52 ccw(c6202.07,3804.6) 6202.07,3796.5 ; v1@6212.47,2806.76 ccw(c6195.25,2823.98) U61.69@6219.6,2823.98 ; v1@6215.19,2804.04 v1(6219.19,2800.04) 6219.6,2800.46 U61.69@6219.6,2837.34 ; v1@6215.3,2803.93 ccw(c6204.91,2814.32) 6219.6,2814.32 ; U61.69@6216.78,2821.32 cw(c6209.95,2814.49) 6219.6,2814.49 cw(c6229.26,2814.49) U61.69@6222.43,2821.32 ; 6219.6,2812.32 ccw(c6231.47,2812.32) v1@6223.08,2803.93 ; U61.69@6219.6,2821.97 ccw(c6241.12,2821.97) v1@6225.91,2806.76 ; v1@6346.28,3242.72 ccw(c6330.06,3258.93) 6353,3258.93 ccw(c6375.93,3258.93) v1@6359.72,3242.72 ; v1@6349.11,3239.89 ccw(c6339.72,3249.28) 6353,3249.28 ccw(c6366.28,3249.28) v1@6356.89,3239.89 ; v1(6353,3236) 6353,3295.56 ; 5855.29,3882.19 ccw(c5882.64,3909.54) 5882.64,3870.86 ; 5855.29,3882.19 ccw(c5882.64,3909.54) 5882.64,3870.86 ; 5855.29,3882.19 ccw(c5842.76,3869.66) 5842.76,3887.38 cw(c5842.76,3869.66) 5855.29,3882.19 ; 5855.29,3882.19 cw(c5867.82,3894.72) 5850.1,3894.72 ccw(c5867.82,3894.72) 5855.29,3882.19 ; 5882.64,3870.86 5935.13,3870.86 5941.18,3870.86 5949.18,3870.86 5966.78,3870.86 5979.04,3858.6 5999.34,3858.6 6027.44,3830.5 6043.94,3814 6089.98,3814 6117.98,3786 6134,3786 6144.5,3796.5 U13.13@6170.59,3796.5 ; U13.13@6170.59,3796.5 6202.07,3796.5 ; 6202.07,3796.5 6227.06,3771.5 6284.57,3771.5 6318,3804.93 6330,3804.93 ; 6298.52,4300.04 6331.86,4333.37 ; 6298.52,4300.04 6298.52,4268.48 6314.5,4252.5 6314.5,4141.5 6287.19,4114.19 6287.19,4071.44 6289.69,4068.94 6289.69,4047.81 6287.36,4045.48 6287.36,3959.21 6298.19,3948.38 6298.19,3912.62 6306.86,3903.95 6325.81,3885 6325.81,3861.09 ; 6298.52,4300.04 6331.86,4333.37 ; 6306.86,3341.71 6306.86,3475.04 6340.19,3508.37 6340.19,3639.19 6379.5,3678.5 6379.5,3755.43 6340.06,3794.87 6330,3804.93 ; 6306.86,3341.71 6353,3295.56 ; 6306.86,3341.71 6353,3295.56 ; 6325.81,3861.09 6326.52,3860.37 ; 6325.81,3861.09 6326.52,3860.37 ; 6326.52,3860.37 6330,3856.9 ; 6326.52,3860.37 6330,3856.9 ; 6330,3804.93 6330,3808.66 ; 6330,3808.66 6330,3816.93 ; 6330,3808.66 6330,3816.93 ; 6330,3816.93 6330,3832 6330,3856.9 ; 6331.86,4333.37 6342.52,4344.04 ; 6331.86,4333.37 6342.52,4344.04
  MidLayer1 w4: v1@6212.47,2806.76 ccw(c6196.26,2822.98) 6219.19,2822.98 ccw(c6242.13,2822.98) v1@6225.91,2806.76 ; v1@6214.7,2804.54 v1(6219.19,2800.04) 6219.19,2919.39 6214.7,2923.89 6214.7,2990 ; v1@6215.3,2803.93 ccw(c6205.91,2813.32) 6219.19,2813.32 ccw(c6232.47,2813.32) v1@6223.08,2803.93 ; v1@6224.24,3207.44 cw(c6215.38,3195.81) 6230,3195.81 ; v1(6230,3215) 6230,3195.81 ; v1@6235.76,3207.44 ccw(c6244.62,3195.81) 6230,3195.81 ; 6214.7,2990 6214.7,3003.8 ; 6214.7,2990 6214.7,3003.8 ; 6214.7,3003.8 6239.5,3028.6 6239.5,3170 ; 6230,3195.81 6239.5,3186.31 ; 6239.5,3170 6239.5,3186.31 ; 6239.5,3170 6239.5,3186.31
  Bottom Layer w4: v1@6230,3220.5 ccw(c6230,3234.14) 6239.64,3224.49 ; v1@6230,3224.5 ccw(c6230,3247.8) 6246.47,3231.32 ; v1@6235.5,3215 cw(c6248.42,3215) 6239.28,3224.13 ; v1@6239.5,3215 cw(c6262.07,3215) 6246.11,3230.96 ; v1@6346.28,3229.28 ccw(c6330.06,3213.06) 6330.06,3236 ccw(c6330.06,3258.93) v1@6346.28,3242.72 ; v1@6349.11,3232.11 ccw(c6339.72,3222.72) 6339.72,3236 ccw(c6339.72,3249.28) v1@6349.11,3239.89 ; v1(6353,3236) 6300.88,3236 6295.17,3241.71 6256.86,3241.71 6230.19,3215.04 v1@6230,3215.04 ; v1(6230,3215) 6225.23,3215 6225.19,3215.04 v1@6230,3215.04
DB_MEM.BUS_D24: U8.F28 U13.42 U17.29 U61.70 | length 4025.8
  Top Layer w4: U8.F28@5921.5,4524.65 5941.18,4524.65 5949.18,4524.65 5969.04,4524.65 6013.19,4480.5 6048.27,4480.5 6081.58,4513.81 6103.71,4513.81 6128.69,4538.79 6128.69,4566.87 v1(6109.52,4586.04) ; U8.F28@5926.69,4519.45 cw(c5939.22,4506.92) 5939.22,4524.65 cw(c5939.22,4542.37) U8.F28@5926.69,4529.84 ; v1@6109.52,4576.54 cw(c6109.52,4553.61) 6125.74,4569.82 cw(c6141.96,4586.04) v1@6119.02,4586.04 ; v1@6109.52,4580.54 cw(c6109.52,4567.26) 6118.91,4576.65 cw(c6128.3,4586.04) v1@6115.02,4586.04 ; U61.70@6197.09,2853.36 ccw(c6190.07,2860.38) 6200,2860.38 ; U61.70@6198.52,2841.71 6200,2843.18 6200,2918.18 6215.19,2933.37 6215.19,3074.04 6198.52,3090.71 6198.52,3150.04 6248.52,3200.04 6248.52,3217.71 v1(6313.19,3282.37) ; 6200,2859.99 ccw(c6209.38,2859.99) U61.70@6202.75,2853.36 ; v1@6303.69,3282.37 cw(c6280.76,3282.37) 6296.97,3266.16 cw(c6313.19,3249.94) v1@6313.19,3272.87 ; v1@6307.69,3282.37 cw(c6294.41,3282.37) 6303.8,3272.99 cw(c6313.19,3263.6) v1@6313.19,3276.87 ; v1@6319.28,3374.72 ccw(c6304.21,3389.79) 6325.52,3389.79 ; v1@6322.11,3371.89 ccw(c6313.87,3380.13) 6325.52,3380.13 ; v1@6325.52,3368 6325.52,3426.33 6314.86,3437 6314.86,3471.73 6348.19,3505.06 6348.19,3635.88 6387.5,3675.19 v1@6387.5,3775.02 ; 6325.52,3382.43 ccw(c6340.43,3382.43) v1@6329.89,3371.89 ; 6325.52,3392.08 ccw(c6350.08,3392.08) v1@6332.72,3374.72 ; v1(6454.52,4498.04) 6454.52,4483.35 6467.36,4470.52 6467.36,4446.52 6459.5,4438.66 6459.5,4252.87 6444.53,4237.91 6444.53,3941.78 6573.52,3812.79 ; v1(6565.52,4495.37) 6602.11,4495.37 U17.29@6605,4498.27 ; v1@6567.23,3798.82 ccw(c6554.88,3812.79) 6573.52,3812.79 ; v1@6569.41,4491.49 cw(c6578.8,4482.1) 6578.8,4495.37 cw(c6578.8,4508.65) v1@6569.41,4499.26 ; v1@6569.88,3795.83 ccw(c6562.73,3803.91) 6573.52,3803.91 ccw(c6584.32,3803.91) v1@6577.17,3795.83 ; v1@6572.24,4488.66 cw(c6588.46,4472.44) 6588.46,4495.37 cw(c6588.46,4518.31) v1@6572.24,4502.09 ; v1@6574.58,3790.65 cw(c6588.7,3776.53) 6588.7,3796.5 ; v1@6577.41,3787.82 cw(c6598.36,3766.87) U13.42@6598.36,3796.5 ; v1@6578.19,3796.37 v1(6573.52,3791.71) 6573.52,3812.79 ; v1@6578.19,3796.5 U13.42@6619.41,3796.5 ; v1@6579.82,3798.82 cw(c6592.16,3812.79) 6573.52,3812.79 ; v1@6580.24,3784.99 cw(c6608.02,3757.21) U13.42@6608.02,3796.5 ; v1@6580.24,3798.43 ccw(c6584.9,3803.08) 6584.9,3796.5 ; 6585.21,4495.37 ccw(c6585.21,4514.91) U17.29@6599.02,4501.1 ; 6589.52,4495.37 cw(c6589.52,4485.94) U17.29@6596.19,4492.61
  MidLayer1 w4: v1@6306.47,3289.09 ccw(c6290.26,3305.31) 6313.19,3305.31 ccw(c6336.13,3305.31) v1@6319.91,3289.09 ; v1@6309.3,3286.26 ccw(c6299.91,3295.65) 6313.19,3295.65 ccw(c6326.47,3295.65) v1@6317.08,3286.26 ; v1(6313.19,3282.37) 6313.19,3318.19 6325.52,3330.52 v1@6325.52,3367.71 ; v1@6319.28,3361.28 cw(c6304.21,3346.21) 6325.52,3346.21 ; v1@6322.11,3364.11 cw(c6313.87,3355.87) 6325.52,3355.87 ; 6325.52,3343.92 cw(c6350.08,3343.92) v1@6332.72,3361.28 ; 6325.52,3353.57 cw(c6340.43,3353.57) v1@6329.89,3364.11 ; v1(6454.52,4498.04) 6502.33,4498.04 6505,4495.37 v1(6565.52,4495.37) ; v1@6458.41,4494.15 cw(c6467.8,4484.76) 6467.8,4498.04 cw(c6467.8,4511.32) v1@6458.41,4501.93 ; v1@6461.24,4491.32 cw(c6477.46,4475.11) 6477.46,4498.04 cw(c6477.46,4520.98) v1@6461.24,4504.76 ; v1@6558.81,4488.66 ccw(c6542.59,4472.44) 6542.59,4495.37 ccw(c6542.59,4518.31) v1@6558.81,4502.09 ; v1@6561.64,4491.49 ccw(c6552.25,4482.1) 6552.25,4495.37 ccw(c6552.25,4508.65) v1@6561.64,4499.26
  MidLayer2 w4: v1(6109.52,4586.04) 6095.86,4572.37 6067.86,4572.37 6048.52,4591.71 6023.52,4591.71 6006.86,4575.04 6006.86,4487.14 6021.18,4472.82 6055.63,4472.82 6091.19,4508.37 6259.19,4508.37 6267.52,4516.71 ; 6268.02,4517.2 6435.36,4517.2 v1(6454.52,4498.04) ; v1@6445.02,4498.04 ccw(c6422.09,4498.04) 6438.31,4514.26 ccw(c6454.52,4530.48) v1@6454.52,4507.54 ; v1@6449.02,4498.04 ccw(c6435.75,4498.04) 6445.14,4507.43 ccw(c6454.52,4516.82) v1@6454.52,4503.54
  Bottom Layer w4: v1@6387.52,3765.54 cw(c6387.52,3736.17) 6408.29,3756.94 ; v1@6387.52,3769.54 cw(c6387.52,3749.83) 6401.46,3763.77 ; v1@6390.19,3775.04 6414.86,3750.37 6503.17,3750.37 6544.5,3791.71 v1(6573.52,3791.71) ; v1@6397.02,3775.04 ccw(c6413.52,3775.04) 6401.86,3763.37 ; v1@6566.81,3784.99 ccw(c6550.59,3768.77) 6550.59,3791.71 ccw(c6550.59,3814.64) v1@6566.81,3798.43 ; v1@6569.64,3787.82 ccw(c6560.25,3778.43) 6560.25,3791.71 ccw(c6560.25,3804.99) v1@6569.64,3795.6
  other v1: 6326,3368 6387.52,3775.04
DB_MEM.BUS_D25: U8.W22 U13.44 U17.30 U61.72 | length 4144.7
  Top Layer w4: U8.W22@5685.28,4005.49 cw(c5685.28,3987.77) 5697.81,4000.3 cw(c5710.34,4012.83) U8.W22@5692.62,4012.83 ; U8.W22@5685.28,4012.83 v3(5704.96,3993.15) ; v1@6151.37,2926.95 cw(c6143.88,2916.36) 6156.86,2916.36 ; v1(6156.86,2934.71) 6156.86,2916.35 ; U61.72@6157.72,2853.36 ccw(c6149.35,2861.73) 6161.19,2861.73 ; U61.72@6161.19,2850.04 6161.19,2905 ; 6161.19,2858.64 ccw(c6168.66,2858.64) U61.72@6163.38,2853.36 ; v1@6162.34,2926.95 ccw(c6169.83,2916.36) 6156.86,2916.36 ; v1(6397.19,3016.71) 6418.71,3016.71 ; v1@6401.25,3013 cw(c6409.65,3005.35) 6409.65,3016.71 cw(c6409.65,3028.06) v1@6401.25,3020.41 ; v1@6404.21,3010.31 cw(c6418.71,2997.09) 6418.71,3016.71 ; v1@6404.21,3023.11 ccw(c6418.71,3036.32) 6418.71,3016.71 ; v1@6440.19,3848.87 cw(c6440.19,3825.94) 6456.41,3842.16 cw(c6472.63,3858.37) v1@6449.69,3858.37 ; v1@6440.19,3852.87 cw(c6440.19,3839.6) 6449.58,3848.99 cw(c6458.97,3858.37) v1@6445.69,3858.37 ; v1(6440.19,3858.37) 6498.52,3800.04 6498.52,3608.04 6406.86,3516.37 6406.86,3141.71 6423.52,3125.04 6423.52,3021.52 6418.71,3016.71 ; 6531.86,4136.04 v1(6573.52,4094.37) ; 6531.86,4500.04 6557.42,4525.6 6561.58,4529.76 U17.30@6619.41,4529.76 ; 6532.02,4136.2 6532.02,4499.88 ; v1@6564.02,4094.37 ccw(c6541.09,4094.37) 6557.31,4110.59 ccw(c6573.52,4126.81) v1@6573.52,4103.87 ; v1@6568.02,4094.37 ccw(c6554.75,4094.37) 6564.13,4103.76 ccw(c6573.52,4113.15) v1@6573.52,4099.87 ; U17.30@6596.19,4524.11 ccw(c6582.54,4510.45) 6582.54,4529.76 ccw(c6582.54,4549.08) U17.30@6596.19,4535.42 ; U13.44@6619.41,3859.49 6649.19,3859.49 ; U13.44@6644.3,3856.29 cw(c6649.19,3854.15) 6649.19,3859.49 ; U13.44@6644.3,3862.69 ccw(c6649.19,3864.82) 6649.19,3859.49 ; v1(6665.19,3858.37) 6650.3,3858.37 6649.19,3859.49 ; 5692.16,4005.95 cw(c5679.35,3993.15) 5697.46,3993.15 ccw(c5679.35,3993.15) 5692.16,4005.95 ; 5692.16,4005.95 ccw(c5704.96,4018.76) 5704.96,4000.65 cw(c5704.96,4018.76) 5692.16,4005.95 ; 6156.86,2916.35 6161.19,2912.02 ; 6161.19,2905 6161.19,2912.02 ; 6161.19,2905 6161.19,2912.02
  MidLayer1 w4: v1@6398.52,3990.54 cw(c6398.52,3967.61) 6414.74,3983.82 cw(c6430.96,4000.04) v1@6408.02,4000.04 ; v1@6398.52,3994.54 cw(c6398.52,3981.26) 6407.91,3990.65 cw(c6417.3,4000.04) v1@6404.02,4000.04 ; v1(6398.52,4000.04) 6456.86,3941.71 6456.86,3875.04 v1(6440.19,3858.37) ; v1@6440.19,3863.87 ccw(c6440.19,3877.15) 6449.58,3867.76 ccw(c6458.97,3858.37) v1@6445.69,3858.37 ; v1@6440.19,3867.87 ccw(c6440.19,3890.81) 6456.41,3874.59 ccw(c6472.63,3858.37) v1@6449.69,3858.37
  MidLayer2 w4: v3@5705.61,3985.68 cw(c5707.19,3967.64) 5718.83,3981.51 cw(c5730.47,3995.38) v3@5712.43,3993.8 ; 5718.54,3981.76 ccw(c5728.47,3991.69) 5728.47,3977.64 5822.01,3977.64 6002.36,3977.64 6010,3970 6055,3970 6070,3985 6070,4005 6080,4015 6171,4015 6216,3970 6229.5,3970 6261.88,4002.37 6362.63,4002.37 6364.96,4000.04 v1(6398.52,4000.04) ; v1@6391.81,3993.32 ccw(c6375.59,3977.11) 6375.59,4000.04 ccw(c6375.59,4022.98) v1@6391.81,4006.76 ; v1@6394.64,3996.15 ccw(c6385.25,3986.76) 6385.25,4000.04 ccw(c6385.25,4013.32) v1@6394.64,4003.93
  Bottom Layer w4: v1@6152.16,2942.97 ccw(c6147.57,2951.04) 6156.86,2951.04 ; v1(6156.86,2934.71) 6156.86,2951.04 ; v1@6161.55,2942.97 cw(c6166.15,2951.04) 6156.86,2951.04 ; v1@6390.47,3009.99 ccw(c6374.26,2993.77) 6374.26,3016.71 ccw(c6374.26,3039.64) v1@6390.47,3023.43 ; v1@6393.3,3012.82 ccw(c6383.91,3003.43) 6383.91,3016.71 ccw(c6383.91,3029.99) v1@6393.3,3020.6 ; v1(6397.19,3016.71) 6231.86,3016.71 6181.86,2966.71 6172.52,2966.71 6156.86,2951.04 ; v1(6398.52,4000.04) 6479.19,4000.04 v1(6573.52,4094.37) ; v1@6402.41,3996.15 cw(c6411.8,3986.76) 6411.8,4000.04 cw(c6411.8,4013.32) v1@6402.41,4003.93 ; v1@6405.24,3993.32 cw(c6421.46,3977.11) 6421.46,4000.04 cw(c6421.46,4022.98) v1@6405.24,4006.76 ; v1(6440.19,3858.37) 6490.19,3908.37 6581.86,3908.37 6631.86,3858.37 v1(6665.19,3858.37) ; v1@6440.19,3863.87 ccw(c6440.19,3877.15) 6449.58,3867.76 ccw(c6458.97,3858.37) v1@6445.69,3858.37 ; v1@6440.19,3867.87 ccw(c6440.19,3890.81) 6456.41,3874.59 ccw(c6472.63,3858.37) v1@6449.69,3858.37 ; v1@6564.02,4094.37 cw(c6541.09,4094.37) 6557.31,4078.16 cw(c6573.52,4061.94) v1@6573.52,4084.87 ; v1@6568.02,4094.37 cw(c6554.75,4094.37) 6564.14,4084.99 cw(c6573.52,4075.6) v1@6573.52,4088.87 ; v1@6658.47,3851.66 ccw(c6642.26,3835.44) 6642.26,3858.37 ccw(c6642.26,3881.31) v1@6658.47,3865.09 ; v1@6661.3,3854.49 ccw(c6651.91,3845.1) 6651.91,3858.37 ccw(c6651.91,3871.65) v1@6661.3,3862.26
DB_MEM.BUS_D26: U8.V24 U13.45 U17.31 U61.73 | length 3737.1
  Top Layer w4: U8.V24@5764.02,4044.86 cw(c5764.02,4027.14) 5776.55,4039.67 cw(c5789.08,4052.2) U8.V24@5771.36,4052.2 ; U8.V24@5764.02,4052.2 v3(5783.7,4032.52) ; U61.73@6138.19,2821.17 cw(c6134.14,2816.68) 6140.19,2816.68 cw(c6144.49,2816.68) U61.73@6142.61,2820.55 ; U61.73@6140.19,2837.34 6140.19,2816.71 6148.52,2808.37 6161.9,2795 6178.56,2795 6183,2795 v1(6209,2769) ; U61.73@6140.86,2824.14 ccw(c6145.86,2820.11) 6141.32,2815.58 ; U61.73@6143.98,2821.63 ccw(c6149.34,2817.3) 6144.47,2812.43 ; v1@6199.5,2769 ccw(c6176.56,2769) 6192.78,2785.22 ccw(c6209,2801.43) v1@6209,2778.5 ; v1@6203.5,2769 ccw(c6190.22,2769) 6199.61,2778.39 ccw(c6209,2787.78) v1@6209,2774.5 ; v1@6571.76,3885.14 cw(c6585.86,3871.04) 6585.86,3890.98 ; v1(6573.52,3883.37) 6581.13,3890.98 U13.45@6619.41,3890.98 6649,3890.98 ; v1@6574.58,3882.31 cw(c6595.52,3861.38) U13.45@6595.52,3890.98 ; v1@6577.41,3879.49 cw(c6605.17,3851.73) U13.45@6605.17,3890.98 ; v1@6580.24,3876.66 cw(c6614.83,3842.07) U13.45@6614.83,3890.98 ; U17.31@6619.41,4561.26 6652.24,4561.26 ; U17.31@6643.54,4556.7 cw(c6652.24,4550.68) 6652.24,4561.26 ; U17.31@6643.54,4565.82 ccw(c6652.24,4571.84) 6652.24,4561.26 ; U13.45@6644.35,3887.89 cw(c6649,3885.94) 6649,3890.98 ; U13.45@6644.35,3894.08 ccw(c6649,3896.03) 6649,3890.98 ; 6695.94,4047.5 6706.19,4037.25 ; 5770.9,4045.32 cw(c5758.09,4032.52) 5776.2,4032.52 ccw(c5758.09,4032.52) 5770.9,4045.32 ; 5770.9,4045.32 ccw(c5783.7,4058.13) 5783.7,4040.02 cw(c5783.7,4058.13) 5770.9,4045.32 ; 6649,3890.98 6689.69,3931.68 6689.69,3949.27 6706.19,3965.77 6706.19,4037.25 ; 6652.24,4561.26 6698.52,4514.98 6698.52,4372.33 6673.12,4346.93 6673.12,4324.38 6690.19,4307.31 6689.4,4306.52 6689.4,4282.58 6689.4,4100.83 ; 6689.4,4100.83 6692.5,4097.73 ; 6689.4,4100.83 6692.5,4097.73 ; 6692.5,4097.73 6692.5,4065 6692.5,4050.94 6706.19,4037.25
  MidLayer1 w4: v3@5784.35,4025.05 cw(c5785.93,4007.01) 5797.57,4020.88 cw(c5809.21,4034.75) v3@5791.17,4033.17 ; 5797.28,4021.13 ccw(c5807.21,4031.06) 5807.21,4017.01 5881.33,4017.01 6006.93,4017.01 6011.23,4017.01 6019.44,4008.8 6084.05,4008.8 6086.95,4011.7 6092,4011.7 ; 6173.36,3574.88 6173.36,3377.58 6182.19,3368.75 6182.19,3310 6182.19,3276.24 6212.5,3245.93 6212.5,3202 6231.5,3183 6231.5,3031.92 6206.02,3006.44 6206.02,2918.98 6211.19,2913.81 6211.19,2824.5 6201.69,2815 6201.69,2800 6201.69,2790 6209,2782.69 v1(6209,2769) ; 6173.52,3575.04 6190.19,3591.71 6251.61,3591.71 6284.02,3624.13 6284.02,3637.34 ; v1@6236.28,3795.72 ccw(c6220.06,3811.93) 6243,3811.93 ccw(c6265.93,3811.93) v1@6249.72,3795.72 ; v1@6236.56,3782.02 cw(c6223,3767.31) 6243,3767.31 ; v1@6239.11,3792.89 ccw(c6229.72,3802.28) 6243,3802.28 ccw(c6256.28,3802.28) v1@6246.89,3792.89 ; v1@6239.27,3784.96 cw(c6231.42,3776.45) 6243,3776.45 cw(c6254.58,3776.45) v1@6246.73,3784.96 ; v1@6249.44,3782.02 ccw(c6263,3767.31) 6243,3767.31 ; 6284.02,3638.62 6284.02,3637.34 ; 6092,4011.7 6101.45,4011.7 ; 6092,4011.7 6101.45,4011.7 ; 6101.45,4011.7 6136.26,4011.7 6189,3958.96 6189,3894 6189,3886 6189,3845 6207,3827 6232.25,3827 6243,3816.25 v1(6243,3789) 6243,3778.98 6243,3767.31 ; 6243,3767.31 6273.15,3737.16 6282.19,3728.12 6282.19,3640.46 6282.19,3639.18 6284.02,3637.34
  Bottom Layer w4: v1(6243,3789) 6270.71,3816.71 6435,3816.71 6448.52,3816.71 6470.54,3816.71 6487.88,3834.04 6524.19,3834.04 v1(6573.52,3883.37) ; v1@6243,3794.5 ccw(c6243,3807.78) 6252.39,3798.39 ccw(c6261.78,3789) v1@6248.5,3789 ; v1@6243,3798.5 ccw(c6243,3821.43) 6259.22,3805.22 ccw(c6275.43,3789) v1@6252.5,3789 ; v1@6564.02,3883.37 cw(c6541.09,3883.37) 6557.31,3867.16 cw(c6573.52,3850.94) v1@6573.52,3873.87 ; v1@6568.02,3883.37 cw(c6554.75,3883.37) 6564.14,3873.99 cw(c6573.52,3864.6) v1@6573.52,3877.87
DB_MEM.BUS_D27: U8.V21 U13.47 U17.32 U61.74 | length 4010.9
  Top Layer w4: U8.V21@5645.91,4044.86 cw(c5645.91,4027.14) 5658.44,4039.67 cw(c5670.97,4052.2) U8.V21@5653.25,4052.2 ; U8.V21@5645.91,4052.2 v3(5665.59,4032.52) ; v1@6111.86,2940.54 cw(c6111.86,2917.61) 6128.07,2933.82 cw(c6144.29,2950.04) v1@6121.36,2950.04 ; v1@6111.86,2944.54 cw(c6111.86,2931.26) 6121.25,2940.65 cw(c6130.64,2950.04) v1@6117.36,2950.04 ; v1(6111.86,2950.04) 6152.86,2909.04 6152.86,2883.86 6143,2874 6127,2874 6121.18,2868.18 U61.74@6121.18,2837.34 ; U61.74@6118.35,2853.36 ccw(c6111.52,2860.19) 6121.18,2860.19 ccw(c6130.84,2860.19) U61.74@6124.01,2853.36 ; v1@6536.81,3990.99 ccw(c6520.59,3974.77) 6520.59,3997.71 ccw(c6520.59,4020.64) v1@6536.81,4004.43 ; v1@6539.64,3993.82 ccw(c6530.25,3984.43) 6530.25,3997.71 ccw(c6530.25,4010.99) v1@6539.64,4001.6 ; v1@6543.52,3988.21 cw(c6543.52,3965.27) 6559.74,3981.49 cw(c6575.96,3997.71) v1@6553.02,3997.71 ; v1@6543.52,3992.21 cw(c6543.52,3978.93) 6552.91,3988.32 cw(c6562.3,3997.71) v1@6549.02,3997.71 ; 6580.01,4591.71 ccw(c6580.01,4614.6) U17.32@6596.19,4598.41 ; 6585.07,4591.71 cw(c6585.07,4575.97) U17.32@6596.19,4587.1 ; 6589.66,4591.71 ccw(c6589.66,4604.94) U17.32@6599.02,4595.58 ; U13.47@6595.11,3949.67 ccw(c6587.26,3944.66) 6587.26,3953.98 ; U13.47@6595.11,3958.28 cw(c6587.26,3963.29) 6587.26,3953.98 ; U13.47@6619.41,3953.98 6587.26,3953.98 ; U17.32@6619.41,4592.76 6601.84,4592.76 6601.84,4591.71 6515.19,4591.71 6498.52,4575.04 6498.52,4493.35 6524.02,4467.86 6524.02,4192.2 6456.86,4125.04 6456.86,4115 6456.86,4025.04 6484.19,3997.71 v1(6543.52,3997.71) 6587.26,3953.98 ; 5652.79,4045.32 cw(c5639.98,4032.52) 5658.09,4032.52 ccw(c5639.98,4032.52) 5652.79,4045.32 ; 5652.79,4045.32 ccw(c5665.59,4058.13) 5665.59,4040.02 cw(c5665.59,4058.13) 5652.79,4045.32
  MidLayer1 w4: v1(6448.83,3111.72) 6448.83,3108.68 6450.35,3110.2 6490.19,3150.04 6490.19,3246.82 ; v1@6448.83,3117.22 ccw(c6448.83,3137.83) 6463.4,3123.26 ; v1@6448.83,3121.22 ccw(c6448.83,3151.49) 6470.23,3130.08 ; v1@6458.33,3111.72 cw(c6473.93,3111.72) 6462.9,3122.75 ; v1@6534.02,3997.71 cw(c6511.09,3997.71) 6527.31,3981.49 cw(c6543.52,3965.27) v1@6543.52,3988.21 ; v1@6538.02,3997.71 cw(c6524.75,3997.71) 6534.13,3988.32 cw(c6543.52,3978.93) v1@6543.52,3992.21 ; v1(6543.52,3997.71) 6515.19,3969.37 6515.19,3820 6515.19,3793.01 6515.19,3669.08 6511.19,3665.08 ; 6490.19,3246.82 6506.86,3263.48 ; 6490.19,3246.82 6506.86,3263.48 ; 6490.19,3246.82 6506.86,3263.48 ; 6506.86,3263.48 6506.86,3280 6506.86,3381.34 6506.86,3405 6506.86,3660.75 ; 6506.86,3660.75 6511.19,3665.08 ; 6506.86,3660.75 6511.19,3665.08
  MidLayer2 w4: v3@5666.24,4025.05 cw(c5667.82,4007.01) 5679.46,4020.88 ; v3@5673.06,4033.17 ccw(c5691.1,4034.75) 5679.46,4020.88 ; v1(6543.52,3997.71) 6508.02,4033.21 6477.9,4033.21 6473.7,4029 6389.82,4029 6379.19,4018.37 6207.94,4018.37 6184.11,4042.2 6092.8,4042.2 6083.2,4051.8 6022.75,4051.8 5979.61,4008.66 5822.01,4008.66 5802.59,4008.66 5728.47,4008.66 5708.97,4008.66 cw(c5708.97,4050.39) 5679.46,4020.88
  Bottom Layer w4: v1(6111.86,2950.04) 6131.86,2950.04 ; v1@6116.12,2946.57 cw(c6123.44,2940.6) 6123.44,2950.04 cw(c6123.44,2959.48) v1@6116.12,2953.52 ; v1@6119.22,2944.04 cw(c6131.86,2933.74) 6131.86,2950.04 ; v1@6119.22,2956.04 ccw(c6131.86,2966.34) 6131.86,2950.04 ; 6433.71,3093.56 ccw(c6419.5,3107.77) v1@6439.42,3110.45 ; 6437.8,3097.65 cw(c6448.83,3086.62) v1@6448.83,3102.22 ; 6439.42,3099.27 ccw(c6429.57,3109.13) v1@6443.38,3110.98 ; v1(6448.83,3111.72) 6448.83,3108.68 6432.19,3092.04 6180.29,3092.04 6165.19,3076.94 6165.19,2983.37 6131.86,2950.04
DB_MEM.BUS_D28: U8.V22 U13.48 U17.35 U61.76 | length 4307.4
  Top Layer w4: U8.V22@5685.28,4044.86 cw(c5685.28,4027.14) 5697.81,4039.67 cw(c5710.34,4052.2) U8.V22@5692.62,4052.2 ; U8.V22@5685.28,4052.2 v3(5704.96,4032.52) ; U61.76@6078.98,2821.32 cw(c6072.15,2814.49) 6081.81,2814.49 cw(c6091.47,2814.49) U61.76@6084.64,2821.32 ; U61.76@6081.81,2837.34 6081.81,2795 6090.19,2786.62 ; v1@6083.7,2771.64 ccw(c6069.67,2786.62) 6090.19,2786.62 ; v1@6086.43,2768.72 ccw(c6078.31,2777.39) 6090.19,2777.39 ccw(c6102.07,2777.39) v1@6093.95,2768.72 ; v1(6090.19,2764.71) 6090.19,2786.62 ; v1@6096.68,2771.64 cw(c6110.71,2786.62) 6090.19,2786.62 ; v1(6476.09,4172.47) 6515.19,4211.57 6515.19,4216.71 6515.19,4465.37 6488.86,4491.71 6488.86,4627.58 6548.52,4687.24 U17.35@6619.41,4687.24 ; v1@6476.09,4177.97 ccw(c6476.09,4191.25) 6485.48,4181.86 ccw(c6494.87,4172.47) v1@6481.59,4172.47 ; v1@6476.09,4181.97 ccw(c6476.09,4204.91) 6492.31,4188.69 ccw(c6508.53,4172.47) v1@6485.59,4172.47 ; v1(6478.52,4066.71) 6503.29,4066.71 6584.53,3985.47 ; v1@6482.41,4062.82 cw(c6491.8,4053.43) 6491.8,4066.71 cw(c6491.8,4079.99) v1@6482.41,4070.6 ; v1@6485.24,4059.99 cw(c6501.46,4043.77) 6501.46,4066.71 cw(c6501.46,4089.64) v1@6485.24,4073.43 ; U13.48@6595.76,3980.29 ccw(c6584.53,3970.72) 6584.53,3985.47 ; U13.48@6595.76,3990.66 cw(c6584.53,4000.23) 6584.53,3985.47 ; U17.35@6596.19,4681.59 ccw(c6582.54,4667.93) 6582.54,4687.24 ccw(c6582.54,4706.56) U17.35@6596.19,4692.9 ; U13.48@6619.41,3985.47 6584.53,3985.47 ; 5692.16,4045.32 cw(c5679.35,4032.52) 5697.46,4032.52 ccw(c5679.35,4032.52) 5692.16,4045.32 ; 5692.16,4045.32 ccw(c5704.96,4058.13) 5704.96,4040.02 cw(c5704.96,4058.13) 5692.16,4045.32
  MidLayer1 w4: v2(6314,4086) 6321,4086 6320,4085 6340,4085 ; v2@6318.12,4090.1 ccw(c6330.38,4102.29) 6330.38,4085 ; v2@6320.94,4079.06 cw(c6335.27,4064.73) 6335.27,4085 ; v2@6320.96,4092.92 ccw(c6340,4111.86) 6340,4085 ; v1@6400.28,2828.72 ccw(c6384.06,2844.93) 6407,2844.93 ccw(c6429.93,2844.93) v1@6413.72,2828.72 ; v1@6403.11,2825.89 ccw(c6393.72,2835.28) 6407,2835.28 ccw(c6420.28,2835.28) v1@6410.89,2825.89 ; v1(6407,2822) 6407,2866.52 6398.52,2875 6398.52,2978.02 6379.19,2997.35 6379.19,3054.08 6399.83,3074.72 6399.83,3086.32 6399.69,3086.45 6399.69,3307.5 6406.86,3314.67 6406.86,3356.39 6431.86,3381.39 6431.86,3631.06 6449.69,3648.89 6449.69,3710.86 6423.69,3736.86 6423.69,3789.19 6406.86,3806.02 6406.86,3900 6406.86,3931.73 6406.86,3937.69 ; v1@6469.38,4165.75 cw(c6453.16,4149.54) 6476.09,4149.54 cw(c6499.03,4149.54) v1@6482.81,4165.75 ; v1@6471.81,4059.99 ccw(c6455.59,4043.77) 6455.59,4066.71 ccw(c6455.59,4089.64) v1@6471.81,4073.43 ; v1@6472.21,4168.58 cw(c6462.82,4159.19) 6476.09,4159.19 cw(c6489.37,4159.19) v1@6479.98,4168.58 ; v1@6474.64,4062.82 ccw(c6465.25,4053.43) 6465.25,4066.71 ccw(c6465.25,4079.99) v1@6474.64,4070.6 ; v1(6476.09,4172.47) 6476.09,4116.09 6465,4105 6430,4105 ; v1(6478.52,4066.71) 6438.29,4066.71 6430,4075 6430,4105 ; 6340,4085 6350,4085 6355,4085 6375,4105 6430,4105 ; 6340,4085 6340,4045 6340,4004.55 6396.14,3948.41 ; 6396.14,3948.41 6406.86,3937.69 ; 6396.14,3948.41 6406.86,3937.69
  MidLayer2 w4: v3@5705.61,4025.05 cw(c5707.19,4007.01) 5718.83,4020.88 cw(c5730.47,4034.75) v3@5712.43,4033.17 ; 5718.54,4021.13 ccw(c5728.47,4031.06) 5728.47,4017.01 5822.01,4017.01 5941.18,4017.01 5949.18,4017.01 5976.65,4017.01 5991.5,4031.86 5991.5,4073.25 6001.75,4083.5 6056.69,4083.5 6066,4092.81 6107.19,4092.81 6108.79,4091.21 6191.21,4091.21 6195.71,4095.71 6215.6,4095.71 6227.81,4083.5 6314,4083.5 6318.5,4083.5 6321,4086 v2(6314,4086)
  Bottom Layer w4: v1(6090.19,2764.71) 6110.87,2785.39 6115.54,2785.39 6166.19,2836.04 6312.52,2836.04 6331.86,2816.71 6370,2816.71 6376.67,2823.37 v1@6407,2823.37 ; v1@6090.19,2770.21 ccw(c6090.19,2783.49) 6099.58,2774.1 ccw(c6108.97,2764.71) v1@6095.69,2764.71 ; v1@6090.19,2774.21 ccw(c6090.19,2797.14) 6106.41,2780.93 ccw(c6122.63,2764.71) v1@6099.69,2764.71 ; 6380.75,2823.37 cw(c6380.75,2795.75) v1@6400.28,2815.28 ; 6387.38,2823.37 ccw(c6387.38,2841.62) v1@6400.28,2828.72 ; 6390.4,2823.37 cw(c6390.4,2805.4) v1@6403.11,2818.11
DB_MEM.BUS_D29: U8.U22 U13.50 U17.36 U61.77 | length 4386.3
  Top Layer w4: U8.U22@5685.28,4084.23 cw(c5685.28,4066.51) 5697.81,4079.04 cw(c5710.34,4091.57) U8.U22@5692.62,4091.57 ; U8.U22@5685.28,4091.57 v3(5704.96,4071.89) ; U61.77@6059.3,2853.36 ccw(c6052.47,2860.19) 6062.13,2860.19 ccw(c6071.78,2860.19) U61.77@6064.95,2853.36 ; U61.77@6062.12,2837.34 6062.13,2867.04 6070.13,2875.04 ; v1@6082.84,2869.02 ccw(c6070.13,2858.6) 6070.13,2875.04 ; v1@6082.84,2881.06 cw(c6070.13,2891.48) 6070.13,2875.04 ; v1@6085.94,2871.56 ccw(c6078.57,2865.52) 6078.57,2875.04 ccw(c6078.57,2884.56) v1@6085.94,2878.53 ; v1(6090.19,2875.04) 6070.13,2875.04 ; v1(6490.19,4225.04) 6506.86,4241.71 6506.86,4462.39 6480.52,4488.73 6480.52,4639.29 6482.69,4641.46 6482.69,4641.54 6566.19,4725.04 6601.84,4725.04 6601.84,4718.74 U17.36@6619.41,4718.74 ; v1@6490.19,4230.54 ccw(c6490.19,4243.82) 6499.58,4234.43 ccw(c6508.97,4225.04) v1@6495.69,4225.04 ; v1@6490.19,4234.54 ccw(c6490.19,4257.48) 6506.41,4241.26 ccw(c6522.63,4225.04) v1@6499.69,4225.04 ; v1@6498.52,4115.54 cw(c6498.52,4092.61) 6514.74,4108.82 cw(c6530.96,4125.04) v1@6508.02,4125.04 ; v1@6498.52,4119.54 cw(c6498.52,4106.26) 6507.91,4115.65 cw(c6517.3,4125.04) v1@6504.02,4125.04 ; v1(6498.52,4125.04) 6575.1,4048.46 U13.50@6619.41,4048.46 6658.44,4048.46 6674.9,4032 v1@6686.69,4032 ; 6567.33,4725.04 cw(c6567.33,4684.21) U17.36@6596.19,4713.08 ; 6576.98,4725.04 cw(c6576.98,4693.87) U17.36@6599.02,4715.91 ; 6586.64,4725.04 cw(c6586.64,4703.53) U17.36@6601.85,4718.74 ; U13.50@6596.19,4042.81 ccw(c6582.54,4029.15) 6582.54,4048.46 ccw(c6582.54,4067.78) U13.50@6596.19,4054.12 ; U13.50@6642.63,4042.81 cw(c6656.28,4029.15) 6656.28,4048.46 cw(c6656.28,4067.78) U13.50@6642.63,4054.12 ; 5692.16,4084.69 cw(c5679.35,4071.89) 5697.46,4071.89 ccw(c5679.35,4071.89) 5692.16,4084.69 ; 5692.16,4084.69 ccw(c5704.96,4097.5) 5704.96,4079.39 cw(c5704.96,4097.5) 5692.16,4084.69
  MidLayer1 w4: v1@6483.47,4218.32 cw(c6467.26,4202.11) 6490.19,4202.11 cw(c6513.13,4202.11) v1@6496.91,4218.32 ; v1@6486.3,4221.15 cw(c6476.91,4211.76) 6490.19,4211.76 cw(c6503.47,4211.76) v1@6494.08,4221.15 ; v1(6490.19,4225.04) 6490.19,4193.33 6498.52,4185 v1(6498.52,4125.04) ; v1@6491.81,4131.76 ccw(c6475.59,4147.98) 6498.52,4147.98 ccw(c6521.46,4147.98) v1@6505.24,4131.76 ; v1@6494.64,4128.93 ccw(c6485.25,4138.32) 6498.52,4138.32 ccw(c6511.8,4138.32) v1@6502.41,4128.93 ; v1(6533.86,2878.37) 6523.52,2888.71 6523.52,3145 6523.52,3150.04 6589.69,3216.21 6589.69,3217.21 ; v1@6680.98,4024.45 ccw(c6670.15,4016.66) 6670.15,4030 ; v1@6680.98,4035.55 cw(c6670.15,4043.34) 6670.15,4030 ; v1(6688.69,4030) 6670.15,4030 ; 6589.69,3217.21 6589.69,3225 ; 6589.69,3217.21 6589.69,3225 ; 6589.69,3225 6589.69,3277.27 6607.7,3295.28 6607.7,3960 6607.7,3967.55 6607.7,3983.57 6654.13,4030 6670.15,4030
  MidLayer2 w4: v3@5705.61,4064.42 cw(c5707.19,4046.38) 5718.83,4060.25 cw(c5730.47,4074.12) v3@5712.43,4072.54 ; 5718.54,4060.5 ccw(c5728.47,4070.43) 5728.47,4056.38 5742.4,4056.38 5802.59,4056.38 5822.01,4056.38 5880.27,4056.38 5938.53,4056.38 5941.18,4056.38 5949.18,4056.38 5975.38,4056.38 5983.5,4064.5 5983.5,4076.56 5988,4081.06 5988,4130.93 6024.57,4167.5 6101.67,4167.5 6111.17,4177 6142.56,4177 6169.69,4149.87 6254.11,4149.87 6259.02,4144.96 6259.02,4126.23 6269.75,4115.5 6284.25,4115.5 6296.56,4127.81 6495.75,4127.81 v1(6498.52,4125.04) ; v1@6090.19,2865.54 cw(c6090.19,2842.61) 6106.41,2858.82 cw(c6122.63,2875.04) v1@6099.69,2875.04 ; v1@6090.19,2869.54 cw(c6090.19,2856.26) 6099.58,2865.65 cw(c6108.97,2875.04) v1@6095.69,2875.04 ; v1@6090.23,2875 v1(6090.19,2875.04) 6107.86,2857.37 6297,2857.37 6305,2865.37 6305,2907.71 6315,2917.71 6470,2917.71 6509.33,2878.37 v1(6533.86,2878.37) ; v1@6527.14,2871.66 ccw(c6510.92,2855.44) 6510.92,2878.37 ccw(c6510.92,2901.31) v1@6527.14,2885.09 ; v1@6529.97,2874.49 ccw(c6520.58,2865.1) 6520.58,2878.37 ccw(c6520.58,2891.65) v1@6529.97,2882.26
DB_MEM.BUS_D30: U8.R25 U13.51 U17.37 U61.78 | length 4756.5
  Top Layer w4: U8.R25@5803.39,4162.97 cw(c5803.39,4145.25) 5815.92,4157.78 cw(c5828.45,4170.31) U8.R25@5810.73,4170.31 ; U8.R25@5803.39,4170.31 v3(5823.07,4150.63) ; U61.78@6039.61,2821.32 cw(c6018.09,2799.8) 6048.52,2799.8 ; U61.78@6042.44,2824.14 cw(c6027.75,2809.46) 6048.52,2809.46 ; U61.78@6045.27,2826.97 cw(c6037.41,2819.11) 6048.52,2819.11 ; U61.78@6048.1,2829.8 cw(c6047.07,2828.77) 6048.52,2828.77 ; 6048.52,2827.29 6048.52,2733.37 v1(6073.52,2708.37) ; v1@6064.02,2708.37 ccw(c6041.09,2708.37) 6057.31,2724.59 ccw(c6073.52,2740.81) v1@6073.52,2717.87 ; v1@6068.02,2708.37 ccw(c6054.75,2708.37) 6064.14,2717.76 ccw(c6073.52,2727.15) v1@6073.52,2713.87 ; 6582.07,4750.04 ccw(c6582.07,4770.02) U17.37@6596.19,4755.89 ; 6583.01,4750.04 cw(c6583.01,4731.39) U17.37@6596.19,4744.58 ; 6591.72,4750.04 ccw(c6591.72,4760.36) U17.37@6599.02,4753.06 ; U13.51@6619.41,4079.96 6653.44,4079.96 ; U17.37@6619.41,4750.2 6619.25,4750.04 6541.19,4750.04 6428.69,4637.54 6428.69,4469.96 6424.36,4465.62 6424.36,4451.13 6443.5,4431.98 6443.5,4386.12 6443.5,4259.5 6421,4237 ; U13.51@6643.26,4075.01 cw(c6653.44,4067) 6653.44,4079.96 ; U13.51@6643.26,4084.91 ccw(c6653.44,4092.92) 6653.44,4079.96 ; 6654.1,4080.62 cw(c6663.8,4070.92) v1@6668.36,4083.85 ; 6658.59,4085.11 cw(c6666.14,4077.56) v1@6669.69,4087.63 ; v1(6670.19,4089.04) 6662.52,4089.04 6653.44,4079.96 ; 5810.27,4163.43 cw(c5797.46,4150.63) 5815.57,4150.63 ccw(c5797.46,4150.63) 5810.27,4163.43 ; 5810.27,4163.43 ccw(c5823.07,4176.24) 5823.07,4158.13 cw(c5823.07,4176.24) 5810.27,4163.43 ; 6413.39,4229.39 cw(c6404,4238.78) 6404,4225.5 ccw(c6404,4238.78) 6413.39,4229.39 ; 6413.39,4229.39 ccw(c6422.78,4220) 6409.5,4220 cw(c6422.78,4220) 6413.39,4229.39 ; 6420.22,4236.22 cw(c6404,4252.43) 6404,4229.5 ccw(c6404,4252.43) 6420.22,4236.22 ; 6420.22,4236.22 ccw(c6436.43,4220) 6413.5,4220 cw(c6436.43,4220) 6420.22,4236.22 ; 6421,4237 v1(6404,4220) 6421,4237
  MidLayer1 w4: v3(5823.07,4150.63) 5900.75,4150.63 6007.93,4150.63 6024.36,4134.21 6024.36,4110.45 6083.11,4051.7 6125,4051.7 6150.18,4051.7 6201.7,4051.7 6205,4055 6230,4055 6275.04,4100.04 6291.54,4100.04 6316.5,4125 6335,4125 6345,4125 6358.69,4125 6404,4170.31 6404,4184 6404,4190 v1(6404,4220) ; v3@5828.26,4145.44 cw(c5840.8,4132.9) 5840.8,4150.63 cw(c5840.8,4168.36) v3@5828.26,4155.82 ; v1@6397.28,4213.28 cw(c6381.06,4197.06) 6404,4197.06 cw(c6426.93,4197.06) v1@6410.72,4213.28 ; v1@6400.11,4216.11 cw(c6390.72,4206.72) 6404,4206.72 cw(c6417.28,4206.72) v1@6407.89,4216.11 ; v1(6448.52,2765.37) 6490.19,2807.04 6490.19,2825.65 6499.19,2834.65 6499.19,3135 ; v1@6448.52,2770.87 ccw(c6448.52,2784.15) 6457.91,2774.76 ccw(c6467.3,2765.37) v1@6454.02,2765.37 ; v1@6448.52,2774.87 ccw(c6448.52,2797.81) 6464.74,2781.59 ccw(c6480.96,2765.37) v1@6458.02,2765.37 ; 6499.19,3140.43 6499.19,3135 ; v1@6660.69,4089.04 cw(c6637.76,4089.04) 6653.97,4072.82 cw(c6670.19,4056.61) v1@6670.19,4079.54 ; v1@6664.69,4089.04 cw(c6651.41,4089.04) 6660.8,4079.65 cw(c6670.19,4070.26) v1@6670.19,4083.54 ; v1(6670.19,4089.04) 6650,4068.85 6650,4059.81 6523.52,3933.34 6523.52,3666.1 6519.19,3661.77 6515.19,3657.77 6515.19,3260.5 6499.19,3244.5 6499.19,3135 ; 5841.18,4150.63 cw(c5841.18,4168.74) 5828.37,4155.93 ccw(c5841.18,4168.74) 5841.18,4150.63 ; 5841.18,4150.63 ccw(c5841.18,4132.52) 5828.37,4145.33 cw(c5841.18,4132.52) 5841.18,4150.63
  MidLayer2 w4: v1@6073.52,2698.87 cw(c6073.52,2675.94) 6089.74,2692.16 cw(c6105.96,2708.37) v1@6083.02,2708.37 ; v1@6073.52,2702.87 cw(c6073.52,2689.6) 6082.91,2698.99 cw(c6092.3,2708.37) v1@6079.02,2708.37 ; v1(6073.52,2708.37) 6131.86,2650.04 6356.79,2650.04 6448.52,2741.78 v1(6448.52,2765.37) ; v1(6404,4220) 6465,4220 6510,4175 6593.21,4175 6615,4153.21 6615,4110 6635.96,4089.04 v1(6670.19,4089.04) ; v1@6407.89,4216.11 cw(c6417.28,4206.72) 6417.28,4220 cw(c6417.28,4233.28) v1@6407.89,4223.89 ; v1@6410.72,4213.28 cw(c6426.93,4197.06) 6426.93,4220 cw(c6426.93,4242.93) v1@6410.72,4226.72 ; v1@6441.81,2758.66 cw(c6425.59,2742.44) 6448.52,2742.44 cw(c6471.46,2742.44) v1@6455.24,2758.66 ; v1@6444.64,2761.49 cw(c6435.25,2752.1) 6448.52,2752.1 cw(c6461.8,2752.1) v1@6452.41,2761.49 ; v1@6663.47,4082.32 ccw(c6647.26,4066.11) 6647.26,4089.04 ccw(c6647.26,4111.98) v1@6663.47,4095.76 ; v1@6666.3,4085.15 ccw(c6656.91,4075.76) 6656.91,4089.04 ccw(c6656.91,4102.32) v1@6666.3,4092.93
DB_MEM.BUS_D31: U8.P25 U13.53 U17.38 U61.80 | length 5148.9
  Top Layer w4: U8.P25@5803.39,4209.68 v3(5823.07,4229.37) ; U8.P25@5803.39,4217.03 ccw(c5803.39,4234.75) 5815.92,4222.22 ccw(c5828.45,4209.68) U8.P25@5810.73,4209.68 ; v1@6000.14,2806.43 ccw(c5993.06,2813.5) 6003.07,2813.5 ; U61.80@6000.24,2821.32 cw(c5993.41,2814.49) 6003.07,2814.49 cw(c6012.73,2814.49) U61.80@6005.9,2821.32 ; 6003.07,2812.47 ccw(c6019.62,2812.47) v1@6007.92,2800.77 ; U61.80@6003.07,2822.13 ccw(c6029.28,2822.13) v1@6010.75,2803.6 ; U61.80@6003.07,2831.79 ccw(c6038.93,2831.79) v1@6013.57,2806.43 ; U61.80@6003.07,2837.34 6003.07,2810.83 6006.86,2807.04 v1(6006.86,2799.71) ; v1@6571.76,4148.27 ccw(c6584.6,4161.12) 6584.6,4142.95 ; v1(6573.52,4150.04) 6573.52,4143.37 6575.19,4141.71 6581.86,4141.71 6583.1,4142.95 U13.53@6619.41,4142.95 ; v1@6574.58,4151.1 ccw(c6594.26,4170.77) U13.53@6594.26,4142.95 ; v1@6577.41,4153.93 ccw(c6603.91,4180.43) U13.53@6603.91,4142.95 ; v1@6580.24,4156.76 ccw(c6613.57,4190.09) U13.53@6613.57,4142.95 ; U17.38@6619.41,4781.73 6631.86,4781.73 6631.86,4775.04 6648.52,4775.04 6656.86,4766.71 6656.86,4722.37 6661.52,4717.71 6698.52,4717.71 6715.19,4701.04 6715.19,4663.94 6653.86,4602.61 6653.86,4570.96 6706.86,4517.96 6706.86,4369.35 6681.12,4343.61 6681.12,4327.7 6699.02,4309.79 6699.02,4295 6699.02,4280.89 6699.02,4280.23 ; U17.38@6636.97,4777.73 cw(c6636.97,4756.33) 6652.1,4771.46 ; U17.38@6640.35,4774.48 cw(c6644.31,4765.97) 6650.96,4772.61 ; 6698.36,4279.57 6698.36,4266.54 6698.36,4185.91 6706.9,4177.37 ; v1@6700.18,4123.22 ccw(c6683.97,4139.43) 6706.9,4139.43 ccw(c6729.83,4139.43) v1@6713.62,4123.22 ; v1@6703.01,4120.39 ccw(c6693.62,4129.78) 6706.9,4129.78 ccw(c6720.18,4129.78) v1@6710.79,4120.39 ; v1(6706.9,4116.5) 6706.9,4177.33 ; 5810.27,4216.57 cw(c5823.07,4203.76) 5823.07,4221.87 ccw(c5823.07,4203.76) 5810.27,4216.57 ; 5810.27,4216.57 ccw(c5797.46,4229.37) 5815.57,4229.37 cw(c5797.46,4229.37) 5810.27,4216.57 ; U17.38@6644.97,4781.73 ccw(c6652.54,4781.73) 6647.19,4776.38 cw(c6652.54,4781.73) U17.38@6644.97,4781.73
  MidLayer1 w4: v3(5823.07,4229.37) 5881.33,4229.37 5900.75,4229.37 5941.18,4229.37 5949.18,4229.37 5970.63,4229.37 5981.57,4218.43 5998.43,4218.43 6032,4252 6058,4252 6062.62,4252 6080.62,4234 6099.69,4234 6108.37,4234 6177.37,4165 6245,4165 v1(6277,4133) ; v3@5828.26,4224.18 cw(c5840.8,4211.64) 5840.8,4229.37 cw(c5840.8,4247.1) v3@5828.26,4234.56 ; v1@6250.14,2676.66 cw(c6233.92,2660.44) 6256.86,2660.44 cw(c6279.79,2660.44) v1@6263.57,2676.66 ; v1@6252.97,2679.49 cw(c6243.58,2670.1) 6256.86,2670.1 cw(c6270.14,2670.1) v1@6260.75,2679.49 ; v1(6256.86,2683.37) 6256.86,2540.77 6272.59,2525.04 6328.88,2525.04 6340.19,2536.35 6340.19,2608.37 6423.52,2691.71 6423.52,2744.69 6423.52,2770.3 6491.19,2837.96 6491.19,2940.71 6430.86,3001.04 6430.86,3055 6430.86,3087.26 6423.69,3094.42 6423.69,3192.69 6498.52,3267.52 6498.52,3378.35 6498.52,3405 6498.52,3663.73 6503.19,3668.39 6506.36,3671.57 6506.36,3795.49 6506.36,3815 6506.36,4082.88 ; v1@6267.5,4133 ccw(c6244.56,4133) 6260.78,4149.22 ccw(c6277,4165.43) v1@6277,4142.5 ; v1@6271.5,4133 ccw(c6258.22,4133) 6267.61,4142.39 ccw(c6277,4151.78) v1@6277,4138.5 ; 6506.86,4083.37 v1(6573.52,4150.04) ; v1@6564.02,4150.04 cw(c6541.09,4150.04) 6557.31,4133.82 cw(c6573.52,4117.61) v1@6573.52,4140.54 ; v1@6568.02,4150.04 cw(c6554.75,4150.04) 6564.14,4140.65 cw(c6573.52,4131.26) v1@6573.52,4144.54 ; 5841.18,4229.37 cw(c5841.18,4247.48) 5828.37,4234.67 ccw(c5841.18,4247.48) 5841.18,4229.37 ; 5841.18,4229.37 ccw(c5841.18,4211.26) 5828.37,4224.07 cw(c5841.18,4211.26) 5841.18,4229.37
  MidLayer2 w4: v1@6006.86,2790.21 cw(c6006.86,2767.27) 6023.07,2783.49 cw(c6039.29,2799.71) v1@6016.36,2799.71 ; v1@6006.86,2794.21 cw(c6006.86,2780.93) 6016.25,2790.32 cw(c6025.64,2799.71) v1@6012.36,2799.71 ; v1(6006.86,2799.71) 6064.86,2741.71 6088.29,2741.71 6154.95,2675.04 6195,2675.04 6203.33,2683.37 v1(6256.86,2683.37) ; v1@6250.14,2676.66 ccw(c6233.92,2660.44) 6233.92,2683.37 ccw(c6233.92,2706.31) v1@6250.14,2690.09 ; v1@6252.97,2679.49 ccw(c6243.58,2670.1) 6243.58,2683.37 ccw(c6243.58,2696.65) v1@6252.97,2687.26
  Bottom Layer w4: v1(6277,4133) 6390.56,4133 6423.52,4100.04 6523.52,4100.04 v1(6573.52,4150.04) 6582.52,4150.04 6628.35,4150.04 6661.69,4116.71 6680,4116.71 v1@6706.69,4116.71 ; v1@6280.89,4129.11 cw(c6290.28,4119.72) 6290.28,4133 cw(c6290.28,4146.28) v1@6280.89,4136.89 ; v1@6283.72,4126.28 cw(c6299.93,4110.06) 6299.93,4133 cw(c6299.93,4155.93) v1@6283.72,4139.72 ; v1@6564.02,4150.04 cw(c6541.09,4150.04) 6557.31,4133.82 cw(c6573.52,4117.61) v1@6573.52,4140.54 ; v1@6568.02,4150.04 cw(c6554.75,4150.04) 6564.14,4140.65 cw(c6573.52,4131.26) v1@6573.52,4144.54 ; v1@6577.41,4146.15 cw(c6586.8,4136.76) 6586.8,4150.04 cw(c6586.8,4163.32) v1@6577.41,4153.93 ; v1@6580.24,4143.32 cw(c6596.46,4127.11) 6596.46,4150.04 cw(c6596.46,4172.98) v1@6580.24,4156.76