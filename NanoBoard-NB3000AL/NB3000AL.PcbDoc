# Altium PCB NB3000AL.PcbDoc (part 35 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_SDRAM_NRAS: U8.AC24 U12.18 U13.18 | length 1941
  Top Layer w4: U8.AC24@5764.02,3848.01 cw(c5764.02,3830.29) 5776.55,3842.82 cw(c5789.08,3855.35) U8.AC24@5771.36,3855.35 ; U8.AC24@5764.02,3855.35 v3(5783.7,3835.67) ; v1@6046,3627.56 v1(6040.19,3633.37) 6040.19,3618.75 6046,3612.94 6046,3600.08 6056.95,3589.13 6087.61,3589.13 6090.19,3591.71 6098.52,3600.04 6098.52,3616.71 6112.76,3630.95 6118.58,3630.95 6126.64,3639.02 U13.18@6170.59,3639.02 6186.22,3639.02 6193.6,3631.63 v1(6215.19,3610.04) ; U13.18@6147.37,3633.36 ccw(c6133.72,3619.7) 6133.72,3639.02 ccw(c6133.72,3658.33) U13.18@6147.37,3644.67 ; U13.18@6188.15,3631.02 cw(c6188.15,3616.37) 6198.51,3626.73 ; U13.18@6192.15,3639.02 ccw(c6206.47,3639.02) 6196.34,3628.89 ; U13.18@6196.15,3639.02 ccw(c6220.13,3639.01) 6203.17,3622.06 ; v1@6205.69,3610.04 ccw(c6182.76,3610.04) 6198.97,3626.26 ccw(c6215.19,3642.48) v1@6215.19,3619.54 ; v1@6209.69,3610.04 ccw(c6196.41,3610.04) 6205.8,3619.43 ccw(c6215.19,3628.82) v1@6215.19,3615.54 ; v1@6789.19,3657.21 cw(c6789.19,3634.27) 6805.41,3650.49 cw(c6821.63,3666.71) v1@6798.69,3666.71 ; v1@6789.19,3661.21 cw(c6789.19,3647.93) 6798.58,3657.32 cw(c6807.97,3666.71) v1@6794.69,3666.71 ; v1(6789.19,3666.71) 6816.88,3639.02 ; 6802.17,3653.73 ccw(c6828.03,3679.59) U12.18@6828.03,3643.02 ; 6809,3646.9 ccw(c6828.03,3665.93) U12.18@6828.03,3639.02 ; 6815.83,3640.07 ccw(c6828.03,3652.27) U12.18@6828.03,3635.02 ; U12.18@6820.45,3636.45 ccw(c6816.88,3635.25) 6816.88,3639.02 ; U12.18@6820.45,3641.58 cw(c6816.88,3642.78) 6816.88,3639.02 ; U12.18@6845.59,3639.02 6816.88,3639.02 ; 5770.9,3848.47 cw(c5758.09,3835.67) 5776.2,3835.67 ccw(c5758.09,3835.67) 5770.9,3848.47 ; 5770.9,3848.47 ccw(c5783.7,3861.28) 5783.7,3843.17 cw(c5783.7,3861.28) 5770.9,3848.47
  MidLayer1 w4: v3@5785,3828.28 cw(c5788.15,3810.45) 5798.53,3825.28 cw(c5808.92,3840.12) v3@5791.09,3836.97 ; 5798.56,3825.25 ccw(c5816.21,3853.29) 5816.38,3820.16 5900.75,3820.16 5941.18,3820.16 5949.18,3820.16 5959.84,3820.16 5968,3812 5968,3642 5976.63,3633.37 v1(6040.19,3633.37) ; v1@6033.47,3626.66 ccw(c6017.26,3610.44) 6017.26,3633.37 ccw(c6017.26,3656.31) v1@6033.47,3640.09 ; v1@6036.3,3629.49 ccw(c6026.91,3620.1) 6026.91,3633.37 ccw(c6026.91,3646.65) v1@6036.3,3637.26
  Bottom Layer w4: v1(6215.19,3610.04) 6237.33,3610.04 ; v1@6219.18,3606.25 cw(c6228.01,3597.85) 6228.01,3610.04 cw(c6228.01,3622.23) v1@6219.18,3613.83 ; v1@6222.08,3603.49 cw(c6237.33,3588.99) 6237.33,3610.04 ; v1@6222.08,3616.59 ccw(c6237.33,3631.09) 6237.33,3610.04 ; 6450,3600 6449.96,3600.04 ; v1@6782.47,3659.99 ccw(c6766.26,3643.77) 6766.26,3666.71 ccw(c6766.26,3689.64) v1@6782.47,3673.43 ; v1@6785.3,3662.82 ccw(c6775.91,3653.43) 6775.91,3666.71 ccw(c6775.91,3679.99) v1@6785.3,3670.6 ; v1(6789.19,3666.71) 6700.67,3666.71 6695,3672.37 6554.19,3672.37 6481.86,3600.04 6449.96,3600.04 ; 6237.33,3610.04 6247.33,3600.04 6249.5,3597.87 6260,3597.87 6280.4,3597.87 6299.57,3617.04 6307.19,3617.04 6330,3617.04 6432.96,3617.04 6449.96,3600.04
DB_MEM.BUS_SRAM_NCS: U8.D13 U16.6 U17.6 | length 2875.9
  Top Layer w4: v3(5311.26,4623.07) U8.D13@5330.94,4603.39 ; U8.D13@5323.6,4603.39 ccw(c5305.88,4603.39) 5318.41,4615.92 ccw(c5330.94,4628.45) U8.D13@5330.95,4610.73 ; v1@6085.3,4931.74 cw(c6080.51,4923.33) 6090.19,4923.33 ; v1@6085.47,4856.76 ccw(c6069.26,4872.98) 6092.19,4872.98 ccw(c6115.13,4872.98) v1@6098.91,4856.76 ; v1@6088.3,4853.93 ccw(c6078.91,4863.32) 6092.19,4863.32 ccw(c6105.47,4863.32) v1@6096.08,4853.93 ; v1(6090,4940) 6090,4946.05 6090.19,4946.24 6090.19,4940 6090.19,4923.33 ; v1@6092.19,4840.54 cw(c6092.19,4817.61) 6108.41,4833.82 cw(c6124.63,4850.04) v1@6101.69,4850.04 ; v1@6092.19,4844.54 cw(c6092.19,4831.26) 6101.58,4840.65 cw(c6110.97,4850.04) v1@6097.69,4850.04 ; v1@6094.98,4931.91 ccw(c6100.26,4923.33) 6090.19,4923.33 ; U17.6@6147.37,4807.57 ccw(c6133.72,4793.91) 6133.72,4813.23 ccw(c6133.72,4832.54) U17.6@6147.37,4818.88 ; U17.6@6170.59,4813.23 6129,4813.23 v1(6092.19,4850.04) 6092.19,4873.67 6098.52,4880 6098.52,4915 6090.19,4923.33 ; v1(6800.86,4825.04) 6812.67,4813.23 ; U16.6@6821.48,4808.64 ccw(c6812.67,4802.48) 6812.67,4813.23 ; U16.6@6821.48,4817.81 cw(c6812.67,4823.97) 6812.67,4813.23 ; U16.6@6845.59,4813.23 6812.67,4813.23 ; 5324.06,4610.27 cw(c5336.87,4623.07) 5318.76,4623.07 ccw(c5336.87,4623.07) 5324.06,4610.27 ; 5324.06,4610.27 ccw(c5311.26,4597.46) 5311.26,4615.57 cw(c5311.26,4597.46) 5324.06,4610.27
  MidLayer1 w4: v3@5306.07,4628.26 ccw(c5293.53,4640.8) 5311.26,4640.8 ccw(c5328.99,4640.8) v3@5316.45,4628.26 ; v3(5311.26,4623.07) 5311.26,4700.75 5311.26,4741.18 5311.26,4749.18 5311.26,4771.11 5365.19,4825.04 5365.19,4835 5365.19,4844.69 5365.19,4925.38 5369.63,4929.81 5380.06,4940.25 5394.82,4940.25 5408.25,4926.81 5422.75,4926.81 5433,4937.06 ; v1@5426.81,4980.66 cw(c5410.59,4964.44) 5433.52,4964.44 cw(c5456.46,4964.44) v1@5440.24,4980.66 ; v1@5429.64,4983.49 cw(c5420.25,4974.1) 5433.52,4974.1 cw(c5446.8,4974.1) v1@5437.41,4983.49 ; 5433.52,4937.59 5433.52,4951.71 v1(5433.52,4987.37) ; v1@6092.19,4840.54 cw(c6092.19,4817.61) 6108.41,4833.82 cw(c6124.63,4850.04) v1@6101.69,4850.04 ; v1@6092.19,4844.54 cw(c6092.19,4831.26) 6101.58,4840.65 cw(c6110.97,4850.04) v1@6097.69,4850.04 ; v1(6092.19,4850.04) 6122.23,4820 6131.5,4820 6159.5,4848 6229.57,4848 6241.02,4859.46 6241.02,4871.02 6253.37,4883.37 6323.52,4883.37 6376.9,4830 6623.29,4830 6635,4841.71 6719.19,4841.71 6745.52,4815.37 6791.19,4815.37 v1(6800.86,4825.04) ; 5311.26,4641.18 cw(c5293.15,4641.18) 5305.96,4628.37 ccw(c5293.15,4641.18) 5311.26,4641.18 ; 5311.26,4641.18 ccw(c5329.37,4641.18) 5316.56,4628.37 cw(c5329.37,4641.18) 5311.26,4641.18
  MidLayer2 w4: v1(5433.52,4987.37) 5618.58,4987.37 5640.42,5009.21 6070.83,5009.21 6119.5,4960.54 6130.77,4960.54 6141.02,4950.29 6141.02,4935.79 6130.77,4925.54 6114.69,4925.54 6104.46,4925.54 v1(6090,4940) ; v1@5437.41,4983.49 cw(c5446.8,4974.1) 5446.8,4987.37 cw(c5446.8,5000.65) v1@5437.41,4991.26 ; v1@5440.24,4980.66 cw(c5456.46,4964.44) 5456.46,4987.37 cw(c5456.46,5010.31) v1@5440.24,4994.09
DB_PROGRAM.CCLK: R78.1 U30.A2 | length 2118
  Top Layer w4: v1@6511.28,2192.72 ccw(c6495.06,2208.93) 6518,2208.93 ccw(c6540.93,2208.93) v1@6524.72,2192.72 ; v1@6514.11,2189.89 ccw(c6504.72,2199.28) 6518,2199.28 ccw(c6531.28,2199.28) v1@6521.89,2189.89 ; v1(6518,2186) 6518,2217.19 6528.69,2227.87 6539.77,2227.87 6551.29,2239.39 6551.29,2256.29 6557,2262 6560,2265 6695,2265 6709.81,2279.81 6744.62,2279.81 6763,2279.81 6769.81,2273 6769.81,2254.62 6754.09,2238.91 U30.A2@6754.09,2160.28 ; U30.A2@6748.9,2165.47 ccw(c6736.37,2178) 6754.09,2178 ccw(c6771.82,2178) U30.A2@6759.29,2165.47
  MidLayer1 w4: v1(6018.86,3180.64) 6018.86,3176.14 6054.86,3140.14 6054.86,2972.96 6059.81,2968 6059.81,2960 6059.81,2940 6059.81,2916.58 6054.86,2911.63 6054.86,2895 6054.86,2853.35 6040.19,2838.69 6040.19,2750 ; 6040.19,2736.36 6040.19,2750 ; v1@6511.28,2192.72 ccw(c6495.06,2208.93) 6518,2208.93 ccw(c6540.93,2208.93) v1@6524.72,2192.72 ; v1@6514.11,2189.89 ccw(c6504.72,2199.28) 6518,2199.28 ccw(c6531.28,2199.28) v1@6521.89,2189.89 ; v1(6518,2186) 6518,2222 6496.13,2243.87 6476.13,2243.87 ; 6040.19,2750 6040.19,2730.39 6006.86,2697.06 6006.86,2644.69 6184.84,2466.71 6253.19,2466.71 6264.7,2455.2 6264.7,2351.49 6385.31,2230.88 6404.36,2230.88 6417.35,2243.87 6475,2243.87 ; 6475,2243.87 6476.13,2243.87 ; 6475,2243.87 6476.13,2243.87
  Bottom Layer w4: R78.1@5928.18,3195 5980,3195 5995.23,3195 6004.5,3195 v1(6018.86,3180.64) ; R78.1@5931.94,3191.24 cw(c5941.02,3182.16) 5941.02,3195 cw(c5941.02,3207.84) R78.1@5931.94,3198.76 ; R78.1@5934.77,3188.41 cw(c5950.68,3172.5) 5950.68,3195 cw(c5950.68,3217.5) R78.1@5934.77,3201.59
DB_PROGRAM.DIN: R79.2 U30.B3 | length 2316.6
  Top Layer w4: v2(6786,2282) 6786,2268.88 ; 6777.81,2260.69 6777.81,2251.31 6777.62,2251.12 6777.62,2140.95 6777.96,2140.62 ; 6777.81,2260.69 6786,2268.88 ; 6777.81,2260.69 6786,2268.88 ; 6777.96,2140.62 ccw(c6788.11,2140.62) 6780.93,2133.44 ; 6777.96,2140.62 ccw(c6788.11,2140.62) 6780.93,2133.44 ; 6780.93,2133.44 ccw(c6793.46,2145.97) 6793.46,2128.25 cw(c6793.46,2145.97) 6780.93,2133.44 ; 6780.93,2133.44 cw(c6768.4,2120.91) 6786.12,2120.91 ccw(c6768.4,2120.91) 6780.93,2133.44
  MidLayer2 w4: v1@6128.28,3198.28 cw(c6112.06,3182.06) 6135,3182.06 cw(c6157.93,3182.06) v1@6141.72,3198.28 ; v1@6131.11,3201.11 cw(c6121.72,3191.72) 6135,3191.72 cw(c6148.28,3191.72) v1@6138.89,3201.11 ; v1(6135,3205) 6135,3104.71 6140,3099.71 6295,3099.71 ; v2(6786,2282) 6798.52,2294.52 6798.52,2300.04 ; 6295,3099.71 6308.86,3099.71 ; 6295,3099.71 6308.86,3099.71 ; 6295,3099.71 6312.92,3099.71 ; 6308.86,3099.71 6312.92,3099.71 ; 6312.92,3099.71 6320,3099.71 ; 6320,3099.71 6331.48,3099.71 ; 6320,3099.71 6331.48,3099.71 ; 6331.48,3099.71 6363.76,3099.71 6380.09,3083.37 6493.26,2970.21 6619.34,2970.21 6620.17,2971.04 6720.88,2971.04 6721.04,2971.2 6726.01,2971.2 6791.69,2905.53 6791.69,2548.87 6778.19,2535.38 6778.19,2520.62 6790.86,2507.95 6790.86,2491.04 6790.86,2453.64 6809.81,2434.69 6809.81,2415 ; 6798.52,2300.04 6798.52,2305 ; 6798.52,2300.04 6798.52,2305 ; 6798.52,2305 6798.52,2350 ; 6798.52,2350 6798.52,2373.29 ; 6798.52,2350 6798.52,2373.29 ; 6798.52,2373.29 6809.81,2384.58 6809.81,2397.31 ; 6809.81,2397.31 6809.81,2415 ; 6809.81,2397.31 6809.81,2415
  Bottom Layer w4: R79.2@5928.18,3075 5970,3075 ; R79.2@5931.94,3071.24 cw(c5941.02,3062.16) 5941.02,3075 cw(c5941.02,3087.84) R79.2@5931.94,3078.76 ; R79.2@5934.77,3068.41 cw(c5950.68,3052.5) 5950.68,3075 cw(c5950.68,3097.5) R79.2@5934.77,3081.59 ; v1@6128.28,3198.28 cw(c6112.06,3182.06) 6135,3182.06 cw(c6157.93,3182.06) v1@6141.72,3198.28 ; v1@6131.11,3201.11 cw(c6121.72,3191.72) 6135,3191.72 cw(c6148.28,3191.72) v1@6138.89,3201.11 ; v1(6135,3205) 6135,3134.83 6075.17,3075 6063.86,3075 ; 5970,3075 5981.88,3075 ; 5970,3075 5981.88,3075 ; 5981.88,3075 6040,3075 ; 6040,3075 6063.86,3075 ; 6040,3075 6063.86,3075
DB_PROGRAM.DONE: R75.1 R77.1 U4.2 U30.A4 | length 11012.3
  Top Layer w4: U30.A4@6827.64,2165.47 ccw(c6815.11,2178) 6832.83,2178 ccw(c6850.56,2178) U30.A4@6838.03,2165.47 ; U30.A4@6832.83,2160.28 6832.83,2242.83 v2(6839,2249) ; 6832.83,2210.43 cw(c6877.57,2210.43) v2@6845.94,2242.06 ; 6832.83,2220.09 cw(c6867.91,2220.09) v2@6843.11,2244.89 ; 6832.83,2229.74 cw(c6858.26,2229.74) v2@6840.28,2247.72 ; v1@7453.86,2910.21 cw(c7453.86,2887.27) 7470.07,2903.49 cw(c7486.29,2919.71) v1@7463.36,2919.71 ; v1@7453.86,2914.21 cw(c7453.86,2900.93) 7463.25,2910.32 cw(c7472.64,2919.71) v1@7459.36,2919.71 ; v1(7453.86,2919.71) 7474.02,2899.55 7474.02,2859.02 7467.19,2852.19 7467.19,2685 ; 7467.19,2658.06 7467.19,2685 ; 7600.25,2525 7578.06,2547.19 ; v1@7683.74,2501.74 ccw(c7667.53,2485.53) 7667.53,2508.46 ccw(c7667.53,2531.4) v1@7683.74,2515.18 ; v1@7686.57,2504.57 ccw(c7677.18,2495.18) 7677.18,2508.46 ccw(c7677.18,2521.74) v1@7686.57,2512.35 ; v1@7690.48,2512.44 7690.48,2508.48 7616.79,2508.46 7578.06,2547.19 ; 7467.19,2685 7467.19,2632.38 7462.19,2627.38 7462.19,2567.62 7482.62,2547.19 7578.06,2547.19
  MidLayer1 w4: v2(7430,2805) 7430,2850 7453.86,2873.86 v1(7453.86,2919.71) ; v1@7447.14,2912.99 cw(c7430.92,2896.77) 7453.86,2896.77 cw(c7476.79,2896.77) v1@7460.57,2912.99 ; v1@7449.97,2915.82 cw(c7440.58,2906.43) 7453.86,2906.43 cw(c7467.14,2906.43) v1@7457.75,2915.82
  MidLayer2 w4: v1(8010,3600) 8015.15,3600 8060.07,3644.93 ; v1@8010,3601.5 ccw(c8010,3617.55) 8021.35,3606.2 ; v1@8010,3605.5 ccw(c8010,3631.21) 8028.18,3613.03 ; v1@8010,3609.5 ccw(c8010,3644.87) 8035.01,3619.86 ; v1@8019.5,3600 cw(c8030,3600) 8022.58,3607.43 ; 8060,3645 8116.19,3701.19 8116.19,3979.44 8216.02,4079.28 8216.02,4799.21 8206.86,4808.37 v1(8206.86,4883.37) ; v1@8200.14,4876.66 cw(c8183.92,4860.44) 8206.86,4860.44 cw(c8229.79,4860.44) v1@8213.57,4876.66 ; v1@8202.97,4879.49 cw(c8193.58,4870.1) 8206.86,4870.1 cw(c8220.14,4870.1) v1@8210.75,4879.49
  Bottom Layer w4: R77.1@5286.18,5085 5286.18,5083.37 5318.52,5083.37 5391.52,5156.37 5391.52,5181.52 5517.5,5307.5 5903.31,5307.5 5913.19,5317.37 6478,5317.37 6528.67,5266.71 7081.67,5266.71 7090,5275.04 7682.33,5275.04 7757.37,5200 7955,5200 8206.86,4948.14 v1(8206.86,4883.37) ; R77.1@5289.94,5088.27 ccw(c5301.76,5100.08) 5301.76,5083.37 ; R77.1@5292.77,5077.92 cw(c5305.94,5064.75) 5305.94,5083.37 ; R77.1@5292.77,5091.1 ccw(c5311.41,5109.74) 5311.41,5083.37 ; R75.1@5921.59,2707.92 cw(c5905.68,2692.01) 5928.18,2692.01 cw(c5950.68,2692.01) R75.1@5934.77,2707.92 ; R75.1@5924.42,2710.75 cw(c5915.34,2701.67) 5928.18,2701.67 cw(c5941.02,2701.67) R75.1@5931.94,2710.75 ; R75.1@5928.18,2715 5928.18,2690.25 5960.06,2658.37 6290.19,2658.37 6305.05,2673.24 6365.39,2733.57 6375.03,2743.21 6410.01,2743.21 6414.67,2747.87 6450,2747.87 6470.73,2747.87 6471.57,2747.04 6652.52,2747.04 6681.86,2776.37 6689.36,2783.87 6841.3,2783.87 6867.42,2810 7277.52,2810 7375.73,2908.2 7395.3,2908.2 ; v2@6832.06,2255.94 ccw(c6815.31,2272.69) 6839,2272.69 ccw(c6862.69,2272.69) v2@6845.94,2255.94 ; v2@6834.89,2253.11 ccw(c6824.97,2263.03) 6839,2263.03 ccw(c6853.03,2263.03) v2@6843.11,2253.11 ; v2@6839,2251 v2(6839,2249) 6839,2296.77 6851.69,2309.46 6851.69,2337.19 6949.81,2435.31 6949.81,2456.69 6912.5,2494 6912.5,2527.5 6935.5,2550.5 7012.38,2550.5 7025.38,2563.5 7061.81,2563.5 7084.81,2540.5 7193.25,2540.5 7222,2569.25 7222,2673.93 7353.07,2805 v2(7430,2805) 7503.04,2805 7533,2775.04 7705,2775.04 7889.58,2775.04 8040.52,2925.98 8040.52,3225 8039.5,3226.02 8039.5,3575.73 v1@8015.19,3600.04 ; 7395.47,2908.04 7442.19,2908.04 v1(7453.86,2919.71) ; v2@7423.06,2798.06 ccw(c7406.31,2781.31) 7406.31,2805 ccw(c7406.31,2828.69) v2@7423.06,2811.94 ; v2@7425.89,2800.89 ccw(c7415.97,2790.97) 7415.97,2805 ccw(c7415.97,2819.03) v2@7425.89,2809.11 ; v2@7434.11,2800.89 cw(c7444.03,2790.97) 7444.03,2805 cw(c7444.03,2819.03) v2@7434.11,2809.11 ; v2@7436.94,2798.06 cw(c7453.69,2781.31) 7453.69,2805 cw(c7453.69,2828.69) v2@7436.94,2811.94 ; v1(7690.46,2508.46) 7706.65,2508.46 ; v1@7698.76,2503.83 cw(c7706.65,2499.42) 7706.65,2508.46 ; v1@7698.76,2513.09 ccw(c7706.65,2517.5) 7706.65,2508.46 ; 7739.69,2541.5 7739.69,2534.5 7727.38,2522.19 7720.38,2522.19 7706.65,2508.46 ; 7739.69,2542.27 7759.61,2562.19 7792.19,2562.19 7802,2572 7857.75,2572 7861.29,2575.54 7882.42,2575.54 7897.36,2560.6 7897.36,2537.81 7890.19,2530.64 7890.19,2497.03 7895.52,2491.71 7906.86,2491.71 7930,2468.56 U4.2@7930,2344.88 ; U4.2@7923.06,2365.6 ccw(c7906.31,2382.35) 7930,2382.35 ccw(c7953.68,2382.35) U4.2@7936.94,2365.6 ; U4.2@7925.89,2362.77 ccw(c7915.97,2372.69) 7930,2372.69 ccw(c7944.03,2372.69) U4.2@7934.11,2362.77 ; v1@8010,3590.5 cw(c8010,3554.94) 8035.15,3580.08 ; v1@8010,3594.5 cw(c8010,3568.59) 8028.32,3586.91 ; v1@8010,3598.5 cw(c8010,3582.25) 8021.49,3593.74 ; v1(8010,3600) v1@8015.15,3600 ; v1@8015.19,3600.19 v1@8015.19,3600.04 ; v1@8019.5,3600 ccw(c8029.81,3600) 8022.52,3592.71 ; v1@8200.14,4890.09 ccw(c8183.92,4906.31) 8206.86,4906.31 ccw(c8229.79,4906.31) v1@8213.57,4890.09 ; v1@8202.97,4887.26 ccw(c8193.58,4896.65) 8206.86,4896.65 ccw(c8220.14,4896.65) v1@8210.75,4887.26 ; v1@8015.15,3600 v1@8015.19,3600.04
DB_PROGRAM.ID0: NT4.1 U30.P14 | length 488.8
  Top Layer w4: U30.P14@7226.54,1641.12 cw(c7226.54,1623.4) 7239.07,1635.93 cw(c7251.6,1648.46) U30.P14@7233.88,1648.46 ; U30.P14@7226.54,1648.46 v3(7246.22,1628.78) ; 7233.42,1641.58 cw(c7220.61,1628.78) 7238.72,1628.78 ccw(c7220.61,1628.78) 7233.42,1641.58 ; 7233.42,1641.58 ccw(c7246.22,1654.39) 7246.22,1636.28 cw(c7246.22,1654.39) 7233.42,1641.58
  MidLayer1 w4: v3@7244.92,1621.39 cw(c7241.77,1603.56) 7256.61,1613.95 ; v1@7248.28,1401.72 ccw(c7232.06,1417.93) 7255,1417.93 ccw(c7277.94,1417.93) v1@7261.72,1401.72 ; v1@7251.11,1398.89 ccw(c7241.72,1408.28) 7255,1408.28 ccw(c7268.28,1408.28) v1@7258.89,1398.89 ; v3@7253.61,1627.48 ccw(c7271.44,1624.33) 7256.61,1613.95 ; v1(7255,1395) 7255,1450 7261.73,1456.73 7261.73,1511.73 7261.73,1596.1 ccw(c7228.6,1596.27) 7256.64,1613.92
  Bottom Layer w4: v1@7248.28,1388.28 cw(c7239.31,1379.31) NT4.1@7252,1379.31 ; NT4.1@7252,1372.8 cw(c7268.47,1372.8) v1@7259.93,1386.88 ; NT4.1@7252,1379.86 ccw(c7258.28,1379.86) NT4.1@7255,1374.5 ; NT4.1@7252,1379.9 cw(c7264.16,1379.9) v1@7257.85,1390.3 ; NT4.1@7255,1370 7252,1373 7252,1387 v1@7255,1390
DB_PROGRAM.ID1: NT5.1 U30.D4 | length 495.3
  Top Layer w4: v3(6813.15,2061.85) U30.D4@6832.83,2042.17 ; U30.D4@6825.49,2042.17 ccw(c6807.77,2042.16) 6820.3,2054.7 ccw(c6832.83,2067.23) U30.D4@6832.83,2049.51 ; 6825.95,2049.05 cw(c6838.76,2061.85) 6820.65,2061.85 ccw(c6838.76,2061.85) 6825.95,2049.05 ; 6825.95,2049.05 ccw(c6813.15,2036.24) 6813.15,2054.35 cw(c6813.15,2036.24) 6825.95,2049.05
  MidLayer1 w4: v1@6768.61,2305.24 cw(c6762.65,2295.37) 6774.19,2295.37 ; v1(6773.52,2313.37) 6774.19,2312.71 6774.19,2295.38 ; v1@6779.34,2305.86 ccw(c6787.46,2295.37) 6774.19,2295.37 ; 6789.29,2138.66 6789.29,2124.73 ; v3@6805.76,2063.15 ccw(c6787.93,2066.3) 6802.76,2076.68 ; v3@6814.45,2069.24 cw(c6817.6,2087.07) 6802.76,2076.68 ; 6774.19,2295.38 6774.13,2295.38 6763.69,2284.94 6763.69,2275.5 6769.81,2269.38 6769.81,2251.19 6789.29,2231.71 6789.29,2198.85 6789.29,2124.73 ; 6789.29,2124.73 6789.29,2101.48 ccw(c6813.06,2101.48) 6795.68,2085.26 6802.76,2076.68
  Bottom Layer w4: v1@6766.81,2320.09 ccw(c6759.1,2327.8) NT5.1@6770,2327.8 ; NT5.1@6770,2328.36 ccw(c6781.45,2328.36) v1@6776.1,2318.24 ; NT5.1@6770,2335 ccw(c6784.96,2335) v1@6777.97,2321.77 ; NT5.1@6770,2335 6770,2323.37 6773.52,2319.85 v1(6773.52,2313.37)
DB_PROGRAM.ID2: NT6.1 U30.R11 | length 1112.5
  Top Layer w4: 7124.93,1499.07 ccw(c7138.23,1512.36) v2@7140.71,1493.73 ; 7126.67,1497.33 cw(c7113.33,1484) v2@7132.19,1484 ; 7130.66,1493.34 ccw(c7139.57,1502.25) v2@7141.23,1489.76 ; v2@7140,1484 7123.93,1500.07 7123.93,1589.38 ; 7120.96,1596.56 cw(c7113.78,1589.38) 7123.93,1589.38 ; 7120.96,1596.56 cw(c7113.78,1589.38) 7123.93,1589.38 ; 7120.96,1596.56 ccw(c7108.42,1584.03) 7108.42,1601.75 cw(c7108.42,1584.03) 7120.96,1596.56 ; 7120.96,1596.56 cw(c7133.49,1609.09) 7115.77,1609.09 ccw(c7133.49,1609.09) 7120.96,1596.56
  MidLayer1 w4: v2@7101,1278.81 ccw(c7101,1292.84) 7110.92,1282.92 ccw(c7120.84,1273) v2@7106.81,1273 ; v2@7101,1282.81 ccw(c7101,1306.5) 7117.75,1289.75 ccw(c7134.5,1273) v2@7110.81,1273 ; v2@7107,1273 7102.5,1273 v2(7101,1273) 7118.81,1290.81 7118.81,1349.5 7113.5,1354.81 7113.5,1453.5 v2@7142,1482 ; 7123.84,1463.84 ccw(c7103.67,1484) v2@7132.19,1484 ; 7128.67,1468.67 cw(c7142,1455.33) v2@7142,1474.19 ; 7130.67,1470.67 ccw(c7117.33,1484) v2@7136.19,1484
  MidLayer2 w4: v2@7094.06,1266.06 cw(c7077.31,1249.31) 7101,1249.31 cw(c7124.69,1249.31) v2@7107.94,1266.06 ; v2@7096.89,1268.89 cw(c7086.97,1258.97) 7101,1258.97 cw(c7115.03,1258.97) v2@7105.11,1268.89 ; v1@7234.5,1274 cw(c7211.56,1274) 7227.78,1257.78 cw(c7244,1241.56) v1@7244,1264.5 ; v1@7238.5,1274 cw(c7225.22,1274) 7234.61,1264.61 cw(c7244,1255.22) v1@7244,1268.5 ; v1(7244,1274) 7208.19,1238.19 7149,1238.19 ; v2@7101,1265.81 v2(7101,1273) v2@7101,1265.81 ; v2@7101,1265.81 7101,1249 7111.81,1238.19 ; 7111.81,1238.19 7149,1238.19 ; 7111.81,1238.19 7128.62,1238.19 ; 7128.62,1238.19 7149,1238.19 ; 7128.62,1238.19 7149,1238.19
  Bottom Layer w4: NT6.1@7212.17,1342.67 cw(c7204.14,1334.64) 7215.5,1334.64 ; NT6.1@7215,1350 NT6.1@7215.5,1349.5 ; 7215.5,1337.05 cw(c7223.45,1337.05) NT6.1@7217.83,1342.67 ; NT6.1@7218.57,1346.43 NT6.1@7215.5,1349.5 ; v1@7234.5,1274 ccw(c7211.56,1274) 7227.78,1290.22 ccw(c7244,1306.43) v1@7244,1283.5 ; v1@7238,1274 v1(7244,1274) 7215.5,1302.5 NT6.1@7215.5,1349.5 ; v1@7238.5,1274 ccw(c7225.22,1274) 7234.61,1283.39 ccw(c7244,1292.78) v1@7244,1279.5
  other v2: 7142,1484
DB_PROGRAM.ID3: NT7.1 U30.B4 | length 404.1
  Top Layer w4: v2@6807.93,2268.29 cw(c6788.39,2243.44) 6820,2243.44 ; v2@6810.41,2271.43 cw(c6794.87,2251.68) 6820,2251.68 ; v2@6812.88,2274.58 cw(c6801.35,2259.92) 6820,2259.92 ; v2(6814,2276) 6820,2270 6820,2244 6817.33,2241.33 6817.33,2140.62 ; 6817.33,2140.62 ccw(c6827.48,2140.62) 6820.3,2133.44 ; 6817.33,2140.62 ccw(c6827.48,2140.62) 6820.3,2133.44 ; 6820.3,2133.44 ccw(c6832.83,2145.97) 6832.83,2128.25 cw(c6832.83,2145.97) 6820.3,2133.44 ; 6820.3,2133.44 cw(c6807.77,2120.91) 6825.49,2120.91 ccw(c6807.77,2120.91) 6820.3,2133.44
  Bottom Layer w4: NT7.1@6800,2335 6800,2318.15 6813.15,2305 6813.15,2276 6813.15,2275.47 6813.46,2275.46 v2(6814,2276) ; v2@6807.06,2282.94 ccw(c6792.37,2297.63) 6813.15,2297.63 ; v2@6809.89,2280.11 ccw(c6802.02,2287.98) 6813.15,2287.98 ; 6813.15,2292.08 ccw(c6830.08,2292.08) v2@6818.11,2280.11 ; 6813.15,2301.74 ccw(c6839.74,2301.74) v2@6820.94,2282.94
DB_PROGRAM.INIT: R76.1 R80.2 U30.D6 | length 8703.1
  Top Layer w4: v1@5958,2984 v1(5960,2986) ; v3(6891.89,2061.85) U30.D6@6911.57,2042.17 ; U30.D6@6904.23,2042.17 ccw(c6886.51,2042.16) 6899.04,2054.7 ccw(c6911.57,2067.23) U30.D6@6911.57,2049.51 ; 6904.69,2049.05 cw(c6917.5,2061.85) 6899.39,2061.85 ccw(c6917.5,2061.85) 6904.69,2049.05 ; 6904.69,2049.05 ccw(c6891.89,2036.24) 6891.89,2054.35 cw(c6891.89,2036.24) 6904.69,2049.05
  MidLayer1 w4: v1@5525.34,5119.29 ccw(c5509.12,5135.5) 5532.05,5135.5 ccw(c5554.99,5135.5) v1@5538.77,5119.29 ; v1@5528.16,5116.46 ccw(c5518.78,5125.85) 5532.05,5125.85 ccw(c5545.33,5125.85) v1@5535.94,5116.46 ; v1(5532.05,5112.57) 5532.05,5285.94 5690.19,5444.08 5690.19,5530.19 5810.04,5650.04 6442.56,5650.04 6818.6,5274 7324.57,5274 v1(7555.52,5043.04) ; v1@5922.22,2671.47 ccw(c5906,2687.69) 5928.94,2687.69 ccw(c5951.87,2687.69) v1@5935.65,2671.47 ; v1@5925.05,2668.64 ccw(c5915.66,2678.03) 5928.94,2678.03 ccw(c5942.21,2678.03) v1@5932.82,2668.64 ; v1(5928.94,2664.75) 5928.94,2694.94 5920,2703.88 5920,2764.49 5922.69,2767.18 5922.69,2782.29 5924,2783.6 5924,2928 5959,2963 5959,2985 v1(5960,2986) ; v1@5953.28,2979.28 cw(c5939.48,2965.48) 5959,2965.48 ; 5959,2962.98 cw(c5979.99,2962.98) v1@5966.23,2978.83 ; 5959,2971.75 cw(c5972.37,2971.75) v1@5963.61,2981.85 ; 6868.03,2138.66 6868.03,2124.73 ; v3@6884.5,2063.15 ccw(c6866.67,2066.3) 6881.5,2076.68 ; v3@6893.19,2069.24 cw(c6896.34,2087.07) 6881.5,2076.68 ; v1(6958,2726) 6958,2712.5 6956.36,2710.86 6956.36,2589.17 6878.69,2511.5 6878.69,2482.19 6864.19,2467.69 6864.19,2271.69 6868.03,2267.85 6868.03,2198.85 6868.03,2124.73 ; v1(7073.52,2791.71) 7159.23,2791.71 7253.89,2886.37 7269.69,2902.17 7269.69,3062.87 7279.29,3072.47 7298.52,3091.71 7298.52,4201.35 7348.86,4251.69 7348.86,4330.17 7399.86,4381.17 7399.86,4465.14 7372.5,4492.5 7372.5,4524.02 7374.02,4525.53 7374.02,4632.88 7372.52,4634.37 7372.52,4717.52 7463.21,4808.21 7489.83,4808.21 7515,4833.37 v1(7549.52,4833.37) ; v1@7077.41,2787.82 cw(c7086.8,2778.43) 7086.8,2791.71 cw(c7086.8,2804.99) v1@7077.41,2795.6 ; v1@7080.24,2784.99 cw(c7096.46,2768.77) 7096.46,2791.71 cw(c7096.46,2814.64) v1@7080.24,2798.42 ; v1@7542.81,4826.66 ccw(c7526.59,4810.44) 7526.59,4833.37 ccw(c7526.59,4856.31) v1@7542.81,4840.09 ; v1@7545.64,4829.49 ccw(c7536.25,4820.1) 7536.25,4833.37 ccw(c7536.25,4846.65) v1@7545.64,4837.26 ; v1@7546.02,5043.04 ccw(c7523.09,5043.04) 7539.31,5059.26 ccw(c7555.52,5075.48) v1@7555.52,5052.54 ; v1@7550.02,5043.04 ccw(c7536.75,5043.04) 7546.14,5052.43 ccw(c7555.52,5061.82) v1@7555.52,5048.54 ; 6868.03,2124.73 6868.03,2101.48 ccw(c6891.8,2101.48) 6874.42,2085.26 6881.5,2076.68
  Bottom Layer w4: R80.2@5418.68,5085 5480,5085 5507.57,5112.57 v1(5532.05,5112.57) ; R80.2@5422.44,5081.24 cw(c5431.52,5072.16) 5431.52,5085 cw(c5431.52,5097.84) R80.2@5422.44,5088.76 ; R80.2@5425.27,5078.41 cw(c5441.18,5062.5) 5441.18,5085 cw(c5441.18,5107.5) R80.2@5425.27,5091.59 ; v1@5525.34,5105.85 ccw(c5509.12,5089.63) 5509.12,5112.57 ccw(c5509.12,5135.5) v1@5525.34,5119.29 ; v1@5528.16,5108.68 ccw(c5518.78,5099.29) 5518.78,5112.57 ccw(c5518.78,5125.85) v1@5528.16,5116.46 ; R76.1@5928.18,2955 5957.18,2984 v1@5958,2984 ; R76.1@5928.18,2960.81 ccw(c5928.18,2974.84) R76.1@5938.1,2964.92 ; R76.1@5928.18,2964.81 ccw(c5928.18,2988.5) 5944.93,2971.75 ; v1(5928.94,2664.75) 5943.65,2650.04 6045.27,2650.04 ; R76.1@5933.5,2955.49 cw(c5945.15,2955.49) R76.1@5936.91,2963.73 ; R76.1@5937.5,2955.49 cw(c5958.81,2955.49) 5943.74,2970.56 ; 5942.38,2969.2 cw(c5960,2951.59) v1@5960,2976.5 ; 5944.36,2971.18 ccw(c5929.54,2986) v1@5950.5,2986 ; 5949.21,2976.03 cw(c5960,2965.24) v1@5960,2980.5 ; 5951.19,2978.01 ccw(c5943.2,2986) v1@5954.5,2986 ; 6045.44,2650.21 6356.96,2650.21 6415.5,2708.75 6415.5,2733.25 6422.13,2739.87 6467.42,2739.87 6469.08,2738.21 6655.01,2738.21 6692.67,2775.87 6908.13,2775.87 v1(6958,2726) 6958,2762 6965.11,2769.11 ; v1@6948.5,2726 ccw(c6925.56,2726) 6941.78,2742.22 ccw(c6958,2758.43) v1@6958,2735.5 ; v1@6951.28,2732.72 ccw(c6935.06,2748.93) 6958,2748.93 ccw(c6980.93,2748.93) v1@6964.72,2732.72 ; v1@6952.5,2726 ccw(c6939.22,2726) 6948.61,2735.39 ccw(c6958,2744.78) v1@6958,2731.5 ; v1@6954.11,2729.89 ccw(c6944.72,2739.28) 6958,2739.28 ccw(c6971.28,2739.28) v1@6961.89,2729.89 ; 6960,2764 6965.11,2769.11 ; v1@7066.81,2784.99 ccw(c7050.59,2768.77) 7050.59,2791.71 ccw(c7050.59,2814.64) v1@7066.81,2798.42 ; v1@7069.64,2787.82 ccw(c7060.25,2778.43) 7060.25,2791.71 ccw(c7060.25,2804.99) v1@7069.64,2795.6 ; v1(7073.52,2791.71) 6987.71,2791.71 6965.11,2769.11 ; v1@7542.81,4840.09 ccw(c7526.59,4856.31) 7549.52,4856.31 ccw(c7572.46,4856.31) v1@7556.24,4840.09 ; v1@7545.64,4837.26 ccw(c7536.25,4846.65) 7549.52,4846.65 ccw(c7562.8,4846.65) v1@7553.41,4837.26 ; v1@7548.81,5036.32 cw(c7532.59,5020.11) 7555.52,5020.11 cw(c7578.46,5020.11) v1@7562.24,5036.32 ; v1(7549.52,4833.37) 7549.52,4999 7555.52,5005 v1(7555.52,5043.04) ; v1@7551.64,5039.15 cw(c7542.25,5029.76) 7555.52,5029.76 cw(c7568.8,5029.76) v1@7559.41,5039.15
DB_PROGRAM.M0: R81.1 U30.K9 | length 3899.2
  Top Layer w4: v1(6570,1888) 6568.19,1886.19 6568.19,1763.31 6573.81,1757.69 6573.81,1710.56 6552.81,1689.56 6552.81,1561.56 6547.5,1556.25 6547.5,1540.53 6556.5,1531.53 6556.5,1285.5 6670,1172 6737,1172 v2(6755,1190) ; v2@6745.19,1190 cw(c6721.5,1190) 6738.25,1173.25 cw(c6755,1156.5) v2@6755,1180.19 ; v2@6749.19,1190 cw(c6735.16,1190) 6745.08,1180.08 cw(c6755,1170.16) v2@6755,1184.19 ; U30.K9@7029.68,1798.6 cw(c7029.68,1780.88) 7042.22,1793.41 cw(c7054.75,1805.94) U30.K9@7037.03,1805.94 ; U30.K9@7029.69,1805.94 v3(7049.37,1786.26) ; 7036.57,1799.06 cw(c7023.76,1786.26) 7041.87,1786.26 ccw(c7023.76,1786.26) 7036.57,1799.06 ; 7036.57,1799.06 ccw(c7049.37,1811.87) 7049.37,1793.76 cw(c7049.37,1811.87) 7036.57,1799.06
  MidLayer1 w4: v1@5935.28,2875.28 cw(c5919.06,2859.06) 5942,2859.06 cw(c5964.93,2859.06) v1@5948.72,2875.28 ; v1@5938.11,2878.11 cw(c5928.72,2868.72) 5942,2868.72 cw(c5955.28,2868.72) v1@5945.89,2878.11 ; v1(5942,2882) 5942,2797.98 5957.69,2782.29 5957.69,2767.79 5930.19,2740.29 5930.19,2705 5946.44,2688.75 5946.44,2617.03 5989.52,2573.94 5989.52,2498.34 6062.82,2425.04 v1(6091.86,2425.04) ; v1@6085.14,2418.32 ccw(c6068.92,2402.11) 6068.92,2425.04 ccw(c6068.92,2447.98) v1@6085.14,2431.76 ; v1@6087.97,2421.15 ccw(c6078.58,2411.76) 6078.58,2425.04 ccw(c6078.58,2438.32) v1@6087.97,2428.93 ; v1(6245.19,2441.71) 6256.7,2430.2 6256.7,2350.86 6248,2342.16 6248,2185.5 6252.29,2181.21 6290.5,2143 6290.5,2049.5 6390.46,1949.54 6519.52,1949.54 6570,1899.06 v1(6570,1888)
  MidLayer2 w4: v1(6091.86,2425.04) 6108.52,2441.71 v1(6245.19,2441.71) ; v1@6091.86,2430.54 ccw(c6091.86,2443.82) 6101.25,2434.43 ccw(c6110.64,2425.04) v1@6097.36,2425.04 ; v1@6091.86,2434.54 ccw(c6091.86,2457.48) 6108.07,2441.26 ccw(c6124.29,2425.04) v1@6101.36,2425.04 ; v1@6238.47,2434.99 ccw(c6222.26,2418.77) 6222.26,2441.71 ccw(c6222.26,2464.64) v1@6238.47,2448.43 ; v1@6241.3,2437.82 ccw(c6231.91,2428.43) 6231.91,2441.71 ccw(c6231.91,2454.99) v1@6241.3,2445.6 ; v2(6755,1190) 6823.25,1190 6842.75,1170.5 6868.56,1170.5 6909.72,1211.66 6909.72,1235.34 6924.19,1249.81 6938.06,1249.81 6983.29,1295.04 v2(6983.29,1351.33) ; v2@6759.11,1185.89 cw(c6769.03,1175.97) 6769.03,1190 cw(c6769.03,1204.03) v2@6759.11,1194.11 ; v2@6761.94,1183.06 cw(c6778.69,1166.31) 6778.69,1190 cw(c6778.69,1213.69) v2@6761.94,1196.94 ; v2@6976.35,1344.39 cw(c6959.61,1327.64) 6983.29,1327.64 cw(c7006.98,1327.64) v2@6990.23,1344.39 ; v2@6979.18,1347.22 cw(c6969.26,1337.3) 6983.29,1337.3 cw(c6997.32,1337.3) v2@6987.4,1347.22
  Bottom Layer w4: R81.1@5921.59,2842.08 ccw(c5905.68,2857.99) 5928.18,2857.99 ccw(c5950.68,2857.99) R81.1@5934.77,2842.08 ; R81.1@5924.42,2839.25 ccw(c5915.34,2848.33) 5928.18,2848.33 ccw(c5941.02,2848.33) R81.1@5931.94,2839.25 ; R81.1@5928.18,2835 5928.18,2868.18 v1(5942,2882) ; v1(6570,1888) 6572,1890 6572,1890.18 v1@6573.52,1891.71 ; v2@6976.35,1358.26 ccw(c6959.61,1375.01) 6983.29,1375.01 ccw(c7006.98,1375.01) v2@6990.23,1358.26 ; v2@6979.18,1355.44 ccw(c6969.26,1365.36) 6983.29,1365.36 ccw(c6997.32,1365.36) v2@6987.4,1355.44 ; v2(6983.29,1351.33) 6983.29,1391.79 7069.81,1478.31 7069.81,1502.78 7064.88,1507.71 7064.88,1669.21 7064.88,1753.58 ccw(c7031.75,1753.75) 7059.79,1771.4 ; v3@7048.07,1778.87 cw(c7044.92,1761.04) 7059.76,1771.43 cw(c7074.59,1781.81) v3@7056.76,1784.96
DB_PROGRAM.PROGRAM: R70.1 R74.1 U30.T9 | length 14014.7
  Top Layer w4: v1@3208.47,5968.32 cw(c3192.26,5952.11) 3215.19,5952.11 cw(c3238.13,5952.11) v1@3221.91,5968.32 ; v1@3211.3,5971.15 cw(c3201.91,5961.76) 3215.19,5961.76 cw(c3228.47,5961.76) v1@3219.08,5971.15 ; v1(3215.19,5975.04) 3215.19,5224.81 3461.52,4978.48 3461.52,3045.37 v1(3481.86,3025.04) ; v1@3472.36,3025.04 ccw(c3449.42,3025.04) 3465.64,3041.26 ccw(c3481.86,3057.48) v1@3481.86,3034.54 ; v1@3476.36,3025.04 ccw(c3463.08,3025.04) 3472.47,3034.43 ccw(c3481.86,3043.82) v1@3481.86,3030.54 ; v1@4609.81,2940.66 cw(c4593.59,2924.44) 4616.52,2924.44 cw(c4639.46,2924.44) v1@4623.24,2940.66 ; v1@4612.64,2943.49 cw(c4603.25,2934.1) 4616.52,2934.1 cw(c4629.8,2934.1) v1@4620.41,2943.49 ; v1@4615.19,2947.37 v1(4616.52,2947.37) 4616.52,2875.37 v1(4658.52,2833.37) ; v1@4649.02,2833.37 ccw(c4626.09,2833.37) 4642.31,2849.59 ccw(c4658.52,2865.81) v1@4658.52,2842.87 ; v1@4653.02,2833.37 ccw(c4639.75,2833.37) 4649.14,2842.76 ccw(c4658.52,2852.15) v1@4658.52,2838.87 ; v1@5458.47,6085.99 cw(c5442.26,6069.77) 5465.19,6069.77 cw(c5488.13,6069.77) v1@5471.91,6085.99 ; v1@5461.3,6088.82 cw(c5451.91,6079.43) 5465.19,6079.43 cw(c5478.47,6079.43) v1@5469.08,6088.82 ; v1(5465.19,6092.71) 5465.19,5816.71 5548.52,5733.37 5681.86,5733.37 5706.86,5708.37 v1(5706.86,5232.04) ; v1@5700.14,5238.76 ccw(c5683.92,5254.98) 5706.86,5254.98 ccw(c5729.79,5254.98) v1@5713.57,5238.76 ; v1@5702.97,5235.93 ccw(c5693.58,5245.32) 5706.86,5245.32 ccw(c5720.14,5245.32) v1@5710.75,5235.93 ; v2(6183,1733) 6240.19,1790.19 v1(6240.19,1850.04) ; v2@6183,1738.81 ccw(c6183,1752.84) 6192.92,1742.92 ccw(c6202.84,1733) v2@6188.81,1733 ; v2@6183,1742.81 ccw(c6183,1766.5) 6199.75,1749.75 ccw(c6216.5,1733) v2@6192.81,1733 ; v1@6233.47,1843.32 cw(c6217.26,1827.11) 6240.19,1827.11 cw(c6263.13,1827.11) v1@6246.91,1843.32 ; v1@6236.3,1846.15 cw(c6226.91,1836.76) 6240.19,1836.76 cw(c6253.47,1836.76) v1@6244.08,1846.15 ; v2@7013.56,1508.45 ccw(c6974.63,1547.38) 7029.68,1547.38 ; v2@7016.39,1505.62 ccw(c6984.29,1537.72) 7029.68,1537.72 ; v2@7019.22,1502.79 ccw(c6993.95,1528.06) 7029.68,1528.06 ; v2(7020.5,1501.51) 7029.68,1510.7 U30.T9@7029.69,1569.72 ; v2@7022.05,1499.96 ccw(c7003.6,1518.4) 7029.68,1518.4 ; U30.T9@7024.49,1564.53 cw(c7011.96,1552) 7029.68,1552 cw(c7047.41,1552) U30.T9@7034.88,1564.53
  MidLayer1 w4: v1(3215.19,5975.04) 3431.86,6191.71 5215.19,6191.71 5315.19,6091.71 5465.19,6091.71 v1(5465.19,6092.71) ; v1@3215.19,5980.54 ccw(c3215.19,5993.82) 3224.58,5984.43 ccw(c3233.97,5975.04) v1@3220.69,5975.04 ; v1@3215.19,5984.54 ccw(c3215.19,6007.48) 3231.41,5991.26 ccw(c3247.63,5975.04) v1@3224.69,5975.04 ; v1@4658.52,2823.87 cw(c4658.52,2800.94) 4674.74,2817.16 cw(c4690.96,2833.37) v1@4668.02,2833.37 ; v1@4658.52,2827.87 cw(c4658.52,2814.6) 4667.91,2823.99 cw(c4677.3,2833.37) v1@4664.02,2833.37 ; v1(4658.52,2833.37) 4700.19,2791.71 v1(4731.86,2791.71) ; v1@4725.14,2784.99 ccw(c4708.92,2768.77) 4708.92,2791.71 ccw(c4708.92,2814.64) v1@4725.14,2798.43 ; v1@4727.97,2787.82 ccw(c4718.58,2778.43) 4718.58,2791.71 ccw(c4718.58,2804.99) v1@4727.97,2795.6 ; 5439.84,6091.71 ccw(c5439.84,6118.06) v1@5458.47,6099.43 ; 5444.67,6091.71 cw(c5444.67,6072.19) v1@5458.47,6085.99 ; 5449.5,6091.71 ccw(c5449.5,6108.4) v1@5461.3,6096.6 ; v1@5850.14,2351.66 cw(c5833.92,2335.44) 5856.86,2335.44 cw(c5879.79,2335.44) v1@5863.57,2351.66 ; v1@5852.97,2354.49 cw(c5843.58,2345.1) 5856.86,2345.1 cw(c5870.14,2345.1) v1@5860.75,2354.49 ; v1(5856.86,2358.37) 5856.86,2312.63 5927.78,2241.71 6095,2241.71 6126.5,2241.71 6133.29,2241.71 6163.92,2211.08 6163.92,2204.29 6163.92,2142.26 6163.92,2130 6163.92,2094.36 6173.81,2084.47 6173.81,2030.69 6173.81,2009.31 6163.92,1999.42 6163.92,1926.31 v1(6240.19,1850.04) ; v2@6176.06,1726.06 cw(c6159.31,1709.31) 6183,1709.31 cw(c6206.69,1709.31) v2@6189.94,1726.06 ; v2@6178.89,1728.89 cw(c6168.97,1718.97) 6183,1718.97 cw(c6197.03,1718.97) v2@6187.11,1728.89 ; v2(6183,1733) 6183,1702 6273.02,1611.98 6273.02,1591.96 6281.81,1583.17 6281.81,1502.62 6271.5,1492.31 6255,1475.81 v2(6255,1399) ; v1@6230.69,1850.04 ccw(c6207.76,1850.04) 6223.97,1866.26 ccw(c6240.19,1882.48) v1@6240.19,1859.54 ; v1@6234.69,1850.04 ccw(c6221.41,1850.04) 6230.8,1859.43 ccw(c6240.19,1868.82) v1@6240.19,1855.54 ; v2@6248.06,1405.94 ccw(c6231.31,1422.69) 6255,1422.69 ccw(c6278.69,1422.69) v2@6261.94,1405.94 ; v2@6250.89,1403.11 ccw(c6240.97,1413.03) 6255,1413.03 ccw(c6269.03,1413.03) v2@6259.11,1403.11 ; v2@7013.56,1494.57 cw(c6996.81,1477.82) 7020.5,1477.82 cw(c7044.18,1477.82) v2@7027.44,1494.57 ; v2@7014,1283.06 7031.81,1300.87 7031.81,1339.31 6990.47,1380.65 6990.47,1402.03 7026.38,1437.95 ; v2@7014,1287.81 ccw(c7014,1299.27) 7022.1,1291.17 ; v2@7014,1291.81 ccw(c7014,1312.93) 7028.93,1298 ; v2@7016.39,1497.4 cw(c7006.47,1487.48) 7020.5,1487.48 cw(c7034.53,1487.48) v2@7024.61,1497.4 ; v2@7019.81,1282 cw(c7036.41,1282) 7024.67,1293.74 ; v2(7020.5,1501.51) 7020.5,1477.5 7032.19,1465.81 7032.19,1443.94 7026.38,1438.13 ; v2@7023.81,1282 cw(c7050.06,1282) 7031.5,1300.56
  MidLayer2 w4: v1(3481.86,3025.04) 3515,3025.04 3557.33,2982.71 4419.33,2982.71 4445,3008.37 v1(4473.52,3008.37) ; v1@3485.75,3021.15 cw(c3495.14,3011.76) 3495.14,3025.04 cw(c3495.14,3038.32) v1@3485.75,3028.93 ; v1@3488.57,3018.32 cw(c3504.79,3002.11) 3504.79,3025.04 cw(c3504.79,3047.98) v1@3488.57,3031.76 ; v1@4466.81,3001.66 ccw(c4450.59,2985.44) 4450.59,3008.37 ccw(c4450.59,3031.31) v1@4466.81,3015.09 ; v1@4469.64,3004.49 ccw(c4460.25,2995.1) 4460.25,3008.37 ccw(c4460.25,3021.65) v1@4469.64,3012.26 ; v1(4731.86,2791.71) 4760,2791.71 4766.67,2785.04 5030,2785.04 5080,2785.04 5085,2785.04 5118.82,2785.04 5158.86,2745 5185,2745 5225,2745 5270.23,2745 5295.02,2720.21 5415.71,2720.21 ; v1@4735.75,2787.82 cw(c4745.14,2778.43) 4745.14,2791.71 cw(c4745.14,2804.99) v1@4735.75,2795.6 ; v1@4738.57,2784.99 cw(c4754.79,2768.77) 4754.79,2791.71 cw(c4754.79,2814.64) v1@4738.57,2798.43 ; 5415.73,2720.19 5499.81,2720.19 5570.29,2649.71 5683.67,2649.71 5685,2651.04 v1(5731.86,2651.04) 5706.86,2626.04 5706.86,2575 5706.86,2551.83 5856.86,2401.83 v1(5856.86,2358.37) ; v1@5722.36,2651.04 cw(c5699.42,2651.04) 5715.64,2634.82 cw(c5731.86,2618.61) v1@5731.86,2641.54 ; v1@5725.14,2644.32 ccw(c5708.92,2628.11) 5708.92,2651.04 ccw(c5708.92,2673.98) v1@5725.14,2657.76 ; v1@5726.36,2651.04 cw(c5713.08,2651.04) 5722.47,2641.65 cw(c5731.86,2632.26) v1@5731.86,2645.54 ; v1@5727.97,2647.15 ccw(c5718.58,2637.76) 5718.58,2651.04 ccw(c5718.58,2664.32) v1@5727.97,2654.93 ; v1@5850.14,2365.09 ccw(c5833.92,2381.31) 5856.86,2381.31 ccw(c5879.79,2381.31) v1@5863.57,2365.09 ; v1@5852.97,2362.26 ccw(c5843.58,2371.65) 5856.86,2371.65 ccw(c5870.14,2371.65) v1@5860.75,2362.26 ; v2(6255,1399) 6272.19,1399 ; v2@6263.45,1394.01 cw(c6272.19,1388.84) 6272.19,1399 ; v2@6263.45,1403.99 ccw(c6272.19,1409.16) 6272.19,1399 ; 6360.86,1352.2 6318.99,1352.2 6272.19,1399 ; 6361.47,1352.81 6370.38,1352.81 6434.19,1289 6434.19,1284.62 6444.62,1274.19 6459.38,1274.19 6461,1275.81 6520.93,1275.81 6542.25,1254.5 6582.25,1254.5 6609.25,1227.5 6648.81,1227.5 6717.81,1158.5 6832.12,1158.5 6836.12,1154.5 6875.19,1154.5 6925.72,1205.03 6925.72,1228.72 6930.82,1233.81 6944.69,1233.81 6992.88,1282 ; v2@7006.5,1275.67 ccw(c6992.88,1264.17) 6992.88,1282 ; v2@7006.5,1288.33 cw(c6992.88,1299.83) 6992.88,1282 ; v2@7009.56,1278.25 ccw(c7001.49,1271.44) 7001.49,1282 ccw(c7001.49,1292.56) v2@7009.56,1285.75 ; v2(7014,1282) 6992.88,1282
  Bottom Layer w4: v1(4473.52,3008.37) 4547.19,3008.37 4608.19,2947.37 v1(4616.52,2947.37) ; v1@4477.41,3004.49 cw(c4486.8,2995.1) 4486.8,3008.37 cw(c4486.8,3021.65) v1@4477.41,3012.26 ; v1@4480.24,3001.66 cw(c4496.46,2985.44) 4496.46,3008.37 cw(c4496.46,3031.31) v1@4480.24,3015.09 ; R70.1@5677.09,5092.08 ccw(c5645.47,5123.7) 5690.19,5123.7 ; R70.1@5679.92,5089.25 ccw(c5655.13,5114.05) 5690.19,5114.05 ; R70.1@5682.75,5086.42 ccw(c5664.78,5104.39) 5690.19,5104.39 ; R70.1@5683.68,5085 5683.68,5083.37 5690.19,5083.37 5690.19,5085 5690.19,5215.37 v1(5706.86,5232.04) ; v1@5697.36,5232.04 cw(c5674.42,5232.04) 5690.64,5215.82 cw(c5706.86,5199.61) v1@5706.86,5222.54 ; v1@5701.36,5232.04 cw(c5688.08,5232.04) 5697.47,5222.65 cw(c5706.86,5213.26) v1@5706.86,5226.54 ; v1@5725.14,2657.76 ccw(c5708.92,2673.98) 5731.86,2673.98 ccw(c5754.79,2673.98) v1@5738.57,2657.76 ; v1@5727.97,2654.93 ccw(c5718.58,2664.32) 5731.86,2664.32 ccw(c5745.14,2664.32) v1@5735.75,2654.93 ; v1(5731.86,2651.04) 5731.86,2680.05 5748.18,2696.37 ; R74.1@5742.76,2706.93 cw(c5735.2,2696.38) 5748.18,2696.38 ; R74.1@5748.18,2715 5748.18,2696.37 ; R74.1@5753.61,2706.93 ccw(c5761.16,2696.38) 5748.18,2696.38
DB_RESET: R107.2 SW6.1 SW6.2 U8.AG12 | length 5623.3
  Top Layer w4: v2@5105.06,799.94 ccw(c5088.31,816.69) 5112,816.69 ccw(c5135.69,816.69) v2@5118.94,799.94 ; v2@5107.89,797.11 ccw(c5097.97,807.03) 5112,807.03 ccw(c5126.03,807.03) v2@5116.11,797.11 ; v2(5112,793) 5112,1009.93 5260,1157.93 5260,1341.31 5152.5,1448.81 5152.5,1970 5152.5,1997.5 5152.5,2008.74 5206.86,2063.1 5206.86,2110 5206.86,2425.04 5240.19,2458.37 5240.19,2883.5 5211.69,2912 5107.52,2912 5089.52,2930 5089.52,2960.48 5040,3010 5040,3040 5050.04,3050.04 5171.86,3050.04 v1(5190.19,3031.71) ; v1@5180.69,3031.71 ccw(c5157.76,3031.71) 5173.97,3047.93 ccw(c5190.19,3064.14) v1@5190.19,3041.21 ; v1@5184.69,3031.71 ccw(c5171.41,3031.71) 5180.8,3041.1 ccw(c5190.19,3050.49) v1@5190.19,3037.21 ; v1@5266.81,3274.99 ccw(c5250.59,3258.77) 5250.59,3281.71 ccw(c5250.59,3304.64) v1@5266.81,3288.43 ; v1@5269.64,3277.82 ccw(c5260.25,3268.43) 5260.25,3281.71 ccw(c5260.25,3294.99) v1@5269.64,3285.6 ; v1(5273.52,3281.71) 5265.19,3281.71 5248.29,3281.71 5240.19,3289.81 5240.19,3409 5240.19,3418.88 5246.02,3424.71 5246.02,3499.81 5281.02,3534.81 5281.02,3556.29 5276.02,3561.29 5276.02,3598.71 5276.07,3598.76 5276.07,3645 ; 5276.07,3638.82 5276.07,3645 ; U8.AG12@5284.23,3697.87 cw(c5266.51,3697.87) 5279.04,3685.34 ; U8.AG12@5291.58,3690.53 ccw(c5291.58,3672.8) 5279.04,3685.34 ; R107.2@5303.87,278.2 ccw(c5292.05,291.71) 5310,291.71 ; R107.2@5306.5,275.19 ccw(c5299.76,282.9) 5310,282.9 ccw(c5320.24,282.9) R107.2@5313.5,275.19 ; R107.2@5310,271.18 5310,291.71 ; R107.2@5316.13,278.2 cw(c5327.95,291.71) 5310,291.71 ; SW6.1@5317.21,325.64 cw(c5307.93,308.84) 5327.13,308.84 ; SW6.1@5319.15,329.14 cw(c5311.67,315.61) 5327.13,315.61 cw(c5342.58,315.62) SW6.1@5335.11,329.14 ; SW6.1@5337.04,325.64 ccw(c5346.33,308.84) 5327.13,308.84 ; SW6.1@5341.96,334.74 cw(c5363.3,313.4) 5363.3,343.58 cw(c5363.3,373.76) SW6.1@5341.96,352.42 ; SW6.1@5344.79,331.92 cw(c5372.96,303.75) 5372.96,343.58 cw(c5372.96,383.42) SW6.1@5344.79,355.25 ; v2@5383.06,336.65 ccw(c5366.31,319.9) 5366.31,343.58 ccw(c5366.31,367.27) v2@5383.06,350.52 ; v2@5385.89,339.47 ccw(c5375.97,329.55) 5375.97,343.58 ccw(c5375.97,357.61) v2@5385.89,347.69 ; v2@5394.11,339.47 cw(c5404.03,329.55) 5404.03,343.58 cw(c5404.03,357.61) v2@5394.11,347.69 ; v2@5396.94,336.65 cw(c5413.69,319.9) 5413.69,343.58 cw(c5413.69,367.27) v2@5396.94,350.52 ; SW6.2@5621.98,329.09 ccw(c5586.99,294.09) 5586.99,343.58 ccw(c5586.99,393.07) SW6.2@5621.98,358.08 ; SW6.2@5624.81,331.92 ccw(c5596.65,303.75) 5596.65,343.58 ccw(c5596.65,383.42) SW6.2@5624.81,355.25 ; SW6.2@5627.64,334.74 ccw(c5606.3,313.4) 5606.3,343.58 ccw(c5606.3,373.76) SW6.2@5627.64,352.42 ; SW6.2@5642.48,343.58 v2(5390,343.58) SW6.1@5327.13,343.58 5327.13,308.83 ; 5276.07,3645 5276.07,3678.16 cw(c5286.22,3678.16) 5279.04,3685.34 ; 5310,291.71 5327.13,308.83
  MidLayer1 w4: v2@5105.06,786.06 ccw(c5088.31,769.31) 5088.31,793 ccw(c5088.31,816.69) v2@5105.06,799.94 ; v2@5107.89,788.89 ccw(c5097.97,778.97) 5097.97,793 ccw(c5097.97,807.03) v2@5107.89,797.11 ; v2(5112,793) 5063,793 5056.19,786.19 5056.19,370.12 5061.31,365 5170,365 5191.42,343.58 v2(5390,343.58) ; v2@5383.06,336.65 ccw(c5366.31,319.9) 5366.31,343.58 ccw(c5366.31,367.27) v2@5383.06,350.52 ; v2@5385.89,339.47 ccw(c5375.97,329.55) 5375.97,343.58 ccw(c5375.97,357.61) v2@5385.89,347.69
  MidLayer2 w4: v1@5183.47,3038.43 ccw(c5167.26,3054.64) 5190.19,3054.64 ccw(c5213.13,3054.64) v1@5196.91,3038.43 ; v1@5186.3,3035.6 ccw(c5176.91,3044.99) 5190.19,3044.99 ccw(c5203.47,3044.99) v1@5194.08,3035.6 ; v1(5190.19,3031.71) 5190.19,3088.88 5256.02,3154.71 5256.02,3264.21 v1(5273.52,3281.71) ; v1@5264.02,3281.71 cw(c5241.09,3281.71) 5257.31,3265.49 cw(c5273.52,3249.27) v1@5273.52,3272.21 ; v1@5268.02,3281.71 cw(c5254.75,3281.71) 5264.14,3272.32 cw(c5273.52,3262.93) v1@5273.52,3276.21
DB_SPI.CLK: U8.AE14 U30.E7 | length 3771.7
  Top Layer w4: v3(5350.63,3756.93) U8.AE14@5370.31,3776.61 ; U8.AE14@5362.97,3776.61 cw(c5345.25,3776.61) 5357.78,3764.08 cw(c5370.31,3751.55) U8.AE14@5370.31,3769.27 ; v2(6696,2470) 6733.15,2470 6755.15,2448 6867,2448 6890,2425 v2(6890,2424) ; v2@6700.11,2465.89 cw(c6710.03,2455.97) 6710.03,2470 cw(c6710.03,2484.03) v2@6700.11,2474.11 ; v2@6702.94,2463.06 cw(c6719.69,2446.31) 6719.69,2470 cw(c6719.69,2493.69) v2@6702.94,2476.94 ; 6872.54,2442.46 cw(c6854.09,2424) v2@6880.19,2424 ; 6874.96,2440.04 ccw(c6890,2455.08) v2@6890,2433.81 ; 6879.37,2435.63 cw(c6867.75,2424) v2@6884.19,2424 ; 6881.79,2433.21 ccw(c6890,2441.43) v2@6890,2429.81 ; v3(6931.26,2022.48) U30.E7@6950.94,2002.8 ; U30.E7@6943.6,2002.79 ccw(c6925.88,2002.79) 6938.41,2015.33 ccw(c6950.94,2027.86) U30.E7@6950.94,2010.14 ; 5363.43,3769.73 cw(c5350.63,3782.54) 5350.63,3764.43 ccw(c5350.63,3782.54) 5363.43,3769.73 ; 5363.43,3769.73 ccw(c5376.24,3756.93) 5358.13,3756.93 cw(c5376.24,3756.93) 5363.43,3769.73 ; 6944.06,2009.68 cw(c6956.87,2022.48) 6938.76,2022.48 ccw(c6956.87,2022.48) 6944.06,2009.68 ; 6944.06,2009.68 ccw(c6931.26,1996.87) 6931.26,2014.98 cw(c6931.26,1996.87) 6944.06,2009.68
  MidLayer1 w4: v3@5345.44,3751.74 cw(c5332.9,3739.2) 5350.63,3739.2 cw(c5368.36,3739.2) v3@5355.82,3751.74 ; v3(5350.63,3756.93) 5350.63,3679.25 5349.9,3678.52 5349.9,3597.73 5376.19,3571.44 5376.19,3531 5381,3526.18 5381,3498.08 5376.74,3493.81 5376.74,3470.19 5382.69,3464.23 5382.69,3392.79 5376.6,3386.7 5376.6,3359.85 5420.41,3316.04 v1@5449.8,3316.04 ; 5426.62,3316.04 ccw(c5426.62,3339.5) v1@5443.21,3322.91 ; 5427.36,3316.04 cw(c5427.36,3293.63) v1@5443.21,3309.48 ; 5436.28,3316.04 ccw(c5436.28,3329.84) v1@5446.04,3320.08 ; 5437.02,3316.04 cw(c5437.02,3303.28) v1@5446.04,3312.3 ; 5350.63,3738.82 cw(c5368.74,3738.82) 5355.93,3751.63 ccw(c5368.74,3738.82) 5350.63,3738.82 ; 5350.63,3738.82 ccw(c5332.52,3738.82) 5345.33,3751.63 cw(c5332.52,3738.82) 5350.63,3738.82
  MidLayer2 w4: v1(5449.93,3316.19) 5449.93,3230.66 5444.62,3225.36 5444.62,3171.86 5541.94,3074.55 6322.68,3074.55 ; 6322.7,3074.55 6355.96,3041.29 6355.96,3013.6 6386.86,2982.71 6438.94,2982.71 6475.44,2946.21 6629.28,2946.21 6629.45,2946.37 6702.19,2946.37 6723.52,2925.04 6723.52,2762 ; v2@6689.06,2476.94 ccw(c6672.31,2493.69) 6696,2493.69 ccw(c6719.69,2493.69) v2@6702.94,2476.94 ; v2@6691.89,2474.11 ccw(c6681.97,2484.03) 6696,2484.03 ccw(c6710.03,2484.03) v2@6700.11,2474.11 ; v2(6696,2470) 6696,2608 6724,2636 6724,2762 ; v2@6883.06,2417.06 cw(c6866.31,2400.31) 6890,2400.31 cw(c6913.69,2400.31) v2@6896.94,2417.06 ; v2@6885.89,2419.89 cw(c6875.97,2409.97) 6890,2409.97 cw(c6904.03,2409.97) v2@6894.11,2419.89 ; v2(6890,2424) 6890,2332.58 6881.36,2323.94 6881.36,2266.27 6915.75,2231.88 6915.75,2139.53 6915.75,2045.99 ccw(c6929.8,2045.99) 6919.87,2036.06 ; v3@6923.79,2023.13 ccw(c6905.75,2024.71) 6919.62,2036.35 ccw(c6933.49,2047.99) v3@6931.91,2029.95
DB_SPI.DIN: U8.AB27 U30.E6 | length 3478.5
  Top Layer w4: v1(6124.52,3807.37) 6109.9,3822 6047.25,3822 6030.75,3838.5 6002.65,3866.6 5982.35,3866.6 5969.73,3879.22 5901.84,3879.22 ; v3(6891.89,2022.48) U30.E6@6911.57,2002.8 ; U30.E6@6904.23,2002.79 ccw(c6886.51,2002.79) 6899.04,2015.33 ccw(c6911.57,2027.86) U30.E6@6911.57,2010.14 ; 5894.66,3882.19 ccw(c5901.84,3889.37) 5901.84,3879.22 ; 5894.66,3882.19 ccw(c5901.84,3889.37) 5901.84,3879.22 ; 5894.66,3882.19 cw(c5907.19,3894.72) 5889.47,3894.72 ccw(c5907.19,3894.72) 5894.66,3882.19 ; 5894.66,3882.19 ccw(c5882.13,3869.66) 5882.13,3887.38 cw(c5882.13,3869.66) 5894.66,3882.19 ; 6904.69,2009.68 cw(c6917.5,2022.48) 6899.39,2022.48 ccw(c6917.5,2022.48) 6904.69,2009.68 ; 6904.69,2009.68 ccw(c6891.89,1996.87) 6891.89,2014.98 cw(c6891.89,1996.87) 6904.69,2009.68
  MidLayer2 w4: v1(6124.52,3807.37) 6139.65,3822.5 6242.5,3822.5 6265.69,3799.31 6399.31,3799.31 6415,3815 6750.96,3815 6766.02,3799.93 6766.02,3784.91 6792.56,3758.37 6897.68,3758.37 7023.52,3632.53 7023.52,3269.59 ; 6880.5,2036.06 cw(c6890.43,2045.99) 6876.38,2045.99 6876.38,2139.53 6876.38,2248.62 6865.19,2259.81 6865.19,2290 6864.19,2291 6864.19,2466.98 6886.69,2489.48 6886.69,2506.31 6863.19,2529.81 6863.19,2557.69 6881.5,2576 6924.48,2576 6970,2621.52 6970,2680 7040.19,2750.19 7040.19,2836.89 ; v3@6884.42,2023.13 ccw(c6866.38,2024.71) 6880.25,2036.35 ccw(c6894.12,2047.99) v3@6892.54,2029.95 ; 7009.5,3255.56 7023.52,3269.59 ; 7023.52,3269.59 6965.19,3211.25 6965.19,3205.19 6965.19,3058.37 6978.56,3045 7075.52,3045 7082.52,3038 7082.52,2985.26 7075.69,2978.42 7075.69,2965 7075.69,2942.79 ; 7040.19,2836.89 7040.19,2907.29 7075.69,2942.79 ; 7040.19,2836.89 7075.69,2872.39 7075.69,2942.79