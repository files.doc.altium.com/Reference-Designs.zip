# Altium PCB NB3000AL.PcbDoc (part 54 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
HOST_SRAM.NCS: U30.F13 U47.6 | length 2515.9
  Top Layer w4: U30.F13@7187.17,1963.43 v3(7206.85,1983.11) ; U30.F13@7187.17,1970.77 ccw(c7187.17,1988.49) 7199.7,1975.96 ccw(c7212.23,1963.43) U30.F13@7194.51,1963.43 ; U47.6@7555.59,3208.23 7585.67,3208.23 ; U47.6@7580.41,3204.87 cw(c7585.67,3202.43) 7585.67,3208.23 ; U47.6@7580.41,3211.59 ccw(c7585.67,3214.03) 7585.67,3208.23 ; v1(7599.19,3194.71) 7585.67,3208.23 ; 7194.05,1970.31 cw(c7206.85,1957.5) 7206.85,1975.61 ccw(c7206.85,1957.5) 7194.05,1970.31 ; 7194.05,1970.31 ccw(c7181.24,1983.11) 7199.35,1983.11 cw(c7181.24,1983.11) 7194.05,1970.31
  MidLayer1 w4: v3@7208.15,1990.5 ccw(c7211.3,2008.33) 7221.68,1993.5 ; v3@7214.24,1981.81 cw(c7232.07,1978.66) 7221.68,1993.5 ; 7283.66,2006.97 7269.73,2006.97 ; v1(7481.86,2283.37) 7536.63,2283.37 7555,2265 7557.19,2262.81 7557.19,2175 7557.19,2141.46 7572.44,2126.21 7582.69,2115.96 7582.69,2095.52 7577.17,2090 7570.21,2083.04 7520.21,2083.04 7423.36,1986.19 7412.94,1986.19 7370.62,1986.19 7349.84,2006.97 7343.85,2006.97 7269.73,2006.97 ; v1@7485.75,2279.49 cw(c7495.14,2270.1) 7495.14,2283.37 cw(c7495.14,2296.65) v1@7485.75,2287.26 ; v1@7488.57,2276.66 cw(c7504.79,2260.44) 7504.79,2283.37 cw(c7504.79,2306.31) v1@7488.57,2290.09 ; 7221.68,1993.5 7230.26,2000.58 cw(c7246.48,1983.2) 7246.48,2006.97 7269.73,2006.97
  MidLayer2 w4: v1@7475.14,2290.09 ccw(c7458.92,2306.31) 7481.86,2306.31 ccw(c7504.79,2306.31) v1@7488.57,2290.09 ; v1@7477.97,2287.26 ccw(c7468.58,2296.65) 7481.86,2296.65 ccw(c7495.14,2296.65) v1@7485.75,2287.26 ; v1(7481.86,2283.37) 7481.86,2347.86 7512.81,2378.81 7512.81,2420.99 7581.86,2490.04 7581.86,2710.86 7732.67,2861.67 7732.67,3282.56 7715.19,3300.04 7656.86,3358.37 7597.19,3358.37 7581.86,3343.04 7581.86,3212.04 v1(7599.19,3194.71) ; v1@7589.69,3194.71 ccw(c7566.76,3194.71) 7582.97,3210.93 ccw(c7599.19,3227.14) v1@7599.19,3204.21 ; v1@7593.69,3194.71 ccw(c7580.41,3194.71) 7589.8,3204.1 ccw(c7599.19,3213.49) v1@7599.19,3200.21
HOST_SRAM.NOE: U30.B16 U47.41 | length 2405.9
  Top Layer w4: U30.B16@7305.28,2120.91 7324.96,2120.91 7372.91,2120.91 v2(7398,2146) ; U30.B16@7310.47,2115.71 cw(c7323,2103.18) 7323,2120.91 cw(c7323,2138.63) U30.B16@7310.47,2126.1 ; v2@7388.19,2146 cw(c7364.5,2146) 7381.25,2129.25 cw(c7398,2112.5) v2@7398,2136.19 ; v2@7392.19,2146 cw(c7378.16,2146) 7388.08,2136.08 cw(c7398,2126.16) v2@7398,2140.19 ; v1(7810.52,2327.37) 7799.19,2338.71 7799.19,2445.62 7782.19,2462.62 7782.19,2477.38 7816.5,2511.69 7816.5,2547.19 7816.5,2559.68 7823.52,2566.71 7865.19,2608.37 7865.19,2608.69 7874.12,2617.62 7874.12,2894.38 7865.19,2903.31 7865.19,3327.33 7869.02,3331.16 7869.02,3358.92 7869.02,3370.21 7886.19,3387.37 8029.53,3387.37 8038.53,3378.37 8038.53,3272.89 8036.86,3271.22 ; U47.41@8004.41,3271.22 8036.86,3271.22 ; U47.41@8028.64,3266.8 cw(c8036.86,3261.36) 8036.86,3271.22 ; U47.41@8028.64,3275.64 ccw(c8036.86,3281.08) 8036.86,3271.22
  Bottom Layer w4: v2@7398,2136.19 cw(c7398,2112.5) 7414.75,2129.25 cw(c7431.5,2146) v2@7407.81,2146 ; v2@7398,2140.19 cw(c7398,2126.16) 7407.92,2136.08 cw(c7417.84,2146) v2@7403.81,2146 ; v2(7398,2146) 7465.5,2078.5 7480,2078.5 7674.25,2078.5 7717.5,2078.5 7775,2136 ; 7756.17,2117.17 7775,2136 ; v1@7801.02,2327.37 cw(c7778.09,2327.37) 7794.31,2311.16 cw(c7810.52,2294.94) v1@7810.52,2317.87 ; v1@7805.02,2327.37 cw(c7791.75,2327.37) 7801.14,2317.99 cw(c7810.52,2308.6) v1@7810.52,2321.87 ; v1(7810.52,2327.37) 7775,2291.85 7775,2136
HOST_SRAM.NWE: U30.C16 U47.17 | length 1568.5
  Top Layer w4: U30.C16@7305.28,2081.54 7395.53,2081.53 7405.07,2072 v2(7420.36,2072) ; U30.C16@7310.47,2076.34 cw(c7323,2063.81) 7323,2081.53 cw(c7323,2099.26) U30.C16@7310.47,2086.73 ; U47.17@7555.59,2861.77 7571.9,2861.77 7708.81,2724.86 7708.81,2629.38 7715.38,2622.81 7727.38,2622.81 7738.81,2611.38 7738.81,2582.5 7748,2573.31 7748,2508.74 7738.81,2499.55 7738.81,2449.43 7758.61,2429.64 7758.61,2085.39 v1(7764,2080) ; U47.17@7573.15,2853.77 cw(c7573.15,2837.48) 7584.67,2849 ; U47.17@7577.15,2861.77 ccw(c7589.83,2861.77) U47.17@7580.86,2852.81 ; U47.17@7581.15,2861.77 ccw(c7603.48,2861.77) 7587.69,2845.98
  Bottom Layer w4: v2(7420.36,2072) 7443.5,2072 ; v2@7424.54,2067.96 cw(c7434.07,2058.75) 7434.07,2072 cw(c7434.07,2085.25) v2@7424.54,2076.04 ; v2@7427.42,2065.18 cw(c7443.5,2049.63) 7443.5,2072 ; v2@7427.42,2078.82 ccw(c7443.5,2094.37) 7443.5,2072 ; v1@7757.28,2073.28 ccw(c7741.06,2057.06) 7741.06,2080 ccw(c7741.06,2102.93) v1@7757.28,2086.72 ; v1@7760.11,2076.11 ccw(c7750.72,2066.72) 7750.72,2080 ccw(c7750.72,2093.28) v1@7760.11,2083.89 ; v1@7765,2080 v1(7764,2080) 7730.31,2080 7720.81,2070.5 ; 7443.5,2072 7445,2070.5 ; 7445,2070.5 7455,2070.5 ; 7445,2070.5 7455,2070.5 ; 7455,2070.5 7705,2070.5 ; 7705,2070.5 7720.81,2070.5 ; 7705,2070.5 7720.81,2070.5
HOST_USB.D0: U30.F9 U56.18 | length 6830.7
  Top Layer w4: U30.F9@7029.69,1963.43 v3(7049.37,1983.11) ; U30.F9@7029.68,1970.77 ccw(c7029.68,1988.49) 7042.22,1975.96 ccw(c7054.75,1963.42) U30.F9@7037.03,1963.42 ; 7036.57,1970.31 cw(c7049.37,1957.5) 7049.37,1975.61 ccw(c7049.37,1957.5) 7036.57,1970.31 ; 7036.57,1970.31 ccw(c7023.76,1983.11) 7041.87,1983.11 cw(c7023.76,1983.11) 7036.57,1970.31
  MidLayer2 w4: v4(6733,6203.9) 6799.1,6270 6850,6270 6872.5,6270 6900,6242.5 7564.65,6242.5 7665.19,6141.96 v1(7665.19,6083.37) ; v4@6733,6211.9 ccw(c6733,6231.21) 6746.66,6217.55 ccw(c6760.31,6203.9) v4@6741,6203.9 ; v3@7048.72,1990.58 ccw(c7047.14,2008.62) 7061.01,1996.98 ; v3@7056.84,1983.76 cw(c7074.88,1985.34) 7061.01,1996.98 ; v1@7658.47,6090.09 ccw(c7642.26,6106.31) 7665.19,6106.31 ccw(c7688.13,6106.31) v1@7671.91,6090.09 ; v1@7661.3,6087.26 ccw(c7651.91,6096.65) 7665.19,6096.65 ccw(c7678.47,6096.65) v1@7669.08,6087.26 ; 8078.21,3458.21 8070,3458.21 ; v1@8285.5,3630 cw(c8262.56,3630) 8278.78,3613.78 cw(c8295,3597.56) v1@8295,3620.5 ; v1@8289.5,3630 cw(c8276.22,3630) 8285.61,3620.61 cw(c8295,3611.22) v1@8295,3624.5 ; v1(8295,3630) 8123.21,3458.21 8070,3458.21 ; 7061.01,1996.98 ccw(c7031.5,2026.49) 7073.23,2026.49 7073.23,2045.99 7073.23,2120.11 7073.23,2139.53 7073.23,2218.08 7066.19,2225.12 7066.19,2381.38 7118.19,2433.38 7118.19,2452.69 7137.31,2471.81 7159.27,2471.81 7256.86,2569.39 7256.86,2681.69 7413.98,2838.81 7420.34,2838.81 7573,2991.47 7573,3351.89 7688.31,3467.2 7866.74,3467.2 7875.74,3458.21 8070,3458.21
  Bottom Layer w4: v1(7665.19,6083.37) 7869,6083.37 7990.81,5961.57 7990.81,5259.19 8265.19,4984.81 8265.19,4521.5 8226,4482.31 8226,3766.95 8295,3697.95 v1(8295,3630) ; v1@7669.08,6079.49 cw(c7678.47,6070.1) 7678.47,6083.37 cw(c7678.47,6096.65) v1@7669.08,6087.26 ; v1@7671.91,6076.66 cw(c7688.13,6060.44) 7688.13,6083.37 cw(c7688.13,6106.31) v1@7671.91,6090.09 ; v1@8288.28,3636.72 ccw(c8272.06,3652.93) 8295,3652.93 ccw(c8317.94,3652.93) v1@8301.72,3636.72 ; v1@8291.11,3633.89 ccw(c8281.72,3643.28) 8295,3643.28 ccw(c8308.28,3643.28) v1@8298.89,3633.89
  Bottom Layer w8: v4(6733,6203.9) U56.18@6764.33,6203.9 ; v4@6737.24,6199.65 cw(c6747.48,6189.41) 6747.48,6203.9 cw(c6747.49,6218.38) v4@6737.24,6208.14
HOST_USB.D1: U30.R14 U56.19 | length 8035.7
  Top Layer w4: v2@7236.06,1496.94 ccw(c7221.62,1511.38) 7242.04,1511.38 ; 7242.04,1506.34 ccw(c7259.34,1506.34) v2@7247.11,1494.11 ; 7242.04,1516 ccw(c7269,1516) v2@7249.94,1496.94 ; v2(7243,1490) 7242.04,1490.96 7242.04,1589.38 ; v2@7479.06,2373.06 cw(c7462.31,2356.31) 7486,2356.31 cw(c7509.69,2356.31) v2@7492.94,2373.06 ; v2@7481.89,2375.89 cw(c7471.97,2365.97) 7486,2365.97 cw(c7500.03,2365.97) v2@7490.11,2375.89 ; v2(7486,2380) 7486,2303.98 7499.36,2290.62 7499.36,2154.55 7481,2136.19 7462.19,2117.38 7462.19,2102.62 7470.18,2094.64 7470.18,1985.36 7464.19,1979.38 7464.19,1945.31 7486,1923.5 7486,1904 7488.88,1901.12 7530.07,1901.12 7541.19,1890 7553.19,1890 7574.19,1869 7574.19,1764.39 7589.81,1748.77 7589.81,1686 7583.81,1680 7583.81,1595.27 7572,1583.46 v2(7572,1548) ; v2@7565.06,1554.94 ccw(c7548.31,1571.69) 7572,1571.69 ccw(c7595.69,1571.69) v2@7578.94,1554.94 ; v2@7567.89,1552.11 ccw(c7557.97,1562.03) 7572,1562.03 ccw(c7586.03,1562.03) v2@7576.11,1552.11 ; 7239.07,1596.56 ccw(c7226.54,1584.03) 7226.54,1601.75 cw(c7226.54,1584.03) 7239.07,1596.56 ; 7239.07,1596.56 cw(c7251.6,1609.09) 7233.88,1609.09 ccw(c7251.6,1609.09) 7239.07,1596.56 ; 7239.07,1596.56 cw(c7231.89,1589.38) 7242.04,1589.38 ; 7239.07,1596.56 cw(c7231.89,1589.38) 7242.04,1589.38
  MidLayer1 w4: v1@7548.28,6218.28 cw(c7532.06,6202.06) 7555,6202.06 cw(c7577.94,6202.06) v1@7561.72,6218.28 ; v1@7551.11,6221.11 cw(c7541.72,6211.72) 7555,6211.72 cw(c7568.28,6211.72) v1@7558.89,6221.11 ; v1@7555,6228.37 7554.86,6228.37 7555,6228.23 v1(7555,6225) 7555,6190 7624,6121 7624,6060.81 7652.19,6032.62 7662.62,6022.19 7677.38,6022.19 7687.19,6032 7946.69,6032 7967,6011.69 7967,5507.87 7958.81,5499.68 7958.81,5388.73 8004.44,5343.11 8004.52,5343.11 8240.52,5107.1 8240.52,5072.34 8241.35,5071.51 8241.35,5059.91 8240.52,5059.08 8240.52,4588.15 8229,4576.63 8229,4253.37 8249,4233.37 8249,3872.76 8215.19,3838.95 8208.21,3831.97 8173.69,3797.45 8157.41,3781.17 8157.41,2939.1 8173.19,2923.31 ; v1@8214.02,2850.04 ccw(c8191.09,2850.04) 8207.31,2866.26 ccw(c8223.52,2882.48) v1@8223.52,2859.54 ; v1@8218.02,2850.04 ccw(c8204.75,2850.04) 8214.14,2859.43 ccw(c8223.52,2868.82) v1@8223.52,2855.54 ; v1(8223.52,2850.04) 8173.19,2900.37 ; 8173.19,2900.37 8173.19,2923.31 ; 8173.19,2900.37 8173.19,2923.31
  MidLayer2 w4: v4(6795.66,6184.21) 6796.45,6185 7065,6185 7105,6225 v1(7555,6225) ; v4@6798.49,6181.38 cw(c6807.22,6172.65) 6807.22,6185 ; v4@6801.32,6178.56 cw(c6816.88,6163) 6816.88,6185 ; v4@6801.32,6189.87 ccw(c6813.07,6201.62) 6813.07,6185 ; v2(7243,1490) 7511,1490 7569,1548 v2(7572,1548) ; v2@7247.11,1485.89 cw(c7257.03,1475.97) 7257.03,1490 cw(c7257.03,1504.03) v2@7247.11,1494.11 ; v2@7249.94,1483.06 cw(c7266.69,1466.31) 7266.69,1490 cw(c7266.69,1513.69) v2@7249.94,1496.94 ; v1@7548.28,6218.28 ccw(c7532.06,6202.06) 7532.06,6225 ccw(c7532.06,6247.93) v1@7548.28,6231.72 ; 7550.13,1529.13 cw(c7572,1507.26) v2@7572,1538.19 ; v1@7551.11,6221.11 ccw(c7541.72,6211.72) 7541.72,6225 ccw(c7541.72,6238.28) v1@7551.11,6228.89 ; 7556.96,1535.96 cw(c7572,1520.92) v2@7572,1542.19 ; 7557.37,1536.37 ccw(c7545.75,1548) v2@7562.19,1548
  Bottom Layer w4: v2(7486,2380) 7486,2380.75 7679.44,2574.19 7748,2574.19 7771.62,2597.81 7791.13,2597.81 7797.4,2591.54 7955,2591.54 ; v2@7486,2385.81 ccw(c7486,2398.03) 7494.64,2389.39 ; v2@7486,2389.81 ccw(c7486,2411.69) 7501.47,2396.22 ; v2@7491.81,2380 cw(c7507.65,2380) 7496.45,2391.2 ; v2@7495.81,2380 cw(c7521.3,2380) 7503.28,2398.03 ; v1@8216.81,2843.32 cw(c8200.59,2827.11) 8223.52,2827.11 cw(c8246.46,2827.11) v1@8230.24,2843.32 ; v1@8219.64,2846.15 cw(c8210.25,2836.76) 8223.52,2836.76 cw(c8236.8,2836.76) v1@8227.41,2846.15 ; v1(8223.52,2850.04) 8223.52,2608.37 8206.86,2591.71 8075,2591.71 ; 7955,2591.54 7969.36,2591.54 ; 7955,2591.54 7969.36,2591.54 ; 7969.36,2591.54 7974.38,2591.54 7990.88,2608.04 8018.21,2608.04 ; 8018.21,2608.04 8034.54,2591.71 ; 8018.21,2608.04 8034.54,2591.71 ; 8034.54,2591.71 8075,2591.71 ; 8034.54,2591.71 8075,2591.71
  Bottom Layer w8: U56.19@6764.33,6184.21 v4(6795.66,6184.21) ; v4@6791.42,6179.97 ccw(c6781.18,6169.73) 6781.18,6184.21 ccw(c6781.17,6198.7) v4@6791.42,6188.46
HOST_USB.D2: U30.A11 U56.20 | length 6495.6
  Top Layer w4: U30.A11@7103.23,2165.47 ccw(c7090.7,2178) 7108.42,2178 ccw(c7126.15,2178) U30.A11@7113.62,2165.47 ; U30.A11@7108.43,2160.28 7108.42,2218 ; 7108.42,2219.3 7108.42,2218 ; 7158.76,2352.07 ccw(c7140.83,2370) v2@7166.19,2370 ; 7160.43,2353.74 cw(c7176,2338.17) v2@7176,2360.19 ; 7165.59,2358.9 ccw(c7154.49,2370) v2@7170.19,2370 ; 7167.26,2360.57 cw(c7176,2351.83) v2@7176,2364.19 ; v2@7176.35,2369.65 7108.42,2301.73 7108.42,2218
  MidLayer1 w4: v2@7176.22,2371.8 ccw(c7178.1,2386.77) 7188.77,2376.1 ; v2@7176.72,2375.77 ccw(c7179.38,2397.05) 7194.55,2381.88 ; v2@7177.22,2379.74 ccw(c7180.67,2407.34) 7200.33,2387.67 ; v2@7180.02,2367.35 7200.34,2387.67 ; v2@7185.81,2370 cw(c7193.4,2370) 7188.03,2375.37 ; v2(7670,6040) 7950,6040 7975,6015 7975,5504.56 7966.81,5496.37 7966.81,5393.19 8042.19,5317.81 v2(8105,5317.81) ; v1@7675.14,5301.66 cw(c7657.73,5284.24) 7682.35,5284.24 ; v1@7677.97,5304.49 cw(c7667.38,5293.9) 7682.35,5293.9 ; v1(7681.86,5308.37) 7682.35,5307.88 7682.35,4808.26 7623.86,4749.77 7623.86,4585.17 7498.52,4459.84 7498.52,3850.04 7456.86,3808.37 7456.86,3314.34 7457.02,3314.17 7457.02,3302.57 7365.35,3210.91 7365.35,2850 7365.35,2769.24 7365.35,2735 7365.35,2713.69 7374.34,2704.7 7374.34,2639.17 7323.48,2588.31 7317.75,2588.31 7200.34,2470.89 7200.34,2387.67 ; 7682.35,5286.64 cw(c7703.6,5286.64) v1@7688.57,5301.66 ; 7682.35,5296.29 cw(c7693.94,5296.29) v1@7685.75,5304.49 ; v2@8098.06,5310.87 ccw(c8081.31,5294.13) 8081.31,5317.81 ccw(c8081.31,5341.5) v2@8098.06,5324.75 ; v2@8100.89,5313.7 ccw(c8090.97,5303.78) 8090.97,5317.81 ccw(c8090.97,5331.84) v2@8100.89,5321.92
  MidLayer2 w4: v4(6733,6164.53) 7259.04,6164.53 7373.52,6050.04 7490.19,6050.04 7500.23,6040 v2(7670,6040) ; v4@6738.66,6158.87 cw(c6752.31,6145.21) 6752.31,6164.53 cw(c6752.31,6183.84) v4@6738.66,6170.18 ; v2@7663.06,6033.06 ccw(c7646.31,6016.31) 7646.31,6040 ccw(c7646.31,6063.69) v2@7663.06,6046.94 ; v2@7665.89,6035.89 ccw(c7655.97,6025.97) 7655.97,6040 ccw(c7655.97,6054.03) v2@7665.89,6044.11 ; v1@7681.86,5298.87 cw(c7681.86,5275.94) 7698.07,5292.16 cw(c7714.29,5308.37) v1@7691.36,5308.37 ; v1@7681.86,5302.87 cw(c7681.86,5289.6) 7691.25,5298.99 cw(c7700.64,5308.37) v1@7687.36,5308.37 ; v1(7681.86,5308.37) 7734.23,5256 7966,5256 8027.81,5317.81 v2(8105,5317.81) ; v2@8098.06,5310.87 ccw(c8081.31,5294.13) 8081.31,5317.81 ccw(c8081.31,5341.5) v2@8098.06,5324.75 ; v2@8100.89,5313.7 ccw(c8090.97,5303.78) 8090.97,5317.81 ccw(c8090.97,5331.84) v2@8100.89,5321.92
  Bottom Layer w8: v4(6733,6164.53) U56.20@6764.33,6164.53 ; v4@6737.24,6160.28 cw(c6747.49,6150.04) 6747.49,6164.53 cw(c6747.49,6179.01) v4@6737.24,6168.77
  other v2: 7176,2370
HOST_USB.D3: U30.D11 U56.21 | length 5934.6
  Top Layer w4: 6782.01,6158.5 cw(c6768.35,6144.84) v4@6787.66,6144.84 ; 6782,6158.5 ccw(c6795.66,6172.16) v4@6795.66,6152.84 ; v4(6795.66,6144.84) 6770,6170.5 6770,6304.85 6825.19,6360.04 6906.65,6360.04 7017.19,6249.5 7240.73,6249.5 7323.52,6166.71 7323.52,5610 7340.52,5593 7340.52,5362.98 7615.19,5088.31 7615.19,4828.37 7646.52,4797.04 7646.52,4392.69 7606.86,4353.02 7606.86,4305 7644.86,4267 7726.69,4267 7791.19,4202.5 7791.19,3665.33 7775.86,3650 v1(7700,3650) ; U30.D11@7108.43,2042.17 v3(7128.11,2061.85) ; U30.D11@7108.43,2049.51 ccw(c7108.43,2067.23) 7120.96,2054.7 ccw(c7133.49,2042.16) U30.D11@7115.77,2042.17 ; v1@7703.89,3646.11 cw(c7713.28,3636.72) 7713.28,3650 cw(c7713.28,3663.28) v1@7703.89,3653.89 ; v1@7706.72,3643.28 cw(c7722.94,3627.06) 7722.94,3650 cw(c7722.94,3672.93) v1@7706.72,3656.72 ; 7115.31,2049.05 cw(c7128.11,2036.24) 7128.11,2054.35 ccw(c7128.11,2036.24) 7115.31,2049.05 ; 7115.31,2049.05 ccw(c7102.5,2061.85) 7120.61,2061.85 cw(c7102.5,2061.85) 7115.31,2049.05
  MidLayer1 w4: v3@7126.81,2069.24 ccw(c7123.66,2087.07) 7138.5,2076.68 ; v3@7135.5,2063.15 cw(c7153.33,2066.3) 7138.5,2076.68 ; 7151.97,2138.66 7151.97,2124.73 ; v1@7693.28,3643.28 ccw(c7677.06,3627.06) 7677.06,3650 ccw(c7677.06,3672.93) v1@7693.28,3656.72 ; v1@7696.11,3646.11 ccw(c7686.72,3636.72) 7686.72,3650 ccw(c7686.72,3663.28) v1@7696.11,3653.89 ; v1(7700,3650) 7646.86,3650 7490.19,3493.33 7490.19,3341.71 7515.19,3316.71 7515.19,2908.37 7448,2841.18 7448,2823.5 7455.81,2815.69 7455.81,2794.31 7441.78,2780.27 7441.78,2738.22 7435.19,2731.63 7435.19,2599.13 7234.81,2398.76 7234.81,2353.31 7181.88,2300.37 7173.19,2300.37 7152.82,2280 7136.19,2263.37 7136.19,2245.62 7151.97,2229.84 7151.97,2218.27 7151.97,2198.85 7151.97,2124.73 ; 7138.5,2076.68 7145.58,2085.26 ccw(c7128.2,2101.48) 7151.97,2101.48 7151.97,2124.73
  Bottom Layer w8: U56.21@6764.33,6144.84 v4(6795.66,6144.84) ; v4@6791.42,6140.6 ccw(c6781.18,6130.36) 6781.18,6144.84 ccw(c6781.18,6159.33) v4@6791.42,6149.09
HOST_USB.D4: U30.J16 U56.22 | length 5867.1
  Top Layer w4: v4@6733,6117.16 cw(c6733,6097.84) 6746.66,6111.5 cw(c6760.31,6125.16) v4@6741,6125.16 ; v4(6733,6125.16) 6765.19,6092.97 6765.19,6073.95 6789.1,6050.04 6831.86,6050.04 6856.86,6025.04 7073.52,6025.04 7140.19,5958.37 7140.19,5251.12 7208.27,5183.04 7263.15,5183.04 7508.19,4938 7508.19,4894.69 7499.19,4885.69 7499.19,4854.31 7508.19,4845.31 7508.19,4804.41 7494.19,4790.41 7494.19,3920 7494.19,3864.86 7494.19,3750.46 7484.36,3740.62 7484.36,3734.36 7484.36,3710.56 7495,3699.92 7564.92,3699.92 7581.86,3682.98 7581.86,3680 7581.86,3501.02 7640.19,3442.69 7640.19,3273.37 7699.02,3214.55 7699.02,3209.56 7698.19,3208.73 7698.19,3036.37 7849.19,2885.37 7849.19,2657.69 7822.5,2631 7822.5,2588.5 7800.5,2566.5 7800.5,2540.56 7800.5,2518.32 7766.19,2484 7766.19,2456 7782.61,2439.58 7782.61,2108.77 7797.5,2093.88 7797.5,2066.12 7782.19,2050.81 7782.19,2004.62 7793.81,1993 7793.81,1976.62 7758.69,1941.5 7659.5,1941.5 7634,1916 v1(7635,1915) ; U30.J16@7305.28,1845.31 7366.13,1845.31 7368.62,1847.81 7398.19,1847.81 7406,1840 ; U30.J16@7310.47,1840.12 cw(c7323,1827.59) 7323,1845.31 cw(c7323,1863.04) U30.J16@7310.47,1850.51 ; 7407.97,1840 ccw(c7407.97,1850.03) v2@7415.06,1842.94 ; 7410.63,1840 cw(c7410.63,1834.32) v2@7416.25,1835.15 ; v2@7412.29,1834.57 ccw(c7406,1833.64) 7406,1840 ; v2(7422,1836) 7422,1837.66 7419.62,1840.04 7419.58,1840 7406,1840 ; v1@7635,1924.5 ccw(c7635,1942.61) 7647.8,1929.8 ; v1@7640.5,1915 cw(c7658.61,1915) 7645.8,1927.8 ; v1@7644.5,1915 cw(c7672.26,1915) 7652.63,1934.63
  MidLayer1 w4: v2(7422,1836) 7440.31,1836 ; v2@7430.17,1830.56 cw(c7440.31,1823.81) 7440.31,1836 ; v2@7430.17,1841.44 ccw(c7440.31,1848.19) 7440.31,1836 ; v1@7634,1915.5 7634,1916 v1(7635,1915) 7662,1888 7662,1838.31 7616.69,1793 7483.31,1793 7440.31,1836 ; v1@7635,1905.5 cw(c7635,1882.56) 7651.22,1898.78 cw(c7667.44,1915) v1@7644.5,1915 ; v1@7635,1909.5 cw(c7635,1896.22) 7644.39,1905.61 cw(c7653.78,1915) v1@7640.5,1915
  Bottom Layer w8: v4(6733,6125.16) U56.22@6764.33,6125.16 ; v4@6737.24,6120.91 cw(c6747.49,6110.67) 6747.49,6125.16 cw(c6747.49,6139.64) v4@6737.24,6129.4
HOST_USB.D5: U30.F11 U56.23 | length 6651.4
  Top Layer w4: U30.F11@7108.43,1963.43 v3(7128.11,1983.11) ; U30.F11@7108.43,1970.77 ccw(c7108.43,1988.49) 7120.96,1975.96 ccw(c7133.49,1963.42) U30.F11@7115.77,1963.42 ; v1@7623.28,5708.28 cw(c7607.06,5692.06) 7630,5692.06 cw(c7652.94,5692.06) v1@7636.72,5708.28 ; v1@7626.11,5711.11 cw(c7616.72,5701.72) 7630,5701.72 cw(c7643.28,5701.72) v1@7633.89,5711.11 ; v1(7630,5715) 7630,5560 7540,5470 7540,5199.7 7874.7,4865 7970.2,4865 8141.1,4694.1 8191.92,4694.1 8216.02,4670 8216.02,4114.05 8140,4038.03 8140,4010 ; v1(8090.19,3135.37) 8047.5,3178.06 8047.5,3262.25 8065.19,3279.94 8065.19,3391.71 7965.19,3491.71 7965.19,3545.44 7967.5,3547.75 7967.5,3562.25 7965.19,3564.56 7965.19,3675.19 8045,3755 8135.19,3755 8140.19,3760 8140.19,4010 ; 7115.31,1970.31 cw(c7128.11,1957.5) 7128.11,1975.61 ccw(c7128.11,1957.5) 7115.31,1970.31 ; 7115.31,1970.31 ccw(c7102.5,1983.11) 7120.61,1983.11 cw(c7102.5,1983.11) 7115.31,1970.31
  MidLayer2 w4: v4(6795.66,6105.47) 6893.09,6105.47 6981.86,6016.71 7059.84,6016.71 7321.54,5755 7590,5755 v1(7630,5715) ; v4@6801.32,6099.82 cw(c6814.97,6086.16) 6814.97,6105.47 cw(c6814.98,6124.79) v4@6801.32,6111.13 ; v3@7126.81,1990.5 ccw(c7123.66,2008.33) 7138.5,1997.94 ; v3@7135.5,1984.41 cw(c7153.33,1987.56) 7138.5,1997.94 ; v1@7159.28,2407.28 cw(c7143.06,2391.06) 7166,2391.06 cw(c7188.94,2391.06) v1@7172.72,2407.28 ; v1@7162.11,2410.11 cw(c7152.72,2400.72) 7166,2400.72 cw(c7179.28,2400.72) v1@7169.89,2410.11 ; v1(7166,2414) 7166,2389.45 7156.55,2380 7156.55,2338.55 7136.19,2318.18 7136.19,2245.62 7151.97,2229.84 7151.97,2139.53 7151.97,2120.11 7151.97,2045.99 7151.97,2022.74 cw(c7128.2,2022.74) 7145.58,2006.52 7138.5,1997.94 ; v1@7620.5,5715 ccw(c7597.56,5715) 7613.78,5731.22 ccw(c7630,5747.43) v1@7630,5724.5 ; v1@7624.5,5715 ccw(c7611.22,5715) 7620.61,5724.39 ccw(c7630,5733.78) v1@7630,5720.5
  Bottom Layer w4: v1@7156.5,2414 cw(c7133.56,2414) 7149.78,2397.78 cw(c7166,2381.56) v1@7166,2404.5 ; v1@7160.5,2414 cw(c7147.22,2414) 7156.61,2404.61 cw(c7166,2395.22) v1@7166,2408.5 ; v1(7166,2414) 7143.71,2391.71 7118.52,2391.71 7106.86,2403.37 7106.86,2430.05 7146.81,2470 7156.69,2470 7293.21,2606.52 7293.21,2623.21 7310.76,2640.76 7327.54,2657.54 7358.77,2657.54 7424.64,2723.41 7536.04,2723.41 7563.34,2750.71 7899.19,2750.71 7925.26,2776.78 8041.19,2892.7 8064.52,2916.04 8064.52,3109.71 v1(8090.19,3135.37) ; v1@8080.69,3135.37 cw(c8057.76,3135.37) 8073.97,3119.16 cw(c8090.19,3102.94) v1@8090.19,3125.87 ; v1@8084.69,3135.37 cw(c8071.41,3135.37) 8080.8,3125.99 cw(c8090.19,3116.6) v1@8090.19,3129.87
  Bottom Layer w8: U56.23@6764.33,6105.47 v4(6795.66,6105.47) ; v4@6791.42,6101.23 ccw(c6781.18,6090.99) 6781.18,6105.47 ccw(c6781.18,6119.96) v4@6791.42,6109.72
HOST_USB.D6: U30.F10 U56.24 | length 6472.6
  Top Layer w4: U30.F10@7069.06,1963.43 v3(7088.74,1983.11) ; U30.F10@7069.06,1970.77 ccw(c7069.06,1988.49) 7081.59,1975.96 ccw(c7094.12,1963.42) U30.F10@7076.4,1963.42 ; 7075.94,1970.31 cw(c7088.74,1957.5) 7088.74,1975.61 ccw(c7088.74,1957.5) 7075.94,1970.31 ; 7075.94,1970.31 ccw(c7063.13,1983.11) 7081.24,1983.11 cw(c7063.13,1983.11) 7075.94,1970.31
  MidLayer1 w4: v1(8248.52,5341.71) 8248.52,5075.65 8249.35,5074.82 8249.35,5056.6 8248.52,5055.77 8248.52,4584.84 8237,4573.31 8237,4256.69 8257,4236.69 8257,3869.45 8224.02,3836.47 8224.02,3805.89 8223.52,3805.39 8223.52,3311.35 8248.19,3286.69 8248.19,3042.04 v1(8265.19,3025.04) ; v1@8255.69,3025.04 ccw(c8232.76,3025.04) 8248.97,3041.26 ccw(c8265.19,3057.48) v1@8265.19,3034.54 ; v1@8259.69,3025.04 ccw(c8246.41,3025.04) 8255.8,3034.43 ccw(c8265.19,3043.82) v1@8265.19,3030.54
  MidLayer2 w4: v4(6733,6085.79) 6901.46,6085.79 6978.54,6008.71 7056.52,6008.71 7098.52,5966.71 7283.03,5782.2 7318.23,5747 7419.23,5747 7790.81,5375.42 7824.52,5341.71 v1(8248.52,5341.71) ; v4@6738.66,6080.13 cw(c6752.31,6066.47) 6752.31,6085.79 cw(c6752.31,6105.1) v4@6738.66,6091.44 ; v3@7088.09,1990.58 ccw(c7086.51,2008.62) 7100.38,1996.98 ; v3@7096.21,1983.76 cw(c7114.25,1985.34) 7100.38,1996.98 ; v1@7123.28,2407.28 cw(c7107.06,2391.06) 7130,2391.06 cw(c7152.94,2391.06) v1@7136.72,2407.28 ; v1@7126.11,2410.11 cw(c7116.72,2400.72) 7130,2400.72 cw(c7143.28,2400.72) v1@7133.89,2410.11 ; v1(7130,2414) 7130,2381.5 7136.5,2375 7136.5,2342.23 7112.6,2318.33 7112.6,2139.53 7112.6,2120.11 7112.6,2045.99 7112.6,2026.49 cw(c7070.87,2026.49) 7100.38,1996.98 ; v1@8241.81,5334.99 ccw(c8225.59,5318.77) 8225.59,5341.71 ccw(c8225.59,5364.64) v1@8241.81,5348.43 ; v1@8244.64,5337.82 ccw(c8235.25,5328.43) 8235.25,5341.71 ccw(c8235.25,5354.99) v1@8244.64,5345.6
  Bottom Layer w4: v1(7130,2414) 7144.19,2428.19 7155.38,2428.19 7157.75,2430.56 7171,2443.81 7171,2452.87 7306.44,2588.31 7323.48,2588.31 7401.88,2666.71 7462.1,2666.71 7471.62,2657.19 7541.94,2657.19 7543.12,2658.37 7587.21,2658.37 7611.65,2682.81 7730,2682.81 7742.38,2682.81 7889.63,2682.81 7916.81,2709.99 8231.86,3025.04 v1(8265.19,3025.04) ; v1@8258.47,3018.32 ccw(c8242.26,3002.11) 8242.26,3025.04 ccw(c8242.26,3047.98) v1@8258.47,3031.76 ; v1@8261.3,3021.15 ccw(c8251.91,3011.76) 8251.91,3025.04 ccw(c8251.91,3038.32) v1@8261.3,3028.93
  Bottom Layer w8: v4(6733,6085.79) U56.24@6764.33,6085.79 ; v4@6737.24,6081.54 cw(c6747.49,6071.3) 6747.49,6085.79 cw(c6747.49,6100.27) v4@6737.24,6090.03
HOST_USB.D7: U30.A9 U56.25 | length 6213.4
  Top Layer w4: v2(7016,2314) 7029.68,2300.32 U30.A9@7029.69,2160.28 ; U30.A9@7024.49,2165.47 ccw(c7011.96,2178) 7029.68,2178 ccw(c7047.41,2178) U30.A9@7034.88,2165.47 ; v1@7915.19,5023.87 cw(c7915.19,5000.94) 7931.41,5017.16 cw(c7947.63,5033.37) v1@7924.69,5033.37 ; v1@7915.19,5027.87 cw(c7915.19,5014.6) 7924.58,5023.99 cw(c7933.97,5033.37) v1@7920.69,5033.37 ; v1(7915.19,5033.37) 7983.9,4964.66 7983.9,4876.01 8149.81,4710.1 8198.55,4710.1 8232.02,4676.63 8232.02,4107.43 8183.81,4059.21 8183.81,3898.62 8171,3885.81 8171,3725 8151,3705 8060,3705 8048.52,3693.52 v1(8048.52,3608.37) ; v1@8041.81,3615.09 ccw(c8025.59,3631.31) 8048.52,3631.31 ccw(c8071.46,3631.31) v1@8055.24,3615.09 ; v1@8044.64,3612.26 ccw(c8035.25,3621.65) 8048.52,3621.65 ccw(c8061.8,3621.65) v1@8052.41,3612.26
  MidLayer1 w4: v4@6795.66,6058.1 cw(c6795.66,6038.79) 6809.32,6052.45 cw(c6822.98,6066.1) v4@6803.66,6066.1 ; v4(6795.66,6066.1) 6866.32,5995.45 6870,5991.76 6870,5879 6833,5842 6833,5741.17 7121,5453.18 7190.03,5453.18 7243.17,5400.04 7820.83,5400.04 7928,5292.87 7928,5120.6 7916.36,5108.96 7916.36,5034.54 v1(7915.19,5033.37) ; v1@7908.47,5040.09 ccw(c7889.44,5059.13) 7916.36,5059.13 ; v1@7911.3,5037.26 ccw(c7899.09,5049.47) 7916.36,5049.47 ; 7916.36,5053.49 ccw(c7935.31,5053.49) v1@7921.91,5040.09
  Bottom Layer w4: v2@7016,2321.52 v2(7016,2314) 7028,2326 7028,2332.51 7068,2372.51 7068,2448 7078.62,2458.62 7124.12,2458.62 7143.5,2478 7153.37,2478 7238,2562.63 7238,2667.3 7322.7,2752 7453,2752 7465.59,2739.41 7529.37,2739.41 7556.67,2766.71 7892.56,2766.71 8048.52,2922.67 8048.52,3246.73 8047.5,3247.75 8047.5,3607.35 v1(8048.52,3608.37) ; v1@8041.81,3601.66 cw(c8028.06,3587.91) 8047.5,3587.91 ; 8047.5,3582.97 cw(c8073.93,3582.97) v1@8055.24,3601.66 ; 8047.5,3592.62 cw(c8064.27,3592.62) v1@8052.41,3604.49
  Bottom Layer w8: U56.25@6764.33,6066.1 v4(6795.66,6066.1) ; v4@6791.42,6061.86 ccw(c6781.18,6051.62) 6781.18,6066.1 ccw(c6781.18,6080.59) v4@6791.42,6070.34
HOST_USB.D8: U30.D8 U56.45 | length 5749.2
  Top Layer w4: v4@6418.68,6040.76 cw(c6405.02,6027.1) 6424.34,6027.1 cw(c6443.65,6027.1) v4@6430,6040.76 ; v4@6423.52,6046.42 v4(6424.34,6046.42) 6424.34,5960.85 6465.19,5920 6465.19,5691.71 6481.86,5675.04 6735.5,5675.04 6785.27,5625.27 ; 6785,5625 6798.52,5611.48 6798.52,5166.71 6815.19,5150.04 6915,5150.04 6990.19,5150.04 7059.96,5150.04 7090,5120 7090,5027.21 7123.86,4993.35 7123.86,4892.04 v1(7106.86,4875.04) ; v3(6970.63,2061.85) U30.D8@6990.32,2042.17 ; U30.D8@6982.97,2042.17 ccw(c6965.25,2042.16) 6977.78,2054.7 ccw(c6990.31,2067.23) U30.D8@6990.31,2049.51 ; v1@7106.86,4880.54 ccw(c7106.86,4893.82) 7116.25,4884.43 ccw(c7125.64,4875.04) v1@7112.36,4875.04 ; v1@7106.86,4884.54 ccw(c7106.86,4907.48) 7123.07,4891.26 ccw(c7139.29,4875.04) v1@7116.36,4875.04 ; 6983.43,2049.05 cw(c6996.24,2061.85) 6978.13,2061.85 ccw(c6996.24,2061.85) 6983.43,2049.05 ; 6983.43,2049.05 ccw(c6970.63,2036.24) 6970.63,2054.35 cw(c6970.63,2036.24) 6983.43,2049.05
  MidLayer1 w4: 6898.19,2443 6898.19,2506.94 6977.69,2586.44 6977.69,2598.85 7268.5,2889.67 7273.19,2894.35 7277.69,2898.85 7277.69,2991.54 7277.69,3059.56 7306.52,3088.39 7306.52,3095.02 7306.52,3115 7306.52,4135 7306.52,4143.39 7306.52,4198.04 7356.86,4248.37 7356.86,4265 7356.86,4326.86 7407.86,4377.86 7407.86,4683.37 7524.52,4800.04 7548.52,4800.04 7573.52,4825.04 7573.52,4866.48 7557.19,4882.81 7514.96,4882.81 ; 6898.19,2465 6898.19,2441.81 6909.81,2430.19 6909.81,2424 6909.81,2385 6909.81,2355.11 6924.52,2340.39 6924.52,2321.71 6924.52,2266.84 6916.19,2258.5 6916.19,2243.62 6926.62,2233.19 6942.81,2233.19 6946.77,2229.23 6946.77,2218.27 6946.77,2198.85 6946.77,2124.73 ; 6946.77,2138.66 6946.77,2124.73 ; v3@6963.24,2063.15 ccw(c6945.41,2066.3) 6960.24,2076.68 ; v3@6971.93,2069.24 cw(c6975.08,2087.07) 6960.24,2076.68 ; v1@7107.35,4874.55 v1(7106.86,4875.04) 7146.5,4875.04 7362.21,4875.04 7507.19,4875.04 ; v1@7110.75,4871.15 cw(c7120.14,4861.76) 7120.14,4875.04 cw(c7120.14,4888.32) v1@7110.75,4878.93 ; v1@7113.57,4868.32 cw(c7129.79,4852.11) 7129.79,4875.04 cw(c7129.79,4897.98) v1@7113.57,4881.76 ; 7506.69,4874.55 7507.19,4875.04 ; 6946.77,2124.73 6946.77,2101.48 ccw(c6970.54,2101.48) 6953.16,2085.26 6960.24,2076.68 ; 7507.19,4875.04 7514.96,4882.81 ; 7507.19,4875.04 7514.96,4882.81
  Bottom Layer w8: v4(6424.34,6046.42) U56.45@6455.67,6046.42 ; v4@6428.58,6042.17 cw(c6438.82,6031.93) 6438.82,6046.42 cw(c6438.82,6060.9) v4@6428.58,6050.66
HOST_USB.D9: U30.A8 U56.46 | length 5656
  Top Layer w4: U30.A8@6985.12,2165.47 ccw(c6972.59,2178) 6990.31,2178 ; U30.A8@6990.32,2160.28 U30.A8@6992.81,2162.77 ; U30.A8@6995.51,2165.47 cw(c7008.04,2178) 6990.31,2178 ; v2@6998.78,2270.68 cw(c6982.03,2253.94) 7005.71,2253.94 cw(c7029.4,2253.94) v2@7012.65,2270.68 ; v2@7001.6,2273.51 cw(c6991.68,2263.59) 7005.71,2263.59 cw(c7019.74,2263.59) v2@7009.82,2273.51 ; v2(7005.71,2277.62) 7005.71,2232.31 6990.31,2216.91 6990.31,2178
  MidLayer1 w4: 6466.22,6066.71 cw(c6466.22,6045.33) v4@6481.34,6060.45 ; 6469.15,6066.71 ccw(c6469.15,6083.95) v4@6481.34,6071.76 ; 6475.88,6066.71 cw(c6475.88,6054.98) v4@6484.17,6063.27 ; v4(6487,6066.1) 6481.86,6066.1 6481.86,6066.71 6460,6066.71 6445,6051.71 6445,6010 6435,6000 6435,5950 6465,5920 6465,5638.92 6821.92,5282 7474.9,5282 7529.71,5227.19 7614,5142.9 7614,4877.89 7609,4872.89 7609,4768.85 7599.86,4759.71 7599.86,4596.02 7570.54,4566.71 7490.19,4566.71 7465.19,4541.71 7465.19,4099.37 ; v2@6999.53,2285.24 ccw(c6988.53,2298.81) 7006,2298.81 ; v2@7002.05,2282.14 ccw(c6995.34,2290.42) 7006,2290.42 ; 7006,2289.91 ccw(c7016.62,2289.91) v2@7009.57,2281.97 ; v2@7006.86,2280 7006,2280.86 7006,2298.81 ; v2@7012.23,2284.96 cw(c7024.52,2298.81) 7006,2298.81 ; 6949.81,2430 6949.81,2423 6942.19,2415.38 6942.19,2362.62 7006,2298.81 ; 6949.81,2430 6949.81,2456.69 ; 6949.81,2430 6949.81,2456.69 ; 6949.81,2456.69 6949.81,2537.03 ; 6949.81,2537.03 6969.29,2556.52 ; 6949.81,2537.03 6969.29,2556.52 ; 6969.29,2556.52 6985.69,2572.91 6985.69,2595.54 7331.86,2941.71 7331.86,3210.75 7331.7,3210.91 7331.7,3370 ; 7331.7,3370 7331.7,3397.82 ; 7331.7,3370 7331.7,3397.82 ; 7331.7,3397.82 7377,3443.12 7377,3603.52 ; 7377,3603.52 7377,3665 ; 7377,3603.52 7377,3665 ; 7377,3665 7377,4011.18 ; 7377,4011.18 7465.19,4099.37 ; 7377,4011.18 7465.19,4099.37
  Bottom Layer w8: U56.46@6455.67,6066.1 v4(6487,6066.1) ; v4@6482.76,6061.86 ccw(c6472.51,6051.62) 6472.51,6066.1 ccw(c6472.51,6080.59) v4@6482.76,6070.35
HOST_USB.D10: U30.A12 U56.47 | length 6529.9
  Top Layer w4: U30.A12@7142.6,2165.47 ccw(c7130.07,2178) 7147.8,2178 ccw(c7165.52,2178) U30.A12@7152.99,2165.47 ; U30.A12@7147.8,2160.28 7147.8,2218 ; 7147.8,2217.46 cw(c7185.43,2217.46) v2@7160.5,2245.65 ; 7147.8,2219.3 7147.8,2218 ; 7147.8,2226.33 cw(c7177.58,2226.33) v2@7157.85,2248.65 ; 7147.8,2235.21 cw(c7169.73,2235.21) v2@7155.2,2251.64 ; v2(7154,2253) 7147.8,2246.8 7147.8,2218
  MidLayer1 w4: v1(7956.86,2633.37) 7989.86,2666.37 7989.86,3466.37 7998.52,3475.04 8119.8,3596.32 8141.41,3617.92 8141.41,3776.2 8141.41,3787.8 8142.23,3788.63 8156.7,3803.09 8233,3879.39 8233,4226.75 8213,4246.75 8213,4583.25 8224.52,4594.78 8224.52,5100.48 8074.96,5250.04 v1(8040.19,5250.04) ; v1@7956.86,2638.87 ccw(c7956.86,2652.15) 7966.25,2642.76 ccw(c7975.64,2633.37) v1@7962.36,2633.37 ; v1@7956.86,2642.87 ccw(c7956.86,2665.81) 7973.07,2649.59 ccw(c7989.29,2633.37) v1@7966.36,2633.37 ; v1@8044.08,5246.15 cw(c8053.47,5236.76) 8053.47,5250.04 cw(c8053.47,5263.32) v1@8044.08,5253.93 ; v1@8046.91,5243.32 cw(c8063.13,5227.11) 8063.13,5250.04 cw(c8063.13,5272.98) v1@8046.91,5256.76
  MidLayer2 w4: v4@6424.34,6077.79 cw(c6424.34,6058.47) 6438,6072.13 cw(c6451.65,6085.79) v4@6432.34,6085.79 ; v4(6424.34,6085.79) 6450.14,6059.99 6450.14,6040.97 6516.06,5975.04 6665.19,5975.04 6681.86,5958.37 6681.86,5717.32 6824.8,5574.37 7269.31,5574.37 7581.69,5262 7617.53,5262 7639.53,5240 8030,5240 v1@8040,5250 ; v1@8040.07,5249.93 v1(8040.19,5250.04)
  Bottom Layer w4: v2@7147.06,2259.94 ccw(c7130.31,2276.69) 7154,2276.69 ccw(c7177.69,2276.69) v2@7160.94,2259.94 ; v2@7149.89,2257.11 ccw(c7139.97,2267.03) 7154,2267.03 ccw(c7168.03,2267.03) v2@7158.11,2257.11 ; v2(7154,2253) 7154,2342.45 7159.36,2347.81 7179,2347.81 7433,2601.81 7532.87,2601.81 7543.56,2612.5 7591.44,2612.5 7594.44,2609.5 7618,2609.5 7654.31,2645.81 7685.69,2645.81 7700.69,2630.81 7735.5,2630.81 7791.06,2630.81 7797.75,2637.5 7819.62,2637.5 7848.93,2608.19 7931.67,2608.19 v1(7956.86,2633.37) ; v1@7947.36,2633.37 cw(c7924.42,2633.37) 7940.64,2617.16 cw(c7956.86,2600.94) v1@7956.86,2623.87 ; v1@7951.36,2633.37 cw(c7938.08,2633.37) 7947.47,2623.99 cw(c7956.86,2614.6) v1@7956.86,2627.87
  Bottom Layer w8: v4(6424.34,6085.79) U56.47@6455.67,6085.79 ; v4@6428.58,6081.54 cw(c6438.82,6071.3) 6438.82,6085.79 cw(c6438.82,6100.27) v4@6428.58,6090.03
HOST_USB.D11: U30.C8 U56.48 | length 5999.5
  Top Layer w4: v3(6970.63,2101.22) U30.C8@6990.32,2081.54 ; U30.C8@6982.97,2081.54 ccw(c6965.25,2081.54) 6977.78,2094.07 ccw(c6990.31,2106.6) U30.C8@6990.31,2088.88 ; 6983.43,2088.42 cw(c6996.24,2101.22) 6978.13,2101.22 ccw(c6996.24,2101.22) 6983.43,2088.42 ; 6983.43,2088.42 ccw(c6970.63,2075.61) 6970.63,2093.72 cw(c6970.63,2075.61) 6983.43,2088.42
  MidLayer1 w4: v1@6923.28,2507.28 cw(c6907.06,2491.06) 6930,2491.06 cw(c6952.93,2491.06) v1@6936.72,2507.28 ; v1@6926.11,2510.11 cw(c6916.72,2500.72) 6930,2500.72 cw(c6943.28,2500.72) v1@6933.89,2510.11 ; 6930,2465.19 6930,2471 v1(6930,2514) ; 6930,2477 6930,2464 6939,2455 6939,2435.81 6917.81,2414.62 6917.81,2358.42 6923.52,2352.71 6934.52,2341.71 6934.52,2277.66 6952.19,2260 6952.19,2254.62 ; v3@6963.24,2102.52 ccw(c6945.41,2105.67) 6960.24,2116.05 ; v3@6971.93,2108.61 cw(c6975.08,2126.44) 6960.24,2116.05 ; v1(7003.19,2577.37) 7024.94,2577.37 ; v1@7007.23,2573.64 cw(c7015.78,2565.71) 7015.78,2577.37 cw(c7015.78,2589.04) v1@7007.23,2581.11 ; v1@7010.16,2570.92 cw(c7024.94,2557.23) 7024.94,2577.37 ; v1@7010.16,2583.83 ccw(c7024.94,2597.52) 7024.94,2577.37 ; v1(7590.19,5217.71) 7615,5217.71 7622,5210.71 7622,4874.58 7617,4869.58 7617,4765.54 7607.86,4756.39 7607.86,4592.71 7573.86,4558.71 7493.5,4558.71 7473.52,4538.73 7473.52,4096.39 7385,4007.87 7385,3439.81 7381.86,3436.67 7339.7,3394.51 7339.7,3214.22 7339.86,3214.06 7339.86,2892.29 7024.94,2577.37 ; v1@7594.08,5213.82 cw(c7603.47,5204.43) 7603.47,5217.71 cw(c7603.47,5230.99) v1@7594.08,5221.6 ; v1@7596.91,5210.99 cw(c7613.13,5194.77) 7613.13,5217.71 cw(c7613.13,5240.64) v1@7596.91,5224.43 ; 6952.19,2254.62 6955.12,2251.69 ; 6952.19,2254.62 6955.12,2251.69 ; 6955.12,2251.69 6955.12,2231.31 6955.12,2218.27 6955.12,2133.9 ccw(c6988.25,2133.73) 6960.21,2116.08
  MidLayer2 w4: 6460.68,6108.37 cw(c6460.68,6079.15) v4@6481.34,6099.82 ; 6470.34,6108.37 cw(c6470.34,6088.81) v4@6484.17,6102.64 ; 6474.69,6108.37 ccw(c6474.69,6117.78) v4@6481.34,6111.13 ; v4(6487,6105.47) 6481.86,6105.47 6481.86,6108.37 6423.52,6108.37 6406.86,6091.71 6406.86,5961.36 6473.52,5894.69 6473.52,5737.79 6478.94,5732.37 6632.86,5732.37 6664.64,5700.59 6815.19,5550.04 7259.7,5550.04 7570.83,5238.92 7570.83,5237.07 v1(7590.19,5217.71) ; v1@6923.28,2520.72 ccw(c6907.06,2536.93) 6930,2536.93 ccw(c6952.93,2536.93) v1@6936.72,2520.72 ; v1@6926.11,2517.89 ccw(c6916.72,2527.28) 6930,2527.28 ccw(c6943.28,2527.28) v1@6933.89,2517.89 ; v1@6929.23,2514 v1(6930,2514) 6930,2526.18 6930,2545 6962.37,2577.37 6981.19,2577.37 ; v1@7580.69,5217.71 ccw(c7557.76,5217.71) 7573.97,5233.93 ccw(c7590.19,5250.14) v1@7590.19,5227.21 ; v1@7584.69,5217.71 ccw(c7571.41,5217.71) 7580.8,5227.1 ccw(c7590.19,5236.49) v1@7590.19,5223.21 ; 6981.19,2577.37 cw(c6981.19,2556.66) 6996.27,2570.86 ccw(c6981.19,2556.66) 6981.19,2577.37 ; 6981.19,2577.37 ccw(c6981.19,2598.09) 6996.27,2583.89 cw(c6981.19,2598.09) 6981.19,2577.37 ; 6981.19,2577.37 v1(7003.19,2577.37) 6981.19,2577.37 ; 6990.45,2577.37 cw(c6990.45,2565.38) 6999.19,2573.6 ccw(c6990.45,2565.38) 6990.45,2577.37 ; 6990.45,2577.37 ccw(c6990.45,2589.37) 6999.19,2581.15 cw(c6990.45,2589.37) 6990.45,2577.37
  Bottom Layer w8: U56.48@6455.67,6105.47 v4(6487,6105.47) ; v4@6482.76,6101.23 ccw(c6472.51,6090.99) 6472.51,6105.47 ccw(c6472.51,6119.96) v4@6482.76,6109.72
HOST_USB.D12: U30.K15 U56.49 | length 6962.9
  Top Layer w4: v4(6424.34,6125.16) 6455,6155.82 6455,6350 6475,6370 6908,6370 7020.5,6257.5 7245,6257.5 7331.52,6170.98 7331.52,5667.04 7370.38,5628.19 7370.38,5590.38 7356.52,5576.52 7356.52,5370.28 7698.52,5028.28 7698.52,4825.04 7662.52,4789.04 7662.52,4296.37 7675.52,4283.37 7798.52,4283.37 7815.19,4266.71 7815.19,3440 7857.19,3398 7857.19,3382 7853.02,3377.83 7853.02,3337.79 7849.19,3333.96 7849.19,2896.69 7857.19,2888.69 7857.19,2654.38 7830.5,2627.69 7830.5,2585.19 7808.5,2563.19 7808.5,2515 7774.19,2480.69 7774.19,2459.31 7791.19,2442.31 7791.19,2140.71 7842.19,2089.71 7842.19,1963.83 7842.95,1963.07 v1(7843.31,1963.07) ; v4@6424.34,6133.16 ccw(c6424.34,6152.47) 6438,6138.82 ccw(c6451.65,6125.16) v4@6432.34,6125.16 ; 7387.27,1780.73 7392,1776 ; v2@7447.06,1769.06 ccw(c7430.31,1752.31) 7430.31,1776 ccw(c7430.31,1799.69) v2@7447.06,1782.94 ; v2@7449.89,1771.89 ccw(c7439.97,1761.97) 7439.97,1776 ccw(c7439.97,1790.03) v2@7449.89,1780.11 ; v2(7454,1776) 7392,1776 ; v1@7836.59,1969.78 ccw(c7823.08,1983.29) 7842.19,1983.29 ; 7842.19,1979.05 ccw(c7859.3,1979.05) v1@7847.2,1966.95 ; 7842.19,1988.71 ccw(c7868.95,1988.71) v1@7850.03,1969.78 ; 7278.44,1793.41 ccw(c7285.62,1800.59) 7285.62,1790.44 ; 7278.44,1793.41 ccw(c7285.62,1800.59) 7285.62,1790.44 ; 7278.44,1793.41 cw(c7290.97,1805.94) 7273.25,1805.94 ccw(c7290.97,1805.94) 7278.44,1793.41 ; 7278.44,1793.41 ccw(c7265.91,1780.88) 7265.91,1798.6 cw(c7265.91,1780.88) 7278.44,1793.41 ; 7285.62,1790.44 7285.95,1790.1 7311.84,1790.1 7312.17,1790.44 7377.56,1790.44 7392,1776
  Bottom Layer w4: v2@7454,1776.5 7454.5,1776.5 7454.19,1776.81 7454.19,1800 7456.19,1802 7456.19,1888 7456.19,1900 7456.19,1982.69 7471.31,1997.81 7492.69,1997.81 7541.99,1948.51 7566.54,1948.51 7573.87,1941.19 7644.87,1941.19 7654.06,1932 7812.25,1932 v1(7843.31,1963.07) v1@7839.67,1966.71 ; v1@7833.81,1963.07 cw(c7810.88,1963.07) 7827.09,1946.85 cw(c7843.31,1930.63) v1@7843.31,1953.57 ; v1@7837.81,1963.07 cw(c7824.53,1963.07) 7833.92,1953.68 cw(c7843.31,1944.29) v1@7843.31,1957.57
  Bottom Layer w8: v4(6424.34,6125.16) U56.49@6455.67,6125.16 ; v4@6428.58,6120.91 cw(c6438.82,6110.67) 6438.82,6125.16 cw(c6438.82,6139.64) v4@6428.58,6129.4
HOST_USB.D13: U30.A10 U56.50 | length 6660.4
  Top Layer w4: v2@7043.06,2417.06 cw(c7006.54,2380.54) 7058.19,2380.54 ; v2@7045.89,2419.89 cw(c7016.2,2390.2) 7058.19,2390.2 ; v2@7048.72,2422.72 cw(c7025.86,2399.86) 7058.19,2399.86 ; v2(7050,2424) 7058.19,2415.81 7058.19,2292.5 7069.05,2281.63 U30.A10@7069.06,2160.28 ; v2@7051.55,2425.55 cw(c7035.51,2409.51) 7058.19,2409.51 ; U30.A10@7063.86,2165.47 ccw(c7051.33,2178) 7069.05,2178 ccw(c7086.78,2178) U30.A10@7074.25,2165.47
  MidLayer2 w4: v4@6481.34,6139.19 ccw(c6467.69,6125.53) 6467.69,6144.84 ccw(c6467.69,6164.16) v4@6481.34,6150.5 ; v4(6487,6144.84) 6393.33,6144.84 6373.52,6125.04 6350,6101.52 6350,6006.9 6373.52,5983.37 6465.19,5891.71 6465.19,5734.81 6475.63,5724.37 6627.19,5724.37 6636.89,5714.68 6805.65,5545.92 6809.86,5541.71 6830,5541.71 7256.72,5541.71 7562.83,5235.6 7562.83,5233.76 7562.83,5219.07 7581.9,5200 7675.07,5200 7691.07,5216 8175.06,5216 8223.86,5167.2 8223.86,4941.05 8147.19,4864.38 8147.19,4652.62 8148.81,4651 8148.81,4640 8148.81,4576.38 8182.81,4542.38 8182.81,4247.62 8181,4245.81 8181,4055.57 8108.19,3982.76 8108.19,3709.71 8040.19,3641.71 7952.19,3641.71 7835.52,3525.04 7834.48,3524 7720.72,3524 7477.69,3524 7459,3505.31 7459,3282.54 7131.86,2955.39 7131.86,2849.36 7127.19,2844.69 7127.19,2823.31 7131.86,2818.64 7131.86,2548.86 7117.86,2534.86 7117.86,2493.86 7079.5,2455.5 ; v2@7050,2426.75 7078.75,2455.5 ; v2@7050,2433.81 ccw(c7050,2450.86) 7062.06,2438.8 ; v2@7055.81,2424 cw(c7076.48,2424) 7061.86,2438.61 ; v2@7059.81,2424 cw(c7090.13,2424) 7068.69,2445.44
  Bottom Layer w8: U56.50@6455.67,6144.84 v4(6487,6144.84) ; v4@6482.76,6140.6 ccw(c6472.51,6130.36) 6472.51,6144.84 ccw(c6472.51,6159.33) v4@6482.76,6149.09
HOST_USB.D14: U30.A6 U56.51 | length 6799.9
  Top Layer w4: v1@6900.14,2306.66 cw(c6872.53,2279.05) 6911.57,2279.05 ; v1@6902.97,2309.49 cw(c6882.19,2288.71) 6911.57,2288.71 ; v1@6905.8,2312.31 cw(c6891.85,2298.36) 6911.57,2298.36 ; U30.A6@6906.38,2165.47 ccw(c6893.85,2178) 6911.57,2178 ccw(c6929.3,2178) U30.A6@6916.77,2165.47 ; v1(6906.86,2313.37) 6911.57,2308.66 U30.A6@6911.57,2160.28 ; 6911.57,2301.83 cw(c6918.4,2301.83) v1@6913.57,2306.66
  MidLayer2 w4: v4@6418.68,6158.87 ccw(c6405.04,6145.23) 6405.04,6164.52 ccw(c6405.01,6183.86) v4@6418.68,6170.18 ; v4@6424.34,6166.71 6424.34,6164.52 6346.34,6164.52 6331.86,6150.04 6331.86,5758.37 6365.19,5725.04 6373.86,5716.37 6623.88,5716.37 6759.26,5580.99 6800.9,5539.35 6806.88,5533.37 6821.15,5533.37 7253.74,5533.37 7335,5452.12 7335,5375 7306.86,5346.86 7306.86,5322.04 7467.9,5161 7563.37,5161 7658.7,5161 7697.7,5200 8168.43,5200 8207.86,5160.57 8207.86,4947.67 8131.19,4871.01 8131.19,4646 8132.81,4644.37 8132.81,4041.32 8084.19,3992.7 8084.19,3792.12 8015.07,3723 7885.78,3723 7710.78,3548 7467.75,3548 7435,3515.25 7435,3292.48 7107.69,2965.17 7107.69,2859.13 7103.19,2854.63 7103.19,2813.37 7107.69,2808.87 7107.69,2645.81 7031.86,2569.98 7031.86,2556.86 6980.19,2505.19 6980.19,2460.69 6931.36,2411.86 ; v1(6906.86,2313.37) 6931.36,2337.87 6931.36,2396.14 ; v1@6906.86,2318.87 ccw(c6906.86,2332.15) 6916.25,2322.76 ccw(c6925.64,2313.37) v1@6912.36,2313.37 ; v1@6906.86,2322.87 ccw(c6906.86,2345.81) 6923.07,2329.59 ccw(c6939.29,2313.37) v1@6916.36,2313.37 ; 6931.36,2396.14 6931.36,2411.86 ; 6931.36,2396.14 6931.36,2400 ; 6931.36,2400 6931.36,2411.86 ; 6931.36,2400 6931.36,2411.86
  Bottom Layer w8: v4(6424.34,6164.53) U56.51@6455.67,6164.53 ; v4@6428.58,6160.28 cw(c6438.82,6150.04) 6438.82,6164.53 cw(c6438.82,6179.01) v4@6428.58,6168.77
HOST_USB.D15: U30.F7 U56.52 | length 6632.5
  Top Layer w4: v3(6931.26,1983.11) U30.F7@6950.94,1963.43 ; U30.F7@6943.6,1963.42 ccw(c6925.88,1963.42) 6938.41,1975.96 ccw(c6950.94,1988.49) U30.F7@6950.94,1970.77 ; 6944.06,1970.31 cw(c6956.87,1983.11) 6938.76,1983.11 ccw(c6956.87,1983.11) 6944.06,1970.31 ; 6944.06,1970.31 ccw(c6931.26,1957.5) 6931.26,1975.61 cw(c6931.26,1957.5) 6944.06,1970.31
  MidLayer2 w4: 6465.66,6183.37 ccw(c6465.66,6205.55) v4@6481.34,6189.87 ; 6469.71,6183.37 cw(c6469.71,6166.92) v4@6481.34,6178.56 ; 6475.32,6183.37 ccw(c6475.32,6195.89) v4@6484.17,6187.04 ; v4@6487,6183.37 6353.88,6183.37 6323.03,6152.53 6323.03,5755.35 6370,5708.37 6620.56,5708.37 6803.9,5525.04 7211.27,5525.04 7275,5461.31 7275,5341.31 7463.31,5153 7566.69,5153 7693.8,5153 8115.19,4731.61 8115.19,4639.37 8116.81,4637.75 8116.81,4047.95 8068.19,3999.33 8068.19,3800.82 8008.25,3740.87 7881.02,3740.87 7704.15,3564 7461.12,3564 7331.86,3434.74 7331.86,3333.17 7098.52,3099.84 7098.52,2978.63 7091.69,2971.8 7091.69,2865.76 7087.19,2861.26 7087.19,2806.74 7091.69,2802.24 7091.69,2730.54 6929.15,2568 6884.81,2568 6871.19,2554.38 6871.19,2534.71 6895,2510.9 6895,2484 6872.19,2461.19 6872.19,2309.17 6873.36,2308 ; 6873.36,2309.83 6873.36,2262.96 6907.4,2228.92 6907.4,2120.11 6907.4,2045.99 6907.4,2026.49 ccw(c6949.13,2026.49) 6919.62,1996.98 ; v3@6923.79,1983.76 ccw(c6905.75,1985.34) 6919.62,1996.98 ; v3@6931.91,1990.58 cw(c6933.49,2008.62) 6919.62,1996.98
  Bottom Layer w8: U56.52@6455.67,6184.21 v4(6487,6184.21) ; v4@6482.76,6179.97 ccw(c6472.51,6169.73) 6472.51,6184.21 ccw(c6472.52,6198.7) v4@6482.76,6188.46
HOST_USB.FIFOADR0: U30.E8 U56.37 | length 6372
  Top Layer w4: v3(6970.63,2022.48) U30.E8@6990.32,2002.8 ; U30.E8@6982.97,2002.79 ccw(c6965.25,2002.79) 6977.78,2015.33 ccw(c6990.31,2027.86) U30.E8@6990.31,2010.14 ; 6983.43,2009.68 cw(c6996.24,2022.48) 6978.13,2022.48 ccw(c6996.24,2022.48) 6983.43,2009.68 ; 6983.43,2009.68 ccw(c6970.63,1996.87) 6970.63,2014.98 cw(c6970.63,1996.87) 6983.43,2009.68
  MidLayer2 w4: 6959.24,2036.06 cw(c6969.17,2045.99) 6955.12,2045.99 6955.12,2139.53 6955.12,2222 6955.12,2251.69 6952.19,2254.62 6952.19,2265 6935,2282.19 6935,2325 6939.36,2329.36 6940,2330 6940,2335.2 6940,2398.81 6940,2409.19 7001,2470.19 7008.69,2470.19 7023.81,2485.31 7023.81,2494 7062.62,2532.81 7069.52,2539.71 7069.52,2582.21 7123.86,2636.54 7123.86,2815.33 7119.19,2820 7119.19,2848 7123.69,2852.51 7123.69,2958.54 7451,3285.85 7451,3508.63 7474.37,3532 7717.4,3532 7831.17,3532 7832.54,3533.37 7949.7,3650.54 7954.68,3650.54 7955.17,3650.04 8037.21,3650.04 8100.19,3713.02 8100.19,3986.07 8152.19,4038.07 8152.19,4140 8160,4147.81 v1(8160,4196) ; v3@6963.16,2023.13 ccw(c6945.12,2024.71) 6958.99,2036.35 ccw(c6972.86,2047.99) v3@6971.28,2029.95 ; v1@8153.28,4189.28 cw(c8137.06,4173.06) 8160,4173.06 cw(c8182.94,4173.06) v1@8166.72,4189.28 ; v1@8156.11,4192.11 cw(c8146.72,4182.72) 8160,4182.72 cw(c8173.28,4182.72) v1@8163.89,4192.11
  Bottom Layer w4: v4@6580.47,5941.34 cw(c6580.47,5922.02) 6594.13,5935.68 cw(c6607.79,5949.34) v4@6588.47,5949.34 ; v4(6580.47,5949.34) 6631.86,5897.95 6631.86,5741.71 6665.19,5708.37 7095.54,5708.37 7167.17,5780 7375.67,5780 7710.33,5445.33 ; 7710,5445 7730,5425 7895,5425 7906.86,5413.14 7906.86,5320.52 8248.69,4978.69 8248.69,4858.69 8140,4750 8140,4208.9 8152.9,4196 v1(8160,4196) ; 8143.55,4205.35 ccw(c8150.07,4211.86) v1@8154.96,4204.05 ; 8147.1,4201.79 ccw(c8152.8,4207.49) v1@8157.08,4200.66 ; 8148.8,4200.09 cw(c8144.71,4196) v1@8150.5,4196
  Bottom Layer w8: v4@6576.23,5953.58 ccw(c6565.99,5963.82) 6580.47,5963.82 ccw(c6594.96,5963.82) v4@6584.72,5953.58 ; v4(6580.47,5949.34) U56.37@6580.47,5980.67
HOST_USB.FIFOADR1: U30.D16 U56.38 | length 6392.7
  Top Layer w4: U30.D16@7305.28,2042.17 7324.96,2042.16 7369.84,2042.16 7382,2030 v2@7412,2030 ; U30.D16@7310.47,2036.97 cw(c7323,2024.44) 7323,2042.16 cw(c7323,2059.89) U30.D16@7310.47,2047.36 ; 7385.49,2030 ccw(c7385.49,2060.51) v2@7407.06,2038.94 ; v2@7407.06,2025.06 ccw(c7395.14,2013.14) 7395.14,2030 ccw(c7395.14,2050.86) v2@7409.89,2036.11
  MidLayer2 w4: v4@6560.79,6004 cw(c6560.79,5984.69) 6574.44,5998.34 cw(c6588.1,6012) v4@6568.79,6012 ; v4(6560.79,6012) 6581.08,5991.71 6678.84,5991.71 6725,5945.55 6725,5685.49 6828.11,5582.37 7272.63,5582.37 7585,5270 7620.84,5270 7642.84,5248 8005,5248 8024.54,5267.54 8157.46,5267.54 8248.52,5176.48 8248.52,4077.84 8140.19,3969.5 8140.19,3872.31 8290,3722.5 8335,3677.5 8335,3461.31 8307.42,3433.73 8023.52,3149.84 8023.52,2500.04 7840.19,2316.71 7826.86,2316.71 7790.19,2280.04 7790.19,2081.44 7771.25,2062.5 7652.69,2062.5 7649.38,2065.81 7627.12,2065.81 7619.31,2058 7500.82,2058 7474.82,2032 v2(7414,2032) ; v2@7418.11,2027.89 cw(c7428.03,2017.97) 7428.03,2032 cw(c7428.03,2046.03) v2@7418.11,2036.11 ; v2@7420.94,2025.06 cw(c7437.69,2008.31) 7437.69,2032 cw(c7437.69,2055.69) v2@7420.94,2038.94
  Bottom Layer w8: v4@6556.54,6007.76 cw(c6546.3,5997.51) 6560.79,5997.51 cw(c6575.27,5997.51) v4@6565.03,6007.76 ; U56.38@6560.79,5980.67 v4(6560.79,6012)