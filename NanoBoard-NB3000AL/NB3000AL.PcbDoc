# Altium PCB NB3000AL.PcbDoc (part 71 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
SW#.D3: J28.4 R105.2 SW4.2 U8.AB6 | length 9071.8
  Top Layer w4: J28.4@4331.86,4074.8 J28.4@4323.39,4074.8 4383.01,4074.8 4407.02,4050.79 4407.02,3992.98 v1(4435,3965) ; J28.4@4349.67,4070.65 cw(c4359.69,4060.62) 4359.69,4074.8 cw(c4359.69,4088.98) J28.4@4349.67,4078.96 ; v1@4425.5,3965 ccw(c4402.56,3965) 4418.78,3981.22 ccw(c4435,3997.43) v1@4435,3974.5 ; v1@4429.5,3965 ccw(c4416.22,3965) 4425.61,3974.39 ccw(c4435,3983.78) v1@4435,3970.5 ; v3(5035.67,3875.04) U8.AB6@5055.35,3894.72 ; U8.AB6@5048.01,3894.72 cw(c5030.29,3894.72) 5042.82,3882.19 cw(c5055.35,3869.66) U8.AB6@5055.35,3887.38 ; v1(6436.52,454.71) 6765.19,783.37 6765.19,891.25 SW4.2@6760.02,896.42 6760.02,948.8 R105.2@6745,963.82 ; v1@6436.52,460.21 ccw(c6436.52,473.49) 6445.91,464.1 ccw(c6455.3,454.71) v1@6442.02,454.71 ; v1@6436.52,464.21 ccw(c6436.52,487.14) 6452.74,470.93 ccw(c6468.96,454.71) v1@6446.02,454.71 ; SW4.2@6745.52,910.91 ccw(c6710.53,945.91) 6760.02,945.91 ccw(c6809.51,945.91) SW4.2@6774.52,910.91 ; R105.2@6745.69,958.5 cw(c6746.08,948.31) R105.2@6753.3,955.52 ; R105.2@6745.85,954.51 cw(c6746.56,935.83) 6759.77,949.05 cw(c6772.04,961.31) R105.2@6754.77,962.94 ; SW4.2@6748.35,908.08 ccw(c6720.19,936.25) 6760.02,936.25 ccw(c6799.85,936.25) SW4.2@6771.69,908.08 ; R105.2@6750.79,963.32 ccw(c6761.05,962.35) R105.2@6753.76,955.06 ; SW4.2@6751.18,905.26 ccw(c6729.84,926.59) 6760.02,926.59 ccw(c6790.2,926.59) SW4.2@6768.86,905.26 ; SW4.2@6751.52,881.92 cw(c6718.53,848.93) 6765.19,848.93 ; SW4.2@6754.35,884.75 cw(c6728.19,858.59) 6765.19,858.59 ; SW4.2@6757.18,887.58 cw(c6737.84,868.24) 6765.19,868.24 ; 6765.19,844.92 cw(c6817.51,844.92) SW4.2@6780.52,881.92 ; 6765.19,854.58 cw(c6807.86,854.58) SW4.2@6777.69,884.75 ; 6765.19,864.24 cw(c6798.2,864.24) SW4.2@6774.86,887.58 ; 6765.19,873.89 cw(c6788.54,873.89) SW4.2@6772.03,890.41 ; 5048.47,3887.84 cw(c5035.67,3900.65) 5035.67,3882.54 ccw(c5035.67,3900.65) 5048.47,3887.84 ; 5048.47,3887.84 ccw(c5061.28,3875.04) 5043.17,3875.04 cw(c5061.28,3875.04) 5048.47,3887.84
  MidLayer1 w4: v1@4083.28,986.72 ccw(c4067.06,1002.93) 4090,1002.93 ccw(c4112.93,1002.93) v1@4096.72,986.72 ; v1@4086.11,983.89 ccw(c4076.72,993.28) 4090,993.28 ccw(c4103.28,993.28) v1@4093.89,983.89 ; v1(4090,980) 4090,1230 4127.63,1267.63 4165,1267.63 4174.59,1258.04 4236.73,1258.04 4246,1267.31 4246,1324.94 4249.86,1328.8 4256,1334.94 4256,1579 4250,1585 4232.02,1602.98 4232.02,1747.28 4302.5,1817.75 4302.5,1832.25 4226,1908.75 4226,2090 4150,2166 4124.19,2191.81 4124.19,2442.98 4181.86,2500.65 4181.86,2933.02 4323.52,3074.69 4323.52,3257.98 4296.52,3284.98 4296.52,3795.39 4398.52,3897.39 4398.52,3931.71 v1@4431.82,3965 ; 4413.35,3946.53 cw(c4435,3924.88) v1@4435,3955.5 ; 4420.18,3953.36 cw(c4435,3938.54) v1@4435,3959.5 ; 4421.03,3954.22 ccw(c4410.25,3965) v1@4425.5,3965 ; v1(4523.52,4000.04) 4543.5,3980.06 4574.06,3949.5 4620,3949.5 4643.02,3949.5 4666.27,3926.26 4666.27,3895 4666.27,3878.99 4666.27,3863.73 4678.82,3851.18 4694.07,3851.18 4715,3851.18 4830.82,3851.18 4838.82,3851.18 4879.25,3851.18 4898.67,3851.18 4972.79,3851.18 ; 4958.86,3851.18 4972.79,3851.18 ; v3@5028.28,3876.34 cw(c5010.45,3879.49) 5020.84,3864.65 ; v3@5034.37,3867.65 ccw(c5031.22,3849.82) 5020.84,3864.65 ; 4972.79,3851.18 4996.04,3851.18 ; 4996.04,3851.18 ccw(c4996.04,3874.95) 4996.21,3851.18 ; 4996.04,3851.18 4996.21,3851.18 ; 4996.21,3851.18 ccw(c4996.04,3874.95) 5012.26,3857.57 5020.84,3864.65
  MidLayer2 w4: v1(4090,980) 4135,980 4147.04,992.04 4447.96,992.04 4465,975 4793.69,975 5022,746.69 5022,386.11 5046.11,362 5208.94,362 5320.9,250.04 6200,250.04 ; v1@4093.89,976.11 cw(c4103.28,966.72) 4103.28,980 cw(c4103.28,993.28) v1@4093.89,983.89 ; v1@4096.72,973.28 cw(c4112.93,957.06) 4112.93,980 cw(c4112.93,1002.93) v1@4096.72,986.72 ; v1@4431.82,3965 v1(4435,3965) 4470.79,3965 4505.83,4000.04 ; v1@4435.37,3965.37 v1@4435.58,3965.16 ; v1@4438.89,3961.11 cw(c4448.28,3951.72) 4448.28,3965 cw(c4448.28,3978.28) v1@4438.89,3968.89 ; v1@4441.72,3958.28 cw(c4457.93,3942.06) 4457.93,3965 cw(c4457.93,3987.93) v1@4441.72,3971.72 ; 6200.33,249.71 6379.71,249.71 6390,260 6390,408.18 v1(6436.52,454.71) ; v1@6427.02,454.71 cw(c6404.09,454.71) 6420.31,438.49 cw(c6436.52,422.27) v1@6436.52,445.21 ; v1@6431.02,454.71 cw(c6417.75,454.71) 6427.14,445.32 cw(c6436.52,435.93) v1@6436.52,449.21 ; 4505.83,4000.04 cw(c4505.83,3988.31) 4515.61,3994.79 ccw(c4505.83,3988.31) 4505.83,4000.04 ; 4505.83,4000.04 ccw(c4505.83,4011.77) 4515.61,4005.29 cw(c4505.83,4011.77) 4505.83,4000.04 ; 4505.83,4000.04 v1(4523.52,4000.04) 4505.83,4000.04
SW#.D4: J28.5 R106.1 SW5.2 U8.AA3 | length 7355.5
  Top Layer w4: 4215.78,4081.27 cw(c4189.64,4055.12) J28.5@4226.61,4055.12 ; 4222.61,4074.44 cw(c4203.29,4055.12) J28.5@4230.61,4055.12 ; 4229.44,4067.61 cw(c4216.95,4055.12) J28.5@4234.61,4055.12 ; J28.5@4236.27,4060.78 cw(c4230.61,4055.12) J28.5@4238.61,4055.12 ; J28.5@4267.24,4053.62 ccw(c4277.64,4064.02) 4277.64,4049.31 ; J28.5@4270.07,4056.44 ccw(c4287.29,4073.67) 4287.29,4049.31 ; J28.5@4272.89,4059.27 ccw(c4296.95,4083.33) 4296.95,4049.31 ; 4752.38,3872.19 4750,3872.19 ; v1@4777.28,1850.72 ccw(c4761.06,1866.93) 4784,1866.93 ccw(c4806.93,1866.93) v1@4790.72,1850.72 ; v1@4780.11,1847.89 ccw(c4770.72,1857.28) 4784,1857.28 ccw(c4797.28,1857.28) v1@4787.89,1847.89 ; v1(4784,1844) 4784,1906.03 4715.19,1974.84 4715.19,2753.02 4681.86,2786.35 4681.86,2855.39 4640.19,2897.06 4640.19,2989.81 4624.02,3005.98 4624.02,3035.86 4624.02,3472.56 ; U8.AA3@4929.9,3934.09 cw(c4912.18,3934.09) 4924.71,3921.56 ; U8.AA3@4937.24,3926.75 ccw(c4937.24,3909.03) 4924.71,3921.56 ; v1@6878.28,941.72 ccw(c6862.06,957.93) 6885,957.93 ccw(c6907.93,957.93) v1@6891.72,941.72 ; v1@6881.11,938.89 ccw(c6871.72,948.28) 6885,948.28 ccw(c6898.28,948.28) v1@6888.89,938.89 ; v1(6885,935) 6885,969.85 6900.15,985 7198.82,985 R106.1@7220,963.82 ; 7203.25,980.57 cw(c7186.5,963.82) R106.1@7210.19,963.82 ; 7204.44,979.38 ccw(c7219.51,994.45) R106.1@7219.51,973.14 ; R106.1@7210.08,973.74 cw(c7200.16,963.82) R106.1@7214.19,963.82 ; R106.1@7211.27,972.55 ccw(c7219.51,980.79) R106.1@7219.51,969.14 ; R106.1@7215.19,963.82 R106.1@7220,963.82 ; R106.1@7220.49,954.5 cw(c7220.49,933.19) 7235.56,948.26 ; R106.1@7220.49,958.5 cw(c7220.49,946.85) R106.1@7228.73,955.09 ; SW5.2@7223.02,910.91 ccw(c7188.03,945.91) 7237.52,945.91 ccw(c7287.01,945.91) SW5.2@7252.02,910.91 ; R106.1@7225.81,963.82 ccw(c7239.84,963.82) R106.1@7229.92,953.9 ; SW5.2@7225.85,908.08 ccw(c7197.69,936.25) 7237.52,936.25 ccw(c7277.35,936.25) SW5.2@7249.19,908.08 ; SW5.2@7228.68,905.26 ccw(c7207.34,926.59) 7237.52,926.59 ccw(c7267.7,926.59) SW5.2@7246.36,905.26 ; R106.1@7229.81,963.82 ccw(c7253.5,963.82) 7236.75,947.07 ; SW5.2@7237.52,915 SW5.2@7237.52,896.42 7237.52,946.3 R106.1@7220,963.82 ; J28.5@4251.78,4055.12 4241.93,4055.12 4210.61,4086.44 4210.61,4102.54 4216.45,4108.37 4280.52,4108.37 4288.86,4100.04 4385,4100.04 ; J28.5@4251.78,4055.12 4256.86,4055.12 J28.5@4256.86,4053.86 ; J28.5@4251.78,4055.12 J28.5@4256.86,4050.04 ; J28.5@4256.86,4050.04 4255.04,4051.86 4255.04,4052.04 J28.5@4256.86,4053.86 ; J28.5@4256.86,4050.04 J28.5@4256.86,4053.86 ; J28.5@4256.86,4053.86 4261.37,4058.37 4270.44,4049.31 4362.04,4049.31 4366.28,4053.54 4380.77,4053.54 4391.02,4043.29 4391.02,3985 4391.02,3973.71 4423.02,3941.71 4448.69,3916.04 4448.69,3785.34 4448.69,3757.17 4454.52,3751.33 4454.52,3714.17 4461.5,3707.19 4461.5,3681.1 4464,3678.6 4473.52,3669.08 4473.52,3663.21 4473.52,3655 4473.52,3609.94 4506.76,3576.71 4593.48,3576.71 4615.19,3555 4615.19,3486.36 ; 4385,4100.04 4408.42,4100.04 ; 4385,4100.04 4408.42,4100.04 ; 4408.42,4100.04 4434.96,4100.04 4461.42,4073.58 4461.42,4047.04 ; 4461.42,4040 4461.42,4028.82 4473.52,4016.71 4515.19,3975.04 4711.27,3975.04 4734.19,3952.12 ; 4461.42,4040 4461.42,4047.04 ; 4461.42,4040 4461.42,4047.04 ; 4615.19,3486.36 4624.02,3477.53 ; 4615.19,3486.36 4624.02,3477.53 ; 4624.02,3472.56 4624.02,3477.53 ; 4624.02,3472.56 4624.02,3477.53 ; 4734.19,3904.38 4732.19,3902.38 4727.19,3897.38 4727.19,3882.62 4737.62,3872.19 4750,3872.19 ; 4734.19,3904.38 4734.19,3950.5 4734.19,3952.12 ; 4734.19,3904.38 4734.19,3952.12 ; 4750,3872.19 4753.5,3872.19 ; 4753.5,3872.19 4761.31,3880 4787.5,3906.19 ; 4753.5,3872.19 4787.5,3906.19 ; 4787.5,3906.19 4791.55,3910.23 4830.82,3910.23 4838.82,3910.23 4897.36,3910.23 ccw(c4897.36,3948.91) 4924.71,3921.56
  MidLayer2 w4: v1@4788,1840.23 cw(c4796.74,1832) 4796.74,1844 cw(c4796.74,1856) v1@4788,1847.77 ; v1@4790.19,1850.04 v1@4784.15,1844 ; v1@4790.92,1837.49 cw(c4806,1823.28) 4806,1844 ; v1@4790.92,1850.51 ccw(c4806,1864.72) 4806,1844 ; v1@6875.5,935 ccw(c6852.56,935) 6868.78,951.22 ccw(c6885,967.43) v1@6885,944.5 ; v1@6879.5,935 ccw(c6866.22,935) 6875.61,944.39 ccw(c6885,953.78) v1@6885,940.5 ; v1(6885,935) 6834.79,985.21 6577.48,985.21 6273.88,1288.81 6261.38,1288.81 6152.5,1288.81 6093.31,1348 5925.62,1348 5823.7,1449.92 5815,1449.92 5795.67,1449.92 5784.68,1460.9 5780.6,1460.9 5770,1460.9 5507.97,1460.9 5448.36,1520.51 5327.32,1641.55 5317.06,1651.81 4998.19,1651.81 4806,1844 ; v1@4784.15,1844 4796.23,1844 4806,1844 ; v1@4784.15,1844 v1(4784,1844) v1@4784.15,1844
TCK: R69.2 U8.P5 | length 5570.7
  Top Layer w4: v1@4447.95,3977.19 cw(c4426.85,3956.09) 4456.69,3956.09 ; v1@4450.77,3980.02 cw(c4436.5,3965.75) 4456.69,3965.75 ; 4456.69,3965.86 cw(c4472.72,3965.86) v1@4461.38,3977.19 ; v1@4456.69,3982.83 4456.69,3760.48 4462.52,3754.64 4462.52,3717.48 4469.5,3710.5 4469.5,3684.42 ; 4472,3681.92 4469.5,3684.42 ; v2@4538.59,3595.58 ccw(c4521.85,3578.83) 4521.85,3602.52 ccw(c4521.85,3626.21) v2@4538.59,3609.46 ; v2@4541.42,3598.41 ccw(c4531.5,3588.49) 4531.5,3602.52 ccw(c4531.5,3616.55) v2@4541.42,3606.63 ; v2(4545.53,3602.52) 4492.26,3602.52 4481.52,3613.26 4481.52,3672.39 4469.5,3684.42 ; v3(4996.3,4229.37) U8.P5@5015.98,4209.68 ; U8.P5@5008.64,4209.68 ccw(c4990.92,4209.68) 5003.45,4222.22 ccw(c5015.98,4234.75) U8.P5@5015.98,4217.03 ; v1@5197,3139 5185,3127 5185,3065 5256.79,2993.21 5498.21,2993.21 v2(5510,3005) ; 5009.1,4216.57 cw(c5021.91,4229.37) 5003.8,4229.37 ccw(c5021.91,4229.37) 5009.1,4216.57 ; 5009.1,4216.57 ccw(c4996.3,4203.76) 4996.3,4221.87 cw(c4996.3,4203.76) 5009.1,4216.57
  MidLayer1 w4: v2(4196,4153) 4309.19,4266.19 4332.38,4266.19 4366.19,4300 4421,4300 4482.19,4238.81 4482.19,4212.62 4500.81,4194 4572.56,4194 4584.32,4182.25 4599.25,4182.25 4606,4189 v1(4619,4189) ; v2@4196,4158.81 ccw(c4196,4172.84) 4205.92,4162.92 ccw(c4215.84,4153) v2@4201.81,4153 ; v2@4196,4162.81 ccw(c4196,4186.5) 4212.75,4169.75 ccw(c4229.5,4153) v2@4205.81,4153 ; v2@4545.53,3592.71 cw(c4545.53,3569.02) 4562.28,3585.77 cw(c4579.03,3602.52) v2@4555.34,3602.52 ; v2@4545.53,3596.71 cw(c4545.53,3582.68) 4555.45,3592.6 cw(c4565.37,3602.52) v2@4551.34,3602.52 ; v2(4545.53,3602.52) 4612.02,3536.03 4612.02,3493.33 4673.91,3431.45 4673.91,3424.17 4688.46,3409.62 ; 4601.2,4184.2 cw(c4612.36,4173.04) v1@4618.42,4187.62 ; 4605.43,4188.43 cw(c4614.85,4179.01) v1@4619.96,4191.31 ; v2@4700.46,3403.67 ccw(c4688.47,3394.54) 4688.47,3409.62 ; v2@4700.46,3415.56 cw(c4688.47,3424.7) 4688.47,3409.62 ; v2(4708.27,3409.62) 4688.46,3409.62 ; v2@4796,4245 4829,4245 4836.89,4244.88 4879.25,4244.88 4972.79,4244.88 cw(c4972.79,4230.83) 4982.72,4240.76 ; v3@4988.83,4228.72 ccw(c4970.79,4227.14) 4982.43,4241.01 ccw(c4994.07,4254.88) v3@4995.65,4236.84
  MidLayer2 w4: v2(4196,4153) 4267,4153 4281.69,4138.31 4281.69,4131.83 4326.71,4086.81 4554.19,4086.81 4559.5,4081.5 4625.56,4081.5 4627.06,4080 4635,4080 v1(4668,4047) ; v2@4200.11,4148.89 cw(c4210.03,4138.97) 4210.03,4153 cw(c4210.03,4167.03) v2@4200.11,4157.11 ; v2@4202.94,4146.06 cw(c4219.69,4129.31) 4219.69,4153 cw(c4219.69,4176.69) v2@4202.94,4159.94 ; v1@4612.28,4195.72 ccw(c4596.06,4211.93) 4619,4211.93 ccw(c4641.93,4211.93) v1@4625.72,4195.72 ; v1@4615.11,4192.89 ccw(c4605.72,4202.28) 4619,4202.28 ccw(c4632.28,4202.28) v1@4622.89,4192.89 ; v1(4619,4189) 4619,4220.93 4635.57,4237.5 4685.5,4237.5 4690.5,4242.5 4722,4242.5 4727.31,4237.19 4742.31,4237.19 4752.13,4247 v2@4793,4247 ; v1@4658.5,4047 ccw(c4635.56,4047) 4651.78,4063.22 ccw(c4668,4079.43) v1@4668,4056.5 ; v1@4662.5,4047 ccw(c4649.22,4047) 4658.61,4056.39 ccw(c4668,4065.78) v1@4668,4052.5 ; v2(5510,3005) 5567.64,3005 5572.64,3010 5625.84,3010 5641.71,2994.13 5641.71,2870.15 5651.96,2859.89 5703.68,2859.89 5709.17,2865.37 ; v2@5514.11,3000.89 cw(c5524.03,2990.97) 5524.03,3005 cw(c5524.03,3019.03) v2@5514.11,3009.11 ; v2@5516.94,2998.06 cw(c5533.69,2981.31) 5533.69,3005 cw(c5533.69,3028.69) v2@5516.94,3011.94 ; 5709.2,2865.37 5723.48,2879.66 5723.48,2965.77 5715.5,2973.75 5715.5,2996.37 5731.63,3012.5 5790.43,3012.5 5814,2988.93 v1(5814,2934) ; v1@5807.28,2940.72 ccw(c5791.06,2956.93) 5814,2956.93 ccw(c5836.93,2956.93) v1@5820.72,2940.72 ; v1@5810.11,2937.89 ccw(c5800.72,2947.28) 5814,2947.28 ccw(c5827.28,2947.28) v1@5817.89,2937.89
  Bottom Layer w4: v1@4454.66,3989.41 ccw(c4454.66,4002.69) 4464.05,3993.3 ccw(c4473.44,3983.91) v1@4460.16,3983.91 ; v1@4454.66,3993.41 ccw(c4454.66,4016.35) 4470.88,4000.13 ccw(c4487.1,3983.91) v1@4464.16,3983.91 ; v1@4456.83,3983.91 v1(4454.66,3983.91) 4488.75,4018 4551,4018 4581.5,3987.5 4630.5,3987.5 4668,4025 ; v1@4661.49,4040.08 cw(c4647.28,4025) 4668,4025 ; v1@4664.23,4043 cw(c4656,4034.26) 4668,4034.26 cw(c4680,4034.26) v1@4671.77,4043 ; v1(4668,4047) 4668,4025 ; v1@4674.51,4040.08 ccw(c4688.72,4025) 4668,4025 ; v2(4708.27,3409.62) 4748.59,3409.62 4758.22,3399.99 4765.9,3399.99 4787.36,3378.53 4787.36,3270 4783.02,3265.66 4783.02,3222.81 4780,3219.79 4780,3132.87 4790,3122.87 5023.06,3122.87 5050.06,3149.87 5136.61,3149.87 5146.49,3140 v1@5195.5,3140 ; v2@4712.38,3405.51 cw(c4722.3,3395.59) 4722.3,3409.62 cw(c4722.3,3423.65) v2@4712.38,3413.73 ; v2@4715.21,3402.68 cw(c4731.95,3385.93) 4731.95,3409.62 cw(c4731.95,3433.3) v2@4715.21,3416.55 ; v1@5190.28,3133.28 ccw(c5174.06,3117.06) 5174.06,3140 ccw(c5174.06,3162.93) v1@5190.28,3146.72 ; v1@5193.11,3136.11 ccw(c5183.72,3126.72) 5183.72,3140 ccw(c5183.72,3153.28) v1@5193.11,3143.89 ; R69.2@5705.82,3065.19 cw(c5705.82,3041.5) 5722.57,3058.25 ; R69.2@5705.82,3069.19 cw(c5705.82,3055.16) R69.2@5715.74,3065.08 ; R69.2@5705.82,3075 5729.02,3051.8 5789.89,3051.8 5814,3027.69 v1(5814,2934) ; R69.2@5711.14,3074.51 ccw(c5722.79,3074.51) R69.2@5714.55,3066.27 ; R69.2@5715.14,3074.51 ccw(c5736.45,3074.51) 5721.38,3059.44
  other v1: 5197,3140
  other v2: 4796,4250
TDI: R72.2 U8.P7 | length 6911.6
  Top Layer w4: v1@3952.14,3801.66 ccw(c3935.92,3785.44) 3935.92,3808.37 ccw(c3935.92,3831.31) v1@3952.14,3815.09 ; v1@3954.97,3804.49 ccw(c3945.58,3795.1) 3945.58,3808.37 ccw(c3945.58,3821.65) v1@3954.97,3812.26 ; v1(3958.86,3808.37) 3905.52,3808.37 3840.19,3873.71 3839.5,3874.4 3839.5,4010.56 3840.19,4011.25 3840.19,4046.69 3973.52,4180.02 3973.52,4825.04 3998.52,4850.04 v1(4040.19,4850.04) ; v1@4033.47,4843.32 ccw(c4017.26,4827.11) 4017.26,4850.04 ccw(c4017.26,4872.98) v1@4033.47,4856.76 ; v1@4036.3,4846.15 ccw(c4026.91,4836.76) 4026.91,4850.04 ccw(c4026.91,4863.32) v1@4036.3,4853.93 ; v3(5075.04,4229.37) U8.P7@5094.72,4209.68 ; U8.P7@5087.38,4209.68 ccw(c5069.66,4209.68) 5082.19,4222.22 ccw(c5094.72,4234.75) U8.P7@5094.72,4217.03 ; 5087.84,4216.57 cw(c5100.65,4229.37) 5082.54,4229.37 ccw(c5100.65,4229.37) 5087.84,4216.57 ; 5087.84,4216.57 ccw(c5075.04,4203.76) 5075.04,4221.87 cw(c5075.04,4203.76) 5087.84,4216.57
  MidLayer1 w4: v1(3958.86,3808.37) 4065.19,3808.37 4081.86,3791.71 4081.86,3591.04 v1(4098.5,3574.4) ; v1@3962.75,3804.49 cw(c3972.14,3795.1) 3972.14,3808.37 cw(c3972.14,3821.65) v1@3962.75,3812.26 ; v1@3965.57,3801.66 cw(c3981.79,3785.44) 3981.79,3808.37 cw(c3981.79,3831.31) v1@3965.57,3815.09 ; v1@4089,3574.4 ccw(c4066.06,3574.4) 4082.28,3590.62 ccw(c4098.5,3606.83) v1@4098.5,3583.9 ; v1@4093,3574.4 ccw(c4079.72,3574.4) 4089.11,3583.79 ccw(c4098.5,3593.18) v1@4098.5,3579.9 ; v2(4544.6,4274.83) 4580,4310.23 v2(4580,4357.69) ; v2@4544.6,4280.64 ccw(c4544.6,4294.67) 4554.52,4284.75 ccw(c4564.44,4274.83) v2@4550.41,4274.83 ; v2@4544.6,4284.64 ccw(c4544.6,4308.33) 4561.35,4291.58 ccw(c4578.09,4274.83) v2@4554.41,4274.83 ; v2@4573.06,4350.75 cw(c4556.31,4334) 4580,4334 cw(c4603.69,4334) v2@4586.94,4350.75 ; v2@4575.89,4353.58 cw(c4565.97,4343.66) 4580,4343.66 cw(c4594.03,4343.66) v2@4584.11,4353.58
  MidLayer2 w4: v1(4040.19,4850.04) v1(4256.86,4850.04) ; v1@4044.08,4846.15 cw(c4053.47,4836.76) 4053.47,4850.04 cw(c4053.47,4863.32) v1@4044.08,4853.93 ; v1@4046.91,4843.32 cw(c4063.13,4827.11) 4063.13,4850.04 cw(c4063.13,4872.98) v1@4046.91,4856.76 ; v1@4250.14,4843.32 ccw(c4233.92,4827.11) 4233.92,4850.04 ccw(c4233.92,4872.98) v1@4250.14,4856.76 ; v1@4252.97,4846.15 ccw(c4243.58,4836.76) 4243.58,4850.04 ccw(c4243.58,4863.32) v1@4252.97,4853.93 ; v2@4537.66,4267.89 cw(c4520.91,4251.15) 4544.6,4251.15 cw(c4568.28,4251.15) v2@4551.53,4267.89 ; v2@4540.49,4270.72 cw(c4530.57,4260.8) 4544.6,4260.8 cw(c4558.63,4260.8) v2@4548.71,4270.72 ; v2(4544.6,4274.83) 4544.6,4199.34 4581.44,4162.5 4596.56,4162.5 4608.97,4150.09 4627.47,4150.09 4633.19,4155.81 4687.44,4155.81 4688.75,4154.5 4703.25,4154.5 4737.75,4189 4743,4189 4750,4196 4789.82,4196 4830.12,4236.31 4830.12,4244.88 4838.82,4244.88 4957.99,4244.88 5051.53,4244.88 cw(c5051.53,4230.83) 5061.46,4240.76 ; v2@4580,4347.88 cw(c4580,4324.19) 4596.75,4340.94 cw(c4613.5,4357.69) v2@4589.81,4357.69 ; v2@4580,4351.88 cw(c4580,4337.85) 4589.92,4347.77 cw(c4599.84,4357.69) v2@4585.81,4357.69 ; v2(4580,4357.69) 4597.19,4340.5 4617.25,4340.5 4627.5,4350.75 4627.5,4372.56 4661.5,4406.56 4661.5,4532.81 4669.5,4540.81 4669.5,4575.19 4648.69,4596 4648.69,4687.81 4648.19,4688.31 ; v2@4628.23,4792.77 cw(c4611.49,4776.02) 4635.17,4776.02 cw(c4658.86,4776.02) v2@4642.11,4792.77 ; v2@4631.06,4795.6 cw(c4621.14,4785.68) 4635.17,4785.68 cw(c4649.2,4785.68) v2@4639.28,4795.6 ; v2(4635.17,4799.71) 4635.17,4741.18 4636.52,4739.83 4636.52,4699.98 ; v3@5067.57,4228.72 ccw(c5049.53,4227.14) 5061.17,4241.01 ccw(c5072.81,4254.88) v3@5074.39,4236.84 ; 4636.52,4699.98 4648.19,4688.31 ; 4636.52,4699.98 4648.19,4688.31
  Bottom Layer w4: v1@4092.25,3567.24 cw(c4080.26,3553.5) 4098.5,3553.5 ; v1@4094.88,3570.26 cw(c4087.94,3562.3) 4098.5,3562.3 cw(c4109.06,3562.3) v1@4102.12,3570.26 ; v1(4098.5,3574.4) 4098.5,3553.5 ; v1@4104.75,3567.24 ccw(c4116.74,3553.5) 4098.5,3553.5 ; v1@4256.86,4840.54 cw(c4256.86,4817.61) 4273.07,4833.82 cw(c4289.29,4850.04) v1@4266.36,4850.04 ; v1@4256.86,4844.54 cw(c4256.86,4831.26) 4266.25,4840.65 cw(c4275.64,4850.04) v1@4262.36,4850.04 ; v1(4256.86,4850.04) 4298.52,4808.37 4307.19,4799.71 4338.64,4799.71 4342.4,4795.95 4363.78,4795.95 4367.53,4799.71 v2(4635.17,4799.71) ; v2@4628.23,4792.77 ccw(c4611.49,4776.02) 4611.49,4799.71 ccw(c4611.49,4823.39) v2@4628.23,4806.65 ; v2@4631.06,4795.6 ccw(c4621.14,4785.68) 4621.14,4799.71 ccw(c4621.14,4813.74) v2@4631.06,4803.82 ; R72.2@5699.23,2828.41 ccw(c5683.32,2812.5) 5683.32,2835 ccw(c5683.32,2857.5) R72.2@5699.23,2841.59 ; R72.2@5702.06,2831.24 ccw(c5692.98,2822.16) 5692.98,2835 ccw(c5692.98,2847.84) R72.2@5702.06,2838.76 ; 4098.5,3553.5 4089.36,3544.36 4089.36,3495.85 4107.69,3477.52 4107.69,3381.21 4068.19,3341.71 4068.19,3033.35 4121,2980.54 4362.71,2980.54 4365.21,2983.04 4415.17,2983.04 4484.34,2913.87 4798.38,2913.87 4840.02,2872.23 4840.02,2869.5 4867.48,2842.04 4985.98,2842.04 4994.44,2850.5 5015.56,2850.5 5023.69,2842.37 5083.5,2842.37 5091.17,2850.04 5100.84,2850.04 5117.84,2833.04 5188.19,2833.04 5234.95,2879.8 5313.41,2879.8 5315.67,2877.54 5436.79,2877.54 5457.82,2898.57 5483,2898.57 5509.94,2925.5 5551.56,2925.5 5589.36,2887.71 5589.36,2867.79 5607.61,2849.54 5648.91,2849.54 5663.45,2835 R72.2@5705.82,2835 ; R72.2@5705.82,2835 5705.82,2834.51 R72.2@5705.82,2835
TDO: R71.2 U8.P6 | length 7746.6
  Top Layer w4: v3(5035.67,4229.37) U8.P6@5055.35,4209.68 ; U8.P6@5048.01,4209.68 ccw(c5030.29,4209.68) 5042.82,4222.22 ccw(c5055.35,4234.75) U8.P6@5055.35,4217.03 ; v1@6423.69,3233.37 ccw(c6400.76,3233.37) 6416.97,3249.59 ccw(c6433.19,3265.81) v1@6433.19,3242.87 ; v1@6427.69,3233.37 ccw(c6414.41,3233.37) 6423.8,3242.76 ccw(c6433.19,3252.15) v1@6433.19,3238.87 ; v1(6433.19,3233.37) 6414.86,3251.71 6414.86,3513.06 6506.86,3605.06 6506.86,3868.14 6436.53,3938.47 6436.53,4241.22 6451.5,4256.19 6451.5,4441.98 6459.36,4449.83 6459.36,4467.21 6437.02,4489.54 6437.02,4620.54 v1(6465.19,4648.71) ; v1@6455.69,4648.71 cw(c6432.76,4648.71) 6448.97,4632.49 cw(c6465.19,4616.27) v1@6465.19,4639.21 ; v1@6459.69,4648.71 cw(c6446.41,4648.71) 6455.8,4639.32 cw(c6465.19,4629.93) v1@6465.19,4643.21 ; 5048.47,4216.57 cw(c5061.28,4229.37) 5043.17,4229.37 ccw(c5061.28,4229.37) 5048.47,4216.57 ; 5048.47,4216.57 ccw(c5035.67,4203.76) 5035.67,4221.87 cw(c5035.67,4203.76) 5048.47,4216.57
  MidLayer1 w4: v2@4487.78,4383.98 cw(c4498.59,4390.01) 4489.84,4398.77 ; v2(4489.69,4385.05) 4489.69,4398.63 ; v2@4489.69,4394.69 4489.69,4398.63 ; v2@4491.27,4385.93 cw(c4503.4,4392.7) 4493.58,4402.52 ; v2@4494.76,4387.88 cw(c4508.2,4395.38) 4497.32,4406.26 ; v2@4498.26,4389.83 cw(c4513,4398.06) 4501.06,4410 ; 4672.19,4367.62 4679,4360.81 4703.38,4360.81 4713.81,4350.38 4713.81,4335.62 4703.38,4325.19 4686.62,4325.19 4683.31,4328.5 4619.75,4328.5 4615.06,4323.81 4608.25,4323.81 4598,4313.56 4598,4299.06 4608.25,4288.81 4622.75,4288.81 4646.44,4312.5 4667.56,4312.5 4682.5,4297.56 4682.5,4275 4692.5,4265 4709,4265 4714.57,4270.57 4714.57,4273.31 4728.26,4287 4795.19,4287 4812.52,4269.67 4812.52,4257.48 4816.77,4253.23 4828.53,4253.23 4838.23,4253.23 4898.67,4253.23 4972.79,4253.23 4992.29,4253.23 cw(c4992.29,4211.5) 5021.8,4241.01 ; 4672.5,4367.25 4649.15,4390.59 4543.09,4390.59 4523.69,4410 4501.06,4410 4489.69,4398.63 ; v3@5028.2,4228.72 ccw(c5010.16,4227.14) 5021.8,4241.01 ; v3@5035.02,4236.84 cw(c5033.44,4254.88) 5021.8,4241.01
  MidLayer2 w4: v2@4483.8,4392.89 ccw(c4474.93,4404.69) 4489.69,4404.69 ; v2(4489.69,4385.05) 4489.69,4404.69 ; v2@4495.58,4392.89 cw(c4504.45,4404.69) 4489.69,4404.69 ; v2(4500,5010) 4570,5010 4604.36,4975.64 4604.36,4828.02 4593.36,4817.03 4593.36,4780.58 4596,4777.94 4596,4777.69 4597.36,4776.33 4597.36,4659.94 4595.02,4657.6 4595.02,4614.27 ; v2@4504.11,5005.89 cw(c4514.03,4995.97) 4514.03,5010 cw(c4514.03,5024.03) v2@4504.11,5014.11 ; v2@4506.94,5003.06 cw(c4523.69,4986.31) 4523.69,5010 cw(c4523.69,5033.69) v2@4506.94,5016.94 ; 4595,4614.25 4595,4593.82 4613.32,4575.5 4635.25,4575.5 4645.5,4565.25 4645.5,4550.75 4635.25,4540.5 4586,4540.5 4577.41,4531.91 4567.16,4531.91 4548.5,4513.25 4548.5,4498.75 4563.75,4483.5 4611.25,4483.5 4621.5,4473.25 4621.5,4441.5 4610,4430 4515,4430 4489.69,4404.69 ; v2(5411.45,5056.45) 5425.4,5042.5 5457.25,5042.5 5467.5,5052.75 5467.5,5069.15 5490.55,5092.2 5505.05,5092.2 5556.04,5041.21 5970.11,5041.21 6001.4,5072.5 6047.25,5072.5 6054.75,5065 v2(6115,5065) ; v2@6108.06,5058.06 ccw(c6091.31,5041.31) 6091.31,5065 ccw(c6091.31,5088.69) v2@6108.06,5071.94 ; v2@6110.89,5060.89 ccw(c6100.97,5050.97) 6100.97,5065 ccw(c6100.97,5079.03) v2@6110.89,5069.11
  Bottom Layer w4: v2(4500,5010) 4678.5,5010 4688.79,4999.71 4735.1,4999.71 4742.62,4992.19 4757.38,4992.19 4764.9,4999.71 4928.98,4999.71 4962.15,4966.54 5020.16,4966.54 ; v2@4504.11,5005.89 cw(c4514.03,4995.97) 4514.03,5010 cw(c4514.03,5024.03) v2@4504.11,5014.11 ; v2@4506.94,5003.06 cw(c4523.69,4986.31) 4523.69,5010 cw(c4523.69,5033.69) v2@4506.94,5016.94 ; 5021.09,4966.5 5054.71,4932.87 5093.75,4932.87 5108.69,4947.81 5108.69,4953.69 5157.82,5002.82 5320.23,5002.82 5371.81,5054.4 v2@5409.4,5054.4 ; R71.2@5699.23,2962.08 ccw(c5683.32,2977.99) 5705.82,2977.99 ccw(c5728.32,2977.99) R71.2@5712.41,2962.08 ; R71.2@5702.06,2959.25 ccw(c5692.98,2968.33) 5705.82,2968.33 ccw(c5718.66,2968.33) R71.2@5709.58,2959.25 ; R71.2@5705.82,2955 5705.82,2984.41 5665.19,3025.04 5665.19,3108.37 5681.82,3125 6063.75,3125 6118.05,3179.31 6118.05,3193.8 ; v2(6115,5065) 6210,5065 6219.7,5055.3 6219.7,4980.6 6237.65,4962.65 6246.27,4962.65 6341.02,4867.89 6341.02,4796.02 6307.69,4762.69 6307.69,4734.46 6333.34,4708.81 6405.09,4708.81 v1(6465.19,4648.71) ; 6117.5,3194.36 6117.5,3212.25 6130.25,3225 6150,3225 6158.71,3216.29 6158.71,3191.29 6175,3175 6225,3175 6240.19,3175.04 6273.52,3208.37 6408.19,3208.37 v1(6433.19,3233.37) ; v2@6119.11,5060.89 cw(c6129.03,5050.97) 6129.03,5065 cw(c6129.03,5079.03) v2@6119.11,5069.11 ; v2@6121.94,5058.06 cw(c6138.69,5041.31) 6138.69,5065 cw(c6138.69,5088.69) v2@6121.94,5071.94 ; v1@6423.69,3233.37 cw(c6400.76,3233.37) 6416.97,3217.16 cw(c6433.19,3200.94) v1@6433.19,3223.87 ; v1@6427.69,3233.37 cw(c6414.41,3233.37) 6423.8,3223.99 cw(c6433.19,3214.6) v1@6433.19,3227.87 ; v1@6455.69,4648.71 ccw(c6432.76,4648.71) 6448.97,4664.93 ccw(c6465.19,4681.14) v1@6465.19,4658.21 ; v1@6459.69,4648.71 ccw(c6446.41,4648.71) 6455.8,4658.1 ccw(c6465.19,4667.49) v1@6465.19,4654.21
TFT_IO.BL: R214.2 U8.AF26 | length 2358.9
  Top Layer w4: U8.AF26@5842.76,3729.9 cw(c5842.76,3712.18) 5855.29,3724.71 ; U8.AF26@5850.1,3737.24 ccw(c5867.82,3737.24) 5855.29,3724.71 ; v1@6032.5,3338 ccw(c6009.56,3338) 6025.78,3354.22 ccw(c6042,3370.43) v1@6042,3347.5 ; v1@6036.5,3338 ccw(c6023.22,3338) 6032.61,3347.39 ccw(c6042,3356.78) v1@6042,3343.5 ; v1(6042,3338) 6020.71,3359.29 6020.71,3390.71 6040,3410 6040,3527.37 5969.12,3598.26 5969.12,3693.26 5948.99,3713.38 5941.18,3713.38 5882.64,3713.38 ; R214.2@6788.82,2615 6788.82,2638.82 6796,2646 v1(6856,2646) 6856.56,2646 v1@6856.86,2645.71 ; v1@6849.28,2639.28 ccw(c6833.06,2623.06) 6833.06,2646 ccw(c6833.06,2668.93) v1@6849.28,2652.72 ; v1@6852.11,2642.11 ccw(c6842.72,2632.72) 6842.72,2646 ccw(c6842.72,2659.28) v1@6852.11,2649.89 ; 5855.29,3724.71 ccw(c5882.64,3752.06) 5882.64,3713.38 ; 5855.29,3724.71 ccw(c5882.64,3752.06) 5882.64,3713.38
  MidLayer2 w4: v1(6042,3338) 6042,3338.1 6042.6,3338.7 6097.55,3338.7 6111.25,3325 6260,3325 ; v1@6045.89,3334.11 cw(c6056.97,3323.03) 6056.97,3338.7 ; v1@6045.89,3341.89 ccw(c6053.59,3349.59) 6053.59,3338.7 ; v1@6048.72,3331.28 cw(c6066.62,3313.38) 6066.62,3338.7 ; v1@6048.72,3344.72 ccw(c6063.25,3359.25) 6063.25,3338.7 ; v1@6849.28,2652.72 ccw(c6833.06,2668.93) 6856,2668.93 ccw(c6878.93,2668.93) v1@6862.72,2652.72 ; v1@6852.11,2649.89 ccw(c6842.72,2659.28) 6856,2659.28 ccw(c6869.28,2659.28) v1@6859.89,2649.89 ; v1@6856.86,2646 6856.86,2645.71 6856.56,2646 v1(6856,2646) 6856,2677.52 6856,2707.52 6856,2949.14 6856.86,2950 6856.86,2998.14 6821.63,3033.37 6663.52,3033.37 6656.86,3040.04 ; 6260,3325 6275,3310 ; 6260,3325 6275,3310 ; 6275,3310 6413.56,3310 6431.86,3291.71 6465.19,3258.37 6576.63,3258.37 6681.86,3153.14 6681.86,3125.04 6648.52,3091.71 6648.52,3048.37 ; 6648.52,3048.37 6656.86,3040.04 ; 6648.52,3048.37 6656.86,3040.04
TFT_IO.CS: J27.22 U8.AG18 | length 1154.1
  Top Layer w4: U8.AG18@5527.79,3690.53 cw(c5527.79,3672.8) 5540.33,3685.34 ; U8.AG18@5535.14,3697.87 ccw(c5552.86,3697.87) 5540.33,3685.34 ; 5878.72,3078.18 cw(c5865.8,3065.25) J27.22@5884.02,3063.88 ; 5884.88,3072.01 cw(c5877.26,3064.39) J27.22@5888.01,3063.58 ; J27.22@5885.89,3041.61 5885.9,3063.73 5890.19,3063.73 5890.19,3066.71 5876.19,3080.71 5698.52,3080.71 5690.19,3089.04 5690.19,3191.71 5682.69,3199.21 5608.04,3199.21 5565.5,3241.75 5565.5,3243.65 5551.95,3257.2 5457.8,3257.2 5450.27,3264.73 5450.27,3291.1 5431.02,3310.35 5431.02,3322.04 5444.31,3335.33 5444.31,3420.79 5447.83,3424.31 5453.31,3424.31 5485.2,3456.2 5495.55,3456.2 5501.62,3456.2 5511.8,3466.38 5511.8,3532.19 5516.3,3536.69 5516.3,3586.3 5543.3,3613.3 5543.3,3678.16 ccw(c5533.15,3678.16) 5540.33,3685.34
TFT_IO.DB0: J27.34 U8.AF15 | length 1038.5
  Top Layer w4: U8.AF15@5409.68,3729.9 cw(c5409.68,3712.18) 5422.22,3724.71 ; 5415.83,3302.92 5414.69,3304.06 ; U8.AF15@5417.03,3737.24 ccw(c5434.75,3737.24) 5422.22,3724.71 ; 5633.78,3075.78 ccw(c5648.72,3090.72) J27.34@5649.46,3069.61 ; 5640.28,3069.28 ccw(c5649.16,3078.16) J27.34@5649.6,3065.61 ; J27.34@5642.36,3067.2 cw(c5638.9,3063.74) J27.34@5643.8,3063.74 ; J27.34@5649.67,3041.61 5648.52,3042.76 5648.52,3061.04 5631.86,3077.71 5581.86,3077.71 5573.52,3086.04 5573.52,3151.31 5540.21,3184.63 5522.63,3184.63 5510,3172 5510,3160 5491.71,3141.71 5463.19,3141.71 5448.52,3156.37 5448.52,3217.69 5430,3236.21 5430,3288.74 5414.69,3304.06 ; 5414.69,3304.06 5414.69,3328.33 5428.3,3341.94 5428.3,3369.64 5386.8,3411.14 5386.8,3513.2 5375,3525 5375,3551.69 5433.55,3610.24 5433.55,3638.82 5433.55,3697.36 ccw(c5394.87,3697.36) 5422.22,3724.71
TFT_IO.DB1: J27.32 U8.AD17 | length 1687.5
  Top Layer w4: U8.AD17@5488.42,3808.64 cw(c5488.42,3790.92) 5500.96,3803.45 cw(c5513.49,3815.98) U8.AD17@5495.77,3815.98 ; U8.AD17@5488.43,3815.98 v3(5508.11,3796.3) ; v1(5598.52,2941.71) 5626.21,2941.71 5689.04,3004.54 J27.32@5689.04,3019.48 ; v1@5602.41,2937.82 cw(c5611.8,2928.43) 5611.8,2941.71 cw(c5611.8,2954.99) v1@5602.41,2945.6 ; v1@5605.24,2934.99 cw(c5621.46,2918.77) 5621.46,2941.71 cw(c5621.46,2964.64) v1@5605.24,2948.43 ; J27.32@5684.89,3015.33 cw(c5674.85,3005.3) 5689.04,3005.3 cw(c5703.22,3005.31) J27.32@5693.19,3015.33 ; 5495.31,3809.1 cw(c5482.5,3796.3) 5500.61,3796.3 ccw(c5482.5,3796.3) 5495.31,3809.1 ; 5495.31,3809.1 ccw(c5508.11,3821.91) 5508.11,3803.8 cw(c5508.11,3821.91) 5495.31,3809.1
  MidLayer1 w4: v1(5412.3,3482) 5442,3482 5462,3482 5470,3490 ; v1@5416.19,3478.11 cw(c5425.58,3468.72) 5425.58,3482 cw(c5425.58,3495.28) v1@5416.19,3485.89 ; v1@5419.02,3475.28 cw(c5435.24,3459.06) 5435.24,3482 cw(c5435.24,3504.93) v1@5419.02,3488.72 ; v3@5507.46,3788.83 cw(c5505.88,3770.79) 5519.75,3782.43 cw(c5533.62,3794.07) v3@5515.58,3795.65 ; 5519.5,3782.72 cw(c5509.57,3772.79) 5523.62,3772.79 ; 5523.62,3758.86 5523.62,3772.79 ; 5470,3490 5481.93,3490 ; 5470,3490 5481.93,3490 ; 5481.93,3490 5484.75,3492.82 5502.82,3492.82 5515,3505 5515,3592.89 5523.62,3601.5 5523.62,3630.82 5523.62,3638.82 5523.62,3679.25 5523.62,3772.79
  MidLayer2 w4: v1@5402.8,3482 cw(c5379.86,3482) 5396.08,3465.78 cw(c5412.3,3449.56) v1@5412.3,3472.5 ; v1@5406.8,3482 cw(c5393.52,3482) 5402.91,3472.61 cw(c5412.3,3463.22) v1@5412.3,3476.5 ; v1(5412.3,3482) 5382.69,3452.39 5382.69,3441.63 ; v1@5589.02,2941.71 ccw(c5566.09,2941.71) 5582.31,2957.93 ccw(c5598.52,2974.14) v1@5598.52,2951.21 ; v1@5593.02,2941.71 ccw(c5579.75,2941.71) 5589.14,2951.1 ccw(c5598.52,2960.49) v1@5598.52,2947.21 ; v1(5598.52,2941.71) 5553.04,2987.19 5517.38,2987.19 5510,2987.19 5502.62,2987.19 5496,2993.81 5452.44,2993.81 5415.69,3030.56 5415.69,3051.91 5415.69,3080 5415.69,3163.24 5393.62,3185.31 5393.62,3215 5393.62,3239.82 5402.17,3248.37 5417.5,3263.7 5417.5,3284.04 ; 5382.69,3435 5382.69,3441.63 ; 5382.69,3435 5382.69,3441.63 ; 5382.69,3435 5382.69,3385.32 5376.6,3379.23 5376.6,3364.73 5383.2,3358.13 5383.2,3318.34 5406,3295.54 ; 5406,3295.54 5417.5,3284.04 ; 5406,3295.54 5417.5,3284.04
TFT_IO.DB2: J27.30 U8.AH12 | length 1672.4
  Top Layer w4: 5284.02,3595.4 5284.02,3564.6 5289.02,3559.6 5289.02,3492.97 5300.34,3481.65 5300.34,3448.01 5323.31,3425.04 5331.44,3425.04 5339.69,3416.79 5339.69,3389.48 5344.07,3385.1 5352.44,3385.1 5395.34,3342.2 5395.34,3333.83 5396,3333.17 v1(5396,3268) ; 5284.07,3595.44 5284.07,3615.04 5291.58,3622.55 U8.AH12@5291.57,3658.5 ; U8.AH12@5286.38,3653.31 cw(c5273.85,3640.78) 5291.57,3640.78 cw(c5309.3,3640.78) U8.AH12@5296.77,3653.31 ; v1@5389.28,3274.72 ccw(c5373.06,3290.93) 5396,3290.93 ccw(c5418.93,3290.93) v1@5402.72,3274.72 ; v1@5392.11,3271.89 ccw(c5382.72,3281.28) 5396,3281.28 ccw(c5409.28,3281.28) v1@5399.89,3271.89 ; v1(5470,2881) 5471.5,2882.5 5549.3,2882.5 5583.51,2916.71 5623.52,2916.71 5723.52,3016.71 5723.52,3033.37 5728.41,3033.37 J27.30@5728.41,3041.61 ; v1@5473.89,2877.11 cw(c5486.9,2864.1) 5486.9,2882.5 ; v1@5476.72,2874.28 cw(c5496.56,2854.44) 5496.56,2882.5 ; v1@5476.72,2887.72 ccw(c5489.31,2900.31) 5489.31,2882.5 ; 5714.79,3007.97 cw(c5728.41,2994.35) J27.30@5728.41,3013.61 ; 5719.87,3013.06 ccw(c5713.44,3019.49) J27.30@5722.54,3019.49 ; J27.30@5721.62,3014.8 cw(c5728.41,3008) J27.30@5728.41,3017.61
  MidLayer2 w4: v1@5386.5,3268 cw(c5363.56,3268) 5379.78,3251.78 cw(c5396,3235.56) v1@5396,3258.5 ; v1@5390.5,3268 cw(c5377.22,3268) 5386.61,3258.61 cw(c5396,3249.22) v1@5396,3262.5 ; v1(5396,3268) 5377.62,3249.62 5377.62,3159.93 5348.52,3130.83 5348.52,3053.52 5281.02,2986.02 5281.02,2925 5331.82,2874.21 5420,2874.21 5426.79,2881 v1(5470,2881) v1@5470,2880 ; v1@5463.28,2874.28 ccw(c5447.06,2858.06) 5447.06,2881 ccw(c5447.06,2903.93) v1@5463.28,2887.72 ; v1@5466.11,2877.11 ccw(c5456.72,2867.72) 5456.72,2881 ccw(c5456.72,2894.28) v1@5466.11,2884.89
TFT_IO.DB3: J27.28 U8.AG17 | length 1841
  Top Layer w4: v1@5423,3508.7 v1@5423.1,3508.8 ; v1(5429.37,3503.12) 5451.9,3525.65 5451.9,3537.6 5461.2,3546.9 5461.2,3554.26 5492.3,3585.36 5492.3,3599.73 5503.93,3611.36 5503.93,3630.82 5503.93,3638.82 5503.93,3678.16 ccw(c5493.78,3678.16) 5500.96,3685.34 ; v1@5429.37,3508.62 ccw(c5429.37,3521.89) 5438.76,3512.51 ccw(c5448.15,3503.12) v1@5434.87,3503.12 ; v1@5429.37,3512.62 ccw(c5429.37,3535.55) 5445.58,3519.33 ccw(c5461.8,3503.12) v1@5438.87,3503.12 ; U8.AG17@5488.42,3690.53 cw(c5488.42,3672.8) 5500.96,3685.34 ; U8.AG17@5495.77,3697.87 ccw(c5513.49,3697.87) 5500.96,3685.34 ; v1@5732.86,2986.74 ccw(c5734.91,3007.72) 5749.81,2992.81 ; v1(5733.1,2989.23) 5733.1,2985.23 5734,2984.33 5734,2982 5735,2981 5738,2981 5739.66,2982.66 5767.78,3010.78 ; v1@5733.25,2990.72 ccw(c5735.97,3018.63) 5755.8,2998.8 ; v1@5733.64,2994.7 ccw(c5737.04,3029.54) 5761.79,3004.79 ; v1@5734.02,2998.68 ccw(c5738.1,3040.45) 5767.78,3010.78 ; 5751.6,2994.6 ccw(c5726.71,3019.49) J27.28@5761.91,3019.49 ; 5758.43,3001.43 ccw(c5740.36,3019.49) J27.28@5765.91,3019.49 ; 5765.25,3008.25 ccw(c5754.02,3019.49) J27.28@5769.91,3019.49 ; J27.28@5765.58,3014.04 cw(c5764.25,3010.78) 5767.78,3010.78 ; J27.28@5767.78,3041.61 5767.78,3019.48 5767.78,3010.78 ; J27.28@5769.98,3014.04 ccw(c5771.3,3010.78) 5767.78,3010.78
  MidLayer1 w4: v1@5726.38,2995.94 ccw(c5710.17,3012.16) 5733.1,3012.16 ccw(c5756.04,3012.16) v1@5739.82,2995.94 ; v1@5729.21,2993.12 ccw(c5719.82,3002.51) 5733.1,3002.51 ccw(c5746.38,3002.51) v1@5736.99,2993.12 ; v1@5731.86,3256.71 5733.56,3255 v1(5734,3255) 5734,3241.56 5724.02,3231.59 ; v1@5733.9,2984.3 v1@5733.9,2984.43 ; v1@5733.9,2997 5733.9,2989.23 v1@5733.9,2984.43 ; v1@5739.66,2982.66 5738,2981 5735,2981 5734,2982 5734,2984.33 v1@5733.9,2984.43 ; 5724.02,3029.66 5724.02,3045 ; 5724.02,3029.66 5724.02,3045 ; 5724.02,3029.66 5724.02,3045 ; 5724.02,3029.66 5733.1,3020.58 v1(5733.1,2989.23) 5733.1,2985.23 v1@5733.9,2984.43 ; 5724.02,3045 5724.02,3060 ; 5724.02,3045 5724.02,3060 ; 5724.02,3060 5724.02,3220 ; 5724.02,3220 5724.02,3231.59 ; 5724.02,3220 5724.02,3231.59
  Bottom Layer w4: v1@5422.65,3496.4 ccw(c5406.43,3480.18) 5406.43,3503.12 ccw(c5406.43,3526.05) v1@5422.65,3509.83 ; v1@5423.48,3509 v1(5429.37,3503.12) 5394.88,3503.12 5389,3509 ; v1@5425.48,3499.23 ccw(c5416.09,3489.84) 5416.09,3503.12 ccw(c5416.09,3516.39) v1@5425.48,3507.01 ; v1@5724.5,3255 ccw(c5701.56,3255) 5717.78,3271.22 ccw(c5734,3287.43) v1@5734,3264.5 ; v1@5728.5,3255 ccw(c5715.22,3255) 5724.61,3264.39 ccw(c5734,3273.78) 5734,3260.5 v1(5734,3255) 5701.81,3287.19 5701.81,3292.69 ; 5375,3523 5389,3509 ; 5375,3523 5356.25,3523 5346,3512.75 5346,3498.25 5351.8,3492.45 5351.8,3468.75 5408.5,3412.05 5408.5,3408.75 5426.75,3390.5 5452.36,3390.5 5558.36,3284.5 5606.56,3284.5 5621.5,3299.44 5621.5,3303.25 5641.75,3323.5 5655,3323.5 ; 5375,3523 5389,3509 ; 5655,3323.5 5671,3323.5 ; 5655,3323.5 5671,3323.5 ; 5671,3323.5 5701.81,3292.69 ; 5671,3323.5 5701.81,3292.69
TFT_IO.DB4: J27.9 U8.AG26 | length 871.5
  Top Layer w4: J27.9@6140.19,3140.37 J27.9@6141.8,3141.98 ; J27.9@6141.79,3140.37 J27.9@6141.8,3118.39 J27.9@6141.8,3141.98 ; 5855.29,3685.34 ccw(c5842.76,3672.8) 5842.76,3690.53 cw(c5842.76,3672.8) 5855.29,3685.34 ; 5855.29,3685.34 cw(c5867.82,3697.87) 5850.1,3697.87 ccw(c5867.82,3697.87) 5855.29,3685.34 ; 5855.29,3685.34 cw(c5848.11,3678.16) 5858.26,3678.16 ; 5855.29,3685.34 cw(c5848.11,3678.16) 5858.26,3678.16 ; 5857,3571.81 5857,3572 5857.19,3572 ; 5857,3571.81 5857.19,3572 ; 5857,3571.81 5845,3559.81 5845,3510.25 5930.75,3424.5 5984.65,3424.5 5990.19,3418.96 5990.19,3373 6023.81,3339.38 6023.81,3324.34 6031.44,3316.71 6090.19,3316.71 6152.5,3254.4 6152.5,3195 6141.8,3184.3 J27.9@6141.8,3141.98 ; 5857.19,3572 5862.59,3577.4 5873,3587.81 5873,3602.19 5858.26,3616.92 5858.26,3630.82 5858.26,3638.82 5858.26,3678.16
TFT_IO.DB5: J27.35 U8.AH18 | length 954.3
  Top Layer w4: v1@5483.57,3481.94 ccw(c5478.9,3490.1) 5488.3,3490.1 ccw(c5497.7,3490.1) v1@5493.03,3481.94 ; v1(5484.22,3161.74) 5515.11,3192.63 5543.52,3192.63 5552.75,3183.4 5596.25,3183.4 5608.86,3170.79 5608.86,3161.14 5629.99,3140.01 J27.35@5629.99,3118.39 ; v1@5484.22,3167.24 ccw(c5484.22,3180.52) 5493.61,3171.13 ccw(c5503,3161.74) v1@5489.72,3161.74 ; v1@5484.22,3171.24 ccw(c5484.22,3194.17) 5500.44,3177.96 ccw(c5516.66,3161.74) v1@5493.72,3161.74 ; v1(5488.3,3473.7) 5488.3,3490.1 5503.8,3505.6 5503.8,3535.5 5508.3,3540 5508.3,3589.61 5527.79,3609.11 5527.79,3630.82 5527.79,3638.82 U8.AH18@5527.8,3658.5 ; U8.AH18@5522.6,3653.31 cw(c5510.07,3640.78) 5527.79,3640.78 cw(c5545.52,3640.78) U8.AH18@5532.99,3653.31 ; 5619.11,3150.89 ccw(c5629.99,3161.77) J27.35@5629.99,3146.39 ; 5620.31,3149.69 cw(c5611.13,3140.51) J27.35@5624.11,3140.51
  MidLayer2 w4: 5467.92,3178.17 cw(c5451.48,3161.74) v1@5474.72,3161.74 ; 5468.22,3177.87 ccw(c5484.22,3193.87) v1@5484.22,3171.24 ; 5474.74,3171.34 cw(c5465.14,3161.74) v1@5478.72,3161.74 ; 5475.05,3171.04 ccw(c5484.22,3180.21) v1@5484.22,3167.24 ; v1@5484.22,3161.86 5452.62,3193.47 5452.62,3222.04 5485.69,3255.11 5485.69,3388.68 5516.04,3419.03 5516.04,3445.27 5508.31,3453 ; v1@5487.51,3472.91 5507.41,3453
TFT_IO.DB6: J27.37 U8.AH17 | length 1363.4
  Top Layer w4: v1@5465.7,3589.2 ccw(c5465.7,3600.68) 5473.82,3592.56 ; v1@5465.7,3593.2 ccw(c5465.7,3614.34) 5480.65,3599.39 ; v1@5466.58,3585.33 5488.4,3607.15 5488.4,3630.59 5488.42,3638.82 U8.AH17@5488.43,3658.5 ; v1@5471.2,3583.7 cw(c5486.28,3583.7) 5475.62,3594.36 ; v1@5475.2,3583.7 cw(c5499.93,3583.7) 5482.44,3601.19 ; U8.AH17@5483.23,3653.31 cw(c5470.7,3640.78) 5488.42,3640.78 cw(c5506.15,3640.78) U8.AH17@5493.62,3653.31 ; v1@5583.47,3157.99 cw(c5567.26,3141.77) 5590.19,3141.77 cw(c5613.13,3141.77) v1@5596.91,3157.99 ; v1@5586.3,3160.82 cw(c5576.91,3151.43) 5590.19,3151.43 cw(c5603.47,3151.43) v1@5594.08,3160.82 ; v1(5590.19,3164.71) 5590.19,3140.13 5590.62,3140.13 J27.37@5590.62,3118.39
  MidLayer2 w4: v1@5412.4,3207.42 ccw(c5396.18,3223.63) 5419.12,3223.63 ccw(c5442.05,3223.63) v1@5425.84,3207.42 ; v1@5415.23,3204.59 ccw(c5405.84,3213.98) 5419.12,3213.98 ccw(c5432.4,3213.98) v1@5423.01,3204.59 ; v1(5419.12,3200.7) 5419.12,3235.92 5419.12,3242.69 5433.5,3257.07 5433.5,3296.56 5424.43,3305.63 5424.43,3326.76 5438.8,3341.13 5438.8,3366.2 5408.5,3396.5 ; v1@5465.7,3574.2 cw(c5465.7,3551.26) 5481.92,3567.48 cw(c5498.13,3583.7) v1@5475.2,3583.7 ; v1@5465.7,3578.2 cw(c5465.7,3564.92) 5475.09,3574.31 cw(c5484.48,3583.7) v1@5471.2,3583.7 ; v1(5465.7,3583.7) 5488.2,3561.2 5493.95,3561.2 5502.57,3552.57 5505.33,3549.82 5505.33,3537.58 5502.27,3534.52 5493.95,3526.2 5470.15,3526.2 5459.9,3515.95 5459.9,3477.35 5485.94,3451.31 5497.79,3451.31 5508.04,3441.06 5508.04,3426.56 5497.79,3416.31 5495.18,3416.31 5483.29,3416.31 5461.9,3437.7 5461.9,3449.15 5451.05,3460 5437.68,3460 5412.68,3435 5408.5,3430.82 5408.5,3423.25 ; 5408.5,3396.5 5408.5,3423.25 ; 5408.5,3396.5 5408.5,3410 5408.5,3423.25
  Bottom Layer w4: v1@5419.12,3191.2 cw(c5419.12,3168.26) 5435.34,3184.48 cw(c5451.55,3200.7) v1@5428.62,3200.7 ; v1@5419.12,3195.2 cw(c5419.12,3181.92) 5428.51,3191.31 cw(c5437.89,3200.7) v1@5424.62,3200.7 ; v1(5419.12,3200.7) 5475.58,3144.24 5493.72,3144.24 5535.44,3144.24 5540.21,3149.01 5555.91,3164.71 v1(5590.19,3164.71) ; v1@5583.47,3157.99 ccw(c5567.26,3141.77) 5567.26,3164.71 ccw(c5567.26,3187.64) v1@5583.47,3171.43 ; v1@5586.3,3160.82 ccw(c5576.91,3151.43) 5576.91,3164.71 ccw(c5576.91,3177.99) v1@5586.3,3168.6
TFT_IO.DB7: J27.39 U8.AE12 | length 1269.8
  Top Layer w4: v3(5271.89,3756.93) U8.AE12@5291.57,3776.61 ; U8.AE12@5284.23,3776.61 cw(c5266.51,3776.61) 5279.04,3764.08 cw(c5291.57,3751.55) U8.AE12@5291.57,3769.27 ; v1(5524.52,3116.71) 5549.57,3116.71 J27.39@5551.25,3118.39 ; v1@5528.41,3112.82 cw(c5537.8,3103.43) 5537.8,3116.71 cw(c5537.8,3129.99) v1@5528.41,3120.6 ; v1@5531.24,3109.99 cw(c5547.46,3093.77) 5547.46,3116.71 cw(c5547.46,3139.64) v1@5531.24,3123.43 ; 5541.12,3116.71 cw(c5541.12,3108.26) J27.39@5547.09,3114.23 ; 5542.67,3116.71 ccw(c5542.67,3126.96) J27.39@5549.92,3119.71 ; 5284.69,3769.73 cw(c5271.89,3782.54) 5271.89,3764.43 ccw(c5271.89,3782.54) 5284.69,3769.73 ; 5284.69,3769.73 ccw(c5297.5,3756.93) 5279.39,3756.93 cw(c5297.5,3756.93) 5284.69,3769.73
  MidLayer1 w4: v3@5266.59,3751.63 cw(c5253.78,3738.82) 5271.89,3738.82 cw(c5290,3738.82) v3@5277.19,3751.63 ; v3@5266.7,3751.74 cw(c5254.16,3739.2) 5271.89,3739.2 cw(c5289.62,3739.2) v3@5277.08,3751.74 ; v3(5271.89,3756.93) 5271.89,3638.82 5271.89,3630.82 5271.89,3610.74 5289.25,3593.37 5289.25,3502.75 5292,3500 5292,3335 5281.9,3324.9 v1(5281.9,3308.8) ; v1@5277.31,3317.12 ccw(c5273.01,3324.9) 5281.9,3324.9 ccw(c5290.79,3324.9) v1@5286.49,3317.12
  MidLayer2 w4: v1@5281.86,3308.37 5281.9,3308.42 v1(5281.9,3308.8) 5296.5,3294.2 5296.5,3238.76 5295,3237.26 v1(5295,3170) ; v1@5288.28,3176.72 ccw(c5272.06,3192.93) 5295,3192.93 ccw(c5317.93,3192.93) v1@5301.72,3176.72 ; v1@5291.11,3173.89 ccw(c5281.72,3183.28) 5295,3183.28 ccw(c5308.28,3183.28) v1@5298.89,3173.89
  Bottom Layer w4: v1(5295,3170) 5308.37,3183.37 5343.7,3183.37 5368.7,3158.37 5398.52,3158.37 5440.19,3116.71 v1(5524.52,3116.71) ; v1@5517.81,3109.99 ccw(c5501.59,3093.77) 5501.59,3116.71 ccw(c5501.59,3139.64) v1@5517.81,3123.43 ; v1@5520.64,3112.82 ccw(c5511.25,3103.43) 5511.25,3116.71 ccw(c5511.25,3129.99) v1@5520.64,3120.6
TFT_IO.DB10: J27.11 U8.AE23 | length 1171.9
  Top Layer w4: U8.AE23@5724.65,3769.27 cw(c5724.65,3751.55) 5737.18,3764.08 cw(c5749.71,3776.61) U8.AE23@5731.99,3776.61 ; U8.AE23@5724.65,3776.61 v3(5744.33,3756.93) ; v1@6093.84,3179.84 cw(c6077.62,3163.62) 6100.55,3163.62 cw(c6123.49,3163.62) v1@6107.27,3179.84 ; v1@6096.66,3182.66 cw(c6087.28,3173.28) 6100.55,3173.28 cw(c6113.83,3173.28) v1@6104.44,3182.66 ; v1(6100.55,3186.55) 6100.55,3161.87 6102.43,3160 6102.43,3133.37 J27.11@6102.43,3118.39 ; 5731.53,3769.73 cw(c5718.72,3756.93) 5736.83,3756.93 ccw(c5718.72,3756.93) 5731.53,3769.73 ; 5731.53,3769.73 ccw(c5744.33,3782.54) 5744.33,3764.43 cw(c5744.33,3782.54) 5731.53,3769.73
  MidLayer1 w4: v3@5739.14,3751.74 cw(c5726.6,3739.2) 5744.33,3739.2 cw(c5762.06,3739.2) v3@5749.52,3751.74 ; v3(5744.33,3756.93) 5744.33,3679.25 5744.33,3643.01 5761.84,3625.5 5804.25,3625.5 5827.5,3602.25 5827.5,3592.31 5827.5,3581.63 5904.84,3504.29 5920.5,3488.63 5920.5,3465.5 5920.5,3424.75 5932,3413.25 5932,3385 5932,3367.17 5986,3313.17 5986,3291.38 6090.82,3186.55 v1(6100.55,3186.55) ; 6067.72,3209.65 ccw(c6100.55,3242.48) v1@6100.55,3196.05 ; 6074.55,3202.82 ccw(c6100.55,3228.83) v1@6100.55,3192.05 ; 6081.38,3196 ccw(c6100.55,3215.17) v1@6100.55,3188.05 ; 6088.21,3189.17 ccw(c6100.55,3201.51) v1@6100.55,3184.05 ; 5744.33,3738.82 cw(c5762.44,3738.82) 5749.63,3751.63 ccw(c5762.44,3738.82) 5744.33,3738.82 ; 5744.33,3738.82 ccw(c5726.22,3738.82) 5739.03,3751.63 cw(c5726.22,3738.82) 5744.33,3738.82
TFT_IO.DB11: J27.13 U8.AH26 | length 983.8
  Top Layer w4: U8.AH26@5837.56,3653.31 cw(c5825.03,3640.78) 5842.76,3640.78 cw(c5860.48,3640.78) U8.AH26@5847.95,3653.31 ; U8.AH26@5842.76,3658.5 5843,3658.26 5843,3608.19 5835.25,3600.44 5835.25,3567 5835.25,3560 5835.25,3507.52 5865.19,3477.58 5865.19,3341.71 5881.86,3325.04 5881.86,3300.04 v1(5919.52,3262.37) ; v1@5910.02,3262.37 ccw(c5887.09,3262.37) 5903.31,3278.59 ccw(c5919.52,3294.81) v1@5919.52,3271.87 ; v1@5914.02,3262.37 ccw(c5900.75,3262.37) 5910.13,3271.76 ccw(c5919.52,3281.15) v1@5919.52,3267.87 ; J27.13@6063.06,3145.06 6073.52,3155.52 ; J27.13@6064.91,3140.79 cw(c6075.46,3142.37) 6067.92,3149.92 ; J27.13@6068.87,3141.38 cw(c6085.21,3143.84) 6073.52,3155.52 ; v1(6104,3262) 6104,3247.18 6104,3225.48 6073.52,3195 6073.52,3155.52
  Bottom Layer w4: v1@5919.52,3252.87 cw(c5919.52,3229.94) 5935.74,3246.16 cw(c5951.96,3262.37) v1@5929.02,3262.37 ; v1@5919.52,3256.87 cw(c5919.52,3243.6) 5928.91,3252.99 cw(c5938.3,3262.37) v1@5925.02,3262.37 ; v1(5919.52,3262.37) 5938.9,3243 6023,3243 6030.33,3250.33 6043.5,3263.5 6078.21,3263.5 ; 6084.69,3263.5 ccw(c6084.69,3281.31) v1@6097.28,3268.72 ; 6087.59,3263.5 cw(c6087.59,3246.26) v1@6100.03,3258.19 ; v1@6097.14,3255.42 ccw(c6078.21,3237.26) 6078.21,3263.5 ; v1@6102.5,3263.5 6078.21,3263.5
TFT_IO.DB12: J27.15 U8.AE20 | length 1531.6
  Top Layer w4: U8.AE20@5606.54,3769.27 cw(c5606.54,3751.55) 5619.07,3764.08 cw(c5631.6,3776.61) U8.AE20@5613.88,3776.61 ; U8.AE20@5606.54,3776.61 v3(5626.22,3756.93) ; J27.15@6021.56,3140.51 cw(c6039.02,3140.51) 6026.68,3152.86 ; J27.15@6023.69,3118.39 J27.15@6023.68,3140.51 ; 6023.86,3150.04 6045.86,3172.04 v1(6045.86,3175.04) ; J27.15@6025.56,3140.51 cw(c6052.68,3140.51) 6033.5,3159.69 ; 6027.52,3153.7 ccw(c6006.18,3175.04) v1@6036.36,3175.04 ; 6034.35,3160.53 ccw(c6019.84,3175.04) v1@6040.36,3175.04 ; 6034.76,3160.94 cw(c6045.86,3149.85) v1@6045.86,3165.54 ; 5613.42,3769.73 cw(c5600.61,3756.93) 5618.72,3756.93 ccw(c5600.61,3756.93) 5613.42,3769.73 ; 5613.42,3769.73 ccw(c5626.22,3782.54) 5626.22,3764.43 cw(c5626.22,3782.54) 5613.42,3769.73
  MidLayer1 w4: v3@5620.92,3751.63 cw(c5608.11,3738.82) 5626.22,3738.82 cw(c5644.33,3738.82) v3@5631.52,3751.63 ; v3@5621.03,3751.74 cw(c5608.49,3739.2) 5626.22,3739.2 cw(c5643.95,3739.2) v3@5631.41,3751.74 ; v3(5626.22,3756.93) 5626.22,3679.25 5626.22,3638.82 5626.22,3630.82 5626.22,3519.03 5653.25,3492 v1(5664,3492) ; 5631.6,3513.66 ccw(c5661.14,3543.19) v1@5663.47,3501.49 ; 5637.92,3507.33 ccw(c5661.81,3531.22) v1@5663.69,3497.49 ; 5644.24,3501.01 ccw(c5662.48,3519.24) v1@5663.92,3493.5 ; 5650.56,3494.69 ccw(c5663.15,3507.27) v1@5664.14,3489.5
  MidLayer2 w4: v1@5658,3484.64 cw(c5647.7,3472) 5664,3472 ; v1@5660.53,3487.74 cw(c5654.56,3480.42) 5664,3480.42 cw(c5673.44,3480.42) v1@5667.47,3487.74 ; v1@5663.82,3492 v1(5664,3492) 5664,3472 ; v1@5670,3484.64 ccw(c5680.3,3472) 5664,3472 ; v1@6039.14,3168.32 cw(c6022.92,3152.11) 6045.86,3152.11 cw(c6068.79,3152.11) v1@6052.57,3168.32 ; v1@6041.97,3171.15 cw(c6032.58,3161.76) 6045.86,3161.76 cw(c6059.14,3161.76) v1@6049.75,3171.15 ; v1(6045.86,3175.04) 6045.86,3145.86 6041.71,3141.71 6012.52,3141.71 ; 5664,3472 5652,3460 5652,3433.94 5631.5,3413.44 5631.5,3298.75 5646.88,3283.37 5649.2,3283.37 5699.2,3233.37 5795.19,3233.37 5818.56,3210 5905,3210 5973.29,3141.71 6000,3141.71 ; 6000,3141.71 6012.52,3141.71 ; 6000,3141.71 6012.52,3141.71