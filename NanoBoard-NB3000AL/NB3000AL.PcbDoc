# Altium PCB NB3000AL.PcbDoc (part 46 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Top Layer w12: J33.A40@-785.98,2652.86 -701.48,2652.86 ; J33.A39@-785.98,2692.23 -701.48,2692.23 ; J33.A38@-785.98,2731.6 -678.25,2731.6 v1(-659.81,2750.04) ; J33.A39@-718.03,2688.12 ccw(c-713.87,2706.15) -700.79,2693.07 ; J33.A40@-717.08,2648.64 ccw(c-717.08,2676.13) -697.64,2656.69 ; J33.A40@-717.08,2660.64 ccw(c-717.08,2717.11) -677.16,2677.18 ; J33.A38@-711.58,2726.1 cw(c-698.3,2712.82) -698.3,2731.6 cw(c-698.3,2750.38) J33.A38@-711.58,2737.1 ; J33.A40@-710.87,2648.18 cw(c-701.48,2641.09) -701.48,2652.86 ; J33.A40@-710.87,2657.54 ccw(c-701.48,2664.63) -701.48,2652.86 ; J33.A39@-710.87,2687.55 cw(c-701.48,2680.46) -701.48,2692.23 ; J33.A39@-710.87,2696.91 ccw(c-701.48,2704) -701.48,2692.23 ; -694.14,2699.71 cw(c-679.79,2685.36) v1@-670.63,2703.47 ; -686.64,2707.21 cw(c-668.14,2688.72) v1@-668.14,2714.87 ; -682.43,2711.42 cw(c-671.92,2700.91) v1@-665.21,2714.17 ; v1@-672.03,2712.26 cw(c-681.42,2721.65) -681.42,2708.37 cw(c-681.42,2695.1) -672.03,2704.49 cw(c-681.42,2695.1) -668.14,2695.1 cw(c-654.86,2695.1) v1@-664.25,2704.49 ; v1@-665.31,2750.04 cw(c-678.59,2750.04) -669.2,2740.65 cw(c-659.81,2731.26) v1@-659.81,2744.54 ; v2(-460,2670) -420.98,2709.02 U1.6@-320,2709.02 -276.78,2709.02 ; v2@-460,2675.81 ccw(c-460,2689.84) -450.08,2679.92 ccw(c-440.16,2670) v2@-454.19,2670 ; v2(-455,2475) -255,2475 -172.17,2557.83 U1.13@-79.84,2557.83 ; v2@-450.89,2470.89 cw(c-440.97,2460.97) -440.97,2475 cw(c-440.97,2489.03) v2@-450.89,2479.11 ; C191.2@-441.59,3882.53 ccw(c-498.56,3939.5) -417.99,3939.5 ; C3.2@-441.59,4052.47 cw(c-498.56,3995.5) -417.99,3995.5 cw(c-337.43,3995.5) C3.2@-394.4,4052.47 ; C191.2@-433.1,3874.05 ccw(c-469.58,3910.53) -417.99,3910.53 ccw(c-366.4,3910.53) C191.2@-402.88,3874.05 ; C3.2@-433.1,4060.95 cw(c-469.58,4024.47) -417.99,4024.47 cw(c-366.4,4024.47) C3.2@-402.88,4060.95 ; C191.2@-417.99,3855 -417.99,4041.71 -418.14,4041.71 -418.14,4080 -418.14,4083.07 -417.99,4083.22 C3.2@-417.99,4080 -258.62,4239.37 v1(-130.48,4239.37) ; -417.99,3939.5 ccw(c-337.43,3939.5) C191.2@-394.4,3882.53 ; C3.2@-417.99,4105.31 ccw(c-417.99,4166.4) -374.79,4123.2 ; C3.2@-417.99,4117.31 ccw(c-417.99,4207.37) -354.3,4143.69 ; C3.2@-396.62,4083.94 cw(c-354.53,4083.94) C3.2@-384.29,4113.7 ; C3.2@-384.62,4083.94 cw(c-313.56,4083.94) -363.81,4134.18 ; v1@-253.98,2750.04 cw(c-267.25,2750.04) -257.86,2740.65 cw(c-248.48,2731.26) v1@-248.48,2744.54 ; v1(-248.48,2750.04) -265.4,2733.12 -265.4,2720.4 -276.78,2709.02 ; v1@-238.36,2684.49 ccw(c-247.75,2675.1) -247.75,2688.37 ccw(c-247.75,2701.65) v1@-238.36,2692.26 ; v1(-234.48,2688.37) -256.14,2688.37 -276.78,2709.02 ; C2.2@-180.26,1938.86 ccw(c-228.64,1987.93) -159.72,1987.93 ccw(c-90.8,1987.93) C2.2@-139.19,1938.86 ; v1@-175.03,2024.15 cw(c-211.99,1987.2) -159.72,1987.2 ; v1(-171.14,2028.04) -159.72,2016.62 -159.72,1935.99 -148.78,1925.04 v1(-84.81,1925.04) v1@-84.81,1924.76 ; v1@-166.55,2032.64 cw(c-183.02,2016.17) -159.72,2016.17 ; C1.2@-164.74,5479.53 ccw(c-176.33,5517.66) -136.48,5517.66 ; C1.2@-159.72,5459.09 -136.48,5459.09 -136.48,5550.04 v1(-136.48,5633.37) ; v1@-140.36,5629.49 cw(c-149.75,5620.1) -136.48,5620.1 cw(c-123.2,5620.1) v1@-132.59,5629.49 ; C2.2@-137.61,1937.17 ccw(c-111.07,1960.15) -111.07,1925.04 ; C1.2@-136.48,5506.48 ccw(c-116.28,5506.48) C1.2@-130.56,5492.2 ; -136.48,5532.74 cw(c-117.51,5532.74) v1@-130.92,5546.15 ; -136.48,5567.34 ccw(c-117.51,5567.34) v1@-130.92,5553.93 ; v1@-134.36,4235.49 ccw(c-143.75,4226.1) -143.75,4239.37 ccw(c-143.75,4252.65) v1@-134.36,4243.26 ; C2.2@-133.1,1905.94 cw(c-103.44,1892.47) -103.44,1925.04 ; v1@-116.7,1650.15 cw(c-125.65,1641.2) -112.99,1641.2 ; C4.2@-112.99,1595 -112.99,1654.04 v1(-112.81,1654.04) ; -112.99,1640.32 cw(c-99.09,1640.32) v1@-108.92,1650.15 ; v1@-88.7,1921.15 ccw(c-98.09,1911.76) -98.09,1925.04 ccw(c-98.09,1938.32) v1@-88.7,1928.93 ; v1@583.97,3139.15 cw(c574.2,3129.38) 588.01,3129.38 ; v1(587.86,3143.04) 588.01,3142.88 EXTHDR1.99@588.01,3071.85 ; 588.01,3130.14 cw(c600.76,3130.14) v1@591.75,3139.15 ; v1@615.46,3139.15 cw(c605.7,3129.38) 619.51,3129.38 ; EXTHDR1.97@619.51,3071.85 v1@619.51,3142.88 ; 619.51,3130.14 cw(c632.25,3130.14) v1@623.24,3139.15 ; v1@646.96,3139.15 cw(c637.19,3129.38) 651.01,3129.38 ; EXTHDR1.95@651.01,3071.85 v1@651.01,3142.88 ; 651.01,3130.14 cw(c663.75,3130.14) v1@654.74,3139.15 ; v1@2064.28,3139.15 cw(c2054.52,3129.38) 2068.33,3129.38 ; EXTHDR1.5@2068.33,3071.85 v1@2068.33,3142.88 ; 2068.33,3130.14 cw(c2081.07,3130.14) v1@2072.06,3139.15 ; v1@2095.78,3139.15 cw(c2086.01,3129.38) 2099.83,3129.38 ; EXTHDR1.3@2099.83,3071.85 v1@2099.83,3142.88 ; 2099.83,3130.14 cw(c2112.57,3130.14) v1@2103.56,3139.15 ; v1@2127.28,3139.15 cw(c2117.51,3129.38) 2131.32,3129.38 ; EXTHDR1.1@2131.32,3071.85 v1@2131.32,3142.88 ; EXTHDR1.1@2131.32,3079.72 EXTHDR1.MH1@2236.94,3079.72 ; 2131.32,3130.14 cw(c2144.07,3130.14) v1@2135.06,3139.15 ; EXTHDR1.1@2134.15,3069.02 cw(c2159.99,3043.18) 2159.99,3079.72 ; EXTHDR1.MH1@2222.39,3065.17 ccw(c2187.27,3030.05) 2187.27,3079.72 ccw(c2187.27,3129.39) EXTHDR1.MH1@2222.39,3094.27 ; v1@2793.19,5344.54 cw(c2793.19,5331.26) 2802.58,5340.65 cw(c2811.97,5350.04) v1@2798.69,5350.04 ; v1(2793.19,5350.04) 2809.52,5333.71 ; v1@2811.3,5679.49 cw(c2801.91,5670.1) 2815.19,5670.1 cw(c2828.47,5670.1) v1@2819.08,5679.49 ; v1(2815.19,5683.37) 2815.19,5660.15 LED5.2@2842.08,5633.26 ; v1(2823.52,6048.37) 2839.27,6032.63 LED4.2@2839.27,5930 ; LED5.2@2828.4,5633.26 ccw(c2795.36,5633.26) 2818.72,5656.62 ccw(c2842.08,5679.99) LED5.2@2842.08,5646.95 ; LED4.2@2829.6,5939.68 ccw(c2806.23,5963.04) 2839.27,5963.04 ccw(c2872.31,5963.04) LED4.2@2848.95,5939.68 ; LED7.2@2832.37,5324.12 ccw(c2809.52,5301.69) 2809.52,5333.71 ; LED7.2@2832.37,5343.3 cw(c2809.52,5365.74) 2809.52,5333.71 ; LED6.2@2832.41,5473.79 cw(c2809.04,5450.43) 2842.08,5450.43 cw(c2875.12,5450.43) LED6.2@2851.76,5473.79 ; LED6.2@2842.08,5483.47 2842.08,5440.99 2858.07,5425 v1(2975,5425) ; LED7.2@2842.14,5333.71 2809.52,5333.71 ; v1@2873.11,5421.11 ccw(c2863.72,5411.72) 2863.72,5425 ccw(c2863.72,5438.28) v1@2873.11,5428.89 ; v1@2880.89,5421.11 cw(c2890.28,5411.72) 2890.28,5425 cw(c2890.28,5438.28) v1@2880.89,5428.89 ; v1@2971.11,5421.11 ccw(c2961.72,5411.72) 2961.72,5425 ccw(c2961.72,5438.28) v1@2971.11,5428.89 ; C116.2@3570.22,4850.89 cw(c3560.3,4840.97) 3574.33,4840.97 cw(c3588.36,4840.97) C116.2@3578.44,4850.89 ; Y3.3@3573.17,4713.1 cw(c3563.25,4703.17) 3577.28,4703.17 cw(c3591.31,4703.18) Y3.3@3581.39,4713.1 ; Y3.3@3573.17,4744.94 ccw(c3563.25,4754.86) 3577.28,4754.86 ccw(c3591.31,4754.85) Y3.3@3581.39,4744.94 ; v1@3573.4,4804.73 cw(c3564.01,4795.34) 3577.28,4795.34 cw(c3590.56,4795.34) v1@3581.17,4804.73 ; 3574.33,4829.02 ccw(c3597.69,4829.02) v1@3581.17,4812.5 ; C116.2@3574.33,4855 3574.33,4811.57 v1(3577.28,4808.61) Y3.3@3577.28,4729.02 3577.28,4700.04 3585.62,4691.71 3604.38,4691.71 3612.72,4700.04 Y3.2@3612.72,4729.02 ; TP8.1@3576.12,4008.23 3623.09,4055.2 3623.09,4065.94 3631.86,4074.71 3631.86,4172.04 v1(3603.86,4200.04) ; TP8.1@3576.12,4032.23 ccw(c3576.12,4090.18) 3617.09,4049.21 ccw(c3658.06,4008.23) TP8.1@3600.12,4008.23 ; 3592.8,4209.18 ccw(c3610.73,4209.18) v1@3599.95,4194.85 ; v1@3598.52,4200.04 v1(3603.86,4200.04) ; v1@3603.86,4194.54 cw(c3603.86,4181.26) 3613.25,4190.65 cw(c3622.64,4200.04) v1@3609.36,4200.04 ; v1@3607.16,4204.44 cw(c3628.82,4233.23) U27.7@3592.8,4233.23 3592.8,4211.1 v1(3603.86,4200.04) ; Y3.2@3608.61,4713.1 cw(c3598.69,4703.17) 3612.72,4703.17 cw(c3626.74,4703.18) Y3.2@3616.83,4713.1 ; v1@3692.31,5274.49 v1(3692.19,5274.37) U10.2@3725,5274.41 ; v1@3692.31,5400.26 3702.64,5410.59 U9.2@3725,5410.59 ; v1@3692.89,5399.11 cw(c3720.6,5371.4) U9.2@3720.6,5410.59 ; v1@3696.08,5270.49 cw(c3705.55,5261.01) 3705.55,5274.41 ; v1@3696.08,5278.26 ccw(c3705.39,5287.57) 3705.39,5274.41 ; C115.2@3737.99,5040 3814.23,5040 ; C115.2@3753.69,5025.5 cw(c3786.81,4994.92) 3786.81,5040 cw(c3786.81,5085.08) C115.2@3753.69,5054.5 ; C115.2@3762.51,5017.36 cw(c3814.23,4969.6) 3814.23,5040 ; C115.2@3762.51,5062.64 ccw(c3814.23,5110.4) 3814.23,5040 ; 3846.42,5033.37 cw(c3846.42,5013.27) v1@3860.64,5027.49 ; v1(3847.19,5267.04) v1@3847.19,5274.37 ; v1(3847.19,5410.71) 3847.31,5410.59 U22.2@3880,5410.59 ; v1@3847.22,5274.41 U11.2@3880,5274.41 ; v1@3851.08,5263.15 cw(c3878.26,5235.97) U11.2@3878.26,5274.41 ; v1@3851.08,5406.82 cw(c3860.18,5397.71) 3860.18,5410.59 ; v1@3851.08,5414.6 ccw(c3860.75,5424.27) 3860.75,5410.59 ; v1(3864.52,5031.37) 3856.19,5031.37 3854.19,5033.37 3820.86,5033.37 3814.23,5040 ; U31.7@3920,3321.46 3949.11,3321.46 v1(3966.86,3303.71) 3974.33,3296.23 C124.1@3974.33,3270 ; U32.7@3926.46,3865 3931.86,3859.6 v1(3931.86,3833.37) ; U32.7@3926.46,3866.46 U32.7@3920,3866.46 ; v1@3927.97,3837.26 ccw(c3918.58,3846.65) 3931.86,3846.65 ccw(c3945.14,3846.65) v1@3935.75,3837.26 ; U32.7@3928.54,3862.92 ccw(c3920,3854.39) U32.7@3920,3866.46 ; 3931.86,3852.76 ccw(c3918.02,3852.76) U32.7@3920,3866.46 ; v1@3961.36,3303.71 ccw(c3948.08,3303.71) 3957.47,3313.1 ccw(c3966.86,3322.49) v1@3966.86,3309.21 ; v1@3962.97,3299.82 cw(c3935.54,3272.39) C124.1@3974.33,3272.39 ; C121.1@3969.33,4090.81 ccw(c3969.33,4113.47) 3985.35,4097.45 ; C124.1@3970.22,3274.11 ccw(c3960.3,3284.03) 3974.33,3284.03 ccw(c3988.36,3284.03) C124.1@3978.44,3274.11 ; C121.1@3970.59,4090.67 ccw(c3973.24,4102.57) 3981.86,4093.95 ; C121.1@3973.71,4089.38 cw(c3954.03,4069.7) 3981.86,4069.7 ; v1@3977.97,4039.93 ccw(c3968.58,4049.32) 3981.86,4049.32 ccw(c3995.14,4049.32) v1@3985.75,4039.93 ; v1(3981.86,4036.04) 3981.86,4093.95 ; v1@4165.19,3505 NT31.2@4185,3505 ccw(c4185,3479.67) v1@4165.99,3496.41 ; NT28.2@4185,4020 4185,4033.37 4176.67,4041.71 4123.52,4041.71 4090.19,4075.04 4058.42,4106.81 3994.72,4106.81 3981.86,4093.95 ; 4185,4022.71 ccw(c4193.8,4022.71) NT28.2@4187.58,4016.49 ; v1@4201.86,5294.54 cw(c4201.86,5281.26) 4211.25,5290.65 cw(c4220.64,5300.04) v1@4207.36,5300.04 ; v1@4204.22,5305.01 ccw(c4211.64,5320.55) 4223.82,5308.37 ; v1@4212.18,5436.41 ccw(c4194.09,5460) R124.1@4223.82,5460 ; v1(4215.52,5432.04) 4216.86,5433.37 4222.78,5433.37 4223.82,5434.41 R124.1@4223.82,5460 ; R93.1@4217.17,5323.16 cw(c4234.81,5324.92) 4222.28,5337.46 ; R95.1@4220.06,5259.25 ccw(c4210.98,5268.33) 4223.82,5268.33 ccw(c4236.66,5268.33) R95.1@4227.58,5259.25 ; R93.1@4220.06,5319.08 cw(c4210.98,5310) 4223.82,5310 ; R93.1@4220.06,5327.59 ccw(c4210.98,5336.67) 4223.82,5336.67 ccw(c4236.66,5336.67) R93.1@4227.58,5327.59 ; R91.1@4220.06,5387.41 cw(c4210.98,5378.33) 4223.82,5378.33 cw(c4236.66,5378.33) R91.1@4227.58,5387.41 ; R95.1@4223.82,5255 4223.82,5278.08 v1(4201.86,5300.04) 4215.49,5300.04 4223.82,5308.37 ; 4223.82,5310 cw(c4236.66,5310) R93.1@4227.58,5319.08 ; R91.1@4223.82,5391.67 4223.82,5371.71 4228.82,5366.71 ; 4228.86,5366.71 v1(4240.19,5355.37) 4223.82,5339 R93.1@4223.82,5323.33 4223.82,5308.37 ; 4230.74,5364.79 ccw(c4240.19,5374.24) v1@4240.19,5360.87 ; 4230.83,5364.7 cw(c4221.5,5355.37) 4234.69,5355.37 cw(c4221.41,5355.37) 4230.8,5345.99 cw(c4240.19,5336.6) v1@4240.19,5349.87 ; v1(4370.52,3621.37) 4385,3635.85 NT30.2@4385,3645 ; NT29.2@4385,3880 4414.86,3880 4418.86,3876 ; 4418.86,3876 ccw(c4436.8,3876) v1@4426.38,3861.39 ; v1(4423.19,3856.91) 4423.19,3871.67 4418.86,3876 ; v1@4423.52,3855.71 4418.86,3860.37 4418.86,3876 ; R97.1@4777.42,5414.25 ccw(c4768.34,5423.33) 4781.18,5423.33 ccw(c4794.02,5423.33) R97.1@4784.94,5414.25 ; R97.1@4781.18,5408.75 cw(c4820.38,5408.75) v1@4793.9,5437.65 ; R97.1@4781.18,5410 4781.18,5432.71 v1(4790.19,5441.71) ; v1@4815.19,3450.21 cw(c4815.19,3436.93) 4824.58,3446.32 cw(c4833.97,3455.71) v1@4820.69,3455.71 ; v1(4815.19,3455.71) 4837.01,3433.89 ; C278.2@4821.62,3408.55 ccw(c4808.45,3433.89) 4837.01,3433.89 ; v1@4827.97,4936.26 ccw(c4818.58,4945.65) 4831.86,4945.65 ccw(c4845.14,4945.65) v1@4835.75,4936.26 ; C276.2@4830.3,4968.37 cw(c4828.61,4960.15) 4837.01,4960.15 ; v1(4831.86,4932.37) 4831.86,4955 4837.01,4960.15 ; C278.2@4837.01,3375 4837.01,3433.89 ; C276.2@4837.01,5005 4837.01,4960.15 ; C276.2@4843.71,4968.37 ccw(c4845.4,4960.15) 4837.01,4960.15 ; C278.2@4852.4,3408.55 cw(c4865.57,3433.89) 4837.01,3433.89 ; v1@4852.97,5273.82 cw(c4843.58,5264.43) 4856.86,5264.43 cw(c4870.14,5264.43) v1@4860.75,5273.82 ; Q4.3@4856.86,5225.79 v1(4856.86,5277.71) ; 4856.86,5255.29 ccw(c4891.41,5255.29) Q4.3@4872.24,5226.54 ; Q4.3@4872.22,5225.02 cw(c4883.53,5211.12) 4896.21,5223.79 ; Q4.3@4872.28,5225.06 cw(c4882.73,5203.89) 4899.42,5220.58 ; Q4.3@4872.4,5225.79 4894.21,5225.79 ; Q4.3@4882.17,5219.32 cw(c4894.21,5211.35) 4894.21,5225.79 ; Q4.3@4882.17,5232.26 ccw(c4894.21,5240.23) 4894.21,5225.79 ; v1@4896.11,5193.89 ccw(c4886.72,5203.28) 4900,5203.28 ccw(c4913.28,5203.28) v1@4903.89,5193.89 ; v1(4900,5190) 4900,5220 4894.21,5225.79 ; v1@5111.3,2953.93 ccw(c5081.79,2983.44) 5123.52,2983.44 ; v1@5114.97,5246.15 cw(c5105.58,5236.76) 5118.86,5236.76 cw(c5132.14,5236.76) v1@5122.75,5246.15 ; v1@5115.19,2944.54 cw(c5115.19,2931.26) 5124.58,2940.65 cw(c5133.97,2950.04) v1@5120.69,2950.04 ; v1(5118.86,5250.04) 5118.86,5176.14 5164.33,5130.67 5164.33,5107.04 C260.2@5164.33,5005 ; U33.7@5123.52,3011.46 5123.52,2958.37 v1(5115.19,2950.04) 5131.86,2933.37 5192.71,2933.37 C122.1@5219.33,2960 ; v1(5140,3310) 5164.33,3334.33 C265.2@5164.33,3375 ; v1@5140,3315.5 ccw(c5140,3328.78) 5149.39,3319.39 ccw(c5158.78,3310) v1@5145.5,3310 ; C260.2@5140.73,5032.53 ccw(c5083.77,5089.5) 5164.33,5089.5 ; C260.2@5149.22,5024.05 ccw(c5112.74,5060.53) 5164.33,5060.53 ccw(c5215.92,5060.53) C260.2@5179.44,5024.05 ; 5164.33,5089.5 ccw(c5244.89,5089.5) C260.2@5187.93,5032.53 ; C122.1@5213.52,2960 cw(c5199.49,2960) 5209.41,2950.08 cw(c5219.33,2940.16) C122.1@5219.33,2954.19 ; v1@5319.64,5376.26 ccw(c5297.46,5398.44) R126.1@5328.82,5398.44 ; v1(5323.52,5372.37) 5323.52,5370.37 5323.82,5370.37 5324.67,5371.23 5328.82,5375.37 R126.1@5328.82,5410 ; R126.1@5325.06,5405.75 cw(c5315.98,5396.67) 5328.82,5396.67 cw(c5341.66,5396.67) R126.1@5332.58,5405.75 ; SW6.3@5327.13,166.81 5392.63,166.81 5392.52,166.71 5598.52,166.71 5598.52,166.81 ; SW6.3@5344.79,155.14 cw(c5372.96,126.98) 5372.96,166.81 cw(c5372.96,206.65) SW6.3@5344.79,178.48 ; v1@5441.11,5188.89 ccw(c5425.92,5204.08) 5447.4,5204.08 ; v1(5445,5185) 5441.82,5185 5440.19,5183.37 5440.19,5191.04 5440.4,5191.04 5447.4,5198.04 Q6.3@5447.4,5225.79 ; Y5.2@5447.3,1834.3 cw(c5410.59,1797.59) 5462.5,1797.59 cw(c5514.41,1797.59) Y5.2@5477.7,1834.3 ; Y5.2@5453.02,1876.8 ccw(c5445.55,1892.02) 5462.5,1892.02 ; 5469.74,1899.26 ccw(c5447.3,1921.7) v1@5478.58,1927.07 ; Y5.2@5471.98,1876.8 cw(c5479.46,1892.02) 5462.5,1892.02 ; v1@5484,1921.5 ccw(c5484,1947.22) 5502.19,1929.03 ; v1(5484,1928) 5498.48,1928 5462.5,1892.02 ; v1@5484,1933.5 ccw(c5484,1988.19) 5522.67,1949.52 ; 5486.13,1915.65 ccw(c5475.28,1926.5) v1@5490.41,1929.1 ; v1@5487.89,1924.11 cw(c5497.38,1914.62) 5497.38,1928.04 ; v1@5487.89,1931.89 ccw(c5497.18,1941.18) 5497.18,1928.04 ; 5498.52,1928.04 5501.2,1928.04 5534.97,1961.81 5557.29,1961.81 5557.5,1962.02 ; C157.1@5498.56,2080.89 cw(c5488.64,2070.97) 5502.67,2070.97 cw(c5516.7,2070.97) C157.1@5506.78,2080.89 ; C157.1@5502.67,2085 5502.67,2022.33 5508.5,2016.5 ; U61.123@5516.83,2390.4 5556.55,2390.4 v1(5572.52,2406.37) 5549.13,2429.77 U61.121@5516.83,2429.77 ; U61.117@5516.83,2508.51 5548.52,2508.51 5548.52,2508.37 5581.86,2508.37 5598.52,2525.04 v1(5598.52,2616.71) 5549.24,2665.99 U61.109@5516.83,2665.99 ; Y5.4@5541.68,2001.94 ccw(c5508.5,1971.42) 5508.5,2016.5 ; Y5.4@5541.68,2031.06 cw(c5508.5,2061.58) 5508.5,2016.5 ; Y5.4@5542.6,1997 cw(c5508.99,1962.02) 5557.5,1962.02 ; Y5.4@5572.4,1997 ccw(c5606.01,1962.02) 5557.5,1962.02 ; v1@5572.52,2400.87 ccw(c5572.52,2387.6) 5563.14,2396.99 ccw(c5553.75,2406.37) 5567.02,2406.37 ccw(c5553.75,2406.37) 5563.14,2415.76 ccw(c5572.52,2425.15) v1@5572.52,2411.87 ; C169.1@5580.67,2085 5583.54,2087.87 5629.36,2087.87 v1(5650.52,2066.71) ; C169.1@5584.78,2080.89 cw(c5601.64,2064.03) 5601.64,2087.87 ; C267.2@5592.42,4986.25 cw(c5545.53,4939.36) 5611.84,4939.36 ; v1@5593.02,2616.71 ccw(c5579.75,2616.71) 5589.14,2626.1 ccw(c5598.52,2635.49) v1@5598.52,2622.21 ; v1@5594.64,2612.82 cw(c5585.25,2603.43) 5598.52,2603.43 cw(c5611.8,2603.43) v1@5602.41,2612.82 ; v1(5596,4838) 5611.36,4853.36 5611.36,4995.54 C267.2@5606.86,5000.04 ; C267.2@5600.56,4985.95 cw(c5574.49,4959.88) 5611.36,4959.88 ; U61.3@5609.37,2238.17 cw(c5642.58,2238.17) v2@5623.36,2265.26 ; U61.3@5609.37,2240 5609.37,2260.37 v2@5620,2260.37 ; 5609.37,2261.4 cw(c5626.1,2261.4) v2@5616.42,2275.05 ; 5611.36,4939.06 cw(c5677.67,4939.06) C267.2@5630.78,4985.95 ; C266.2@5615.67,3375 5671.48,3375 ; v2@5616.32,2265.5 cw(c5594.41,2238.66) U61.4@5629.06,2238.66 ; U50.4@5619.97,1764.5 ccw(c5606.69,1751.22) 5606.69,1770 ccw(c5606.69,1788.78) U50.4@5619.97,1775.5 ; v2(5620,2270) v2@5620,2260.37 ; SW6.4@5624.41,155.56 ccw(c5598.53,131.41) 5598.53,166.81 ; SW6.4@5624.41,178.07 cw(c5598.53,202.21) 5598.53,166.81 ; U61.4@5629.06,2240 5629.06,2260.37 v2@5620,2260.37 ; U61.99@5629.06,2824.14 ccw(c5649.53,2824.14) 5635.05,2809.67 ; U61.99@5629.06,2837.34 5629.06,2815.67 5644.69,2800.03 5644.69,2760.69 v1(5644,2760) ; v1@5640.11,2763.89 ccw(c5629.06,2774.94) 5644.69,2774.94 ; SW1.3@5642.87,1073.58 5680.86,1073.58 ; 5644.69,2771.62 ccw(c5655.62,2771.62) v1@5647.89,2763.89 ; v1@5645.02,2066.71 ccw(c5631.75,2066.71) 5641.14,2076.1 ccw(c5650.52,2085.49) v1@5650.52,2072.21 ; C266.2@5645.06,3359.21 cw(c5671.48,3345.01) 5671.48,3375 ; C266.2@5645.07,3390.79 ccw(c5671.48,3404.99) 5671.48,3375 ; U53.4@5649.5,1424.5 cw(c5636.22,1411.22) 5655,1411.22 cw(c5673.78,1411.22) U53.4@5660.5,1424.5 ; U53.4@5655,1430 5655,1395 5708.29,1341.71 v1(5756.86,1341.71) ; U50.4@5655,1770 5585.86,1770 5582.86,1767 5582.86,1766.71 5481.83,1766.71 5462.5,1786.04 Y5.2@5462.5,1853.5 Y5.2@5462.5,1855.99 ; SW6.4@5660.15,155.14 cw(c5688.31,126.98) 5688.31,166.81 cw(c5688.32,206.65) SW6.4@5660.15,178.48 ; SW1.3@5662.32,1064.02 cw(c5680.86,1050.84) 5680.86,1073.58 ; SW1.3@5662.32,1083.15 ccw(c5680.86,1096.33) 5680.86,1073.58 ; 5671.86,3375.04 5673.52,3373.37 5673.52,3351.71 ; 5673.52,3350.71 5677.52,3346.71 v2@5690,3346.71 ; 5690.92,166.81 cw(c5690.92,149.77) v1@5702.97,161.82 ; v1(5695,1045) 5695,1059.44 5680.86,1073.58 ; 5695.89,1058.55 cw(c5682.33,1045) v1@5701.5,1045 ; v1(5706.86,165.71) 5707.96,166.81 5706.86,166.81 SW6.4@5642.48,166.81 5598.52,166.81 ; U61.8@5707.8,2226.81 ccw(c5717.39,2221.61) 5709.67,2213.89 ; U61.8@5707.79,2240 5707.8,2217.37 5707.13,2216.71 5706.86,2216.71 5715.19,2208.37 5819.95,2208.37 5823.52,2211.95 ; v1@5752.97,1337.82 ccw(c5743.58,1328.43) 5743.58,1341.71 ccw(c5743.58,1354.99) v1@5752.97,1345.6 ; v1@5761.45,1646.26 ccw(c5751.25,1656.46) 5765.67,1656.46 ; v1(5765.34,1642.37) 5765.67,1642.71 C158.2@5765.67,1670 ; 5765.67,1654.85 ccw(c5777.81,1654.85) v1@5769.22,1646.26 ; C187.2@5769.41,2079.19 cw(c5769.41,2065.16) 5779.33,2075.08 cw(c5789.26,2085) C187.2@5775.23,2085 ; C187.2@5769.41,2085 5783.86,2070.56 v1@5783.86,2050.04 ; C187.2@5772.84,2090.15 cw(c5759.15,2069.59) 5783.86,2069.59 ; v1@5778.13,2053.93 ccw(c5764.31,2067.75) 5783.86,2067.75 ; v1(5782.02,2050.04) v1@5783.86,2050.04 ; v1(5783.18,2995) 5783.18,2992.68 5795.86,2980 NT41.2@5805,2980 ; v1@5785.91,2053.93 ccw(c5802.18,2070.2) 5802.18,2047.19 ; 5812.21,2864.98 ccw(c5826.66,2850.53) 5806.22,2850.53 cw(c5814.39,2854.39) 5808,2860.77 ; C164.2@5820.22,1665.89 cw(c5810.3,1655.97) 5824.33,1655.97 cw(c5838.36,1655.97) C164.2@5828.44,1665.89 ; U61.14@5823.52,2221.06 cw(c5831.65,2221.06) 5825.91,2226.81 ccw(c5843.59,2236.49) 5843.59,2216.33 ; U61.14@5823.52,2258.94 ccw(c5831.65,2258.94) 5825.91,2253.19 cw(c5857.84,2253.19) 5835.26,2275.78 ; 5824.33,1648.73 ccw(c5840.54,1648.73) v1@5829.08,1637.26 ; C164.2@5824.33,1670 5824.33,1642.57 5825.19,1641.71 v1(5825.19,1633.37) 5840.19,1618.37 5840.19,1406.71 5863.52,1383.37 5863.67,1383.37 5864.6,1382.45 ; U61.14@5825.9,2240 5825.91,2214.33 ; v1@5827.97,2368.49 cw(c5818.58,2359.1) 5831.86,2359.1 cw(c5845.14,2359.1) v1@5835.75,2368.49 ; v1(5831.86,2372.37) 5831.86,2350.04 5848.52,2333.37 5848.52,2289.04 5823.52,2264.04 5823.52,2211.95 ; 5839.44,2809.29 ccw(c5824.58,2824.14) U61.88@5845.59,2824.14 ; U61.15@5845.59,2226.81 cw(c5827.91,2236.49) 5827.91,2216.33 ; U61.15@5845.59,2240 5845.59,2214.33 ; U61.88@5845.59,2837.34 5845.59,2815.44 5830.19,2800.04 5809.86,2800.04 5806.22,2803.68 5808,2805.46 5808,2860.77 ; 5861.52,2038.71 5869.84,2038.71 ; C165.1@5861.56,1359.11 ccw(c5851.64,1369.03) 5865.67,1369.03 ccw(c5879.7,1369.03) 5869.78,1359.11 cw(c5884.88,1374.21) 5863.52,1374.21 ; C159.1@5861.56,2014.11 ccw(c5851.64,2024.03) 5865.67,2024.03 ccw(c5879.7,2024.03) C159.1@5869.78,2014.11 ; C165.1@5863.52,1352.85 5863.52,1355 5863.52,1381.37 5864.6,1382.45 ; C165.1@5865.67,1355 5865.67,1381.37 ; C159.1@5865.67,2010 5865.67,2034.54 ; v1(5872.19,4797.04) 5903.02,4827.87 5903.02,4846.58 5893.5,4856.09 5893.5,4873.91 5906.09,4886.5 5926.91,4886.5 5942.99,4902.59 C277.2@5942.99,5005 ; v1@5872.19,4802.54 ccw(c5872.19,4815.82) 5881.58,4806.43 ccw(c5890.97,4797.04) v1@5877.69,4797.04 ; C277.2@5919.4,4977.47 cw(c5862.43,4920.5) 5942.99,4920.5 cw(c6023.55,4920.5) C277.2@5966.59,4977.47 ; U61.19@5924.33,2240 5924.33,2275.04 ; C277.2@5927.88,4985.95 cw(c5891.4,4949.47) 5942.99,4949.47 cw(c5994.58,4949.47) C277.2@5958.1,4985.95 ; C279.2@5943.52,3340.37 C279.2@5943.52,3374.47 ; R257.2@5948.77,2075.08 cw(c5958.69,2065.16) R257.2@5958.69,2079.19 ; R257.2@5949.96,2076.27 ccw(c5941.72,2084.51) R257.2@5953.37,2084.51 ; R128.1@5950.15,5407.61 cw(c5961.06,5412.82) R128.1@5952.51,5421.37 ; R128.1@5952.42,5414.25 ccw(c5943.34,5423.33) 5956.18,5423.33 ccw(c5969.02,5423.33) R128.1@5959.94,5414.25 ; R128.1@5956.18,5410 5956.18,5425.04 5964.51,5433.37 v1(5973.52,5442.37) 5999.86,5416.04 5999.86,5362.71 5990.19,5353.04 5973.52,5353.04 5971.52,5351.04 5971.52,5300.04 6040.19,5231.37 6040.19,5226.77 6037.4,5226.77 Q7.3@6037.4,5225.79 ; R257.2@5958.69,2085 5923.69,2050 5881.13,2050 5869.84,2038.71 ; 5964.12,5432.98 cw(c5973.53,5423.57) 5973.52,5436.87 cw(c5973.52,5423.6) 5982.91,5432.99 cw(c5992.3,5442.37) v1@5979.02,5442.37 ; 5964.14,5433 ccw(c5954.77,5442.37) v1@5968.02,5442.37 ; U61.22@5983.39,2226.81 ccw(c5996.07,2222.82) 5986.67,2213.42 ; U61.22@5983.38,2240 5983.39,2216.71 ; U61.81@5983.38,2837.34 5983.39,2784.85 5993.19,2775.04 6023.52,2775.04 6031.86,2783.37 6031.86,2808.37 6026.86,2813.37 ; 6009.56,2955 cw(c6009.56,2937.56) v2@6021.89,2949.89 ; 6012.17,5259.39 cw(c5979.55,5226.77) Q7.3@6025.69,5226.77 ; v2@6015.43,3291.41 ccw(c5989.77,3271.26) 5989.77,3303.89 ; 6019.47,2213.42 ccw(c6010.07,2222.82) U61.24@6022.75,2226.81 ; v2(6020,3295) 6011.11,3303.89 5989.77,3303.89 ; U61.24@6022.76,2240 6022.76,2216.71 ; U61.79@6022.75,2824.14 ccw(c6038.85,2824.14) 6027.47,2812.76 ; U61.79@6022.76,2837.34 6022.76,2817.37 6026.76,2813.37 6026.86,2813.37 ; v2(6026,2954) 6021,2954 v2@6020,2955 ; v2@6030.08,2958.14 ccw(c6037.52,2965.67) 6045,2958.18 ; 6034.21,2276.83 cw(c6056.86,2254.17) v1@6056.86,2286.21 ; v1@6035.52,2882.54 ccw(c6035.52,2895.82) 6044.91,2886.43 ccw(c6054.3,2877.04) v1@6041.02,2877.04 ; NT38.2@6045,2980 6045,2958.18 ; v1@6060.75,2287.82 cw(c6070.14,2278.43) 6070.14,2291.71 cw(c6070.14,2304.99) v1@6060.75,2295.6 ; U61.26@6062.12,2240 6062.13,2271.71 6057.13,2276.71 6056.86,2276.71 v1(6056.86,2291.71) ; v1(6065.19,1083.71) SW2.3@6110.25,1083.71 ; v1@6069.08,1079.82 cw(c6078.47,1070.43) 6078.47,1083.71 cw(c6078.47,1096.99) v1@6069.08,1087.6 ; 6087.36,1083.71 cw(c6087.36,1055.94) SW2.3@6110.61,1071.12 ; 6115.86,2266.04 cw(c6103.01,2253.19) U61.29@6121.18,2253.19 ; v1@6118.64,4676.82 cw(c6109.25,4667.43) 6122.52,4667.43 cw(c6135.8,4667.43) v1@6126.41,4676.82 ; v1(6122.52,4680.71) 6122.52,4641.92 6140.19,4624.25 U17.12@6170.59,4624.25 ; U61.29@6123.52,2221.15 ccw(c6115.52,2221.15) 6121.18,2226.81 ccw(c6139.9,2226.81) 6126.66,2213.57 ; U61.29@6123.52,2240 6123.52,2216.71 6131.86,2208.37 6140,2208.37 6152.22,2208.37 6160.55,2216.71 ; U61.29@6123.52,2241.71 6123.52,2258.37 6090.19,2291.71 v1(6056.86,2291.71) ; 6128.95,4635.5 ccw(c6147.61,4654.16) U17.12@6152.32,4628.19 ; U51.4@6130,1430 6255,1430 ; U52.4@6130,1770 6160.76,1739.24 6160.76,1714.24 v1(6165,1710) 6169.33,1705.67 C160.2@6169.33,1670 ; v1@6130.97,2895.6 ccw(c6121.58,2904.99) 6134.86,2904.99 ccw(c6148.14,2904.99) v1@6138.75,2895.6 ; v1(6134.86,2891.71) 6134.86,2908.04 6117.86,2925.04 6083.52,2925.04 v1(6035.52,2877.04) 6023.52,2865.04 6023.52,2837.34 6023.52,2816.71 6026.86,2813.37 ; R258.2@6148.52,2085 R258.2@6147.44,2085 6190,2085 6200,2075 6223,2075 v1(6226,2072) ; R258.2@6151.2,2081.24 cw(c6160.28,2072.16) 6160.28,2085 cw(c6160.28,2097.84) R258.2@6151.2,2088.76 ; 6157.27,2213.42 ccw(c6147.87,2222.82) U61.31@6160.55,2226.81 ; U61.31@6160.55,2240 6160.55,2216.71 ; U61.31@6160.55,2253.19 cw(c6180.37,2253.19) 6166.35,2267.2 ; 6160.76,1733.51 ccw(c6188.51,1733.51) v1@6168.89,1713.89 ; v1@6161.11,1706.11 cw(c6141.27,1686.27) 6169.33,1686.27 ; U51.4@6165.03,1424.5 cw(c6178.31,1411.22) 6178.31,1430 cw(c6178.31,1448.78) U51.4@6165.03,1435.5 ; C160.2@6165.22,1674.11 ccw(c6155.3,1684.03) 6169.33,1684.03 ccw(c6183.36,1684.03) C160.2@6173.44,1674.11 ; U13.12@6170.59,3827.99 6196.01,3827.99 v1(6219,3805) ; U13.6@6170.59,4016.97 6196.12,4016.97 v1(6215.19,4036.04) ; v1@6176.64,2896.15 cw(c6167.94,2887.46) 6180.24,2887.46 ; NT39.2@6180,3175.85 cw(c6205.48,3175.85) v1@6196.86,3199.82 ; NT39.2@6180,3180 6180,3206.37 6180,3206.56 6180.19,3206.37 6193.63,3206.37 v1(6195,3205) ; 6180,3192.91 cw(c6199.35,3192.91) v1@6192.8,3211.12 ; U61.71@6180.24,2837.34 6180.24,2891.71 6180.52,2891.71 v1(6180.52,2900.04) ; 6180.24,2886.06 cw(c6194.5,2886.06) v1@6184.41,2896.15 ; U61.33@6199.92,2240 6199.92,2266.71 6191.59,2275.04 ; 6205.48,2075 cw(c6205.48,2051.48) v1@6222.11,2068.11 ; v1@6209.69,4036.04 cw(c6196.41,4036.04) 6205.8,4026.65 cw(c6215.19,4017.26) v1@6215.19,4030.54 ; v1@6213.5,3805 ccw(c6200.22,3805) 6209.61,3814.39 ccw(c6219,3823.78) v1@6219,3810.5 ; 6253.27,2266.96 cw(c6239.51,2253.19) U61.36@6258.97,2253.19 ; U61.36@6258.97,2240 6258.98,2261.26 6245.19,2275.04 6191.59,2275.04 ; C162.2@6268.14,2010 cw(c6284.95,2010) 6273.06,2021.88 ; C161.1@6270.22,1359.11 ccw(c6254.31,1375.02) 6276.81,1375.02 ; C162.2@6270.42,2014.3 ccw(c6262.36,2023.15) 6274.33,2023.15 ccw(c6286.3,2023.15) C162.2@6278.24,2014.3 ; C162.2@6274.33,2010 6274.33,2023.15 R259.2@6336.18,2085 ; C161.1@6276.81,1357.48 6276.81,1408.19 6255,1430 ; C162.2@6280.14,2010 cw(c6325.92,2010) 6293.55,2042.37 ; v1@6285.11,1481.11 cw(c6275.72,1471.72) 6289,1471.72 cw(c6302.28,1471.72) v1@6292.89,1481.11 ; v1(6289,1485) 6289,1464 6255,1430 ; v1(6298.52,1609.37) 6313.02,1623.87 6313.02,1667.35 C163.1@6315.67,1670 ; v1@6312.64,2603.15 cw(c6303.25,2593.76) 6316.52,2593.76 cw(c6329.8,2593.76) 6320.41,2603.15 cw(c6329.55,2594.02) 6329.55,2606.94 ; 6313.02,1649.59 cw(c6336.08,1649.59) C163.1@6319.78,1665.89 ; v1@6320.41,2610.93 ccw(c6330.06,2620.57) 6330.06,2606.94 ; R259.2@6326.26,2075.08 cw(c6336.18,2065.16) R259.2@6336.18,2079.19 ; R259.2@6327.45,2076.27 ccw(c6319.21,2084.51) R259.2@6330.86,2084.51 ; U61.53@6351.52,2566.71 6316.52,2566.71 6316.52,2567.57 ; U61.44@6351.93,2390.4 6388.55,2390.4 6391.58,2387.37 v1(6433.19,2387.37) ; U61.55@6351.93,2606.94 v1@6316.52,2606.94 ; U61.63@6351.93,2764.42 6375,2764.42 ; U61.63@6364.67,2764.42 ccw(c6364.67,2796.9) v1@6387.64,2773.93 ; v1@6386.43,2772.11 cw(c6375,2776.75) 6375,2764.42 ; v1(6391.52,2770.04) 6380.62,2770.04 6375,2764.42 ; v1@6402.11,2481.89 ccw(c6386.23,2497.77) 6408.69,2497.77 ; v1@6408.69,2482 6408.69,2547.21 6389.19,2566.71 6389.19,2566.9 6388.52,2567.57 U61.53@6351.93,2567.57 6316.52,2567.57 ; v1@6429.3,2383.49 ccw(c6419.91,2374.1) 6419.91,2387.37 ccw(c6419.91,2400.65) v1@6429.3,2391.26 ; 6466.19,2240.86 cw(c6500,2207.05) C251.2@6500,2254.86 ; 6479.01,2253.67 cw(c6489.27,2243.42) C251.2@6496.93,2255.73 ; v2(6482,1928) 6491.33,1928 C238.2@6500,1919.33 ; 6486.68,2261.34 cw(c6500,2248.02) C251.2@6500,2266.86 ; C240.2@6494.19,2110.67 ccw(c6480.16,2110.67) 6490.08,2120.59 ccw(c6500,2130.51) C240.2@6500,2116.48 ; C251.2@6495.88,2256.57 ccw(c6486.01,2246.73) 6486.01,2260.67 ; C251.2@6495.88,2264.77 cw(c6486.01,2274.61) 6486.01,2260.67 ; U48.7@6497.8,3016.02 6531.97,3016.02 ; U48.6@6497.8,3041.61 6531.97,3041.61 ; C240.2@6500,2110.67 6452.67,2158 6452.67,2227.33 6486.01,2260.67 ; v2@6500.89,2650.89 cw(c6490.97,2640.97) 6505,2640.97 cw(c6519.03,2640.97) v2@6509.11,2650.89 ; v2@6500.89,2659.11 ccw(c6490.97,2669.03) 6505,2669.03 ccw(c6519.03,2669.03) v2@6509.11,2659.11 ; C202.2@6501.1,2588.27 ccw(c6486.6,2615) 6517.01,2615 ccw(c6547.41,2615) C202.2@6532.92,2588.27 ; v4@6501.63,5953.48 6501.73,5953.37 v4(6501.73,5949.34) ; C251.2@6504.11,2256.56 cw(c6514.03,2246.64) 6514.03,2260.67 cw(c6514.03,2274.7) C251.2@6504.11,2264.78 ; v2@6506.86,2653.14 v2(6505,2655) ; C189.2@6510.18,2693.4 cw(c6508.43,2685) 6517.01,2685 ; C202.2@6517.01,2555 6517.01,2615 6505,2627.01 v2(6505,2655) ; C189.2@6517.01,2730 6517.01,2685 ; 6518.77,2260.67 cw(c6518.77,2239.02) v1@6538.42,2248.1 ; U48.8@6522,2990 6531.97,2999.97 ; U48.8@6523.74,2991.06 ccw(c6503.88,3010.92) 6531.97,3010.92 ; U48.7@6523.74,3016.65 ccw(c6503.88,3036.52) 6531.97,3036.52 ; U48.6@6523.74,3040.99 cw(c6503.88,3021.12) 6531.97,3021.12 ; C189.2@6523.83,2693.4 ccw(c6525.59,2685) 6517.01,2685 ; U48.7@6523.81,3015.33 cw(c6510.03,2998.26) 6531.97,2998.26 ; U48.8@6524.27,2991.32 ccw(c6523.26,2999.97) 6531.97,2999.97 ; U48.6@6524.38,3042.5 ccw(c6524.55,3062.55) 6538.73,3048.37 ; v1@6527.53,2243.07 ccw(c6500,2230.34) C251.2@6500,2260.67 ; v1(6532.52,2245.37) 6532.52,2257.48 6529.33,2260.67 C251.2@6500,2260.67 ; v1@6542.3,5454.49 cw(c6532.93,5445.12) 6546.18,5445.12 ; R130.1@6542.42,5414.25 ccw(c6533.34,5423.33) 6546.18,5423.33 ccw(c6559.02,5423.33) R130.1@6549.94,5414.25 ; R130.1@6546.18,5410 v1(6546.19,5458.37) ; 6546.18,5445.07 cw(c6559.49,5445.07) v1@6550.08,5454.49 ; v1(6554.52,4650.04) 6560.23,4655.75 U17.34@6619.41,4655.75 ; v1@6558.41,4646.15 cw(c6581.58,4622.98) 6581.58,4655.75 ; SW3.3@6586.21,1085.25 ccw(c6558.04,1113.42) 6597.87,1113.42 ccw(c6637.71,1113.42) SW3.3@6609.54,1085.25 ; SW3.3@6597.87,1073.58 6597.87,1146.87 v1(6627.78,1176.78) ; v1@6609.69,3026.37 ccw(c6596.41,3026.37) 6605.8,3035.76 ccw(c6615.19,3045.15) v1@6615.19,3031.87 ; v1(6615.19,3026.37) 6593.19,3048.37 6538.73,3048.37 ; Q8.3@6615.43,5241.18 ccw(c6605.16,5255.04) 6622.4,5255.04 ; U13.28@6619.41,3355.55 6670.7,3355.55 6683.52,3368.37 v1(6683.52,3375.71) ; U13.41@6619.41,3765 6645,3765 v1(6670,3790) ; U13.46@6619.41,3922.48 6663.52,3922.48 6665.19,3924.15 v1(6665.19,3941.71) ; U13.52@6619.41,4111.46 6655.86,4111.46 6667.52,4123.12 v1(6667.52,4158.37) 6650.86,4175.04 6623.52,4175.04 6623.52,4174.45 U13.54@6619.41,4174.45 ; Q8.3@6622.12,5231.76 cw(c6673.62,5233.27) 6637.19,5269.7 ; v1@6622.28,1176.78 cw(c6609,1176.78) 6618.39,1167.39 cw(c6627.78,1158) v1@6627.78,1171.28 ; Q8.3@6622.4,5230.79 6622.4,5255.04 ; Q8.3@6629.38,5241.18 cw(c6639.65,5255.04) 6622.4,5255.04 ; 6633.25,5265.77 ccw(c6594.02,5305) v1@6649.5,5305 ; U13.41@6636.97,3769 ccw(c6636.97,3798.05) 6657.51,3777.51 ; U13.54@6636.97,4182.45 cw(c6636.97,4166.8) 6648.03,4177.87 ; U13.54@6639.8,4171.62 cw(c6648.05,4163.36) 6648.05,4175.04 ; 6653.73,5286.25 ccw(c6634.99,5305) v1@6661.5,5305 ; v1(6655,5305) 6656.86,5303.14 6656.86,5289.37 6622.52,5255.04 6622.4,5255.04 ; C232.2@6655.67,1355 6655.67,1324.33 v2(6674,1306) ; C215.2@6655.67,2375.04 6698.19,2375.04 v1(6702.52,2370.71) ; C215.2@6659.78,2370.89 cw(c6669.8,2360.87) 6669.8,2375.04 ; C215.2@6659.78,2379.11 ccw(c6669.6,2388.93) 6669.6,2375.04 ; v1@6661.3,3937.82 cw(c6651.91,3928.43) 6665.19,3928.43 cw(c6678.47,3928.43) v1@6669.08,3937.82 ; v1@6662.02,4158.37 ccw(c6648.75,4158.37) 6658.13,4167.76 ccw(c6667.52,4177.15) v1@6667.52,4163.87 ; v1@6663.64,4154.49 cw(c6654.25,4145.1) 6667.52,4145.1 cw(c6680.8,4145.1) v1@6671.41,4154.49 ; v1@6664.5,3790 cw(c6651.22,3790) 6660.61,3780.61 cw(c6670,3771.22) v1@6670,3784.5 ; v2@6668.19,1306 ccw(c6654.16,1306) 6664.08,1315.92 ccw(c6674,1325.84) v2@6674,1311.81 ; 6674.37,3359.22 ccw(c6663.6,3369.99) v1@6678.24,3374.19 ; v1@6674.4,4737.4 ccw(c6690.66,4753.66) 6690.66,4730.67 ; 6678.79,2375.04 cw(c6678.79,2346.97) v1@6698.64,2366.82 ; v1(6679,4742) 6690.33,4730.67 C80.2@6735,4730.67 6768.52,4697.14 6768.52,4616.37 v1(6767.19,4615.04) ; v1@6682.89,4745.89 ccw(c6719.63,4782.63) 6719.63,4730.67 ; v1@6693.11,4617.11 cw(c6680.04,4604.04) 6698.52,4604.04 ; v1(6697,4621) 6698.52,4619.48 6698.52,4595.04 6703.6,4589.96 C83.2@6735,4589.96 ; v1(6723.19,3552.71) 6723.19,3545.18 6740,3528.37 C68.2@6740,3495.51 ; v1@6728.68,3552.33 ccw(c6754.64,3550.54) 6736.24,3532.14 ; C84.2@6730.89,4403.81 cw(c6720.97,4393.89) 6735,4393.89 cw(c6749.03,4393.89) C84.2@6739.11,4403.81 ; C83.2@6730.89,4585.85 ccw(c6720.97,4575.94) 6720.97,4589.96 ccw(c6720.97,4603.99) C83.2@6730.89,4594.07 ; C80.2@6730.89,4726.56 ccw(c6720.97,4716.64) 6720.97,4730.67 ccw(c6720.97,4744.7) C80.2@6730.89,4734.78 ; C84.2@6735,4407.92 6735,4391.71 6743.33,4383.37 6748.52,4378.18 v1(6748.52,4335.04) ; C80.2@6735,4724.86 cw(c6735,4710.83) 6744.92,4720.75 cw(c6754.84,4730.67) C80.2@6740.81,4730.67 ; C79.2@6735,4830.04 6735,4822.56 v1(6768.19,4789.37) ; C68.2@6735.89,3499.62 ccw(c6725.97,3509.54) 6740,3509.54 ccw(c6754.03,3509.54) C68.2@6744.11,3499.62 ; C67.2@6740,3678.11 6764.26,3678.11 6777.52,3691.37 6777.52,3816 6789.52,3827.99 6791.24,3827.99 ; C66.2@6740,3860.16 6774.31,3860.16 6777.52,3856.94 6777.52,3841.71 6791.24,3827.99 ; C65.2@6740,4028.67 cw(c6740,4014.65) 6749.92,4024.57 cw(c6759.84,4034.48) C65.2@6745.81,4034.48 ; C65.2@6740,4034.48 6759.11,4015.37 6759.19,4015.37 v1(6766.19,4008.37) 6774.78,4016.97 U12.6@6845.59,4016.97 ; C79.2@6740.81,4830.04 ccw(c6772.88,4830.04) 6750.2,4807.36 ; C67.2@6744.11,3674 cw(c6754.03,3664.08) 6754.03,3678.11 cw(c6754.03,3692.14) C67.2@6744.11,3682.22 ; C66.2@6744.11,3856.05 cw(c6754.03,3846.13) 6754.03,3860.16 cw(c6754.03,3874.19) C66.2@6744.11,3864.27 ; v1@6744.64,4338.93 ccw(c6735.25,4348.32) 6748.52,4348.32 ccw(c6761.8,4348.32) v1@6752.41,4338.93 ; 6756.66,4017.82 ccw(c6766.19,4027.35) v1@6766.19,4013.87 ; 6756.86,4017.63 cw(c6747.61,4008.37) v1@6760.69,4008.37 ; v1@6762.69,4789.37 ccw(c6749.41,4789.37) 6758.8,4798.76 ccw(c6768.19,4808.15) v1@6768.19,4794.87 ; v1@6763.3,4618.93 ccw(c6750.69,4631.54) 6768.52,4631.54 ; v1@6770.08,4004.49 cw(c6800.21,3974.35) 6800.21,4016.97 ; v1@6788.3,2965.93 ccw(c6778.91,2975.32) 6792.19,2975.32 ccw(c6805.47,2975.32) v1@6796.08,2965.93 ; SW8.1@6790,110.71 6890,110.71 6990,110.71 7090,110.71 7190,110.71 SW8.6@7290,110.71 ; v1(6792.19,2962.04) 6792.19,2980.71 6791.46,2981.44 6791.46,3016.46 U34.7@6820,3016.46 ; SW8.1@6793,98.5 cw(c6822.49,69.01) 6822.49,110.71 ; SW8.1@6801.49,90.01 cw(c6851.46,40.04) 6851.46,110.71 ; C242.2@6805.67,2375 6845,2375 C196.2@6914.33,2375 ; C242.2@6809.65,2375 cw(c6809.65,2344.65) v1@6831.11,2366.11 ; 6828.54,110.71 cw(c6828.54,40.04) SW8.2@6878.51,90.01 ; v1@6838.89,2366.11 cw(c6860.35,2344.65) 6860.35,2375 ; U16.12@6845.59,4624.25 6878.52,4624.25 6880.86,4626.58 6880.86,4633.37 6890.19,4642.71 v1(6890.19,4658.37) ; 6857.51,110.71 cw(c6857.51,69.01) SW8.2@6887,98.5 ; 6873.34,3827.99 ccw(c6873.34,3869.89) v1@6902.97,3840.26 ; SW8.2@6893,98.5 cw(c6922.49,69.01) 6922.49,110.71 ; SW8.2@6901.49,90.01 cw(c6951.46,40.04) 6951.46,110.71 ; v1(6906.86,3836.37) 6898.47,3827.99 U12.12@6845.59,3827.99 6791.24,3827.99 ; C196.2@6910.22,2370.89 ccw(c6900.3,2360.97) 6900.3,2375 ccw(c6900.3,2389.03) C196.2@6910.22,2379.11 ; 6928.54,110.71 cw(c6928.54,40.04) SW8.3@6978.51,90.01 ; C123.1@6945.67,2965 6988.86,2965 7003.52,2950.33 7003.52,2950.04 ; C123.1@6949.78,2960.89 cw(c6959.7,2950.97) 6959.7,2965 ; C123.1@6949.78,2969.11 ccw(c6959.7,2979.03) 6959.7,2965 ; 6957.51,110.71 cw(c6957.51,69.01) SW8.3@6987,98.5 ; SW8.3@6993,98.5 cw(c7022.49,69.01) 7022.49,110.71 ; 6995.47,2958.39 cw(c6976.08,2939) v1@7003.5,2939 ; SW8.3@7001.49,90.01 cw(c7051.46,40.04) 7051.46,110.71 ; 7028.54,110.71 cw(c7028.54,40.04) SW8.4@7078.51,90.01 ; 7057.51,110.71 cw(c7057.51,69.01) SW8.4@7087,98.5 ; SW4.3@7075.37,1073.19 7116.04,1073.19 ; 7077.13,1250.87 cw(c7055.26,1229) v2@7086.19,1229 ; SW8.4@7078.51,112.98 ccw(c7050.78,140.71) 7090,140.71 ccw(c7129.22,140.71) SW8.4@7101.49,112.98 ; SW8.4@7084.65,116.83 ccw(c7082.01,124.37) 7090,124.37 ; 7090,310.05 cw(c7126.26,310.05) v1@7100.62,335.69 ; v2@7092,1223.19 cw(c7092,1205.38) 7104.59,1217.97 ; SW8.4@7093,98.5 cw(c7122.49,69.01) 7122.49,110.71 ; v1@7093.52,343.37 7090,339.85 7090,124.37 ; SW4.3@7094.18,1062.78 cw(c7116.04,1045.02) 7116.04,1073.19 ; SW4.3@7094.18,1083.59 ccw(c7116.04,1101.36) 7116.04,1073.19 ; SW8.4@7095.35,116.83 cw(c7097.99,124.37) 7090,124.37 ; SW8.4@7101.49,90.01 cw(c7151.46,40.04) 7151.46,110.71 ; Q11.3@7102.22,2645.02 cw(c7113.21,2631.9) 7125.31,2644 ; Q11.3@7102.3,2645.07 cw(c7111.77,2621.11) 7129.99,2639.32 ; Q11.3@7102.4,2645.79 7123.52,2645.79 ; C199.2@7105.67,1355 7114.81,1345.86 7114.81,1315.97 7102.03,1303.19 7100.34,1303.19 7079.19,1282.03 7079.19,1248.81 7091.19,1236.81 7091.19,1231.37 7124.52,1198.04 7124.52,1081.67 7116.04,1073.19 ; Q11.3@7109.92,2635.82 cw(c7121.66,2621.81) 7134.58,2634.73 ; Q11.3@7112.34,2639.58 cw(c7123.52,2632.61) 7123.52,2645.79 ; Q11.3@7112.34,2651.99 ccw(c7123.52,2658.97) 7123.52,2645.79 ; v1@7117.22,2356.21 ccw(c7110.81,2375) C197.2@7130.67,2375 ; v1(7119,2351) 7130.67,2362.67 C197.2@7130.67,2375 ; v1@7121.1,2344.85 ccw(c7116.53,2358.23) 7130.67,2358.23 ; 7128.54,110.71 cw(c7128.54,40.04) SW8.5@7178.51,90.01 ; U35.7@7130,3016.46 7163.52,3016.46 7163.52,2976.71 v1(7198.52,2941.71) 7206.86,2950.04 7206.86,2950.33 7216.52,2960 ; U35.7@7156.48,3016.46 cw(c7139.48,2999.45) 7163.52,2999.45 ; 7157.51,110.71 cw(c7157.51,69.01) SW8.5@7187,98.5 ; v1@7191.11,2603.89 ccw(c7181.72,2613.28) 7195,2613.28 ccw(c7208.28,2613.28) v1@7198.89,2603.89 ; SW8.5@7193,98.5 cw(c7222.49,69.01) 7222.49,110.71 ; v1@7193.02,2941.71 ccw(c7179.75,2941.71) 7189.14,2951.1 ccw(c7198.52,2960.49) 7198.52,2947.21 ccw(c7198.52,2959.78) 7207.41,2950.89 ; v1(7195,2600) 7195,2625.81 ; SW8.5@7201.49,90.01 cw(c7251.46,40.04) 7251.46,110.71 ; v1@7204.02,2941.71 cw(c7218.01,2941.71) 7208.12,2951.6 ; C223.2@7214.33,1349.19 cw(c7214.33,1335.16) 7224.25,1345.08 cw(c7234.17,1355) C223.2@7220.14,1355 ; C223.2@7214.33,1355 7236.14,1333.19 7241.66,1333.19 7258.19,1316.66 7258.19,1302.97 7270.97,1290.19 7278.71,1290.19 7293.19,1275.71 v2(7293.19,1274.81) ; C125.1@7224.96,2956.17 ccw(c7216.52,2948.79) 7216.52,2960 ; C125.1@7224.96,2963.83 cw(c7216.52,2971.2) 7216.52,2960 ; 7228.54,110.71 cw(c7228.54,40.04) SW8.6@7278.51,90.01 ; C125.1@7229.33,2960 7216.52,2960 ; 7250.26,4096.44 cw(c7276.85,4069.85) U12.52@7276.85,4107.46 ; C219.2@7255.67,2375 7275.19,2375 7290.19,2390 ; 7257.51,110.71 cw(c7257.51,69.01) SW8.6@7287,98.5 ; 7259.4,4105.58 cw(c7268.77,4096.22) U12.52@7274.98,4107.92 ; C219.2@7259.78,2370.89 cw(c7269.7,2360.97) 7269.7,2375 cw(c7269.7,2389.03) C219.2@7259.78,2379.11 ; 7265.76,4175.04 cw(c7265.76,4163.36) U12.54@7274.02,4171.62 ; SW8.6@7278.51,112.98 ccw(c7250.78,140.71) 7290,140.71 ccw(c7329.22,140.71) SW8.6@7301.49,112.98 ; SW8.6@7290,75.71 SW8.6@7290,110.71 ; 7290.19,2389.04 7290.19,2390 ; SW8.6@7293,98.5 cw(c7322.49,69.01) 7322.49,110.71 ; U12.28@7294.41,3355.55 7345.7,3355.55 7373.52,3383.37 v1(7390.19,3383.37) 7440.19,3433.37 7440.19,3489.04 7433.72,3495.51 C70.2@7385,3495.51 ; U12.41@7294.41,3765 7311.96,3765 v1@7401.9,3765 ; U12.46@7294.41,3922.48 7367.22,3922.48 7385,3904.7 C64.2@7385,3860.16 ; U12.52@7294.41,4111.46 7265.19,4111.46 7265.19,4111.37 7253.86,4100.04 7232.86,4100.04 7224.52,4108.37 7224.52,4139.04 7260.52,4175.04 7294.41,4175.04 7298.52,4175.04 U12.54@7298.52,4174.45 ; U12.54@7294.41,4174.45 U12.54@7298.52,4174.45 ; U16.34@7294.41,4655.75 7334.15,4655.75 v1(7346.52,4643.37) ; SW8.6@7301.49,90.01 cw(c7351.46,40.04) 7351.46,110.71 ; U16.34@7303.37,4655.75 cw(c7303.37,4600.23) v1@7342.64,4639.49 ; v1@7321.11,241.11 cw(c7311.72,231.72) 7325,231.72 cw(c7338.28,231.72) v1@7328.89,241.11 ; v1(7325,245) 7325,200 7290,165 SW8.6@7290,110.71 ; 7328.54,110.71 cw(c7328.54,40.04) SW8.7@7378.51,90.01 ; 7332.35,4655.75 cw(c7332.35,4629.2) v1@7351.12,4647.97 ; 7352.35,3362.2 cw(c7390.19,3324.36) v1@7390.19,3377.87 ; 7357.51,110.71 cw(c7357.51,69.01) SW8.7@7387,98.5 ; 7365.19,3375.04 cw(c7378.78,3361.46) v1@7387.65,3378.5 ; 7372.84,3382.69 cw(c7390.19,3365.33) v1@7390.19,3389.87 ; 7376.76,3386.61 cw(c7386.7,3376.67) v1@7393.19,3389.14 ; C63.2@7380.89,3723.56 ccw(c7370.97,3733.48) 7385,3733.48 ccw(c7399.03,3733.48) C63.2@7389.11,3723.56 ; C64.2@7380.89,3864.27 ccw(c7370.97,3874.19) 7385,3874.19 ccw(c7399.03,3874.19) C64.2@7389.11,3864.27 ; C69.2@7380.89,4079.93 ccw(c7370.97,4089.85) 7385,4089.85 ccw(c7399.03,4089.85) C69.2@7389.11,4079.93 ; C81.2@7380.89,4403.81 cw(c7370.97,4393.89) 7385,4393.89 cw(c7399.03,4393.89) C81.2@7389.11,4403.81 ; C85.2@7380.89,4734.78 ccw(c7370.97,4744.7) 7385,4744.7 ccw(c7399.03,4744.7) C85.2@7389.11,4734.78 ; C86.2@7381.33,4594.47 ccw(c7375.06,4602.18) 7385,4602.18 ; C63.2@7385,3719.45 7385,3745.04 ; C69.2@7385,4075.82 7385,4121.52 7413.52,4150.04 v1(7440.19,4150.04) v1(7440.19,4150.04) 7415.86,4174.45 U12.54@7298.52,4174.45 ; C81.2@7385,4407.92 7385,4385.04 7386.67,4383.37 7398.52,4383.37 7418.19,4363.71 v1(7418.19,4359.04) ; C86.2@7385,4589.96 7385,4602.18 ; C85.2@7385,4724.86 cw(c7385,4710.83) 7394.92,4720.75 cw(c7404.84,4730.67) C85.2@7390.81,4730.67 ; C85.2@7385,4733.14 cw(c7438.76,4733.14) v1@7400.75,4771.15 ; 7385,4762.11 cw(c7409.79,4762.11) v1@7392.26,4779.64 ; C82.2@7385,4871.38 7419.86,4871.38 7423.52,4871.37 ; 7385.19,3745.04 v1(7403.52,3763.37) ; v1@7386.3,3379.49 ccw(c7376.91,3370.1) 7376.91,3383.37 ccw(c7376.91,3396.65) v1@7386.3,3387.26 ; 7386.32,3765 cw(c7386.32,3746.17) v1@7399.64,3759.49 ; C86.2@7388.67,4594.47 cw(c7394.95,4602.18) 7385,4602.18 ; C70.2@7389.11,3491.41 cw(c7399.03,3481.49) 7399.03,3495.51 cw(c7399.03,3509.54) C70.2@7389.11,3499.62 ; C82.2@7389.11,4867.27 cw(c7399.03,4857.35) 7399.03,4871.38 cw(c7399.03,4885.41) C82.2@7389.11,4875.49 ; C184.2@7389.99,2695.33 cw(c7381.69,2675.71) 7402.99,2675.71 ; v1@7390.19,3388.87 ccw(c7390.19,3402.15) 7399.58,3392.76 ccw(c7408.97,3383.37) v1@7395.69,3383.37 ; C201.2@7390.51,2589.89 ccw(c7383.06,2608.37) 7402.99,2608.37 ; C64.2@7390.79,3865.95 7406.7,3850.04 v1(7431.86,3850.04) ; C86.2@7390.81,4589.96 cw(c7434.34,4589.96) 7403.56,4620.75 ; SW8.7@7393,98.5 cw(c7422.49,69.01) 7422.49,110.71 ; 7395.74,2419.49 cw(c7384.25,2408) v1@7400.5,2408 ; C201.2@7395.98,2563.9 cw(c7414.91,2529.25) 7442.83,2557.17 ; v1(7396.86,4775.04) 7388.52,4775.04 7385,4771.52 C85.2@7385,4730.67 7406.86,4708.81 7406.86,4703.04 v1(7433.86,4676.04) 7433.86,4651.04 7385,4602.18 ; v1@7398.02,3763.37 cw(c7384.75,3763.37) 7394.14,3753.99 cw(c7403.52,3744.6) v1@7403.52,3757.87 ; SW8.7@7401.49,90.01 cw(c7451.46,40.04) 7451.46,110.71 ; C216.2@7401.56,1350.89 cw(c7391.3,1340.63) 7405.81,1340.63 ; C233.2@7401.56,2379.11 ccw(c7391.64,2389.03) 7405.67,2389.03 ccw(c7419.7,2389.03) C233.2@7409.78,2379.11 ; C201.2@7401.73,2553.37 cw(c7422.92,2514.59) 7454.16,2545.84 ; v1@7402.11,2404.11 cw(c7393.52,2395.52) 7405.67,2395.52 ; C184.2@7402.99,2730 7402.99,2675.71 ; 7405.5,4376.4 cw(c7388.15,4359.04) v1@7412.69,4359.04 ; C216.2@7405.67,1355 7405.81,1354.86 7405.81,1334.42 v1(7431.86,1308.37) ; C233.2@7405.67,2375 v1@7405.67,2399.71 ; 7405.67,2393.92 cw(c7420.08,2393.92) v1@7409.89,2404.11 ; 7405.81,1341.31 cw(c7419.36,1341.31) C216.2@7409.78,1350.89 ; C201.2@7407.48,2542.84 cw(c7430.92,2499.93) 7465.5,2534.5 ; v1@7407.86,2407.37 7406.62,2408.62 7373.52,2441.71 7331.86,2441.71 ; v1@7413.3,4923.82 cw(c7388.62,4899.14) 7423.52,4899.14 ; C201.2@7415.47,2589.89 cw(c7422.93,2608.37) 7402.99,2608.37 ; C184.2@7416,2695.33 ccw(c7424.3,2675.71) 7402.99,2675.71 ; v1(7417.19,4927.71) 7423.52,4921.37 7423.52,4871.37 ; v1@7426.36,1308.37 ccw(c7413.08,1308.37) 7422.47,1317.76 ccw(c7431.86,1327.15) v1@7431.86,1313.87 ; v1@7427.97,3846.15 ccw(c7418.58,3836.76) 7418.58,3850.04 ccw(c7418.58,3863.32) v1@7427.97,3853.93 ; v1@7428.36,4676.04 ccw(c7415.08,4676.04) 7424.47,4685.43 ccw(c7433.86,4694.82) v1@7433.86,4681.54 ; 7428.54,110.71 cw(c7428.54,40.04) SW8.8@7478.51,90.01 ; v1@7429.97,4672.15 cw(c7420.58,4662.76) 7433.86,4662.76 cw(c7447.14,4662.76) v1@7437.75,4672.15 ; 7430.75,4159.56 cw(c7421.23,4150.04) v1@7434.69,4150.04 ; 7430.93,4159.38 ccw(c7440.19,4168.64) v1@7440.19,4155.54 ; C201.2@7435.5,2547.45 cw(c7445,2545.25) 7445,2555 ; C201.2@7435.5,2562.55 ccw(c7445,2564.75) 7445,2555 ; v1@7436.3,4146.15 ccw(c7426.91,4136.76) 7426.91,4150.04 ccw(c7426.91,4163.32) v1@7436.3,4153.93 ; 7454.4,4859.83 cw(c7431.17,4836.6) v1@7464.02,4836.6 ; 7457.51,110.71 cw(c7457.51,69.01) SW8.8@7487,98.5 ; v1@7461.3,2468.6 ccw(c7451.91,2477.99) 7465.19,2477.99 ccw(c7478.47,2477.99) v1@7469.08,2468.6 ; v1(7465.19,2464.71) 7465.19,2534.81 7445,2555 ; v1@7465.19,3024.33 7475.19,3014.33 C156.2@7490,3014.33 ; v1@7465.19,3024.37 v1(7457.52,3024.37) 7457.52,2976.71 v1(7459.19,2975.04) 7463.52,2975.04 7465.19,2973.37 7465.19,2969 7473.52,2960.67 C155.2@7490,2960.67 ; v1(7469.52,4836.6) 7469.52,4844.71 7442.86,4871.37 7423.52,4871.37 ; C155.2@7485.89,2956.56 ccw(c7475.97,2946.64) 7475.97,2960.67 ccw(c7475.97,2974.7) C155.2@7485.89,2964.78 ; C156.2@7485.89,3010.22 ccw(c7475.97,3000.3) 7475.97,3014.33 ccw(c7475.97,3028.36) C156.2@7485.89,3018.44 ; SW8.8@7490,110.71 7390,110.71 SW8.6@7290,110.71 ; v1@7500.89,2026.89 7500.89,2027.66 v1(7504.54,2031.31) ; v1(7501.86,3733.37) v1@7505.19,3730.04 ; v1@7502,2026 7503,2027 v1@7503.63,2026.37 ; v2@7503.19,1681.09 ccw(c7494.97,1696) 7512,1696 ; v1@7503.67,2026.37 7520,2042.71 C193.2@7520,2069.33 ; v1@7505.19,3729.96 7515.19,3719.96 R157.1@7530,3719.96 ; v2(7506,1676) 7512,1682 7512,1696 ; 7508.31,1727.08 cw(c7562.25,1727.08) C195.2@7524.11,1765.22 ; 7508.31,1756.05 cw(c7533.28,1756.05) C195.2@7515.62,1773.71 ; C217.2@7515.89,1465.22 cw(c7505.97,1455.3) 7520,1455.3 cw(c7534.03,1455.3) C217.2@7524.11,1465.22 ; C194.2@7515.89,1964.78 ccw(c7505.97,1974.7) 7520,1974.7 ccw(c7534.03,1974.7) C194.2@7524.11,1964.78 ; C193.2@7515.89,2065.22 cw(c7505.97,2055.3) 7520,2055.3 cw(c7534.03,2055.3) C193.2@7524.11,2065.22 ; C252.2@7515.89,2264.78 ccw(c7505.97,2274.7) 7520,2274.7 ccw(c7534.03,2274.7) C252.2@7524.11,2264.78 ; v2@7515.89,2300.89 cw(c7505.97,2290.97) 7520,2290.97 cw(c7534.03,2290.97) v2@7524.11,2300.89 ; 7520,1397.16 ccw(c7545.31,1397.16) v1@7527.41,1379.26 ; C217.2@7520,1469.33 7520,1378.9 v1(7523.52,1375.37) ; C220.2@7520,1660.67 7520,1688 7512,1696 ; C195.2@7520,1769.33 7508.31,1757.64 7508.31,1722.36 7506.29,1720.33 7506.29,1701.71 7512,1696 ; C194.2@7520,1960.67 7520,1978.71 v2@7547.65,2006.35 ; C252.2@7520,2260.67 v2(7520,2305) ; C58.2@7525.08,4615.75 ccw(c7515.16,4625.67) C58.2@7529.19,4625.67 ; C58.2@7525.08,4615.75 cw(c7535,4605.83) C58.2@7535,4619.86 ; R157.1@7525.75,3716.2 ccw(c7516.67,3707.12) 7516.67,3719.96 ccw(c7516.67,3732.8) R157.1@7525.75,3723.72 ; R155.1@7530,4076.18 7578.72,4076.18 7579.86,4075.04 v1(7598.52,4075.04) 7598.52,4233.37 7556.86,4275.04 7556.86,4325 7551.19,4330.67 C60.2@7535,4330.67 7535,4371.18 v1(7585.19,4421.37) ; C60.2@7530.89,4334.78 ccw(c7520.97,4344.7) 7535,4344.7 ccw(c7549.03,4344.7) 7539.11,4334.78 ccw(c7549.03,4344.7) 7549.03,4330.67 ccw(c7549.03,4316.64) C60.2@7539.11,4326.56 ; C59.2@7530.89,4489.78 ccw(c7520.97,4499.7) 7535,4499.7 ccw(c7549.03,4499.7) C59.2@7539.11,4489.78 ; C60.2@7532,4336.08 cw(c7538.52,4324.33) 7548.03,4333.83 ; 7532.34,1991.04 ccw(c7513.38,2010) v2@7540.19,2010 ; C60.2@7533.57,4336.69 cw(c7537.55,4319.91) 7549.75,4332.1 ; R155.1@7534.25,4072.42 cw(c7543.33,4063.34) 7543.33,4076.18 cw(c7543.33,4089.02) R155.1@7534.25,4079.94 ; C59.2@7535,4485.67 7535,4503.04 7529.67,4508.37 7507.19,4508.37 7506.19,4509.37 7506.19,4597.04 7521.19,4612.04 7521.56,4612.04 7521.56,4612.23 C58.2@7535,4625.67 7572.9,4625.67 7578.23,4631 ; 7536.04,4502 cw(c7522.72,4488.69) C59.2@7541.01,4484.19 ; C60.2@7537.82,4325.59 cw(c7546.55,4309.85) 7559.28,4322.58 ; C58.2@7539.11,4621.56 cw(c7549.03,4611.64) 7549.03,4625.67 cw(c7549.03,4639.7) C58.2@7539.11,4629.78