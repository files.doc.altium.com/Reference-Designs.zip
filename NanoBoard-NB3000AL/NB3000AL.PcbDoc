# Altium PCB NB3000AL.PcbDoc (part 25 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
CODEC.I2S_WCLK: R18.1 U8.AF14 | length 7580.9
  Top Layer w4: v1@5358.47,3406.76 ccw(c5342.26,3422.98) 5365.19,3422.98 ccw(c5388.13,3422.98) v1@5371.91,3406.76 ; v1@5360.9,3404.33 v1(5365.19,3400.04) 5365.19,3455.36 5346,3474.55 5346,3494.35 5346.4,3494.75 5346.4,3497.85 5346,3498.25 5346,3512.75 5355,3521.75 5355,3597.19 5346.45,3605.74 5346.45,3630.55 5346.45,3638.82 5346.45,3697.36 cw(c5385.13,3697.36) 5357.78,3724.71 ; v1@5361.3,3403.93 ccw(c5351.91,3413.32) 5365.19,3413.32 ccw(c5378.47,3413.32) v1@5369.08,3403.93 ; U8.AF14@5362.97,3737.24 cw(c5345.25,3737.24) 5357.78,3724.71 ; U8.AF14@5370.32,3729.9 ccw(c5370.32,3712.18) 5357.78,3724.71
  MidLayer1 w4: v1@5323.28,3288.28 cw(c5296.48,3261.48) 5334.38,3261.48 ; v1@5326.11,3291.11 cw(c5306.14,3271.14) 5334.38,3271.14 ; v1@5328.94,3293.94 cw(c5315.8,3280.8) 5334.38,3280.8 ; 5334.38,3282.64 cw(c5342.35,3282.64) v1@5336.72,3288.28 ; v1@5334.38,3297.42 5334.38,3260.18 5385.62,3208.95 5385.62,3166.93 5350.02,3131.33 5350.02,2992.66 5347.36,2990 5347.36,2957.54 v2@5360,2944.9 ; v2(5360,2945) v2@5360,2944.9 ; v2@5365.2,2939.7 v2@5360,2944.9
  MidLayer2 w4: v1@-374.86,2948.43 ccw(c-391.08,2964.64) -368.14,2964.64 ccw(c-345.21,2964.64) v1@-361.43,2948.43 ; v1@-372.03,2945.6 ccw(c-381.42,2954.99) -368.14,2954.99 ccw(c-354.86,2954.99) v1@-364.25,2945.6 ; v1(-368.14,2941.71) -368.14,3036.9 -363,3042.04 180.33,3042.04 415.37,2807 563.31,2807 626.31,2870 2110.9,2870 2140.05,2840.85 2172.66,2840.85 2215.19,2883.37 2290.19,2883.37 2308.56,2865 2453.29,2865 2488.33,2900.04 4673.52,2900.04 4690.19,2916.71 4698.48,2925 4988.37,2925 5018.37,2895 v2(5085,2895) ; v2@5078.06,2888.06 ccw(c5061.31,2871.31) 5061.31,2895 ccw(c5061.31,2918.69) v2@5078.06,2901.94 ; v2@5080.89,2890.89 ccw(c5070.97,2880.97) 5070.97,2895 ccw(c5070.97,2909.03) v2@5080.89,2899.11
  Bottom Layer w4: v1(-368.14,2941.71) -341.18,2941.71 -341.18,2944.51 R18.1@-341.18,2945 ; v1@-364.25,2937.82 cw(c-354.86,2928.43) -354.86,2941.71 cw(c-354.86,2954.99) v1@-364.25,2945.6 ; v1@-361.43,2934.99 cw(c-345.21,2918.77) -345.21,2941.71 cw(c-345.21,2964.64) v1@-361.43,2948.43 ; v2(5085,2895) 5130,2940 5132.37,2942.37 5192.37,2942.37 5200,2942.37 5209.56,2942.37 5218,2950.81 5250.69,2950.81 5267.79,2933.71 5308.31,2933.71 5319.61,2945 v2(5360,2945) 5360,2934.85 v2@5365.15,2940 ; v2@5085,2900.81 ccw(c5085,2914.84) 5094.92,2904.92 ccw(c5104.84,2895) v2@5090.81,2895 ; v2@5085,2904.81 ccw(c5085,2928.5) 5101.75,2911.75 ccw(c5118.5,2895) v2@5094.81,2895 ; v1(5330,3295) 5333.1,3298.1 5368.35,3298.1 5378.6,3308.35 5378.6,3355.04 5365.19,3368.45 v1(5365.19,3400.04) ; v1@5331.06,3293.94 cw(c5341.11,3283.89) 5341.11,3298.1 ; v1@5333.89,3291.11 cw(c5350.76,3274.24) 5350.76,3298.1 ; v1@5336.72,3288.28 cw(c5360.42,3264.58) 5360.42,3298.1 ; v1@5336.72,3301.72 ccw(c5345.45,3310.45) 5345.45,3298.1 ; v2@5353.06,2938.06 ccw(c5336.31,2921.31) 5336.31,2945 ccw(c5336.31,2968.69) v2@5353.06,2951.94 ; v2@5355.89,2940.89 ccw(c5345.97,2930.97) 5345.97,2945 ccw(c5345.97,2959.03) v2@5355.89,2949.11 ; v1@5358.47,3393.32 cw(c5342.26,3377.11) 5365.19,3377.11 cw(c5388.13,3377.11) v1@5371.91,3393.32 ; v1@5361.3,3396.15 cw(c5351.91,3386.76) 5365.19,3386.76 cw(c5378.47,3386.76) v1@5369.08,3396.15
CODEC.SPI_CLK: U1.10 U8.D15 | length 10156.8
  Top Layer w4: v1(-450,2605) -395,2605 -391.77,2608.23 U1.10@-320,2608.23 ; v1@-446.11,2601.11 cw(c-436.72,2591.72) -436.72,2605 cw(c-436.72,2618.28) v1@-446.11,2608.89 ; v1@-443.28,2598.28 cw(c-427.07,2582.06) -427.07,2605 cw(c-427.07,2627.93) v1@-443.28,2611.72 ; U1.10@-339.74,2604.63 ccw(c-348.42,2595.95) -348.42,2608.23 ccw(c-348.42,2620.51) U1.10@-339.74,2611.83 ; U8.D15@5409.68,4603.39 v3(5429.37,4623.07) ; U8.D15@5409.69,4610.73 ccw(c5409.69,4628.45) 5422.22,4615.92 ccw(c5434.75,4603.39) U8.D15@5417.03,4603.39 ; 5416.57,4610.27 cw(c5429.37,4597.46) 5429.37,4615.57 ccw(c5429.37,4597.46) 5416.57,4610.27 ; 5416.57,4610.27 ccw(c5403.76,4623.07) 5421.87,4623.07 cw(c5403.76,4623.07) 5416.57,4610.27
  MidLayer1 w4: v1@-456.72,2598.28 ccw(c-472.94,2582.06) -472.94,2605 ccw(c-472.94,2627.93) v1@-456.72,2611.72 ; v1@-453.89,2601.11 ccw(c-463.28,2591.72) -463.28,2605 ccw(c-463.28,2618.28) v1@-453.89,2608.89 ; v1(-450,2605) -482.19,2605 -492.19,2615 -492.19,3021.25 -463.39,3050.04 -463.39,3136.61 -450,3150 v1(-395,3150) ; v1@-401.72,3143.28 ccw(c-417.94,3127.06) -417.94,3150 ccw(c-417.94,3172.93) v1@-401.72,3156.72 ; v1@-398.89,3146.11 ccw(c-408.28,3136.72) -408.28,3150 ccw(c-408.28,3163.28) v1@-398.89,3153.89 ; v2@-11.94,3216.94 ccw(c-28.69,3233.69) -5,3233.69 ccw(c18.69,3233.69) v2@1.94,3216.94 ; v2@-9.11,3214.11 ccw(c-19.03,3224.03) -5,3224.03 ccw(c9.03,3224.03) v2@-0.89,3214.11 ; v2(-5,3210) -5,3275 -18.31,3288.31 -18.31,3741.5 15.19,3775 15.19,3833.37 31.86,3850.04 165.19,3850.04 190.19,3875.04 190.19,4291.71 581.86,4683.37 581.86,4981.86 598,4998 1213,4998 v2(1240,5025) v2@1241.69,5023.31 ; v2@1230.19,5025 cw(c1206.5,5025) 1223.25,5008.25 cw(c1240,4991.5) v2@1240,5015.19 ; v2@1234.19,5025 cw(c1220.16,5025) 1230.08,5015.08 cw(c1240,5005.16) v2@1240,5019.19 ; v3@5424.18,4628.26 ccw(c5411.64,4640.8) 5429.37,4640.8 ccw(c5447.1,4640.8) v3@5434.56,4628.26 ; 5428.68,4897.05 5428.51,4896.89 ; v3(5429.37,4623.07) 5429.37,4700.75 5429.37,4741.18 5429.19,4749.19 5410.78,4749.19 5401.7,4758.27 5401.7,4771.11 5418.19,4787.6 5418.19,4820 5418.19,4836.44 ; v2(5460,4855) 5499.75,4855 5514.75,4870 5514.75,4900.48 5506.86,4908.37 5483.27,4908.37 5475.65,4916 5461.15,4916 5453.52,4908.37 5435,4908.37 ; v2@5464.11,4850.89 cw(c5474.03,4840.97) 5474.03,4855 cw(c5474.03,4869.03) v2@5464.11,4859.11 ; v2@5466.94,4848.06 cw(c5483.69,4831.31) 5483.69,4855 cw(c5483.69,4878.69) v2@5466.94,4861.94 ; 5418.19,4836.44 5428.51,4846.77 ; 5418.19,4836.44 5428.51,4846.77 ; 5418.19,4836.44 5428.51,4846.77 ; 5428.51,4846.77 5428.51,4896.89 ; 5428.51,4896.89 5428.51,4901.89 ; 5428.51,4896.89 5428.51,4901.89 ; 5428.51,4901.89 5428.68,4902.05 ; 5428.51,4901.89 5428.68,4902.05 ; 5428.68,4902.05 5435,4908.37 ; 5428.68,4902.05 5435,4908.37 ; 5428.68,4902.05 5435,4908.37 ; 5429.37,4641.18 cw(c5411.26,4641.18) 5424.07,4628.37 ccw(c5411.26,4641.18) 5429.37,4641.18 ; 5429.37,4641.18 ccw(c5447.48,4641.18) 5434.67,4628.37 cw(c5447.48,4641.18) 5429.37,4641.18
  MidLayer2 w4: v1(-395,3150) -335,3210 v2(-5,3210) ; v1@-395,3155.5 ccw(c-395,3168.78) -385.61,3159.39 ccw(c-376.22,3150) v1@-389.5,3150 ; v1@-395,3159.5 ccw(c-395,3182.43) -378.78,3166.22 ccw(c-362.57,3150) v1@-385.5,3150 ; v2@-11.94,3203.06 ccw(c-28.69,3186.31) -28.69,3210 ccw(c-28.69,3233.69) v2@-11.94,3216.94 ; v2@-9.11,3205.89 ccw(c-19.03,3195.97) -19.03,3210 ccw(c-19.03,3224.03) v2@-9.11,3214.11 ; v2(4080,4980) 4165,4980 4275,4870 4314.88,4870 4328,4856.87 4355.77,4856.87 4366.02,4867.13 4366.02,4881.62 4320.62,4927.02 4309.6,4927.02 4299.35,4937.28 4299.35,4955.62 4313.73,4970 ; v2@4084.11,4975.89 cw(c4094.03,4965.97) 4094.03,4980 cw(c4094.03,4994.03) v2@4084.11,4984.11 ; v2@4086.94,4973.06 cw(c4103.69,4956.31) 4103.69,4980 cw(c4103.69,5003.69) v2@4086.94,4986.94 ; v2@4321.32,4965.42 ccw(c4313.74,4961.42) 4313.74,4970 ; v2@4321.32,4974.58 cw(c4313.74,4978.58) 4313.74,4970 ; v2(4330,4970) 4313.73,4970
  Bottom Layer w4: v2(1240,5025) 1320.45,5025 1369.92,4975.54 3808.99,4975.54 3817.98,4966.54 3871.54,4966.54 3895,4990 4070,4990 v2(4080,4980) ; v2(4330,4970) 4363.65,4970 4377.35,4983.71 4728.48,4983.71 4736,4976.19 4764,4976.19 4771.52,4983.71 4920.29,4983.71 4953.46,4950.54 5014.42,4950.54 5048.09,4916.87 5100.38,4916.87 5124.69,4941.18 5124.69,4947.07 5164.45,4986.82 5307.93,4986.82 5361.63,4933.13 5361.63,4855 5361.63,4835.63 5388.75,4808.5 5403.25,4808.5 5404.49,4809.74 5426.19,4831.44 5426.19,4851.19 5430,4855 v2(5460,4855) ; v2@4334.11,4965.89 cw(c4344.03,4955.97) 4344.03,4970 cw(c4344.03,4984.03) v2@4334.11,4974.11 ; v2@4336.94,4963.06 cw(c4353.69,4946.31) 4353.69,4970 cw(c4353.69,4993.69) v2@4336.94,4976.94 ; v2@5453.06,4848.06 ccw(c5436.31,4831.31) 5436.31,4855 ccw(c5436.31,4878.69) v2@5453.06,4861.94 ; v2@5455.89,4850.89 ccw(c5445.97,4840.97) 5445.97,4855 ccw(c5445.97,4869.03) v2@5455.89,4859.11
CODEC.SPI_CS_N: U1.11 U8.W4 | length 7745.2
  Top Layer w4: v1(-455,2575) -423.03,2575 -415,2583.03 U1.11@-320,2583.03 ; v1@-451.11,2571.11 cw(c-441.72,2561.72) -441.72,2575 cw(c-441.72,2588.28) v1@-451.11,2578.89 ; v1@-448.28,2568.28 cw(c-432.07,2552.06) -432.07,2575 cw(c-432.07,2597.93) v1@-448.28,2581.72 ; U1.11@-339.74,2579.43 ccw(c-348.42,2570.75) -348.42,2583.03 ccw(c-348.42,2595.31) U1.11@-339.74,2586.63 ; v3(4956.93,3993.15) U8.W4@4976.61,4012.83 ; U8.W4@4969.27,4012.83 cw(c4951.55,4012.83) 4964.08,4000.3 cw(c4976.61,3987.77) U8.W4@4976.61,4005.49 ; 4969.73,4005.95 cw(c4956.93,4018.76) 4956.93,4000.65 ccw(c4956.93,4018.76) 4969.73,4005.95 ; 4969.73,4005.95 ccw(c4982.54,3993.15) 4964.43,3993.15 cw(c4982.54,3993.15) 4969.73,4005.95
  MidLayer1 w4: v1(3313.19,2339.71) 3342.29,2368.81 3391.69,2368.81 3698.52,2675.65 3698.52,3194.69 4038.84,3535 4074.42,3535 4096.29,3556.87 4117.42,3556.87 4138.29,3536 4203.52,3536 4224.19,3556.67 4224.19,3773.41 4213.9,3783.71 4181.48,3783.71 4165,3800.19 4165,3820 ; v1@3313.19,2345.21 ccw(c3313.19,2358.49) 3322.58,2349.1 ccw(c3331.97,2339.71) v1@3318.69,2339.71 ; v1@3313.19,2349.21 ccw(c3313.19,2372.14) 3329.41,2355.93 ccw(c3345.63,2339.71) v1@3322.69,2339.71 ; 4165.19,3820 4165.19,3936.1 4189.95,3960.87 4220.99,3960.87 4279.13,4019.01 4279.13,4050.7 4324.64,4096.21 4414.89,4096.21 4421.49,4102.81 4543.51,4102.81 4572.82,4073.5 4622.25,4073.5 4634.5,4061.25 4634.5,4036.44 4663.5,4007.44 4663.5,4004.75 4673.75,3994.5 4688.25,3994.5 4699.75,4006 4754,4006 4766.85,3993.15 4830.82,3993.15 4838.82,3993.15 4879.25,3993.15 v3(4956.93,3993.15) ; v3@4951.74,3987.96 ccw(c4939.2,3975.42) 4939.2,3993.15 ccw(c4939.2,4010.88) v3@4951.74,3998.34 ; 4938.82,3993.15 cw(c4938.82,3975.04) 4951.63,3987.85 ccw(c4938.82,3975.04) 4938.82,3993.15 ; 4938.82,3993.15 ccw(c4938.82,4011.26) 4951.63,3998.45 cw(c4938.82,4011.26) 4938.82,3993.15
  MidLayer2 w4: v1@-464.5,2575 cw(c-487.44,2575) -471.22,2558.78 cw(c-455,2542.56) v1@-455,2565.5 ; v1@-460.5,2575 cw(c-473.78,2575) -464.39,2565.61 cw(c-455,2556.22) v1@-455,2569.5 ; v1(-455,2575) -485,2545 -485,2460 -382.71,2357.71 -122.29,2357.71 -110,2370 -90,2370 -28.37,2308.37 1631.86,2308.37 1640.19,2300.04 2203.98,2300.04 2228.48,2324.54 2359.79,2324.54 2387.5,2352.25 2397.75,2362.5 2412.25,2362.5 2441.37,2333.37 2743.63,2333.37 2752.75,2342.5 2767.25,2342.5 2776.37,2333.37 3198.52,2333.37 3201.9,2330 3275,2330 3284.71,2339.71 v1(3313.19,2339.71) ; v1@3306.47,2332.99 ccw(c3290.26,2316.77) 3290.26,2339.71 ccw(c3290.26,2362.64) v1@3306.47,2346.43 ; v1@3309.3,2335.82 ccw(c3299.91,2326.43) 3299.91,2339.71 ccw(c3299.91,2352.99) v1@3309.3,2343.6
CODEC.SPI_DIN: U1.12 U8.Y4 | length 7718.2
  Top Layer w4: v1(-370,2555) -367.17,2557.83 U1.12@-320,2557.83 ; v1@-366.11,2551.11 cw(c-349.88,2534.88) -349.88,2557.83 ; v1@-363.28,2548.28 cw(c-340.22,2525.22) U1.12@-340.22,2557.83 ; v1@-363.28,2561.72 ccw(c-353.91,2571.09) -353.91,2557.83 ; U1.12@-339.74,2554.24 ccw(c-348.42,2545.55) -348.42,2557.83 ccw(c-348.42,2570.11) U1.12@-339.74,2561.43 ; v3(4956.93,3953.78) U8.Y4@4976.61,3973.46 ; U8.Y4@4969.27,3973.46 cw(c4951.55,3973.46) 4964.08,3960.93 cw(c4976.61,3948.4) U8.Y4@4976.61,3966.12 ; 4969.73,3966.58 cw(c4956.93,3979.39) 4956.93,3961.28 ccw(c4956.93,3979.39) 4969.73,3966.58 ; 4969.73,3966.58 ccw(c4982.54,3953.78) 4964.43,3953.78 cw(c4982.54,3953.78) 4969.73,3966.58
  MidLayer1 w4: v1@2753.28,2318.28 cw(c2737.06,2302.06) 2760,2302.06 cw(c2782.93,2302.06) v1@2766.72,2318.28 ; v1@2756.11,2321.11 cw(c2746.72,2311.72) 2760,2311.72 cw(c2773.28,2311.72) v1@2763.89,2321.11 ; v1(2760,2325) 2760,2224.5 2829,2155.5 3157.65,2155.5 3189.18,2187.03 3331.86,2329.71 3331.86,2338.37 3348.13,2354.65 3354.29,2360.81 3395,2360.81 3706.86,2672.67 3706.86,3191.71 4041.19,3526.04 4076.77,3526.04 4099.61,3548.87 4114.11,3548.87 4134.98,3528 4206.84,3528 4232.19,3553.35 4232.19,3776.73 4217.21,3791.71 4184.8,3791.71 4173.52,3802.98 4173.52,3933.12 4193.27,3952.87 4224.3,3952.87 4287.13,4015.69 4287.13,4047.38 4327.95,4088.21 4418.2,4088.21 4424.81,4094.81 4540.19,4094.81 4604.5,4030.5 4629.13,4030.5 4655.5,4004.13 4655.5,4001.44 4670.44,3986.5 4698.99,3986.5 4731.71,3953.78 4770,3953.78 4830.82,3953.78 4838.82,3953.78 4879.25,3953.78 v3(4956.93,3953.78) ; v3@4951.63,3948.48 ccw(c4938.82,3935.67) 4938.82,3953.78 ccw(c4938.82,3971.89) v3@4951.63,3959.08 ; v3@4951.74,3948.59 ccw(c4939.2,3936.05) 4939.2,3953.78 ccw(c4939.2,3971.51) v3@4951.74,3958.97
  Bottom Layer w4: v1@-376.72,2548.28 ccw(c-392.94,2532.06) -392.94,2555 ccw(c-392.94,2577.93) v1@-376.72,2561.72 ; v1@-373.89,2551.11 ccw(c-383.28,2541.72) -383.28,2555 ccw(c-383.28,2568.28) v1@-373.89,2558.89 ; v1(-370,2555) -415,2555 -430,2540 -430,2387.5 -346.52,2304.02 2207.96,2304.02 2229.44,2325.5 2759.5,2325.5 v1(2760,2325)
CODEC.SPI_DOUT: U1.9 U8.AG4 | length 7668.2
  Top Layer w4: U1.9@-320,2633.43 -268.17,2633.42 -252.25,2617.5 -188.27,2617.5 v1(-159.81,2589.04) ; U1.9@-300.26,2629.83 cw(c-291.58,2621.15) -291.58,2633.42 cw(c-291.58,2645.71) U1.9@-300.26,2637.02 ; v1@-169.31,2589.04 ccw(c-192.24,2589.04) -176.03,2605.26 ccw(c-159.81,2621.48) v1@-159.81,2598.54 ; v1@-165.31,2589.04 ccw(c-178.59,2589.04) -169.2,2598.43 ccw(c-159.81,2607.82) v1@-159.81,2594.54 ; v1@4873.28,3461.72 ccw(c4857.06,3477.93) 4880,3477.93 ccw(c4902.93,3477.93) v1@4886.72,3461.72 ; v1@4876.11,3458.89 ccw(c4866.72,3468.28) 4880,3468.28 ccw(c4893.28,3468.28) v1@4883.89,3458.89 ; v1(4880,3455) 4880,3495 4860,3515 4860,3540 4876.5,3556.5 4886.12,3556.5 ; 4886.12,3556.5 4906.12,3576.5 ; 4886.12,3556.5 4906.12,3576.5 ; 4906.12,3576.5 4931.61,3601.98 4934.17,3601.98 ; 4934.17,3601.98 4942.17,3601.98 ; 4934.17,3601.98 4942.17,3601.98 ; 4942.17,3601.98 4961.11,3620.92 4961.11,3630.82 4961.11,3638.82 4961.11,3678.16 ; 4961.11,3678.16 cw(c4971.26,3678.16) 4964.08,3685.34 ; 4961.11,3678.16 cw(c4971.26,3678.16) 4964.08,3685.34 ; 4964.08,3685.34 cw(c4976.61,3672.8) 4976.61,3690.53 ccw(c4976.61,3672.8) 4964.08,3685.34 ; 4964.08,3685.34 ccw(c4951.55,3697.87) 4969.27,3697.87 cw(c4951.55,3697.87) 4964.08,3685.34
  MidLayer1 w4: 4857,2418.57 4857.19,2418.37 ; v1@4873.28,3448.28 cw(c4857.06,3432.06) 4880,3432.06 cw(c4902.93,3432.06) v1@4886.72,3448.28 ; v1@4876.11,3451.11 cw(c4866.72,3441.72) 4880,3441.72 cw(c4893.28,3441.72) v1@4883.89,3451.11 ; v1(4880,3455) 4880,3360.84 4898.52,3342.32 ; v1@4899.36,2366.71 ccw(c4876.42,2366.71) 4892.64,2382.93 ccw(c4908.86,2399.14) v1@4908.86,2376.21 ; v1@4903.36,2366.71 ccw(c4890.08,2366.71) 4899.47,2376.1 ccw(c4908.86,2385.49) v1@4908.86,2372.21 ; v1(4908.86,2366.71) 4857.19,2418.37 ; 4857.19,2418.37 4857.19,2494 4857.19,2690.71 4898.52,2732.04 4898.52,3245 ; 4898.52,3245 4898.52,3258.37 ; 4898.52,3245 4898.52,3258.37 ; 4898.52,3258.37 4898.52,3342.32 ; 4898.52,3342.32 4881.86,3358.98 4898.52,3342.32
  MidLayer2 w4: v1@2405,2335.5 cw(c2405,2312.56) 2421.22,2328.78 cw(c2437.43,2345) v1@2414.5,2345 ; v1@2405,2339.5 cw(c2405,2326.22) 2414.39,2335.61 cw(c2423.78,2345) v1@2410.5,2345 ; v1(2405,2345) 2442.5,2307.5 2447.5,2302.5 3359.32,2302.5 3423.52,2366.71 ; 3364.32,2307.5 3365.19,2308.37 3423.52,2366.71 ; v1(4908.86,2366.71) 3423.52,2366.71
  Bottom Layer w4: v1@-166.53,2582.32 cw(c-182.74,2566.11) -159.81,2566.11 cw(c-136.87,2566.11) v1@-153.09,2582.32 ; v1@-163.7,2585.15 cw(c-173.09,2575.76) -159.81,2575.76 cw(c-146.53,2575.76) v1@-155.92,2585.15 ; v1(-159.81,2589.04) -159.81,2337.83 -150,2328.02 2101.29,2328.02 2148.31,2375.04 2245,2375.04 2275.04,2345 v1(2405,2345) ; v1@2398.28,2338.28 ccw(c2382.06,2322.06) 2382.06,2345 ccw(c2382.06,2367.93) v1@2398.28,2351.72 ; v1@2401.11,2341.11 ccw(c2391.72,2331.72) 2391.72,2345 ccw(c2391.72,2358.28) v1@2401.11,2348.89
CODEC_AUD.L: C10.2 C29.1 R23.1 | length 1528.4
  MidLayer1 w4: v1(-35,3790) -35.7,3790 -35.81,3789.89 -35.81,3344.19 -69.25,3310.75 -69.25,3214.25 -37.69,3182.69 62.31,3182.69 90.19,3154.81 90.19,2870.71 v1(160.86,2800.04)
  Bottom Layer w4: C10.2@-179.33,3795.91 -95,3795.91 -89.09,3790 v1(-35,3790) ; C10.2@-175.22,3791.8 cw(c-165.3,3781.88) -165.3,3795.91 ; C10.2@-175.22,3800.02 ccw(c-165.3,3809.94) -165.3,3795.91 ; C29.1@126.56,2799.11 ccw(c115.4,2810.26) 131.18,2810.26 ; R23.1@127.42,2840.75 cw(c118.34,2831.67) 131.18,2831.67 cw(c144.02,2831.67) R23.1@134.94,2840.75 ; C29.1@130.67,2795 C29.1@131.18,2795.51 ; R23.1@130.67,2844.49 R23.1@131.18,2845 C29.1@131.18,2795.51 ; 131.18,2807.79 ccw(c143.46,2807.79) C29.1@134.78,2799.11 ; C29.1@132.1,2793.89 cw(c144.6,2784.27) 144.6,2800.04 ; C29.1@137.61,2801.94 ccw(c142.19,2806.52) C29.1@142.19,2800.04 ; v1@154.14,2793.32 ccw(c137.92,2777.11) 137.92,2800.04 ccw(c137.92,2822.98) v1@154.14,2806.76 ; v1@156.97,2796.15 ccw(c147.58,2786.76) 147.58,2800.04 ccw(c147.58,2813.32) v1@156.97,2803.93 ; v1(160.86,2800.04) 135.71,2800.04 C29.1@131.18,2795.51
CODEC_AUD.R: C15.2 C30.1 R24.1 | length 1959.9
  Top Layer w4: v1(-293.14,3265.71) -227.44,3200 -40,3200 160.86,2999.14 v1(160.86,2891.71)
  MidLayer1 w4: v1(-293.14,3265.71) -293.14,3353.62 -266.31,3380.45 -266.31,3548.69 -122.48,3692.52 -122.48,3869.56 -138.29,3885.37 ; -138.66,3885.37 -157.48,3904.19 -157.48,4029.34 -123,4063.82 -123,4107.81 -116.52,4114.29 v1@-116.52,4135
  Bottom Layer w4: C15.2@-180.81,4134.01 C15.2@-180.28,4130.67 ; C15.2@-179.33,4128.64 C15.2@-179.33,4138.55 ; C15.2@-177.54,4128.92 cw(c-158.19,4131.98) -172.04,4145.83 -160.94,4156.94 -136.94,4156.94 v1(-115,4135) ; C15.2@-173.93,4131.67 C15.2@-173.59,4129.54 ; C30.1@126.56,2899.11 ccw(c115.4,2910.26) 131.18,2910.26 ; R24.1@127.42,2940.75 cw(c118.34,2931.67) 131.18,2931.67 cw(c144.02,2931.67) R24.1@134.94,2940.75 ; R24.1@130.67,2944.49 R24.1@131.18,2945 131.18,2895.51 C30.1@130.67,2895 ; 131.18,2907.79 ccw(c143.46,2907.79) 134.78,2899.11 ccw(c144.7,2909.03) 144.7,2895 ccw(c144.7,2880.97) C30.1@134.78,2890.89 ; C30.1@140.11,2895 cw(c140.11,2871.62) v1@156.91,2887.88 ; 145.87,2895 ccw(c145.87,2906.69) v1@154.14,2898.43 ; 149.55,2895 cw(c149.55,2880.76) v1@159.78,2890.66 ; v1@154.03,2885.1 ccw(c130.67,2862.49) C30.1@130.67,2895 ; v1(160.86,2891.71) 157.56,2895 C30.1@130.67,2895
CODEC_RST: R154.1 U1.14 U45.2 | length 1285
  Top Layer w4: v1(-159.81,2268.37) -66.63,2268.37 -43.14,2291.86 -43.14,2575.03 -51.14,2583.03 U1.14@-79.84,2583.03 ; v1@-155.92,2264.49 cw(c-146.53,2255.1) -146.53,2268.37 cw(c-146.53,2281.65) v1@-155.92,2272.26 ; v1@-153.09,2261.66 cw(c-136.87,2245.44) -136.87,2268.37 cw(c-136.87,2291.31) v1@-153.09,2275.09 ; U1.14@-60.1,2579.43 cw(c-51.42,2570.75) -51.42,2583.03 cw(c-51.42,2595.31) U1.14@-60.1,2586.63
  Bottom Layer w4: -233.65,2013.65 ccw(c-203.74,2043.56) U45.2@-203.09,2001.27 ; -227.78,2007.78 cw(c-250,1985.55) U45.2@-218.57,1985.55 ; -226.97,2006.97 ccw(c-203.54,2030.39) U45.2@-203.03,1997.27 ; -220.95,2000.95 cw(c-236.35,1985.55) U45.2@-214.57,1985.55 ; U45.2@-220.28,2000.28 ccw(c-203.34,2017.23) U45.2@-202.97,1993.27 ; U45.2@-211.79,1954.91 cw(c-223.59,1937.86) -202.85,1937.86 ; U45.2@-209.52,1958.2 cw(c-218.31,1945.49) -202.85,1945.49 cw(c-187.4,1945.49) U45.2@-196.19,1958.2 ; U45.2@-202.85,1976.69 -202.85,1937.85 ; U45.2@-202.85,1982.85 -235,2015 -235,2215 -220,2230 -169.81,2230 -159.81,2240 v1(-159.81,2268.37) ; U45.2@-193.91,1954.91 ccw(c-182.12,1937.86) -202.85,1937.86 ; v1@-166.53,2261.66 cw(c-182.74,2245.44) -159.81,2245.44 cw(c-136.87,2245.44) v1@-153.09,2261.66 ; v1@-163.7,2264.49 cw(c-173.09,2255.1) -159.81,2255.1 cw(c-146.53,2255.1) v1@-155.92,2264.49 ; R154.1@-147.17,1917.74 ccw(c-157.08,1930) -141.32,1930 ccw(c-125.56,1930) R154.1@-135.46,1917.74 ; R154.1@-141.32,1910 -141.32,1930 -146.32,1935 -200,1935 -202.85,1937.85
COMB: C142.1 C143.2 C144.1 NT44.2 U43.2 | length 667.1
  Bottom Layer w12: C144.1@4555.84,2415 ccw(c4541.81,2415) 4551.73,2424.92 ccw(c4561.65,2434.84) C144.1@4561.65,2420.81 ; C142.1@4555.84,2585 cw(c4541.81,2585) 4551.73,2575.08 cw(c4561.65,2565.16) C142.1@4561.65,2579.19 ; C142.1@4557.54,2589.11 ccw(c4528.04,2618.61) 4569.76,2618.61 ; C144.1@4561.65,2409.19 cw(c4561.65,2395.16) 4571.57,2405.08 cw(c4581.49,2415) C144.1@4567.46,2415 ; NT44.2@4562.87,2636.75 cw(c4546.23,2620.11) 4569.76,2620.11 cw(c4593.3,2620.11) NT44.2@4576.66,2636.75 ; NT44.2@4569.76,2653.9 4569.76,2593.11 C142.1@4561.65,2585 4540,2563.35 U43.2@4540,2537.4 4540,2436.65 C144.1@4561.65,2415 4602.99,2373.66 ; C143.2@4583.64,2336.12 ccw(c4556.91,2373.66) 4602.99,2373.66 ; C143.2@4590.6,2326.35 ccw(c4573.48,2350.38) 4602.99,2350.38 ccw(c4632.5,2350.38) C143.2@4615.39,2326.35 ; C143.2@4602.99,2305 4602.99,2373.66 ; C143.2@4622.35,2336.12 cw(c4649.07,2373.66) 4602.99,2373.66
COMC: C181.1 C182.2 C183.1 NT19.2 U58.2 | length 1566.9
  Bottom Layer w12: C181.1@1320,5225.67 1349.33,5225.67 1366.58,5208.42 1366.58,5158.42 1385,5140 1430,5140 1435,5145 1435,5205 ; C181.1@1324.11,5221.56 cw(c1334.03,5211.64) 1334.03,5225.67 cw(c1334.03,5239.7) C181.1@1324.11,5229.78 ; U58.2@1435,5242.4 1435,5205 ; NT19.2@1537,5112.13 ccw(c1520.36,5128.77) 1543.9,5128.77 ccw(c1567.43,5128.77) NT19.2@1550.79,5112.13 ; NT19.2@1543.9,5099.52 cw(c1620.99,5099.52) C182.2@1590.64,5170.39 ; NT19.2@1543.9,5105.24 1543.9,5171.4 C182.2@1577.5,5205 ; NT19.2@1543.9,5117.71 cw(c1613.2,5117.71) C182.2@1585.91,5181.42 ; 1543.9,5135.91 cw(c1605.41,5135.91) C182.2@1581.19,5192.45 ; 1543.9,5154.1 cw(c1597.61,5154.1) C182.2@1576.46,5203.48 ; C182.2@1543.9,5172.3 cw(c1589.82,5172.3) C182.2@1571.74,5214.51 ; C182.2@1553.9,5181.4 ccw(c1496.94,5124.44) 1496.94,5205 ccw(c1496.94,5285.56) C182.2@1553.9,5228.6 ; C182.2@1562.39,5189.89 ccw(c1525.91,5153.41) 1525.91,5205 ccw(c1525.91,5256.59) C182.2@1562.39,5220.11 ; C182.2@1562.79,5238.89 ccw(c1551.2,5262.5) 1577.5,5262.5 ccw(c1603.8,5262.5) C182.2@1592.21,5238.89 ; C183.1@1814.19,5225.67 ccw(c1800.16,5225.67) 1810.08,5235.59 ccw(c1820,5245.51) C183.1@1820,5231.48 ; C183.1@1820,5225.67 1770.67,5275 1590,5275 1577.5,5262.5 C182.2@1577.5,5205 1435,5205
CONF_DONE: R75.2 U8.P24 | length 3829.4
  Top Layer w4: U8.P24@5764.02,4209.68 v3(5783.7,4229.37) ; U8.P24@5764.02,4217.03 ccw(c5764.02,4234.75) 5776.55,4222.22 ccw(c5789.08,4209.68) U8.P24@5771.36,4209.68 ; 5770.9,4216.57 cw(c5783.7,4203.76) 5783.7,4221.87 ccw(c5783.7,4203.76) 5770.9,4216.57 ; 5770.9,4216.57 ccw(c5758.09,4229.37) 5776.2,4229.37 cw(c5758.09,4229.37) 5770.9,4216.57
  MidLayer1 w4: v3@5784.35,4236.84 ccw(c5785.93,4254.88) 5797.57,4241.01 ccw(c5809.21,4227.14) v3@5791.17,4228.72 ; 5797.28,4240.76 cw(c5807.21,4230.83) 5807.21,4244.88 5964.88,4244.88 5980.74,4260.74 6065.2,4260.74 6083.94,4242 6111.69,4242 6146.69,4207 6155,4207 6168.31,4207 6216.31,4255 6225.05,4255 6229.68,4250.37 6429.63,4250.37 6432.75,4247.25 6432.75,4216 6432.75,4187.75 6362,4117 6319.81,4117 6295.36,4092.55 6295.36,3966.52 6314.07,3947.81 6324.69,3947.81 6341.81,3930.69 6341.81,3778.19 6425.69,3694.31 6425.69,3658.84 6416.85,3650 6360,3650 v2(6340,3670) ; v2@5978.06,3523.06 cw(c5961.31,3506.31) 5985,3506.31 cw(c6008.69,3506.31) v2@5991.94,3523.06 ; v2@5980.89,3525.89 cw(c5970.97,3515.97) 5985,3515.97 cw(c5999.03,3515.97) v2@5989.11,3525.89 ; v1@5983.47,2740.09 ccw(c5969.27,2754.3) 5989.36,2754.3 ; v2(5985,3530) 5985,3395 5985,3379 5985,3327.81 5998.52,3314.29 5998.52,3311.96 5998.52,3291.29 6079.14,3210.67 6101.18,3210.67 6123.52,3188.33 6123.52,3175.04 6115.19,3166.71 ; v1@5989.36,2734.21 5989.36,2851.54 6009.19,2871.37 6009.19,2888.59 6043.81,2923.21 6043.81,2946.62 6043.81,2961.38 6037.81,2967.38 6037.81,2990 6037.81,2999.44 6037.81,3083.19 5980,3141 5965,3156 5965,3175 6000,3210 6005,3210 6046.96,3210 6090.46,3166.5 6114.98,3166.5 ; 5989.36,2748.66 ccw(c6005.48,2748.66) v1@5994.08,2737.26 ; 5989.36,2758.32 ccw(c6015.14,2758.32) v1@5996.91,2740.09 ; v2@6340,3660.19 cw(c6340,3636.5) 6356.75,3653.25 cw(c6373.5,3670) v2@6349.81,3670 ; v2@6340,3664.19 cw(c6340,3650.16) 6349.92,3660.08 cw(c6359.84,3670) v2@6345.81,3670
  Bottom Layer w4: R75.2@5885.82,2716.71 R75.2@5885.82,2715 5904.19,2733.37 v1(5990.19,2733.37) ; R75.2@5885.82,2720.81 ccw(c5885.82,2734.84) R75.2@5895.74,2724.92 ; R75.2@5885.82,2724.81 ccw(c5885.82,2748.5) 5902.57,2731.75 ; R75.2@5891.14,2715.49 cw(c5902.79,2715.49) R75.2@5894.55,2723.73 ; R75.2@5895.14,2715.49 cw(c5916.45,2715.49) 5901.38,2730.56 ; v2(5985,3530) 6008.69,3530 ; v2@5989.11,3525.89 cw(c5999.03,3515.97) 5999.03,3530 cw(c5999.03,3544.03) v2@5989.11,3534.11 ; v2@5991.94,3523.06 cw(c6008.69,3506.31) 6008.69,3530 ; v2@5991.94,3536.94 ccw(c6008.69,3553.69) 6008.69,3530 ; v2@6333.06,3663.06 cw(c6316.31,3646.31) 6340,3646.31 cw(c6363.69,3646.31) v2@6346.94,3663.06 ; v2@6335.89,3665.89 cw(c6325.97,3655.97) 6340,3655.97 cw(c6354.03,3655.97) v2@6344.11,3665.89 ; v2(6340,3670) 6340,3643.04 6330,3633.04 6292.94,3633.04 6273.77,3613.87 6256.13,3613.87 6228.63,3641.37 6200,3641.37 6191.69,3641.37 6174.19,3623.88 6174.19,3600 6174.19,3559.44 6174.19,3476.67 6169.02,3471.5 6057.24,3471.5 6030,3498.74 6030,3508.69 6030,3525 6025,3530 6008.69,3530
CRS_U: R52.1 U5.23 U6.8 | length 1968.1
  MidLayer2 w4: v1(2262.86,5583.71) 2269.06,5577.5 2452.25,5577.5 2459.27,5584.52 2488.69,5584.52 2495.71,5577.5 3478.65,5577.5 v1(3484.86,5583.71) ; v1@2263.92,5584.77 ccw(c2281.47,5602.32) 2281.47,5577.5 ; v1@2266.75,5587.6 ccw(c2291.12,5611.97) 2291.12,5577.5 ; v1@2269.57,5590.43 ccw(c2300.78,5621.63) 2300.78,5577.5 ; 3446.94,5577.5 ccw(c3446.94,5621.63) v1@3478.14,5590.43 ; 3456.59,5577.5 ccw(c3456.59,5611.97) v1@3480.97,5587.6 ; 3466.25,5577.5 ccw(c3466.25,5602.32) v1@3483.8,5584.77
  Bottom Layer w4: R52.1@2100.04,5552.5 ccw(c2088.21,5566.03) 2106.18,5566.03 ; R52.1@2102.68,5549.49 ccw(c2095.92,5557.22) 2106.18,5557.22 ccw(c2116.44,5557.21) R52.1@2109.68,5549.49 ; R52.1@2106.18,5545 2106.18,5566.03 ; R52.1@2112.32,5552.5 cw(c2124.16,5566.03) 2106.18,5566.03 ; U5.23@2167.19,5575.75 ccw(c2160.36,5568.93) 2160.36,5578.58 ccw(c2160.36,5588.24) U5.23@2167.19,5581.41 ; U5.23@2219.9,5575.75 cw(c2226.73,5568.93) 2226.73,5578.58 cw(c2226.73,5588.24) U5.23@2219.9,5581.41 ; 2227.55,5578.58 ccw(c2227.55,5619.02) v1@2256.14,5590.43 ; 2237.21,5578.58 ccw(c2237.21,5609.36) v1@2258.97,5587.6 ; 2246.86,5578.58 ccw(c2246.86,5599.7) v1@2261.8,5584.77 ; 2252.29,5578.58 cw(c2252.29,5573.15) v1@2256.14,5576.99 ; v1(2262.86,5583.71) 2257.73,5578.58 U5.23@2193.54,5578.58 2156.86,5578.58 2145.4,5590.04 2130.19,5590.04 2106.18,5566.03 ; v1@3484.86,5574.21 cw(c3484.86,5551.27) 3501.07,5567.49 cw(c3517.29,5583.71) v1@3494.36,5583.71 ; v1@3484.86,5578.21 cw(c3484.86,5564.93) 3494.25,5574.32 cw(c3503.64,5583.71) v1@3490.36,5583.71 ; v1(3484.86,5583.71) 3547.54,5521.02 U6.8@3598.94,5521.02 ; U6.8@3560.62,5516.17 ccw(c3548.91,5504.47) 3548.91,5521.02 ccw(c3548.92,5537.58) U6.8@3560.62,5525.87
DAC.CLK: U8.C14 U28.10 | length 8425.1
  Top Layer w4: U28.10@640.42,5396.54 ccw(c633.59,5389.71) 633.59,5399.37 ccw(c633.59,5409.03) U28.10@640.42,5402.2 ; U28.10@670.71,5399.37 615,5399.37 515,5499.37 515,5925 460,5980 460,6520 515,6575 1340,6575 1425,6490 1650,6490 1922,6762 2633,6762 2690,6705 2690,6225 2735,6180 5225,6180 5281.86,6123.14 5281.86,5325.04 5309.86,5297.04 5309.86,5294 ; 5309.86,5250.04 5309.86,5294 ; U8.C14@5362.97,4642.76 ccw(c5345.25,4642.76) 5357.78,4655.29 ; U8.C14@5370.32,4650.1 cw(c5370.32,4667.82) 5357.78,4655.29 ; 5309.86,5294 5309.86,5243.63 5353.44,5200.04 5374.44,5200.04 5384.84,5189.64 5392,5182.48 5392,5140 5392,5048 5406,5034 5406,4974.18 5399.36,4967.54 5391.72,4959.91 5369.5,4937.68 5369.5,4820.81 5346.45,4797.77 5346.45,4749.18 5346.45,4741.18 5346.45,4682.64 ccw(c5385.13,4682.64) 5357.78,4655.29
DAC.CS: U8.F3 U28.9 | length 5464.9
  Top Layer w4: U28.9@670.71,5379.69 740.31,5379.69 756.86,5363.14 756.86,5314.71 771.52,5300.04 v1(771.52,5207.37) ; U28.9@701,5376.86 cw(c707.83,5370.03) 707.83,5379.69 cw(c707.83,5389.34) U28.9@701,5382.51 ; v1@764.81,5214.09 ccw(c748.59,5230.31) 771.52,5230.31 ccw(c794.46,5230.31) v1@778.24,5214.09 ; v1@767.64,5211.26 ccw(c758.25,5220.65) 771.52,5220.65 ccw(c784.8,5220.65) v1@775.41,5211.26 ; v1@4688.53,4599.48 cw(c4688.53,4573.99) 4706.55,4592.01 ; v1@4688.53,4603.48 cw(c4688.53,4587.65) 4699.72,4598.84 ; v1@4689.59,4608.98 4744.97,4553.59 4755.44,4553.59 4760.53,4548.51 4773.09,4548.51 4830.82,4548.51 4838.82,4548.51 4897.36,4548.51 ; v1@4698.03,4608.98 ccw(c4718.41,4608.98) 4704,4594.57 ; 4897.36,4548.51 cw(c4897.36,4509.83) 4924.71,4537.18 ; 4897.36,4548.51 cw(c4897.36,4509.83) 4924.71,4537.18 ; 4924.71,4537.18 ccw(c4937.24,4549.71) 4937.24,4531.99 cw(c4937.24,4549.71) 4924.71,4537.18 ; 4924.71,4537.18 cw(c4912.18,4524.65) 4929.9,4524.65 ccw(c4912.18,4524.65) 4924.71,4537.18
  MidLayer1 w4: v1@4580.14,4868.32 cw(c4563.92,4852.11) 4586.86,4852.11 cw(c4609.79,4852.11) v1@4593.57,4868.32 ; v1@4582.97,4871.15 cw(c4573.58,4861.76) 4586.86,4861.76 cw(c4600.14,4861.76) v1@4590.75,4871.15 ; v1(4586.86,4875.04) 4586.86,4743.39 4613,4717.25 4613,4706.56 4688.53,4631.03 ; v1@4682,4615.88 ccw(c4667.7,4631.03) 4688.53,4631.03 ; v1@4684.75,4612.98 ccw(c4676.47,4621.74) 4688.53,4621.74 ccw(c4700.59,4621.74) v1@4692.31,4612.98 ; v1@4688.53,4611.47 4688.53,4631.03 ; v1@4695.05,4615.88 cw(c4709.36,4631.03) 4688.53,4631.03
  MidLayer2 w4: v1@771.52,5197.87 cw(c771.52,5174.94) 787.74,5191.16 cw(c803.96,5207.37) v1@781.02,5207.37 ; v1@771.52,5201.87 cw(c771.52,5188.6) 780.91,5197.99 cw(c790.3,5207.37) v1@777.02,5207.37 ; v1(771.52,5207.37) 795.19,5183.71 1365.02,5183.71 1400,5218.69 1400,5340.2 1451.99,5392.19 2443.04,5392.19 2459.39,5408.54 2815.03,5408.54 3006.38,5217.19 3236.5,5217.19 3328.65,5125.04 4248.65,5125.04 4498.65,4875.04 v1(4586.86,4875.04) ; v1@4580.14,4868.32 ccw(c4563.92,4852.11) 4563.92,4875.04 ccw(c4563.92,4897.98) v1@4580.14,4881.76 ; v1@4582.97,4871.15 ccw(c4573.58,4861.76) 4573.58,4875.04 ccw(c4573.58,4888.32) v1@4582.97,4878.93
  other v1: 4688.53,4608.98
DAC.DIN: U8.K3 U28.8 | length 5552.5
  Top Layer w4: U28.8@698.18,5360 U28.8@676.2,5360 ; U28.8@701,5357.17 cw(c707.83,5350.34) 707.83,5360 cw(c707.83,5369.66) U28.8@701,5362.83 ; v1@741.81,5238.76 ccw(c725.59,5254.98) 748.52,5254.98 ccw(c771.46,5254.98) v1@755.24,5238.76 ; v1@744.64,5235.93 ccw(c735.25,5245.32) 748.52,5245.32 ccw(c761.8,5245.32) v1@752.41,5235.93 ; v1(748.52,5232.04) 748.52,5351.48 740,5360 U28.8@676.2,5360 ; v1(4465.19,4500.04) 4533.9,4500.04 4593.44,4440.5 4616.24,4440.5 4622.34,4446.59 4730.16,4446.59 4746.99,4429.77 4758.86,4429.77 4797.6,4391.03 4816.86,4391.03 4825,4391.03 4830.82,4391.03 4838.82,4391.03 4897.36,4391.03 ; v1@4469.08,4496.15 cw(c4478.47,4486.76) 4478.47,4500.04 cw(c4478.47,4513.32) v1@4469.08,4503.93 ; v1@4471.91,4493.32 cw(c4488.13,4477.11) 4488.13,4500.04 cw(c4488.13,4522.98) v1@4471.91,4506.76 ; U28.8@676.2,5360 U28.8@670.71,5360 U28.8@676.2,5360 ; 4897.36,4391.03 cw(c4897.36,4352.35) 4924.71,4379.7 ; 4897.36,4391.03 cw(c4897.36,4352.35) 4924.71,4379.7 ; 4924.71,4379.7 cw(c4912.18,4367.16) 4929.9,4367.16 ccw(c4912.18,4367.16) 4924.71,4379.7 ; 4924.71,4379.7 ccw(c4937.24,4392.23) 4937.24,4374.51 cw(c4937.24,4392.23) 4924.71,4379.7
  MidLayer2 w4: v1@741.81,5225.32 ccw(c725.59,5209.11) 725.59,5232.04 ccw(c725.59,5254.98) v1@741.81,5238.76 ; v1@744.64,5228.15 ccw(c735.25,5218.76) 735.25,5232.04 ccw(c735.25,5245.32) v1@744.64,5235.93 ; v1(748.52,5232.04) 622.04,5232.04 598.52,5208.52 598.52,4981.48 610,4970 1530,4970 1560.04,5000.04 1635,5000.04 3625,5000 ; 3620,5000 3625,5000 ; v1@4455.69,4500.04 ccw(c4432.76,4500.04) 4448.97,4516.26 ccw(c4465.19,4532.48) v1@4465.19,4509.54 ; v1@4459.69,4500.04 ccw(c4446.41,4500.04) 4455.8,4509.43 ccw(c4465.19,4518.82) v1@4465.19,4505.54 ; v1(4465.19,4500.04) 4373.52,4591.71 4048.52,4591.71 3640.23,5000 3625,5000
DB_CLK1: R153.1 U30.F14 | length 6426.5
  Top Layer w4: U30.F14@7226.54,1963.43 v3(7246.22,1983.11) ; U30.F14@7226.54,1970.77 ccw(c7226.54,1988.49) 7239.07,1975.96 ccw(c7251.6,1963.43) U30.F14@7233.88,1963.43 ; 7233.42,1970.31 cw(c7246.22,1957.5) 7246.22,1975.61 ccw(c7246.22,1957.5) 7233.42,1970.31 ; 7233.42,1970.31 ccw(c7220.61,1983.11) 7238.72,1983.11 cw(c7220.61,1983.11) 7233.42,1970.31
  MidLayer1 w4: v3@7247.52,1990.5 ccw(c7250.67,2008.33) 7261.05,1993.5 ccw(c7271.44,1978.66) v3@7253.61,1981.81 ; 7261.08,1993.53 cw(c7278.73,1965.49) 7278.9,1998.62 7346.88,1998.62 7367.31,1978.19 7426.67,1978.19 7464.24,2015.76 7523.52,2075.04 7573.52,2075.04 7590.19,2091.71 7591.58,2093.1 7591.58,2118.38 7575.75,2134.21 7565.19,2144.77 7565.19,2175 7565.19,2499.62 7546.19,2518.62 7546.19,2533.38 7565.19,2552.38 7565.19,2580.44 7572.5,2587.75 7572.5,2602.25 7565.19,2609.56 7565.19,2715.4 7594.79,2745 7708.24,2745 7727.81,2764.57 7727.81,2874.62 7727.81,2889.38 7725.69,2891.5 7724.67,2892.52 7697.05,2920.14 7697.05,2990 7724.67,3017.62 7724.67,3130 7724.67,3150.33 7724.67,3206.46 7737,3218.79 7737,3560 7737,3578 7737,3649.06 7731.52,3654.54 7708.41,3677.65 7612.28,3677.65 7588.89,3701.04 7588.89,4037.37 7641.52,4090 v1(7641.52,4338.37) ; v1@7634.81,4331.66 cw(c7618.59,4315.44) 7641.52,4315.44 cw(c7664.46,4315.44) v1@7648.24,4331.66 ; v1@7637.64,4334.49 cw(c7628.25,4325.1) 7641.52,4325.1 cw(c7654.8,4325.1) v1@7645.41,4334.49
  Bottom Layer w4: R153.1@5769.77,5093.89 ccw(c5766.66,5100.34) 5773.82,5100.34 ; R153.1@5773.82,5085 5773.82,5100.34 ; R153.1@5777.87,5093.89 cw(c5780.98,5100.34) 5773.82,5100.34 ; v1@7634.81,4345.09 ccw(c7618.59,4361.31) 7641.52,4361.31 ccw(c7664.46,4361.31) v1@7648.24,4345.09 ; v1@7637.64,4342.26 ccw(c7628.25,4351.65) 7641.52,4351.65 ccw(c7654.8,4351.65) v1@7645.41,4342.26 ; v1(7641.52,4338.37) 7641.52,4421.37 7645.52,4425.37 7896.52,4425.37 7908.52,4437.37 7908.52,4490 7908.52,4575.04 7908.52,4616.48 7902.47,4622.53 7857.7,4622.53 7847.33,4632.9 7815.19,4665.04 7815.19,4736.71 7781.86,4770.04 7725.19,4770.04 7723.52,4771.71 7723.52,4970.71 7632.23,5062 7576.94,5062 7570.4,5068.54 7536.46,5068.54 7460,5145 7421.63,5183.37 7345,5183.37 7154.48,5183.37 7154.32,5183.54 7142.73,5183.54 7142.56,5183.37 6970,5183.37 6938.43,5183.37 6879.13,5183.37 6867.82,5183.37 6817.48,5233.71 6785,5233.71 5863.71,5233.71 5821.81,5191.81 5821.81,5136.81 5793.37,5108.37 5781.86,5108.37 5773.82,5100.34