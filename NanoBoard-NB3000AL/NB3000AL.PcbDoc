# Altium PCB NB3000AL.PcbDoc (part 50 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Bottom Layer w12: 7405.5,4376.4 cw(c7388.15,4359.04) v1@7412.69,4359.04 ; v1@7411.69,4927.71 cw(c7398.41,4927.71) 7407.8,4918.32 cw(c7417.19,4908.93) v1@7417.19,4922.21 ; v1@7429.97,4672.15 cw(c7420.58,4662.76) 7433.86,4662.76 cw(c7447.14,4662.76) v1@7437.75,4672.15 ; v1(7431.86,1308.37) 7452.86,1329.37 7452.99,1329.37 C93.2@7452.99,1374 v1@7522.19,1374 ; v1@7431.86,1313.87 ccw(c7431.86,1327.15) 7441.25,1317.76 ccw(c7450.64,1308.37) v1@7437.36,1308.37 ; v1(7433.86,4676.04) 7433.86,4651.04 7385.19,4602.37 ; v1@7453.64,3020.49 ccw(c7444.25,3011.1) 7444.25,3024.37 ccw(c7444.25,3037.65) v1@7453.64,3028.26 ; v1@7465.64,4832.71 cw(c7446.59,4813.66) 7473.52,4813.66 ; C93.2@7469.71,1360.69 cw(c7497.3,1338.74) 7497.3,1374 cw(c7497.3,1409.26) C93.2@7469.71,1387.31 ; C90.1@7490.22,499.11 ccw(c7480.3,509.03) 7494.33,509.03 ccw(c7508.36,509.03) C90.1@7498.44,499.11 ; C90.1@7494.33,495 7494.33,524.33 7505,535 7606.86,535 v1(7629.73,557.88) 7656.86,585 7656.86,608.37 ; 7506.93,1374 ccw(c7506.93,1391.97) v1@7519.64,1379.26 ; v2(7550,1868) 7566,1884 C366.2@7571.33,1884 7571.33,1849.67 C365.2@7571.33,1841.25 C364.2@7571.33,1798.5 C363.2@7571.33,1755.75 ; v2@7550,1873.81 ccw(c7550,1887.84) 7559.92,1877.92 ccw(c7569.84,1868) v2@7555.81,1868 ; C365.2@7567.22,1845.36 ccw(c7557.3,1855.28) 7571.33,1855.28 ccw(c7585.36,1855.28) C365.2@7575.44,1845.36 ; C366.2@7567.22,1879.89 cw(c7557.3,1869.97) 7571.33,1869.97 cw(c7585.36,1869.97) C366.2@7575.44,1879.89 ; v1(7575.52,4645.04) 7590.19,4630.37 7590.19,4426.37 v1(7585.19,4421.37) ; v1@7581.3,4425.26 ccw(c7559.84,4446.72) 7590.19,4446.72 ; v1@7624.23,557.88 cw(c7610.96,557.88) 7620.35,548.49 cw(c7629.73,539.1) v1@7629.73,552.38 ; v1@7629.73,563.38 ccw(c7629.73,576.66) 7639.12,567.27 ccw(c7648.51,557.88) v1@7635.23,557.88 ; v1@7661.18,3296.18 C246.2@7695.39,3296.18 ; v1(7661.18,3406.18) C245.2@7695.39,3406.18 C245.2@7694.21,3405 ; v1@7665.07,3292.48 cw(c7673.99,3283.56) 7673.99,3296.18 ; v1@7665.07,3300.26 ccw(c7674.92,3310.12) 7674.92,3296.18 ; v1@7665.07,3402.29 cw(c7674.46,3392.9) 7674.46,3406.18 cw(c7674.46,3419.46) v1@7665.07,3410.07 ; C246.2@7691.28,3292.07 ccw(c7681.36,3282.15) 7681.36,3296.18 ccw(c7681.36,3310.21) C246.2@7691.28,3300.29 ; C245.2@7691.28,3402.07 ccw(c7681.36,3392.15) 7681.36,3406.18 ccw(c7681.36,3420.21) C245.2@7691.28,3410.29 ; C246.2@7695.39,3291.71 C246.2@7699.52,3291.71 ; C228.2@7699.55,4682.11 ccw(c7689.63,4692.03) 7703.66,4692.03 ccw(c7717.69,4692.03) C228.2@7707.77,4682.11 ; C227.2@7699.55,4783.89 cw(c7689.63,4773.97) 7703.66,4773.97 cw(c7717.69,4773.97) C227.2@7707.77,4783.89 ; C228.2@7703.66,4678 7703.66,4740 ; C227.2@7703.66,4788 7703.66,4740 ; C360.2@7707.56,1759.86 ccw(c7697.64,1769.78) 7711.67,1769.78 ccw(c7725.7,1769.78) C360.2@7715.78,1759.86 ; C361.2@7707.56,1794.39 cw(c7697.64,1784.47) 7711.67,1784.47 cw(c7725.7,1784.47) C361.2@7715.78,1794.39 ; C361.2@7707.56,1802.61 ccw(c7697.64,1812.53) 7711.67,1812.53 ccw(c7725.7,1812.53) C361.2@7715.78,1802.61 ; C362.2@7707.56,1837.14 cw(c7697.64,1827.22) 7711.67,1827.22 cw(c7725.7,1827.22) C362.2@7715.78,1837.14 ; C362.2@7707.56,1845.36 ccw(c7697.64,1855.28) 7711.67,1855.28 ccw(c7725.7,1855.28) C362.2@7715.78,1845.36 ; C359.2@7707.56,1879.89 cw(c7697.64,1869.97) 7711.67,1869.97 cw(c7725.7,1869.97) C359.2@7715.78,1879.89 ; C360.2@7711.67,1755.75 C361.2@7711.67,1798.5 C362.2@7711.67,1841.25 C359.2@7711.67,1884 7725.15,1884 ; C359.2@7715.89,1880.01 cw(c7725.15,1871.26) 7725.15,1884 ; C359.2@7715.89,1887.99 ccw(c7725.15,1896.74) 7725.15,1884 ; U49.1@7719.07,1506.69 7806.69,1506.69 7815.19,1515.19 v1(7815.19,1595.04) ; U49.1@7733.62,1492.14 cw(c7768.75,1457.02) 7768.75,1506.69 cw(c7768.75,1556.36) U49.1@7733.62,1521.24 ; v1@7758.3,4748.15 ccw(c7748.91,4738.76) 7748.91,4752.04 ccw(c7748.91,4765.32) v1@7758.3,4755.93 ; v1(7762.19,4752.04) 7728.86,4752.04 7717.86,4741.04 7704.7,4741.04 7703.66,4740 ; 7789.31,1884 ccw(c7789.31,1900.69) v1@7801.11,1888.89 ; v1@7803.56,1884 7764.85,1884 7725.15,1884 ; v1@7811.3,1591.15 cw(c7801.91,1581.76) 7815.19,1581.76 cw(c7828.47,1581.76) v1@7819.08,1591.15 ; C254.2@7831.28,3300.29 ccw(c7821.36,3310.21) 7835.39,3310.21 ccw(c7849.42,3310.21) C254.2@7839.5,3300.29 ; C253.2@7831.28,3402.07 cw(c7821.36,3392.15) 7835.39,3392.15 cw(c7849.42,3392.15) C253.2@7839.5,3402.07 ; v1@7831.64,3341.15 cw(c7822.58,3332.1) 7835.39,3332.1 ; v1@7831.64,3348.93 ccw(c7822.58,3357.99) 7835.39,3357.99 ; C254.2@7835.39,3296.18 7835.39,3344.9 v1(7835.52,3345.04) 7835.39,3345.18 C253.2@7835.39,3406.18 ; 7835.39,3331.43 cw(c7849.14,3331.43) v1@7839.41,3341.15 ; 7835.39,3358.65 ccw(c7849.14,3358.65) v1@7839.41,3348.93 ; C248.2@7839.55,4682.11 ccw(c7829.63,4692.03) 7843.66,4692.03 ccw(c7857.69,4692.03) C248.2@7847.77,4682.11 ; C248.2@7843.66,4678 7843.66,4705.9 7843.8,4706.04 v1(7868.52,4706.04) ; v1@7864.64,4702.15 ccw(c7855.25,4692.76) 7855.25,4706.04 ccw(c7855.25,4719.32) v1@7864.64,4709.93 ; C247.2@7880.89,4792.11 ccw(c7870.97,4802.03) 7885,4802.03 ccw(c7899.03,4802.03) C247.2@7889.11,4792.11 ; v1@7881.3,4816.49 cw(c7872.37,4807.56) 7885,4807.56 ; v1@7881.86,4823.71 v1@7885,4820.56 ; C247.2@7885,4788 7885,4820.37 v1@7885,4820.56 ; 7885,4806.64 cw(c7898.93,4806.64) v1@7889.08,4816.49 ; v1(7885.19,4820.37) v1@7885,4820.56 ; U4.3@7888.49,2362.77 ccw(c7878.57,2372.69) 7892.6,2372.69 ccw(c7906.63,2372.69) U4.3@7896.71,2362.77 ; U4.3@7892.6,2344.88 7892.6,2397.78 v1(7906.86,2412.04) ; C39.1@7905.22,2514.11 ccw(c7891.21,2528.12) 7911.02,2528.12 ; C39.1@7909.33,2510 7911.02,2511.69 7911.02,2547.07 7914.66,2550.71 v1(7914.86,2550.71) ; 7911.02,2528.18 cw(c7937.39,2528.18) v1@7918.75,2546.82 ; v1@7992.52,3799.21 cw(c7992.52,3785.76) 8002.04,3795.27 ; v1(7992.52,3804.71) 7992.6,3804.71 8063.63,3733.67 U70.4@8111.26,3733.67 ; v1@7998.02,3804.71 ccw(c8011.13,3804.71) 8001.86,3795.44 ; D7.1@8124.12,2749.06 ccw(c8104.11,2769.06) 8132.4,2769.06 ccw(c8160.69,2769.06) D7.1@8140.69,2749.06 ; v1@8126.9,2793.42 8124.74,2795.59 8124.65,2795.59 8125.19,2795.04 v1(8125.19,2791.71) 8125.19,2777.21 8132.4,2770 D7.1@8132.4,2739.79 ; -239.81,2665 -223.5,2648.69 -223.5,2626.09 -233,2616.59 ; v1@2435,5141.71 2435.19,5141.71 v1(2435.19,5136.71) 2432.52,5139.37 2434.86,5141.71 v1@2435,5141.71 ; v1@2435,5141.71 2434,5142.71 R41.2@2434,5163.82 2435,5163.82 v1@2435,5141.71 ; 2435.67,5715.97 ccw(c2421.64,5715.97) 2431.56,5725.89 cw(c2421.64,5715.97) 2435.67,5715.97 ; 2435.67,5715.97 cw(c2449.7,5715.97) 2439.78,5725.89 ccw(c2449.7,5715.97) 2435.67,5715.97 ; C47.1@2435.67,5775.04 2438.15,5777.52 C47.1@2440.63,5780 ; C47.1@2435.67,5775.04 C47.1@2435.67,5780 C47.1@2440.63,5780 ; 2445,5455 2445,5500 ; U38.3@4319.14,6137.23 cw(c4309.21,6127.31) 4323.24,6127.31 cw(c4337.27,6127.31) U38.3@4327.35,6137.23 ; U38.3@4319.14,6137.23 cw(c4308.54,6126.63) 4323.52,6126.63 ccw(c4308.54,6126.63) U38.3@4319.14,6137.23 ; U38.3@4327.35,6137.23 ccw(c4336.6,6127.99) 4323.52,6127.99 cw(c4336.6,6127.99) U38.3@4327.35,6137.23 ; 5235,5788.21 5263.21,5788.21 ; 5573.96,2216.71 5587.52,2203.14 ; 5573.96,2216.71 5587.52,2203.14 ; 5587.52,2203.14 5587.52,2070 5587.52,2046.52 5608.93,2025.11 ; 5587.52,2203.14 C338.2@5610,2180.67 5587.52,2203.14 ; C338.2@5600.08,2190.59 ccw(c5610,2200.51) 5610,2186.48 cw(c5610,2200.51) C338.2@5600.08,2190.59 ; C338.2@5600.08,2190.59 cw(c5590.16,2180.67) 5604.19,2180.67 ccw(c5590.16,2180.67) C338.2@5600.08,2190.59 ; 5608.93,2025.11 5608.86,2025.04 5609,2025.04 ; 5608.93,2025.11 5609,2025.04 ; 5609,2025.04 5610,2024.04 ; 5609,2025.04 5610,2024.04 ; v1@5739.52,6058.37 5740.36,6059.21 5764.52,6083.37 5764.52,6135.41 5770.82,6141.71 ; v1@6006.9,3775 v1@6010,3775 ; v1@6006.86,3775.04 v1@6006.9,3775 ; v1@6006.86,3775.04 v1@6006.86,3778.14 ; v1@6006.86,3778.14 v1@6010,3775 ; 6122.52,4667.43 cw(c6135.8,4667.43) 6126.41,4676.82 ccw(c6135.8,4667.43) 6122.52,4667.43 ; 6122.52,4667.43 ccw(c6109.25,4667.43) 6118.64,4676.82 cw(c6109.25,4667.43) 6122.52,4667.43 ; 6130,4655.75 6115.9,4655.75 6115.9,4674.08 v1(6122.52,4680.71) 6122.52,4663.22 6130,4655.75 ; 6681.86,6425 6690.19,6433.33 ; 7322.37,1022.37 7365.19,1022.37 ; 7348.52,4625.04 7362.52,4625.04 7385.19,4602.37 ; 5765.93,6136.82 cw(c5780.25,6122.5) 5783.05,6142.55 ccw(c5780.25,6122.5) 5765.93,6136.82
  Bottom Layer w19: v3(5153.78,4150.63) C345.2@5153.78,4183.76 ; C314.2@5193.15,4210.67 v3(5193.15,4229.37) ; v3(5232.52,4150.63) C302.2@5232.52,4169.33 ; C296.2@5267.61,4067.61 cw(c5257.27,4057.27) C296.2@5271.89,4057.27 ; v3(5271.89,4032.52) C296.2@5271.89,4065.65 ; C268.2@5271.89,4210.67 v3(5271.89,4229.37) ; C297.2@5298,4282 v3(5311.26,4268.74) ; v3(5311.26,4150.63) C274.2@5311.26,4169.33 ; v3(5350.63,4032.52) C317.2@5369.33,4032.52 ; v3(5350.63,4111.26) C316.2@5369.33,4111.26 ; C275.2@5350.63,4202.92 cw(c5375.47,4202.92) C298.2@5369.85,4227.12 ; C275.2@5350.63,4210.67 v3(5350.63,4229.37) C298.2@5369.33,4229.37 ; v3(5350.63,4308.11) C300.2@5369.33,4308.11 ; v3(5350.63,4386.85) 5390,4386.85 C353.2@5390,4425.24 ; C357.2@5390,3954.76 5390,3993.15 v3(5429.37,3993.15) ; C318.2@5410.67,4071.89 v3(5429.37,4071.89) ; C273.2@5410.67,4150.63 v3(5429.37,4150.63) C270.2@5429.37,4169.33 ; C301.2@5410.67,4268.74 v3(5429.37,4268.74) ; C299.2@5410.67,4347.48 v3(5429.37,4347.48) ; v3(5468.74,4111.26) C295.2@5482,4098 ; C269.2@5468.74,4210.67 v3(5468.74,4229.37) ; v3(5508.11,4150.63) C272.2@5508.11,4169.33 ; C313.2@5508.11,4314.35 v3(5508.11,4347.48) ; C313.2@5508.11,4322.73 ccw(c5522.73,4322.73) C313.2@5512.39,4312.39 ; C271.2@5547.48,4210.67 v3(5547.48,4229.37) ; v3(5586.85,4150.63) C315.2@5586.85,4169.33 ; C349.2@5626.22,4196.24 v3(5626.22,4229.37)
  Bottom Layer w20: v1(4811,3653) C327.2@4811,3686.92 ; v1(4988.86,4815.04) 4996.19,4822.37 5055,4822.37 ; v1@4989.92,4813.98 cw(c5010.18,4793.71) 5010.18,4822.37 ; C331.2@5056.34,3590 5080.15,3590 v1(5090.19,3600.04) ; C308.2@5056.34,4790 5056.34,4821.04 5055,4822.37 ; C331.2@5062.33,3590 ccw(c5062.33,3627.9) v1@5089.13,3601.1 ; v1(5094.52,4822.37) 5055,4822.37 ; v1@5166.94,4812.94 cw(c5148.81,4794.81) C292.2@5174.45,4794.81 ; v1(5168,4814) 5174.45,4807.55 C292.2@5174.45,4790
  other v1: 6163,170 5955,280 4395,295 4130,305 4670,315 885,480 5174.79,494.61 5245,494.61 5814.79,494.61 5885,494.61 5494.79,495 5565,495 5250.17,576.71 5890.17,576.71 5570.17,577.1 5250.17,646.92 5570.17,647.31 5890.17,646.92 1335,675 995,680 310,685 435,690 5250.17,725.66 5890.17,725.66 5570.17,726.05 2115,735 5147,818 7348,1013 7383.52,1116.71 4115,1175 784.17,1181.5 75,1245 840,1275 170,1325 5450,1364.88 3770,1406.01 3770,1428.51 3309.02,1438.07 3331.52,1438.07 3354.02,1438.07 4180,1438.07 4202.5,1438.07 4225,1438.07 3770,1451.01 779.17,1462.5 835,1462.5 1864.17,1462.5 1920,1462.5 2949.17,1462.5 3005,1462.5 779.17,1485 835,1485 1864.17,1485 1920,1485 2949.17,1485 3005,1485 5082.52,1491.71 779.17,1507.5 835,1507.5 1864.17,1507.5 1920,1507.5 2949.17,1507.5 3005,1507.5 3309.02,1541.93 3331.52,1541.93 3354.02,1541.93 4180,1541.93 4202.5,1541.93 4225,1541.93 125,1590.98 1106.14,1590.98 1210,1590.98 2191.14,1590.98 2295,1590.98 3546,1597.5 3572,1597.5 3597.99,1597.5 3938.01,1597.5 3964,1597.5 3990,1597.5 125,1613.48 1106.14,1613.48 1210,1613.48 2191.14,1613.48 2295,1613.48 -545,1615 5080,1615 6104,1629 125,1635.98 1106.14,1635.98 1210,1635.98 2191.14,1635.98 2295,1635.98 4347,1660 4515,1660 50.08,1664.92 72.58,1664.92 95.08,1664.92 3526,1682.01 4010,1682.01 3259.02,1708 3285.02,1708 3526,1708.01 4010,1708.01 -460,1730 4789,1731 3259.02,1733 3285.02,1733 4010,1734 5024,1743 3259.02,1758 3285.02,1758 4010,1760 3285.02,1858 3311.01,1858 3337.01,1858 3363,1858 3389,1858 3415,1858 3440.99,1858 3466.99,1858 3259.02,1883 3285.02,1883 3311.01,1883 3337.01,1883 3363,1883 3389,1883 3415,1883 3440.99,1883 3466.99,1883 3526,1889.98 4029.02,1900 4055.02,1900 4081.01,1900 4107.01,1900 4133,1900 4159,1900 4185,1900 3259.02,1908 3285.02,1908 3311.01,1908 3337.01,1908 3363,1908 3389,1908 3415,1908 3440.99,1908 3466.99,1908 3526,1915.98 4029.02,1925 4055.02,1925 4081.01,1925 4107.01,1925 4133,1925 4159,1925 4185,1925 3526.01,1941.97 747.01,1954.88 769.51,1954.88 792.01,1954.88 1832.01,1954.88 1854.51,1954.88 1877.01,1954.88 3386.46,1954.88 3408.96,1954.88 3431.46,1954.88 4107.01,1954.88 4129.51,1954.88 4152.01,1954.88 3001.3,1992.64 1106.14,2010 1210,2010 2191.14,2010 2295,2010 21.14,2010.98 125,2010.98 3001.3,2015.14 1106.14,2032.5 1210,2032.5 2191.14,2032.5 2295,2032.5 21.14,2033.48 125,2033.48 3001.3,2037.64 3474.99,2045.96 3526.01,2045.96 4009.99,2045.96 4034.99,2045.96 4059.99,2045.96 3284.02,2053 3310.02,2053 3336.01,2053 1106.14,2055 1210,2055 2191.14,2055 2295,2055 21.14,2055.98 125,2055.98 6368.52,2066.71 3474.99,2071.95 3526.01,2071.95 4009.99,2071.95 4034.99,2071.95 4059.99,2071.95 747.01,2076.93 769.51,2076.93 792.01,2076.93 1832.01,2076.93 1854.51,2076.93 1877.01,2076.93 2917.01,2076.93 2939.51,2076.93 2962.01,2076.93 3386.46,2076.93 3408.96,2076.93 3431.46,2076.93 4107.01,2076.93 4129.51,2076.93 4152.01,2076.93 3284.02,2078 3310.02,2078 3336.01,2078 5020,2080 3474.99,2097.95 3526.01,2097.95 4009.99,2097.95 4034.99,2097.95 4059.99,2097.95 3284.02,2103 3310.02,2103 3336.01,2103 4775,2110 7620,2110 4335,2115 4630,2120 3474.99,2123.94 3526.01,2123.94 4009.99,2123.94 4034.99,2123.94 4059.99,2123.94 4920,2140 3545,2145 3571,2145 3596.99,2145 3622.99,2145 3648.98,2145 3674.98,2145 3700.98,2145 3726.97,2145.01 3752.97,2145.01 3778.96,2145.01 3804.96,2145.01 3830.96,2145.01 3856.95,2145.01 3882.95,2145.01 3908.94,2145.01 3934.94,2145.01 3960.94,2145.01 3986.93,2145.01 2052,2152 1030,2180 6578.52,2238.37 1290,2240 -531,2271 8125,2300 3893.94,2338.94 1225,2355 805,2365 375,2395 7406,2408 3281,2414 975,2445 1085,2450 5305,2475 6406,2478 1560,2480 1635,2480 1835,2485 7660,2490 2885,2525 2735,2605 7940,2695 1330,2775 7415,2780 5302.8,2854.3 2530,2865 4374,2866 700,2970 1685,2980 2510,2995 3740,3055 3300,3105 7930,3110 619.35,3143.04 650.85,3143.04 2068.17,3143.04 2099.67,3143.04 2131.17,3143.04 3135,3150 2665,3175 1255,3230 3425,3230 1585,3265 3275,3270 7661.18,3296.37 -90,3344 4161.86,3500.04 5890,3549 7350,3605 7421.86,3608.37 -83,3639 4864.5,3647.5 4723,3814.5 6038,3856 4691.77,3923.72 4760,4058 3810,4075 3495,4315 45,4360 3225,4435 4550,4455 3695,4510 4060,4510 565,4563 1745,4650 -40,4655 3670,4660 4090,4695 2236,4723 535,4730 6015.5,4755 2302,4764 5245,4790 7025,4860 635,4870 852,4886 7573.52,4920.04 2770,4940 4420,5015 7165,5035 525,5045 760,5070 1115,5095 7265.19,5133.37 7385,5155 3280,5220 3301.57,5220 3485,5220 3506.57,5220 7330,5220 3263.19,5247.6 3318.39,5247.6 3468.19,5247.6 3523.39,5247.6 3280,5275.2 3301.57,5275.2 3485,5275.2 3506.57,5275.2 3485,5356 3506.57,5356 3280,5365 3301.57,5365 3523.39,5374.6 3263.19,5392.6 3318.39,5392.6 3523.39,5402.6 3689,5403 3280,5420.2 3301.57,5420.2 3485,5421.2 3506.57,5421.2 2877,5425 5484.37,5465 3685,5483.57 3910,5516.37 540,5525 7440,5540 3861.86,5586.9 4325,5670 7840,5725 580,5750 2490,5780 7885,5780 7695,5795 5135.19,5804.04 7770,5810 3265,5860 -435,5870 7800,5890 7160,5945 7575,5970 -100,5985 7765,5990 810,6035 6372.5,6045.19 39.01,6147.63 5780,6245 3880,6295 6690,6500
  other v2: 4865,812 7058.62,1210 7092,1229 6880,1265 5846,1702 7546,2010 7172.38,2274.37 7448,2321.19 7175,2330 -112,2446 3485,2705 5567,2748 1040,2962 -488,3305 5690,3351.71 -469,3403 5790,3560 4977,3589 6015,3745 4726,4074 6085,4075 4721.75,4125.62 4530,4130 4500,4220 4734,4267 5999,4890 5305,5115 7764.51,5149.9 7789.61,5149.9 7814.7,5149.9 7839.8,5149.9 7864.8,5150 7764.51,5169.9 7789.61,5169.9 7814.7,5169.9 7839.8,5169.9 7864.8,5170 5074.13,5546.38 5121.38,5546.38 5215.87,5546.38 5074.13,5593.62 5121.38,5593.62 5215.87,5593.62 5074.13,5640.87 5121.38,5640.87 5215.87,5640.87 -210,5800 -185,5800
  other v4: 7528.27,935.66
  other v6: 7325.51,655.51 7372.76,655.51 7420,655.51 7467.24,655.51 7514.49,655.51 7325.51,702.76 7372.76,702.76 7420,702.76 7467.24,702.76 7514.49,702.76 7325.51,750 7372.76,750 7420,750 7467.24,750 7514.49,750 7325.51,797.24 7372.76,797.24 7420,797.24 7467.24,797.24 7514.49,797.24 7325.51,844.49 7372.76,844.49 7420,844.49 7467.24,844.49 7514.49,844.49 6515.51,6040.51 6562.76,6040.51 6610,6040.51 6657.24,6040.51 6704.49,6040.51 6515.51,6087.76 6562.76,6087.76 6610,6087.76 6657.24,6087.76 6704.49,6087.76 6515.51,6135 6562.76,6135 6610,6135 6657.24,6135 6704.49,6135 6515.51,6182.24 6562.76,6182.24 6610,6182.24 6657.24,6182.24 6704.49,6182.24 6515.51,6229.49 6562.76,6229.49 6610,6229.49 6657.24,6229.49 6704.49,6229.49
  other v7: -755.79,1925 8515,2090 8540,2345 3790,3430 3770,3505 8455,4065 -815,5200 -615,5515 8545,5760 -540,6050 1630,6140 8270,6140 -590,6150 225,6825
  other v11: 5941.18,3638.82 4838.82,4741.18 5941.18,4741.18
GOLD_FLASH.FLASH_CS_N: R159.1 U30.A5 U50.1 U69.1 | length 7852.5
  Top Layer w4: U50.1@5655,1920 5704.52,1920 ; U50.1@5694.83,1914.29 cw(c5704.52,1908.92) 5704.52,1920 ; U50.1@5694.83,1925.71 ccw(c5704.52,1931.08) 5704.52,1920 ; 5713.71,1925.04 cw(c5713.71,1902.04) v1@5729.97,1918.3 ; 5713.8,1925.04 ccw(c5713.8,1947.91) v1@5729.97,1931.74 ; 5723.37,1925.04 cw(c5723.37,1911.7) v1@5732.8,1921.13 ; 5723.46,1925.04 ccw(c5723.46,1938.25) v1@5732.8,1928.91 ; v1@5736.69,1925.04 5709.57,1925.04 5704.52,1920 ; v2(6710,2334) 6726,2350 6739.52,2350 6782,2350 6797.79,2334.21 6841.44,2334.21 6872.2,2303.44 U30.A5@6872.2,2160.28 ; v2@6710.19,2339.81 ccw(c6710.6,2352.35) 6719.48,2343.48 ccw(c6728.35,2334.6) v2@6715.81,2334.19 ; v2@6710.32,2343.81 ccw(c6711.02,2364.98) 6726,2350 ccw(c6740.98,2335.02) v2@6719.81,2334.32 ; U30.A5@6867.01,2165.47 ccw(c6854.48,2178) 6872.2,2178 ccw(c6889.93,2178) U30.A5@6877.4,2165.47 ; v2@7181.06,2555.06 cw(c7173.97,2547.97) 7184,2547.97 cw(c7202.03,2547.97) v2@7189.28,2560.72 ; 7184,2528.66 cw(c7221.34,2528.66) v2@7194.94,2555.06 ; 7184,2538.31 cw(c7211.69,2538.31) v2@7192.11,2557.89 ; v2@7184,2558 7184,2500 7184,2492.05 v2@7232.05,2444 ; v2@7223.5,2442.74 ccw(c7199.81,2442.74) 7216.56,2459.49 ccw(c7233.31,2476.24) v2@7233.31,2452.55 ; v2@7227.5,2442.74 ccw(c7213.47,2442.74) 7223.39,2452.66 ccw(c7233.31,2462.58) v2@7233.31,2448.55 ; R159.1@7714.59,4842.92 cw(c7698.68,4827.01) 7721.18,4827.01 cw(c7743.68,4827.01) R159.1@7727.77,4842.92 ; R159.1@7715.25,4857.68 ccw(c7703.44,4872) 7722,4872 ; R159.1@7717.42,4845.75 cw(c7708.34,4836.67) 7721.18,4836.67 cw(c7734.02,4836.67) R159.1@7724.94,4845.75 ; R159.1@7717.8,4854.59 ccw(c7710.44,4863.51) 7722,4863.51 ; R159.1@7721.18,4850 7721.18,4715.18 7670.52,4664.52 7670.52,4299.69 7678.84,4291.37 7802.63,4291.37 7823.19,4270.81 7823.19,3576.81 7862,3538 7862,3486 7865.19,3482.81 7865.19,3377.69 7861.02,3373.52 7861.02,3334.48 ; R159.1@7722,4852 7722,4872 7735,4885 ; 7722,4871.01 ccw(c7741.7,4871.01) R159.1@7727.77,4857.08 ; 7736.73,4885 ccw(c7736.73,4905.27) v2@7751.06,4890.94 ; 7743.51,4885 cw(c7743.51,4871.99) v2@7753.53,4880.29 ; v2@7750.45,4877.74 ccw(c7735,4864.94) 7735,4885 ; v2@7758,4885 7735,4885 ; 7861.02,3355.6 7861.02,3334.48 ; v2@7861.19,2626 7865.19,2622 7865.19,2626 7865.19,2892 7857.19,2900 7857.19,3330.64 7861.02,3334.48
  MidLayer1 w4: v1@6400.14,1998.43 ccw(c6383.92,2014.64) 6406.86,2014.64 ccw(c6429.79,2014.64) v1@6413.57,1998.43 ; v1@6402.97,1995.6 ccw(c6393.58,2004.99) 6406.86,2004.99 ccw(c6420.14,2004.99) v1@6410.75,1995.6 ; v1(6406.86,1991.71) 6406.86,2042.17 6585.56,2220.87 ; 6585.77,2220.87 6644,2279.1 6644,2299 6679,2334 v2(6710,2334) 6744,2334 6760,2350 6760,2378 v2(6740,2398) ; v2@6703.06,2327.06 ccw(c6686.31,2310.31) 6686.31,2334 ccw(c6686.31,2357.69) v2@6703.06,2340.94 ; v2@6705.89,2329.89 ccw(c6695.97,2319.97) 6695.97,2334 ccw(c6695.97,2348.03) v2@6705.89,2338.11 ; v2@6714.11,2329.89 cw(c6724.03,2319.97) 6724.03,2334 cw(c6724.03,2348.03) v2@6714.11,2338.11 ; v2@6716.94,2327.06 cw(c6733.69,2310.31) 6733.69,2334 cw(c6733.69,2357.69) v2@6716.94,2340.94 ; v2@6740,2388.19 cw(c6740,2364.5) 6756.75,2381.25 cw(c6773.5,2398) v2@6749.81,2398 ; v2@6740,2392.19 cw(c6740,2378.16) 6749.92,2388.08 cw(c6759.84,2398) v2@6745.81,2398 ; v2(7758,4884) 7791,4884 7813.36,4906.36 7813.36,4951.68 ; v2@7762.11,4879.89 cw(c7772.03,4869.97) 7772.03,4884 cw(c7772.03,4898.03) v2@7762.11,4888.11 ; v2@7764.94,4877.06 cw(c7781.69,4860.31) 7781.69,4884 cw(c7781.69,4907.69) v2@7764.94,4890.94 ; 7813.36,4950 7813.36,4988.36 v2(7850,5025) ; v2@7840.19,5025 cw(c7816.5,5025) 7833.25,5008.25 cw(c7850,4991.5) v2@7850,5015.19 ; v2@7844.19,5025 cw(c7830.16,5025) 7840.08,5015.08 cw(c7850,5005.16) v2@7850,5019.19
  MidLayer2 w4: v2(7850,5025) 7895,5025 7945,4975 8125,4975 8135,4965 v1(8135,4905) ; v2@7854.11,5020.89 cw(c7864.03,5010.97) 7864.03,5025 cw(c7864.03,5039.03) v2@7854.11,5029.11 ; v2@7856.94,5018.06 cw(c7873.69,5001.31) 7873.69,5025 cw(c7873.69,5048.69) v2@7856.94,5031.94 ; v1@8128.28,4911.72 ccw(c8112.06,4927.93) 8135,4927.93 ccw(c8157.94,4927.93) v1@8141.72,4911.72 ; v1@8131.11,4908.89 ccw(c8121.72,4918.28) 8135,4918.28 ccw(c8148.28,4918.28) v1@8138.89,4908.89
  Bottom Layer w4: v1@5736.69,1930.52 ccw(c5736.69,1953.05) 5752.62,1937.12 ; v1@5736.69,1934.52 ccw(c5736.69,1966.71) 5759.45,1943.95 ; v1@5740.52,1925.02 5763.51,1948.01 5770,1948.01 5784.81,1948.01 5800.42,1963.62 5806.61,1969.81 6261.37,1969.81 6267.56,1963.62 6293,1938.19 6330,1938.19 6345.38,1938.19 6400,1938.19 6406.86,1945.05 v1(6406.86,1991.71) ; v1@5746.19,1925.02 cw(c5759.88,1925.02) 5750.2,1934.7 ; v1@6400.14,1984.99 cw(c6383.92,1968.77) 6406.86,1968.77 cw(c6429.79,1968.77) v1@6413.57,1984.99 ; v1@6402.97,1987.82 cw(c6393.58,1978.43) 6406.86,1978.43 cw(c6420.14,1978.43) v1@6410.75,1987.82 ; v2(6740,2398) 6901.19,2398 6941.81,2438.62 6941.81,2453.38 6927.26,2467.93 6904.5,2490.69 6904.5,2530.81 6929.69,2556 6932.19,2558.5 6956.12,2558.5 7009.06,2558.5 7022.06,2571.5 7037.44,2571.5 7065.12,2571.5 7088.12,2548.5 7105,2548.5 7115.88,2548.5 7174.5,2548.5 v2(7188,2562) ; v2@6744.11,2393.89 cw(c6754.03,2383.97) 6754.03,2398 cw(c6754.03,2412.03) v2@6744.11,2402.11 ; v2@6746.94,2391.06 cw(c6763.69,2374.31) 6763.69,2398 cw(c6763.69,2421.69) v2@6746.94,2404.94 ; v2(7233.31,2442.74) 7257.5,2466.93 7257.5,2516.74 ; v2@7233.31,2448.55 ccw(c7233.31,2462.58) 7243.23,2452.66 ccw(c7253.15,2442.74) v2@7239.12,2442.74 ; v2@7233.31,2452.55 ccw(c7233.31,2476.24) 7250.06,2459.49 ccw(c7266.81,2442.74) v2@7243.12,2442.74 ; 7257.5,2489.25 7257.5,2516.74 ; 7835.66,2644.34 ccw(c7856.26,2664.94) v2@7856.3,2635.81 ; 7841.2,2638.8 cw(c7828.39,2626) v2@7846.5,2626 ; 7842.47,2637.53 ccw(c7856.28,2651.33) v2@7856.3,2631.81 ; v2@7854,2626 7834.5,2645.5 7794.44,2645.5 7787.75,2638.81 7738.82,2638.81 7704,2638.81 7689,2653.81 7651,2653.81 7614.68,2617.5 7597.75,2617.5 7594.75,2620.5 7540.25,2620.5 7532.25,2612.5 7512.69,2612.5 7487.38,2637.81 7484,2641.19 7441.07,2641.19 7372.18,2572.31 7313.06,2572.31 7257.5,2516.74 ; U69.1@8098.58,4755.7 8098.58,4768.58 8135,4805 v1(8135,4905) ; U69.1@8100.45,4764.56 cw(c8114.68,4764.56) 8104.62,4774.62 ; U69.1@8104.45,4764.56 cw(c8128.34,4764.56) 8111.45,4781.45 ; v1@8128.28,4898.28 cw(c8112.06,4882.06) 8135,4882.06 cw(c8157.94,4882.06) v1@8141.72,4898.28 ; v1@8131.11,4901.11 cw(c8121.72,4891.72) 8135,4891.72 cw(c8148.28,4891.72) v1@8138.89,4901.11
  other v1: 5736.69,1925.02
  other v2: 7856.31,2626
HOST_AUDIO.L: R1.1 U30.G2 | length 9561.1
  Top Layer w4: v1(6565.19,1941.71) 6585.29,1961.81 6621.38,1961.81 6631.81,1951.38 6631.81,1950.19 6642.44,1939.56 6734.38,1939.56 ; v1@6565.19,1947.21 ccw(c6565.19,1960.49) 6574.58,1951.1 ccw(c6583.97,1941.71) v1@6570.69,1941.71 ; v1@6565.19,1951.21 ccw(c6565.19,1974.14) 6581.41,1957.93 ccw(c6597.63,1941.71) v1@6574.69,1941.71 ; 6734.38,1939.56 cw(c6734.38,1929.41) 6741.56,1936.59 ; 6734.38,1939.56 cw(c6734.38,1929.41) 6741.56,1936.59 ; 6741.56,1936.59 cw(c6729.03,1924.05) 6746.75,1924.05 ccw(c6729.03,1924.05) 6741.56,1936.59 ; 6741.56,1936.59 ccw(c6754.09,1949.12) 6754.09,1931.4 cw(c6754.09,1949.12) 6741.56,1936.59
  MidLayer1 w4: v1@-156.19,3851.66 cw(c-172.41,3835.44) -149.48,3835.44 cw(c-126.54,3835.44) v1@-142.76,3851.66 ; v1@-153.36,3854.49 cw(c-162.75,3845.1) -149.48,3845.1 cw(c-136.2,3845.1) v1@-145.59,3854.49 ; v1(-149.48,3858.37) -149.48,3694.33 -283.81,3560 -283.81,3387.7 -472.5,3199.01 -472.5,3052.25 -500.19,3024.56 -500.19,2595.44 -254.25,2349.5 v1@-101.02,2349.5 ; -124.72,2349.5 ccw(c-124.72,2374.28) v1@-107.19,2356.76 ; -122.11,2349.5 cw(c-122.11,2328.41) v1@-107.19,2343.32 ; -115.06,2349.5 ccw(c-115.06,2364.62) v1@-104.36,2353.93 ; -112.45,2349.5 cw(c-112.45,2338.07) v1@-104.36,2346.15 ; v1(6565.19,1941.71) v1@6568.29,1941.71
  MidLayer2 w4: v1@-100.48,2340.54 cw(c-100.48,2317.61) -84.26,2333.82 cw(c-68.04,2350.04) v1@-90.98,2350.04 ; v1@-100.48,2344.54 cw(c-100.48,2331.26) -91.09,2340.65 cw(c-81.7,2350.04) v1@-94.98,2350.04 ; v1(-100.48,2350.04) -50.44,2300 1001.31,2300 1036.31,2265 1161.31,2265 1188.69,2292.37 1412.63,2292.37 1485,2220 1535.92,2220 1549.21,2233.29 1591.92,2276 1630.29,2276 1631.08,2275.21 1649.3,2275.21 1650.09,2276 2216.62,2276 2226.12,2266.5 2253.88,2266.5 2265.88,2278.5 3368.88,2278.5 3441.38,2206 4695.71,2206 4710,2191.71 4710.5,2191.21 4767.42,2191.21 4982.36,2191.21 5015.19,2158.37 5153.88,2158.37 5422.38,1889.87 5710.6,1889.87 5713.83,1893.1 5740.83,1893.1 5779.74,1932.01 5791.44,1932.01 5797.97,1938.54 5819.03,1938.54 5825.49,1945 6182.88,1945 6209.5,1971.62 6233.53,1971.62 6247.44,1957.71 6308.96,1957.71 ; 6309.1,1957.71 6308.96,1957.71 ; v1@6555.69,1941.71 ccw(c6532.76,1941.71) 6548.97,1957.93 ccw(c6565.19,1974.14) v1@6565.19,1951.21 ; v1@6559.69,1941.71 ccw(c6546.41,1941.71) 6555.8,1951.1 ccw(c6565.19,1960.49) v1@6565.19,1947.21 ; v1(6565.19,1941.71) 6545.09,1961.81 6464,1961.81 6459.72,1957.54 6392.46,1957.54 6372.19,1977.81 6329.06,1977.81 6308.96,1957.71
  Bottom Layer w4: R1.1@-178.82,3851.36 R1.1@-171.81,3858.37 ; R1.1@-177.72,3851.13 cw(c-164.3,3842.32) -164.3,3858.37 ; v1@-156.32,3851.79 ccw(c-171.81,3836.88) R1.1@-171.81,3858.37 ; v1@-156.32,3864.96 cw(c-171.81,3879.87) R1.1@-171.81,3858.37 ; v1@-153.44,3854.56 ccw(c-162.4,3845.93) -162.4,3858.37 ccw(c-162.4,3870.82) v1@-153.44,3862.19 ; v1(-149.48,3858.37) R1.1@-171.81,3858.37
HOST_AUDIO.R: R14.1 U30.F2 | length 10154.3
  Top Layer w4: v2@6614.45,1986.45 ccw(c6631.8,2003.8) 6631.8,1979.27 ; v2(6616,1988) 6616,1986.96 6623.69,1979.27 6734.05,1979.27 6734.38,1978.93 ; v2@6617.28,1989.28 ccw(c6641.45,2013.45) 6641.45,1979.27 ; v2@6620.11,1992.11 ccw(c6651.11,2023.11) 6651.11,1979.27 ; v2@6622.94,1994.94 ccw(c6660.77,2032.77) 6660.77,1979.27 ; 6734.38,1978.93 cw(c6734.38,1968.78) 6741.56,1975.96 ; 6734.38,1978.93 cw(c6734.38,1968.78) 6741.56,1975.96 ; 6741.56,1975.96 cw(c6729.03,1963.42) 6746.75,1963.42 ccw(c6729.03,1963.42) 6741.56,1975.96 ; 6741.56,1975.96 ccw(c6754.09,1988.49) 6754.09,1970.77 cw(c6754.09,1988.49) 6741.56,1975.96
  MidLayer1 w4: v1@825.14,2656.76 ccw(c808.92,2672.98) 831.86,2672.98 ccw(c854.79,2672.98) v1@838.57,2656.76 ; v1@827.97,2653.93 ccw(c818.58,2663.32) 831.86,2663.32 ccw(c845.14,2663.32) v1@835.75,2653.93 ; v1(831.86,2650.04) 831.86,2863.37 840.19,2871.71 840.19,2995 ; 840,2995 840,3030 875.71,3065.71 1018.08,3065.71 1022,3069.63 1022,3148 930,3240 930,4251.9 v1(906.86,4275.04) ; v1@906.86,4265.54 cw(c906.86,4242.61) 923.07,4258.82 cw(c939.29,4275.04) v1@916.36,4275.04 ; v1@906.86,4269.54 cw(c906.86,4256.26) 916.25,4265.65 cw(c925.64,4275.04) v1@912.36,4275.04
  MidLayer2 w4: v1(-110.81,4306.04) 20,4306.04 51,4275.04 v1(906.86,4275.04) ; v1@-106.92,4302.15 cw(c-97.53,4292.76) -97.53,4306.04 cw(c-97.53,4319.32) v1@-106.92,4309.93 ; v1@-104.09,4299.32 cw(c-87.87,4283.11) -87.87,4306.04 cw(c-87.87,4328.98) v1@-104.09,4312.76 ; v1(831.86,2650.04) 1080,2650.04 1146.67,2716.71 1936.98,2716.71 2093.69,2560 3056.27,2560 3096.98,2600.71 3439.29,2600.71 3640.63,2399.37 4156,2399.37 4226.63,2470 4328.94,2470 4349.44,2449.5 4430.81,2449.5 4489.69,2508.38 4489.69,2510.6 4504.63,2525.54 4596.44,2525.54 4628.28,2557.37 4940,2557.37 4948.62,2566 4979,2566 4987.5,2557.5 5221.5,2557.5 5245.63,2533.37 5640.19,2533.37 5682.86,2490.71 5682.86,2206.08 5726.75,2162.19 5984,2162.19 6049.69,2162.19 6063.5,2176 ; v1@835.75,2646.15 cw(c845.14,2636.76) 845.14,2650.04 cw(c845.14,2663.32) v1@835.75,2653.93 ; v1@838.57,2643.32 cw(c854.79,2627.11) 854.79,2650.04 cw(c854.79,2672.98) v1@838.57,2656.76 ; v1@900.14,4268.32 ccw(c883.92,4252.11) 883.92,4275.04 ccw(c883.92,4297.98) v1@900.14,4281.76 ; v1@902.97,4271.15 ccw(c893.58,4261.76) 893.58,4275.04 ccw(c893.58,4288.32) v1@902.97,4278.93 ; 6289.82,2148 6290.91,2149.09 ; v2(6616,1988) 6616,1990.06 6563.52,2042.54 ; 6057.04,2169.55 6063.5,2176 ; 6057.04,2169.55 6063.5,2176 ; 6057.04,2169.55 6063.5,2176 ; 6063.5,2176 6191.5,2176 6220,2147.5 6272.25,2147.5 6289.32,2147.5 6290.91,2149.09 ; 6290.91,2149.09 6309.32,2167.5 6317.32,2175.5 6409.38,2175.5 6542.34,2042.54 ; 6542.34,2042.54 6563.52,2042.54 ; 6542.34,2042.54 6563.52,2042.54
  Bottom Layer w4: R14.1@-176.48,4295.71 -176.48,4295.49 -178.82,4295.49 R14.1@-178.82,4295 -121.85,4295 v1(-110.81,4306.04) ; R14.1@-175.06,4291.24 cw(c-165.98,4282.16) -165.98,4295 cw(c-165.98,4307.84) R14.1@-175.06,4298.76 ; R14.1@-172.23,4288.41 cw(c-156.32,4272.5) -156.32,4295 cw(c-156.32,4317.5) R14.1@-172.23,4301.59
HOST_CLK.CS_N: R30.1 U2.9 U30.P16 | length 3589.9
  Top Layer w4: U30.P16@7305.28,1648.46 7352,1648.46 ; U30.P16@7310.47,1643.27 cw(c7323,1630.74) 7323,1648.46 cw(c7323,1666.19) U30.P16@7310.47,1653.66 ; 7354.33,1648.46 7352,1648.46 ; 7372.36,1648.46 cw(c7372.36,1616.36) v2@7395.06,1639.06 ; 7382.02,1648.46 cw(c7382.02,1626.02) v2@7397.89,1641.89 ; 7384.26,1648.46 ccw(c7384.26,1663.74) v2@7395.06,1652.94 ; v2@7401.54,1648.46 7352,1648.46 ; R30.1@8059.51,3525 8076.48,3525 ; R30.1@8067.38,3520 cw(c8076.48,3514.21) 8076.48,3525 ; R30.1@8067.38,3530 ccw(c8076.48,3535.79) 8076.48,3525 ; v1@8084.18,3520.49 ccw(c8076.52,3516.32) 8076.52,3525.04 ; v1@8084.18,3529.59 cw(c8076.52,3533.76) 8076.52,3525.04 ; v1@8085.81,3531.76 ccw(c8069.59,3547.98) 8092.52,3547.98 ccw(c8115.46,3547.98) v1@8099.24,3531.76 ; v1@8088.64,3528.93 ccw(c8079.25,3538.32) 8092.52,3538.32 ccw(c8105.8,3538.32) v1@8096.41,3528.93 ; U2.9@8090.73,3572.56 cw(c8075.03,3555) 8098.58,3555 ; U2.9@8093.4,3575.54 cw(c8083.03,3563.94) 8098.58,3563.94 cw(c8114.14,3563.95) U2.9@8103.77,3575.54 ; U2.9@8098.58,3581.34 8098.58,3555 ; U2.9@8106.44,3572.56 ccw(c8122.14,3555) 8098.58,3555 ; 8076.52,3525.04 v1(8092.52,3525.04) 8092.52,3548.94 8098.58,3555
  MidLayer1 w4: v1@8085.81,3518.32 ccw(c8069.59,3502.11) 8069.59,3525.04 ccw(c8069.59,3547.98) v1@8085.81,3531.76 ; v1@8088.64,3521.15 ccw(c8079.25,3511.76) 8079.25,3525.04 ccw(c8079.25,3538.32) v1@8088.64,3528.93 ; v1(8092.52,3525.04) 8059.84,3525.04 7997.86,3463.06 7997.86,2615.67 8020,2593.52 8020,2570 8015.48,2565.48 8015.48,2561.66 8015.48,2545 8015.48,2374.67 8008.19,2367.38 8008.19,2301.48 8015.48,2294.19 8015.48,1811.35 8165.19,1661.64 v1(8165.19,1600.04) ; v1@8158.47,1606.76 ccw(c8142.26,1622.98) 8165.19,1622.98 ccw(c8188.13,1622.98) v1@8171.91,1606.76 ; v1@8161.3,1603.93 ccw(c8151.91,1613.32) 8165.19,1613.32 ccw(c8178.47,1613.32) v1@8169.08,1603.93
  MidLayer2 w4: v2@7402,1648 7442,1648 7683,1648 7683.37,1648.37 7709.21,1674.21 7730.44,1674.21 7735.06,1669.59 7911.81,1669.59 7941.22,1699 8131,1699 8165.19,1664.81 v1(8165.19,1600.04) ; v2@7406.11,1641.89 cw(c7420.86,1627.14) 7420.86,1648 cw(c7420.86,1664.86) v2@7408.94,1652.94 ; v2@7408.94,1639.06 cw(c7430.51,1617.49) 7430.51,1648 ; v1@8158.47,1606.76 ccw(c8142.26,1622.98) 8165.19,1622.98 ccw(c8188.13,1622.98) v1@8171.91,1606.76 ; v1@8161.3,1603.93 ccw(c8151.91,1613.32) 8165.19,1613.32 ccw(c8178.47,1613.32) v1@8169.08,1603.93
  other v2: 7402,1646
HOST_CLK.DIN: U2.12 U30.P11 | length 4896.4
  Top Layer w4: U30.P11@7108.43,1641.12 cw(c7108.43,1623.4) 7120.96,1635.93 cw(c7133.49,1648.46) U30.P11@7115.77,1648.46 ; U30.P11@7108.43,1648.46 v3(7128.11,1628.78) ; v1@7631.86,2457.21 cw(c7631.86,2434.27) 7648.07,2450.49 cw(c7664.29,2466.71) v1@7641.36,2466.71 ; v1@7631.86,2461.21 cw(c7631.86,2447.93) 7641.25,2457.32 cw(c7650.64,2466.71) v1@7637.36,2466.71 ; v1(7631.86,2466.71) 7650.56,2448 7696,2448 v2(7708,2460) v2@7706,2460 ; v2@7841,2509 7862.22,2487.78 7862.22,2472.17 7862.22,2427.83 7847.49,2413.1 7847.49,2382.51 7847.49,2374.32 7865.54,2356.28 7865.54,2269.34 7939.67,2195.21 7955.77,2195.21 7969.15,2195.21 7969.36,2195 7974.36,2190 7974.36,2148.61 7891.02,2065.28 7891.02,1990.21 7871.16,1970.35 7864.7,1963.89 7864.7,1945.12 7877.01,1932.81 ; 7877.38,1932.81 7887.81,1922.38 7887.81,1854.81 7872.8,1839.8 7872.8,1788.45 7895.81,1765.44 v2@7895.81,1689.21 ; v2@7887.06,1694.34 ccw(c7865.94,1715.46) 7895.81,1715.46 ; v2@7889.89,1691.51 ccw(c7875.6,1705.8) 7895.81,1705.8 ; 7895.81,1706.71 ccw(c7913.31,1706.71) v2@7900.94,1694.34 ; v1(8041.86,3725.04) 8053.7,3725.04 8060,3731.34 ; U2.12@8065.88,3727.24 ccw(c8060,3725.06) 8060,3731.34 ; U2.12@8065.88,3735.43 cw(c8060,3737.61) 8060,3731.34 ; U2.12@8098.58,3731.34 8060,3731.34 ; 7115.31,1641.58 cw(c7102.5,1628.78) 7120.61,1628.78 ccw(c7102.5,1628.78) 7115.31,1641.58 ; 7115.31,1641.58 ccw(c7128.11,1654.39) 7128.11,1636.28 cw(c7128.11,1654.39) 7115.31,1641.58
  MidLayer1 w4: v3@7126.81,1621.39 cw(c7123.66,1603.56) 7138.5,1613.95 cw(c7153.33,1624.33) v3@7135.5,1627.48 ; 7138.53,1613.92 cw(c7110.49,1596.27) 7143.62,1596.1 7143.62,1511.73 7143.62,1508.77 7159.81,1492.58 7159.81,1476.62 7149.38,1466.19 7143.69,1466.19 7121.5,1444 7121.5,1377.75 7155,1344.25 7155,1314.19 7138.19,1297.38 7138.19,1282.62 ; v2@7193.06,1257.06 ccw(c7176.31,1240.31) 7176.31,1264 ccw(c7176.31,1287.69) v2@7193.06,1270.94 ; v2@7195.89,1259.89 ccw(c7185.97,1249.97) 7185.97,1264 ccw(c7185.97,1278.03) v2@7195.89,1268.11 ; v2@7200,1265.19 7200.81,1265.19 7201,1265 v2(7200,1264) 7156.81,1264 7148.62,1272.19 ; v1@7625.14,2473.43 ccw(c7608.92,2489.64) 7631.86,2489.64 ccw(c7654.79,2489.64) v1@7638.57,2473.43 ; v1@7627.97,2470.6 ccw(c7618.58,2479.99) 7631.86,2479.99 ccw(c7645.14,2479.99) v1@7635.75,2470.6 ; v1(7631.86,2466.71) 7631.86,2535.54 7648.36,2552.04 7648.36,2600.14 7639.19,2609.31 7639.19,2630.69 7687.67,2679.18 7691.31,2682.81 7754,2745.5 7759.81,2751.31 7759.81,2861.37 7759.81,2900 7759.81,2902.63 7757.69,2904.75 7756.67,2905.78 7756.67,2990.46 7756.67,3193.2 7814.19,3250.73 7814.19,3270 7814.19,3287.89 7802.02,3300.06 7802.02,3371.85 7806.69,3376.52 7806.69,3390 7806.69,3410.9 7806.69,3523 7831.69,3548 7935.47,3651.78 7968.6,3651.78 v1(8041.86,3725.04) ; v1@8032.36,3725.04 cw(c8009.42,3725.04) 8025.64,3708.82 cw(c8041.86,3692.61) v1@8041.86,3715.54 ; v1@8036.36,3725.04 cw(c8023.08,3725.04) 8032.47,3715.65 cw(c8041.86,3706.26) v1@8041.86,3719.54 ; 7138.19,1282.62 7148.62,1272.19 ; 7138.19,1282.62 7148.62,1272.19
  Bottom Layer w4: v2@7193.06,1270.94 ccw(c7176.31,1287.69) 7200,1287.69 ccw(c7223.69,1287.69) v2@7206.94,1270.94 ; v2@7195.89,1268.11 ccw(c7185.97,1278.03) 7200,1278.03 ccw(c7214.03,1278.03) v2@7204.11,1268.11 ; v2(7200,1264) 7200,1291.25 7180.5,1310.75 7180.5,1325.25 7180.5,1371.8 7203.2,1394.5 7218.44,1394.5 7316.3,1492.36 7328.94,1505 7597.68,1505 7617.68,1525 7631.94,1539.27 7737,1539.27 7741.73,1544 7797.69,1599.96 7797.69,1645.69 7839.4,1687.4 v2(7894,1687.4) ; v2(7708,2460) 7784.81,2460 7792.62,2452.19 7807.38,2452.19 7841.5,2486.31 ; v2@7712.11,2455.89 cw(c7722.03,2445.97) 7722.03,2460 cw(c7722.03,2474.03) v2@7712.11,2464.11 ; v2@7714.94,2453.06 cw(c7731.69,2436.31) 7731.69,2460 cw(c7731.69,2483.69) v2@7714.94,2466.94 ; v2@7835.37,2504.56 cw(c7820.58,2489.77) 7841.5,2489.77 ; v2@7838.2,2507.39 cw(c7830.23,2499.43) 7841.5,2499.43 ; 7841.5,2495.79 cw(c7857.64,2495.79) v2@7846.37,2507.34 ; v2@7841.5,2510.69 7841.5,2486.31 ; v2@7849.16,2504.48 ccw(c7866.9,2486.3) 7841.5,2486.3 ; v2@7887.06,1680.46 ccw(c7870.31,1663.71) 7870.31,1687.4 ccw(c7870.31,1711.09) v2@7887.06,1694.34 ; v2@7889.89,1683.29 ccw(c7879.97,1673.37) 7879.97,1687.4 ccw(c7879.97,1701.43) v2@7889.89,1691.51
  other v2: 7842.31,2511.5
HOST_CLK.SCLK: U2.8 U30.F15 | length 3201.5
  Top Layer w4: v2@7372,1996.24 cw(c7362.52,1984) 7378,1984 ; v2@7374.44,1999.4 cw(c7368.83,1992.15) 7378,1992.15 cw(c7387.17,1992.15) v2@7381.56,1999.4 ; v2(7378,2004) 7378,1984 ; v2@7384,1996.24 ccw(c7393.48,1984) 7378,1984 ; U2.8@7874.17,3581.34 7924.23,3581.34 ; U2.8@7901.33,3575.84 cw(c7914.58,3562.62) 7914.58,3581.34 cw(c7914.58,3600.06) U2.8@7901.33,3586.83 ; U2.8@7904.16,3573.02 cw(c7924.22,3553) 7924.22,3581.34 ; U2.8@7904.16,3589.66 ccw(c7924.22,3609.68) 7924.22,3581.34 ; 7933.38,3572.18 cw(c7916.2,3555) v1@7940.5,3555 ; 7934.75,3570.82 ccw(c7950,3586.07) v1@7950,3564.5 ; 7940.21,3565.35 cw(c7929.86,3555) v1@7944.5,3555 ; 7941.58,3563.99 ccw(c7950,3572.41) v1@7950,3560.5 ; v1(7950,3555) 7950,3555.56 7924.23,3581.34 ; 7278.44,1975.96 ccw(c7290.97,1963.42) 7273.25,1963.42 cw(c7290.97,1963.42) 7278.44,1975.96 ; 7278.44,1975.96 cw(c7265.91,1988.49) 7265.91,1970.77 ccw(c7265.91,1988.49) 7278.44,1975.96 ; 7278.44,1975.96 cw(c7285.62,1968.78) 7285.62,1978.93 ; 7278.44,1975.96 cw(c7285.62,1968.78) 7285.62,1978.93 ; 7285.62,1978.93 7285.95,1979.27 7373.27,1979.27 7378,1984
  MidLayer1 w4: v1@7918.89,2021.11 cw(c7928.28,2011.72) 7928.28,2025 cw(c7928.28,2038.28) v1@7918.89,2028.89 ; v1@7921.72,2018.28 cw(c7937.94,2002.06) 7937.94,2025 cw(c7937.94,2047.93) v1@7921.72,2031.72 ; v1@7943.28,3548.28 cw(c7927.06,3532.06) 7950,3532.06 cw(c7972.94,3532.06) v1@7956.72,3548.28 ; v1@7946.11,3551.11 cw(c7936.72,3541.72) 7950,3541.72 cw(c7963.28,3541.72) v1@7953.89,3551.11 ; v1@7950,3555.56 v1(7950,3555) 7950,3506.9 ; 7835,2592.37 7838.5,2595.87 ; 7835,2592.37 7832.5,2589.87 7832.5,2556.4 7835,2553.9 7865.4,2523.5 7880.25,2523.5 7948.52,2455.22 7948.52,2300.04 7990.19,2258.37 7990.19,2098.04 7990.19,2045.19 7970,2025 v1@7917.15,2025 ; 7835,2592.37 7838.5,2595.87 ; 7838.5,2595.87 7838.5,2620 ; 7838.5,2620 7838.5,2633.88 ; 7838.5,2620 7838.5,2633.88 ; 7838.5,2633.88 7838.5,2666.8 7838.5,2720 ; 7838.5,2720 7838.5,2735.2 ; 7838.5,2720 7838.5,2735.2 ; 7838.5,2735.2 7838.5,2811.64 ; 7838.5,2811.64 7865.18,2838.32 ; 7838.5,2811.64 7865.18,2838.32 ; 7865.18,2838.32 7981.86,2955 7981.86,3475.04 ; v1@7917.15,2025 v1(7915,2025) 7915.63,2024.37 7916.52,2024.37 v1@7917.15,2025 ; 7950,3506.9 7981.86,3475.04 ; 7950,3506.9 7981.86,3475.04
  Bottom Layer w4: v2@7378,1994.19 cw(c7378,1970.5) 7394.75,1987.25 cw(c7411.5,2004) v2@7387.81,2004 ; v2@7378,1998.19 cw(c7378,1984.16) 7387.92,1994.08 cw(c7397.84,2004) v2@7383.81,2004 ; v2(7378,2004) 7395.5,1986.5 7413.25,1986.5 7483.56,2056.81 7595.69,2056.81 7686.31,1966.19 7783.38,1966.19 7793.81,1976.62 7842.19,2025 ; v1@7908.28,2018.28 ccw(c7892.06,2002.06) 7892.06,2025 ccw(c7892.06,2047.93) v1@7908.28,2031.72 ; v1@7911.11,2021.11 ccw(c7901.72,2011.72) 7901.72,2025 ccw(c7901.72,2038.28) v1@7911.11,2028.89 ; v1@7915.19,2023.04 7915,2023.23 v1(7915,2025) 7865,2025 ; 7842.19,2025 7865,2025 ; 7842.19,2025 7865,2025
HOST_LED1.BLUE: R287.2 U30.R7 U31.3 | length 6433
  Top Layer w4: U31.3@3890.69,3420.99 ccw(c3883.86,3414.16) 3883.86,3423.82 ccw(c3883.86,3433.48) U31.3@3890.69,3426.65 ; U31.3@3920,3423.82 3882.64,3423.82 3864.52,3405.71 3864.52,2945.35 3933.43,2876.45 3933.43,2827.72 4061.15,2700 4165.15,2700 4215.19,2750.04 4256.86,2750.04 4306.86,2700.04 4306.86,2420 ; v1@4341.81,1906.76 ccw(c4325.59,1922.98) 4348.52,1922.98 ccw(c4371.46,1922.98) v1@4355.24,1906.76 ; v1@4344.64,1903.93 ccw(c4335.25,1913.32) 4348.52,1913.32 ccw(c4361.8,1913.32) v1@4352.41,1903.93 ; v1(4348.52,1900.04) 4348.52,1928.78 4306.86,1970.45 4306.86,2420 ; v1(4360,2420) 4345,2420 4330,2420 4320,2420 4306.86,2420 ; v2@6925.06,1502.94 ccw(c6900.02,1527.98) 6935.44,1527.98 ; v2@6927.89,1500.11 ccw(c6909.67,1518.33) 6935.44,1518.33 ; v2@6930.72,1497.28 ccw(c6919.33,1508.67) 6935.44,1508.67 ; 6934.95,1589.38 cw(c6945.59,1589.38) 6938.06,1596.91 ; v2@6935.44,1496 6935.44,1589.38 cw(c6945.59,1589.38) 6938.41,1596.56 ; 6935.44,1511.39 ccw(c6947.39,1511.39) v2@6938.94,1502.94 ; 6938.41,1596.56 cw(c6950.94,1584.03) 6950.94,1601.75 ccw(c6950.94,1584.03) 6938.41,1596.56 ; 6938.41,1596.56 ccw(c6925.88,1609.09) 6943.6,1609.09 cw(c6925.88,1609.09) 6938.41,1596.56
  MidLayer1 w4: v2@6069.06,1885.06 cw(c6052.31,1868.31) 6076,1868.31 cw(c6099.69,1868.31) v2@6082.94,1885.06 ; v2@6071.89,1887.89 cw(c6061.97,1877.97) 6076,1877.97 cw(c6090.03,1877.97) v2@6080.11,1887.89 ; v2@6081.86,1886.14 v2(6076,1892) 6076,1866 6085.44,1856.56 6091.76,1856.56 6224.36,1723.96 6224.36,1695.89 6257.75,1662.5 6272.25,1662.5 6282.5,1652.25 6282.5,1637.75 6281.02,1636.28 6281.02,1595.27 6289.81,1586.48 6289.81,1509 6306.5,1492.31 6306.5,1432.5 ; 6325.77,1413.23 cw(c6306.55,1394.01) 6333.73,1394.01 ccw(c6310.05,1394.01) 6326.79,1410.76 ccw(c6343.54,1427.51) 6343.54,1403.82 cw(c6343.54,1424.01) 6329.27,1409.73 ; 6332.6,1406.4 cw(c6320.21,1394.01) 6337.73,1394.01 ccw(c6323.7,1394.01) 6333.62,1403.93 ccw(c6343.54,1413.85) v2@6343.54,1399.82 ; v2(6932,1496) 6921.81,1485.81 6921.81,1459.31 6915.81,1453.31 6915.81,1311.31 6927.12,1300 ; 6933.14,1300 ccw(c6933.14,1316.86) v2@6945.06,1304.94 ; 6935.55,1300 cw(c6935.55,1284.58) v2@6947.5,1294.33 ; v2@6944.4,1291.8 ccw(c6927.12,1277.7) 6927.12,1300 ; v2(6952,1298) 6950,1300 6927.12,1300 ; 6306.5,1432.5 6306.5,1431.05 v2(6343.54,1394.01) 6343.54,1394.54 6344,1395 6306.5,1432.5
  MidLayer2 w4: v1(5215.19,1858.37) 5215.7,1857.87 5703.97,1857.87 5724.34,1837.5 5896.71,1837.5 5922.02,1812.19 6017.38,1812.19 6034.4,1829.21 6055.77,1829.21 6076,1849.43 v2(6076,1892) ; v2@6069.06,1885.06 cw(c6052.31,1868.31) 6076,1868.31 cw(c6099.69,1868.31) v2@6082.94,1885.06 ; v2@6071.89,1887.89 cw(c6061.97,1877.97) 6076,1877.97 cw(c6090.03,1877.97) v2@6080.11,1887.89 ; v2(6343.54,1394.01) 6344.08,1394.54 6344.46,1394.54 6354.19,1384.81 6394.85,1384.81 6445.78,1333.88 6485.37,1333.88 6498.75,1320.5 6565.75,1320.5 6569.25,1324 6588,1324 6612.19,1299.81 6651.44,1299.81 6680.5,1270.75 6680.5,1268.75 6690.75,1258.5 6737.31,1258.5 6751,1272.19 6771.5,1272.19 6786.19,1286.88 6786.19,1293.38 6801,1308.19 6855,1308.19 6890.62,1343.81 6942.19,1343.81 6952,1334 v2(6952,1298) v2@6950,1296
  Bottom Layer w4: R287.2@4319.71,2439.55 4325.45,2439.55 4335.45,2439.55 4355,2420 v1(4360,2420) ; 4337.96,2437.04 ccw(c4356.57,2455.65) v1@4359.09,2429.46 ; v1@4341.81,1906.76 ccw(c4325.59,1922.98) 4348.52,1922.98 ccw(c4371.46,1922.98) v1@4355.24,1906.76 ; 4343.95,2431.05 ccw(c4357.62,2444.71) v1@4359.47,2425.47 ; v1@4344.64,1903.93 ccw(c4335.25,1913.32) 4348.52,1913.32 ccw(c4361.8,1913.32) v1@4352.41,1903.93 ; 4347.32,2427.68 cw(c4339.64,2420) v1@4350.5,2420 ; v1(4348.52,1900.04) 4348.52,1952.5 4380.4,1984.37 4927.88,1984.37 4962.25,1950 5191.92,1950 5215.19,1926.73 v1(5215.19,1858.37) ; v1@5208.47,1865.09 ccw(c5192.26,1881.31) 5215.19,1881.31 ccw(c5238.13,1881.31) v1@5221.91,1865.09 ; v1@5211.3,1862.26 ccw(c5201.91,1871.65) 5215.19,1871.65 ccw(c5228.47,1871.65) v1@5219.08,1862.26