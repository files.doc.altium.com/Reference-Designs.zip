# Altium PCB NB3000AL.PcbDoc (part 59 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NCONFIG: R74.2 U8.P4 | length 12229.1
  Top Layer w4: v1(4490.19,5533.37) 4587.21,5533.37 4631.86,5488.73 4631.86,5112.6 4665.19,5079.27 4665.19,4929.81 v2(4690,4905) ; v1@4494.08,5529.49 cw(c4503.47,5520.1) 4503.47,5533.37 cw(c4503.47,5546.65) v1@4494.08,5537.26 ; v1@4496.91,5526.66 cw(c4513.13,5510.44) 4513.13,5533.37 cw(c4513.13,5556.31) v1@4496.91,5540.09 ; v2@4680.19,4905 ccw(c4656.5,4905) 4673.25,4921.75 ccw(c4690,4938.5) v2@4690,4914.81 ; v2@4684.19,4905 ccw(c4670.16,4905) 4680.08,4914.92 ccw(c4690,4924.84) v2@4690,4910.81 ; v3(4956.93,4229.37) U8.P4@4976.61,4209.68 ; U8.P4@4969.27,4209.68 ccw(c4951.55,4209.68) 4964.08,4222.22 ccw(c4976.61,4234.75) U8.P4@4976.61,4217.03 ; 4969.73,4216.57 cw(c4982.54,4229.37) 4964.43,4229.37 ccw(c4982.54,4229.37) 4969.73,4216.57 ; 4969.73,4216.57 ccw(c4956.93,4203.76) 4956.93,4221.87 cw(c4956.93,4203.76) 4969.73,4216.57
  MidLayer1 w4: 4606.76,4331.81 4604.94,4331.81 4590,4316.87 4590,4295.75 4604.94,4280.81 4626.06,4280.81 4649.75,4304.5 4664.25,4304.5 4674.5,4294.25 4674.5,4269 4695,4248.5 4722.88,4248.5 4724.19,4247.19 4773.06,4247.19 4790.88,4229.37 4830.63,4229.37 4838.82,4229.37 4879.25,4229.37 v3(4956.93,4229.37) ; 4606.9,4331.81 4617.09,4342 v2@4695,4342 ; 4669.9,4342 ccw(c4669.9,4369.1) v2@4689.06,4349.94 ; 4674.73,4342 cw(c4674.73,4321.73) v2@4689.06,4336.06 ; 4679.56,4342 ccw(c4679.56,4359.44) v2@4691.89,4347.11 ; v3@4951.74,4224.18 ccw(c4939.2,4211.64) 4939.2,4229.37 ccw(c4939.2,4247.1) v3@4951.74,4234.56 ; 4938.82,4229.37 cw(c4938.82,4211.26) 4951.63,4224.07 ccw(c4938.82,4211.26) 4938.82,4229.37 ; 4938.82,4229.37 ccw(c4938.82,4247.48) 4951.63,4234.67 cw(c4938.82,4247.48) 4938.82,4229.37
  MidLayer2 w4: v1(4490.19,5533.37) 4598.52,5641.71 4755,5641.71 4830,5716.71 5312.21,5716.71 5337.7,5691.21 5342.68,5691.21 ; v1@4490.19,5538.87 ccw(c4490.19,5552.15) 4499.58,5542.76 ccw(c4508.97,5533.37) v1@4495.69,5533.37 ; v1@4490.19,5542.87 ccw(c4490.19,5565.81) 4506.41,5549.59 ccw(c4522.63,5533.37) v1@4499.69,5533.37 ; 4663.86,4339.5 ccw(c4663.86,4375.14) v2@4689.06,4349.94 ; 4673.52,4339.5 ccw(c4673.52,4365.48) v2@4691.89,4347.11 ; 4680.76,4339.5 cw(c4680.76,4327.76) v2@4689.06,4336.06 ; v2@4683.06,4898.06 cw(c4666.31,4881.31) 4690,4881.31 cw(c4713.69,4881.31) v2@4696.94,4898.06 ; 4683.18,4339.5 ccw(c4683.18,4355.82) v2@4694.72,4344.28 ; v2@4685.89,4900.89 cw(c4675.97,4890.97) 4690,4890.97 cw(c4704.03,4890.97) v2@4694.11,4900.89 ; v2(4690,4905) 4690,4777.83 4656.69,4744.52 4656.69,4599.31 4677.5,4578.5 4677.5,4537.5 4669.5,4529.5 4669.5,4403.25 4635.5,4369.25 4635.5,4354.75 4650.75,4339.5 v2@4693.5,4339.5 ; 5343.17,5691.71 6614.6,5691.71 6797.77,5508.54 7130,5508.54 7168.54,5470 7255,5470 7267,5458 7267,5338 7460,5145 7690.49,5145 8107.19,4728.3 8107.19,4636.05 8108.81,4634.43 8108.81,4051.26 7877,3819.45 7877,3748.16 7700.84,3572 7457.8,3572 7315.19,3429.39 7315.19,3416.71 v1(7223.52,3325.04) ; v1@7223.52,3330.54 ccw(c7223.52,3343.82) 7232.91,3334.43 ccw(c7242.3,3325.04) v1@7229.02,3325.04 ; v1@7223.52,3334.54 ccw(c7223.52,3357.48) 7239.74,3341.26 ccw(c7255.96,3325.04) v1@7233.02,3325.04
  Bottom Layer w4: R74.2@5699.23,2707.92 cw(c5683.32,2692.01) 5705.82,2692.01 cw(c5728.32,2692.01) R74.2@5712.41,2707.92 ; R74.2@5702.06,2710.75 cw(c5692.98,2701.67) 5705.82,2701.67 cw(c5718.66,2701.67) R74.2@5709.58,2710.75 ; R74.2@5705.82,2715 5705.82,2608.37 5722.49,2591.71 5783.66,2591.71 5814,2561.37 6203.86,2561.37 6250.19,2515.04 6251.99,2513.24 6415.57,2513.24 6424.62,2504.19 6439.38,2504.19 6442.23,2507.04 6555.52,2507.04 6613.02,2564.54 6773.41,2564.54 6778.68,2569.81 6852.68,2569.81 6871.68,2588.81 6894.14,2588.81 6895.83,2590.5 6957.63,2590.5 6986,2618.87 7020.38,2618.87 7028.38,2610.87 7136.32,2610.87 7357.44,2832 7812,2832 7848.52,2868.52 7848.52,3033.37 7831.86,3050.04 7794.96,3050.04 7770,3075 7600,3075 7546.19,3128.81 7291.19,3128.81 7275,3145 7275,3273.56 v1(7223.52,3325.04) ; v1@7223.52,3315.54 cw(c7223.52,3292.61) 7239.74,3308.82 cw(c7255.96,3325.04) v1@7233.02,3325.04 ; v1@7223.52,3319.54 cw(c7223.52,3306.26) 7232.91,3315.65 cw(c7242.3,3325.04) v1@7229.02,3325.04
  other v2: 4696,4343
NetC7_1: C7.1 C8.2 R1.2 | length 440.8
  Bottom Layer w4: C8.2@-279.33,3851.36 R1.2@-221.18,3851.36 -221.18,3864.97 ; C8.2@-275.22,3847.25 cw(c-265.3,3837.34) -265.3,3851.36 ; C8.2@-275.22,3855.47 ccw(c-265.3,3865.39) -265.3,3851.36 ; C8.2@-272.39,3844.43 cw(c-255.65,3827.68) -255.65,3851.36 cw(c-255.64,3875.05) C8.2@-272.39,3858.3 ; R1.2@-227.77,3844.77 ccw(c-243.68,3828.87) -243.68,3851.36 ccw(c-243.68,3873.86) R1.2@-227.77,3857.95 ; R1.2@-224.94,3847.6 ccw(c-234.02,3838.52) -234.02,3851.36 ccw(c-234.02,3864.21) R1.2@-224.94,3855.12 ; R1.2@-224.24,3860.66 ccw(c-225.74,3864.97) -221.18,3864.97 ; R1.2@-223.86,3851.86 cw(c-198.68,3851.86) -216.49,3869.66 ; R1.2@-219.86,3851.86 cw(c-185.02,3851.86) -209.66,3876.49 ; R1.2@-218.12,3860.66 cw(c-216.62,3864.97) -221.18,3864.97 ; R1.2@-215.86,3851.86 cw(c-171.37,3851.86) -202.83,3883.32 ; R1.2@-211.86,3851.86 cw(c-157.71,3851.86) -196,3890.15 ; C7.1@-189.14,3906.82 cw(c-212.83,3906.82) -196.08,3890.07 cw(c-179.33,3873.32) C7.1@-179.33,3897.01 ; C7.1@-185.14,3906.82 cw(c-199.17,3906.82) -189.25,3896.9 cw(c-179.33,3886.98) C7.1@-179.33,3901.01 ; C7.1@-179.33,3906.82 -221.18,3864.97
NetC8_1: C8.1 R2.1 | length 170.4
  Bottom Layer w4: R2.1@-327.77,3802.99 ccw(c-343.68,3818.9) -321.18,3818.9 ccw(c-298.68,3818.9) R2.1@-314.59,3802.99 ; C8.1@-327.61,3844.43 cw(c-343.12,3828.91) -321.18,3828.91 ; R2.1@-324.94,3800.16 ccw(c-334.02,3809.24) -321.18,3809.24 ccw(c-308.34,3809.24) R2.1@-317.42,3800.16 ; C8.1@-324.78,3847.25 cw(c-333.46,3838.57) -321.18,3838.57 ; R2.1@-321.18,3795.91 -321.18,3850.85 C8.1@-320.67,3851.36 ; -321.18,3826.44 cw(c-295.75,3826.44) C8.1@-313.73,3844.43 ; -321.18,3836.1 cw(c-305.4,3836.1) C8.1@-316.56,3847.25
NetC9_1: C9.1 R5.1 | length 169.2
  Bottom Layer w4: R5.1@-327.77,3733.37 cw(c-343.68,3717.46) -321.18,3717.46 cw(c-298.68,3717.47) R5.1@-314.59,3733.37 ; C9.1@-327.54,3692 ccw(c-343.6,3708.37) -320.67,3708.37 ; R5.1@-324.94,3736.2 cw(c-334.02,3727.12) -321.18,3727.12 cw(c-308.34,3727.12) R5.1@-317.42,3736.2 ; C9.1@-324.74,3689.15 ccw(c-334.25,3698.84) -320.67,3698.84 ccw(c-307.08,3698.84) C9.1@-316.6,3689.15 ; R5.1@-321.18,3740.45 -321.18,3708.89 -320.67,3708.37 ; C9.1@-320.67,3685 -320.67,3708.37 ; C9.1@-313.8,3692 cw(c-297.73,3708.37) -320.67,3708.37
NetC10_1: C10.1 R6.1 | length 209.5
  Bottom Layer w4: C10.1@-227.61,3788.97 cw(c-244.36,3772.22) -220.67,3772.22 cw(c-196.98,3772.22) C10.1@-213.73,3788.97 ; C10.1@-224.78,3791.8 cw(c-234.7,3781.88) -220.67,3781.88 cw(c-206.64,3781.88) C10.1@-216.56,3791.8 ; C10.1@-220.67,3795.91 -220.67,3768.2 -218.73,3766.27 -181.27,3766.27 -178.82,3763.82 R6.1@-178.82,3740.45 ; R6.1@-185.41,3747.54 ccw(c-201.32,3763.44) -178.82,3763.44 ccw(c-156.32,3763.44) R6.1@-172.23,3747.54 ; R6.1@-182.58,3744.71 ccw(c-191.66,3753.79) -178.82,3753.79 ccw(c-165.98,3753.79) R6.1@-175.06,3744.71
NetC11_1: C11.1 R7.1 | length 175
  Bottom Layer w4: C11.1@-186.27,3631.94 ccw(c-204.25,3649.92) -178.82,3649.92 ; R7.1@-185.41,3677.92 cw(c-201.32,3662.01) -178.82,3662.01 cw(c-156.32,3662.01) R7.1@-172.23,3677.92 ; C11.1@-183.44,3629.11 ccw(c-194.6,3640.26) -178.82,3640.26 ; R7.1@-182.58,3680.75 cw(c-191.66,3671.67) -178.82,3671.67 cw(c-165.98,3671.67) R7.1@-175.06,3680.75 ; C11.1@-179.33,3625 -178.82,3625.51 R7.1@-178.82,3685 ; -178.82,3637.79 ccw(c-166.54,3637.79) C11.1@-175.22,3629.11 ; -178.82,3647.45 ccw(c-156.88,3647.45) C11.1@-172.39,3631.94
NetC12_1: C12.1 R9.1 | length 133.7
  Bottom Layer w4: R9.1@-185.41,4010.65 cw(c-201.32,3994.74) -178.82,3994.74 cw(c-156.32,3994.74) R9.1@-172.23,4010.65 ; C12.1@-184.56,3970.58 ccw(c-190.51,3980.04) -179.33,3980.04 ; R9.1@-182.58,4013.47 cw(c-191.66,4004.39) -178.82,4004.39 cw(c-165.98,4004.39) R9.1@-175.06,4013.47 ; C12.1@-179.33,3962.27 -179.33,3980.04 ; R9.1@-178.82,4017.73 -178.82,3980.55 -179.33,3980.04 ; C12.1@-174.1,3970.58 cw(c-168.15,3980.04) -179.33,3980.04
NetC12_2: C12.2 C13.1 R8.2 | length 399
  Bottom Layer w4: R8.2@-327.77,3955.19 cw(c-343.68,3939.28) -321.18,3939.28 cw(c-298.68,3939.28) R8.2@-314.59,3955.19 ; C13.1@-327.61,3913.76 ccw(c-343.12,3929.27) -321.18,3929.27 ; R8.2@-324.94,3958.02 cw(c-334.02,3948.94) -321.18,3948.94 cw(c-308.34,3948.94) R8.2@-317.42,3958.02 ; C13.1@-324.78,3910.93 ccw(c-333.46,3919.61) -321.18,3919.61 ; -321.18,3922.08 ccw(c-305.41,3922.08) C13.1@-316.56,3910.93 ; -321.18,3931.74 ccw(c-295.75,3931.74) C13.1@-313.73,3913.76 ; C13.1@-320.67,3906.82 -321.18,3907.33 R8.2@-321.18,3962.27 -321.18,3970.38 -308.19,3983.37 ; R8.2@-319.93,3963.18 cw(c-309.7,3966.61) -317.33,3974.23 ; R8.2@-316.14,3964.45 cw(c-302.85,3968.9) -312.76,3978.8 ; R8.2@-312.34,3965.72 cw(c-296,3971.19) -308.19,3983.37 ; C12.2@-227.61,3955.34 ccw(c-244.35,3938.59) -244.35,3962.27 ccw(c-244.36,3985.96) C12.2@-227.61,3969.21 ; C12.2@-224.78,3958.16 ccw(c-234.7,3948.25) -234.7,3962.27 ccw(c-234.7,3976.3) C12.2@-224.78,3966.38 ; C12.2@-220.67,3962.27 -247.04,3962.27 -268.14,3983.37 -308.19,3983.37
NetC14_1: C14.1 R11.1 | length 172.9
  Bottom Layer w4: R11.1@-278.82,4073.18 C14.1@-220.67,4073.18 ; R11.1@-275.06,4069.42 cw(c-265.98,4060.34) -265.98,4073.18 cw(c-265.98,4086.02) R11.1@-275.06,4076.94 ; R11.1@-272.23,4066.59 cw(c-256.32,4050.69) -256.32,4073.18 cw(c-256.32,4095.68) R11.1@-272.23,4079.77 ; C14.1@-227.61,4066.24 ccw(c-244.35,4049.5) -244.35,4073.18 ccw(c-244.36,4096.87) C14.1@-227.61,4080.12 ; C14.1@-224.78,4069.07 ccw(c-234.7,4059.15) -234.7,4073.18 ccw(c-234.7,4087.21) C14.1@-224.78,4077.29
NetC15_1: C15.1 R12.1 | length 172.9
  Bottom Layer w4: R12.1@-278.82,4128.64 C15.1@-220.67,4128.64 ; R12.1@-275.06,4124.87 cw(c-265.98,4115.8) -265.98,4128.64 cw(c-265.98,4141.48) R12.1@-275.06,4132.4 ; R12.1@-272.23,4122.05 cw(c-256.32,4106.14) -256.32,4128.64 cw(c-256.32,4151.13) R12.1@-272.23,4135.23 ; C15.1@-227.61,4121.7 ccw(c-244.35,4104.95) -244.35,4128.64 ccw(c-244.36,4152.32) C15.1@-227.61,4135.57 ; C15.1@-224.78,4124.53 ccw(c-234.7,4114.61) -234.7,4128.64 ccw(c-234.7,4142.67) C15.1@-224.78,4132.75
NetC16_1: C16.1 R13.1 | length 172.9
  Bottom Layer w4: R13.1@-278.82,4184.09 C16.1@-220.67,4184.09 ; R13.1@-275.06,4180.33 cw(c-265.98,4171.25) -265.98,4184.09 cw(c-265.98,4196.93) R13.1@-275.06,4187.85 ; R13.1@-272.23,4177.5 cw(c-256.32,4161.59) -256.32,4184.09 cw(c-256.32,4206.59) R13.1@-272.23,4190.68 ; C16.1@-227.61,4177.15 ccw(c-244.35,4160.41) -244.35,4184.09 ccw(c-244.36,4207.78) C16.1@-227.61,4191.03 ; C16.1@-224.78,4179.98 ccw(c-234.7,4170.06) -234.7,4184.09 ccw(c-234.7,4198.12) C16.1@-224.78,4188.2
NetC17_1: C17.1 R15.1 | length 267.9
  Bottom Layer w4: C17.1@-320.67,4285.19 cw(c-320.67,4261.5) -303.92,4278.25 cw(c-287.17,4295) C17.1@-310.86,4295 ; C17.1@-320.67,4289.19 cw(c-320.67,4275.16) -310.75,4285.08 cw(c-300.83,4295) C17.1@-314.86,4295 ; C17.1@-320.67,4295 -278.82,4253.15 ; -304,4278.33 cw(c-342.29,4240.04) R15.1@-288.14,4240.04 ; -297.17,4271.5 cw(c-328.63,4240.04) R15.1@-284.14,4240.04 ; -290.34,4264.67 cw(c-314.98,4240.04) R15.1@-280.14,4240.04 ; -283.51,4257.84 cw(c-301.32,4240.04) R15.1@-276.14,4240.04 ; R15.1@-281.88,4248.84 ccw(c-283.38,4253.15) -278.82,4253.15 ; R15.1@-278.82,4239.55 -278.82,4253.15 ; R15.1@-275.76,4248.84 cw(c-274.25,4253.15) -278.82,4253.15
NetC17_2: C17.2 C18.1 R14.2 | length 305.9
  Bottom Layer w4: C17.2@-279.33,4295 R14.2@-221.18,4295 -221.18,4257.55 -220.67,4257.04 ; C17.2@-275.22,4290.89 cw(c-265.3,4280.97) -265.3,4295 ; C17.2@-275.22,4299.11 ccw(c-265.3,4309.03) -265.3,4295 ; C17.2@-272.39,4288.06 cw(c-255.65,4271.32) -255.65,4295 cw(c-255.64,4318.69) C17.2@-272.39,4301.94 ; R14.2@-227.77,4287.92 cw(c-243.68,4272.01) -221.18,4272.01 cw(c-198.68,4272.01) R14.2@-214.59,4287.92 ; R14.2@-227.77,4288.41 ccw(c-243.68,4272.5) -243.68,4295 ccw(c-243.68,4317.5) R14.2@-227.77,4301.59 ; C18.1@-225.79,4247.92 ccw(c-231.36,4257.04) -220.67,4257.04 ; R14.2@-224.94,4290.75 cw(c-234.02,4281.67) -221.18,4281.67 cw(c-208.34,4281.67) R14.2@-217.42,4290.75 ; R14.2@-224.94,4291.24 ccw(c-234.02,4282.16) -234.02,4295 ccw(c-234.02,4307.84) R14.2@-224.94,4298.76 ; C18.1@-220.67,4239.55 -220.67,4257.04 ; C18.1@-215.55,4247.92 cw(c-209.98,4257.04) -220.67,4257.04
NetC23_1: C23.1 C24.2 U1.18 | length 714.1
  Top Layer w4: U1.18@-79.84,2683.82 -35,2683.82 -23.82,2695 15,2695 23.52,2686.48 v1(23.52,2591.71) ; U1.18@-60.1,2680.22 cw(c-51.42,2671.54) -51.42,2683.82 cw(c-51.42,2696.1) U1.18@-60.1,2687.42 ; v1@16.81,2598.43 ccw(c0.59,2614.64) 23.52,2614.64 ccw(c46.46,2614.64) v1@30.24,2598.43 ; v1@19.64,2595.6 ccw(c10.25,2604.99) 23.52,2604.99 ccw(c36.8,2604.99) v1@27.41,2595.6
  Bottom Layer w4: v1(23.52,2591.71) 38.86,2591.71 42.15,2595 C24.2@89.33,2595 89.33,2568.74 ; C23.1@68.65,2528.72 cw(c83.99,2538.03) 71.31,2550.72 ; C23.1@70.63,2525 70.63,2550.04 89.33,2568.74 ; C23.1@72.07,2530.8 cw(c88.48,2540.75) 74.91,2554.32 ; C23.1@75.49,2532.87 cw(c92.97,2543.47) 78.52,2557.93 ; C23.1@78.91,2534.94 cw(c97.46,2546.19) 82.12,2561.53 ; C23.1@82.33,2537.02 cw(c101.95,2548.91) 85.73,2565.14 ; C24.2@82.39,2601.94 cw(c65.64,2618.69) 65.64,2595 cw(c65.65,2571.31) 82.39,2588.06 cw(c65.64,2571.31) 89.33,2571.31 cw(c113.02,2571.32) C24.2@96.27,2588.06 ; C24.2@85.22,2599.11 cw(c75.3,2609.03) 75.3,2595 cw(c75.3,2580.97) 85.22,2590.89 cw(c75.3,2580.97) 89.33,2580.97 cw(c103.36,2580.97) C24.2@93.44,2590.89 ; C23.1@85.75,2539.09 cw(c106.44,2551.64) 89.33,2568.74
NetC25_1: C25.1 C26.1 U1.17 | length 646.4
  Top Layer w4: U1.17@-79.84,2658.62 -43.43,2658.62 -34.81,2650 -34.81,2600 16.86,2548.33 v1(16.86,2523.37) ; U1.17@-60.1,2655.03 cw(c-51.42,2646.34) -51.42,2658.62 cw(c-51.42,2670.9) U1.17@-60.1,2662.22 ; v1@10.14,2530.09 ccw(c-6.08,2546.31) 16.86,2546.31 ccw(c39.79,2546.31) v1@23.57,2530.09 ; v1@12.97,2527.26 ccw(c3.58,2536.65) 16.86,2536.65 ccw(c30.14,2536.65) v1@20.75,2527.26
  Bottom Layer w4: v1@12.32,2515.03 cw(c8.18,2507.4) 16.86,2507.4 ; v1(16.86,2523.37) 16.86,2507.4 ; v1@21.39,2515.03 ccw(c25.53,2507.4) 16.86,2507.4 ; C25.1@58.12,2403.06 ccw(c27.93,2433.25) 70.63,2433.25 ccw(c113.32,2433.25) C25.1@83.14,2403.06 ; C25.1@60.95,2400.23 ccw(c37.59,2423.59) 70.63,2423.59 ccw(c103.67,2423.59) C25.1@80.31,2400.23 ; C25.1@63.78,2397.4 ccw(c47.25,2413.93) 70.63,2413.93 ccw(c94.01,2413.93) C25.1@77.48,2397.4 ; C25.1@70.63,2385.63 70.63,2453.63 ; C26.1@80.76,2450.85 ccw(c72.63,2446.32) 72.63,2455.63 ; C26.1@80.76,2460.41 cw(c72.63,2464.94) 72.63,2455.63 ; C26.1@89.33,2455.63 72.63,2455.63 ; 16.86,2507.4 70.63,2453.63 ; 70.63,2453.63 72.63,2455.63
NetC27_1: C27.1 C28.1 U1.15 | length 505.3
  Top Layer w4: v1@-124.33,2608.23 U1.15@-79.84,2608.23 ; v1@-120.59,2604.49 cw(c-111.55,2595.45) -111.55,2608.23 ; v1@-120.59,2612.26 ccw(c-110.84,2622.01) -110.84,2608.23 ; v1@-117.76,2601.66 cw(c-101.9,2585.79) U1.15@-101.9,2608.23 ; v1@-117.76,2615.09 ccw(c-101.19,2631.66) U1.15@-101.19,2608.23 ; U1.15@-99.58,2604.63 ccw(c-108.26,2595.95) -108.26,2608.23 ccw(c-108.27,2620.51) U1.15@-99.58,2611.83
  Bottom Layer w4: v1(-124.48,2608.37) -109.04,2608.37 ; C27.1@-117.68,2547.29 ccw(c-118.45,2551.3) -114.37,2551.3 ; C27.1@-116.34,2528.71 cw(c-100.16,2538.65) -113.59,2552.08 ; C27.1@-114.37,2525 -114.37,2551.3 ; C27.1@-112.93,2530.8 cw(c-95.72,2541.38) -110.01,2555.66 ; C27.1@-111.06,2547.29 cw(c-110.29,2551.3) -114.37,2551.3 ; C27.1@-109.53,2532.9 cw(c-91.28,2544.11) -106.42,2559.25 ; C27.1@-106.12,2534.99 cw(c-86.84,2546.83) -102.84,2562.83 ; C28.1@-105.34,2596.68 ccw(c-118.47,2598.95) -109.04,2608.37 ; C27.1@-102.71,2537.08 cw(c-82.4,2549.56) -99.25,2566.42 ; C28.1@-102.61,2588.06 cw(c-119.36,2571.31) -95.67,2571.31 cw(c-71.98,2571.31) C28.1@-88.73,2588.06 ; C28.1@-99.78,2590.89 cw(c-109.7,2580.97) -95.67,2580.97 cw(c-81.64,2580.97) C28.1@-91.56,2590.89 ; C27.1@-99.3,2539.18 cw(c-77.96,2552.29) -95.67,2570 ; C28.1@-97.34,2604.67 cw(c-99.62,2617.8) -109.04,2608.37 ; -114.37,2551.3 -95.67,2570 C28.1@-95.67,2595 -109.04,2608.37
NetC27_2: C27.2 R22.2 R25.2 | length 476.4
  Bottom Layer w4: R22.2@-102.77,2647.08 ccw(c-118.68,2662.99) -96.18,2662.99 ccw(c-73.68,2662.99) R22.2@-89.59,2647.08 ; R25.2@-102.77,2677.92 cw(c-118.68,2662.01) -96.18,2662.01 cw(c-73.68,2662.01) R25.2@-89.59,2677.92 ; R22.2@-99.94,2644.25 ccw(c-109.02,2653.33) -96.18,2653.33 ccw(c-83.34,2653.33) R22.2@-92.42,2644.25 ; R25.2@-99.94,2680.75 cw(c-109.02,2671.67) -96.18,2671.67 cw(c-83.34,2671.67) R25.2@-92.42,2680.75 ; R22.2@-98.72,2640.38 ccw(c-87.06,2636.36) -95.78,2627.64 ; R25.2@-96.18,2685 R22.2@-96.18,2640 -96.18,2628.04 -76.48,2608.34 -76.48,2580 -66.48,2570 -40,2570 -35.63,2565.63 ; R22.2@-94.93,2639.08 ccw(c-80.33,2634.04) -91.26,2623.12 ; R22.2@-91.15,2637.77 ccw(c-73.61,2631.72) -86.73,2618.59 ; R22.2@-87.37,2636.47 ccw(c-66.88,2629.4) -82.21,2614.07 ; C27.2@-46.35,2543.99 ccw(c-62.83,2565.63) -35.63,2565.63 ; C27.2@-43.92,2540.81 ccw(c-56.68,2557.55) -35.63,2557.55 ccw(c-14.58,2557.55) C27.2@-27.34,2540.81 ; C27.2@-35.63,2525 -35.63,2565.63 ; C27.2@-24.91,2543.99 cw(c-8.43,2565.63) -35.63,2565.63
NetC31_1: C31.1 C32.1 U1.16 | length 548.5
  Top Layer w4: v1@-166.53,2731.66 cw(c-182.74,2715.44) -159.81,2715.44 cw(c-136.87,2715.44) v1@-153.09,2731.66 ; v1@-163.7,2734.49 cw(c-173.09,2725.1) -159.81,2725.1 cw(c-146.53,2725.1) v1@-155.92,2734.49 ; v1(-159.81,2738.37) -159.81,2665.37 -127.86,2633.42 U1.16@-79.84,2633.43 ; U1.16@-99.58,2629.83 ccw(c-108.26,2621.15) -108.26,2633.42 ccw(c-108.27,2645.71) U1.16@-99.58,2637.02
  Bottom Layer w4: v1(-159.81,2738.37) -138.18,2760 ; v1@-159.81,2743.87 ccw(c-159.81,2757.15) -150.42,2747.76 ccw(c-141.03,2738.37) v1@-154.31,2738.37 ; v1@-159.81,2747.87 ccw(c-159.81,2770.81) -143.59,2754.59 ccw(c-127.37,2738.37) v1@-150.31,2738.37 ; C31.1@-131.3,2754.89 ccw(c-138.18,2752.81) -138.18,2760 ; C31.1@-131.3,2765.11 cw(c-138.18,2767.19) -138.18,2760 ; C31.1@-120.33,2781.57 ccw(c-123.37,2790.04) -114.37,2790.04 ; C31.1@-114.37,2760 -138.18,2760 ; C31.1@-108.41,2781.57 cw(c-105.37,2790.04) -114.37,2790.04 ; C32.1@-102.61,2830.56 cw(c-119.36,2813.81) -95.67,2813.81 cw(c-71.98,2813.82) C32.1@-88.73,2830.56 ; C32.1@-99.78,2833.39 cw(c-109.7,2823.47) -95.67,2823.47 cw(c-81.64,2823.47) C32.1@-91.56,2833.39 ; C32.1@-95.67,2837.5 -95.67,2808.74 -114.37,2790.04 ; -138.18,2760 -126.28,2771.91 -114.37,2783.81 -114.37,2790.04
NetC31_2: C31.2 R26.2 R27.2 | length 495.2
  Bottom Layer w4: R26.2@-102.77,2898.33 ccw(c-118.68,2914.24) -96.18,2914.24 ccw(c-73.68,2914.24) R26.2@-89.59,2898.33 ; R27.2@-102.77,2937.92 cw(c-118.68,2922.01) -96.18,2922.01 cw(c-73.68,2922.01) R27.2@-89.59,2937.92 ; R26.2@-100.65,2882.58 cw(c-104.77,2875.04) -96.18,2875.04 ; R26.2@-99.94,2895.5 ccw(c-109.02,2904.58) -96.18,2904.58 ccw(c-83.34,2904.58) R26.2@-92.42,2895.5 ; R27.2@-99.94,2940.75 cw(c-109.02,2931.67) -96.18,2931.67 cw(c-83.34,2931.67) R27.2@-92.42,2940.75 ; R27.2@-96.18,2945 R26.2@-96.18,2891.25 -96.18,2875.04 ; R26.2@-91.71,2882.58 ccw(c-87.59,2875.04) -96.18,2875.04 ; -66.32,2796.32 cw(c-97.72,2764.92) C31.2@-53.31,2764.92 ; -64.61,2794.61 ccw(c-35.63,2823.59) C31.2@-35.63,2782.61 ; -59.49,2789.49 cw(c-84.06,2764.92) C31.2@-49.31,2764.92 ; -57.78,2787.78 ccw(c-35.63,2809.93) C31.2@-35.63,2778.61 ; C31.2@-52.66,2782.66 cw(c-70.41,2764.92) C31.2@-45.31,2764.92 ; C31.2@-50.95,2780.95 ccw(c-35.63,2796.28) C31.2@-35.63,2774.61 ; C31.2@-35.63,2760 -35.63,2765.63 -76.48,2806.48 -76.48,2855.34 -96.18,2875.04
NetC38_1: C38.1 J12.2 J12.3 J12.4 R36.1 | length 2462.2
  Bottom Layer w12: R36.1@3824.75,1155.06 ccw(c3815.67,1145.98) 3815.67,1158.82 ccw(c3815.67,1171.66) R36.1@3824.75,1162.58 ; C38.1@3824.89,1058.44 cw(c3814.97,1068.36) 3814.97,1054.33 cw(c3814.97,1040.3) 3824.89,1050.22 cw(c3814.97,1040.3) 3829,1040.3 cw(c3843.03,1040.3) C38.1@3833.11,1050.22 ; R36.1@3829,1158.82 3798.82,1158.82 3790,1150 3790,1065 3800.67,1054.33 C38.1@3829,1054.33 3829,800 3829,730 3859.61,699.39 3989.39,699.39 ; J12.3@3970.43,668.42 ccw(c3954.13,697.19) 3987.19,697.19 ; J12.3@3987.19,608.84 3987.19,697.19 ; J12.3@4003.95,668.42 cw(c4020.26,697.19) 3987.19,697.19 ; J12.4@4131.93,659.09 ccw(c4034.64,561.8) 4034.64,699.39 ccw(c4034.64,836.98) J12.4@4131.93,739.69 ; J12.4@4140.42,667.58 ccw(c4063.61,590.77) 4063.61,699.39 ccw(c4063.61,808.01) J12.4@4140.42,731.21 ; J12.4@4148.9,676.06 ccw(c4092.58,619.74) 4092.58,699.39 ccw(c4092.58,779.04) J12.4@4148.9,722.72 ; J12.4@4193.52,699.39 J12.4@4187.98,699.39 ; J12.4@4227.06,676.06 cw(c4283.38,619.74) 4283.38,699.39 cw(c4283.38,779.04) J12.4@4227.06,722.72 ; J12.4@4235.54,667.58 cw(c4312.35,590.77) 4312.35,699.39 cw(c4312.35,808.01) J12.4@4235.54,731.21 ; J12.4@4244.03,659.09 cw(c4341.32,561.8) 4341.32,699.39 cw(c4341.32,836.98) J12.4@4244.03,739.69 ; J12.2@4374.92,669.89 ccw(c4365.4,691.23) 4388.77,691.23 ; J12.2@4388.77,608.84 4388.77,691.23 ; J12.2@4402.61,669.89 cw(c4412.13,691.23) 4388.77,691.23 ; 3987.19,697.19 3989.39,699.39 ; 3989.39,699.39 4015,699.39 J12.4@4187.98,699.39 ; J12.4@4187.98,699.39 4380.61,699.39 4388.77,691.23
NetC38_2: C38.2 D1.1 D2.3 R37.2 | length 1022.6
  Bottom Layer w4: C38.2@3829,1095.67 3854.33,1095.67 3875,1075 3900.79,1075 ; C38.2@3833.11,1091.56 cw(c3843.03,1081.64) 3843.03,1095.67 cw(c3843.03,1109.7) C38.2@3833.11,1099.78 ; C38.2@3835.94,1088.73 cw(c3852.69,1071.98) 3852.69,1095.67 cw(c3852.69,1119.36) C38.2@3835.94,1102.61 ; D2.3@3889.67,1036.11 ccw(c3862.84,1062.94) 3900.79,1062.94 ccw(c3938.73,1062.94) D2.3@3911.9,1036.11 ; D1.1@3889.67,1106.49 cw(c3862.84,1079.66) 3900.79,1079.66 cw(c3938.73,1079.65) D1.1@3911.9,1106.49 ; D2.3@3892.5,1033.28 ccw(c3872.5,1053.29) 3900.79,1053.29 ccw(c3929.07,1053.29) D2.3@3909.07,1033.28 ; D1.1@3892.5,1109.31 cw(c3872.5,1089.31) 3900.79,1089.31 cw(c3929.07,1089.31) D1.1@3909.07,1109.31 ; D2.3@3895.33,1030.46 ccw(c3882.16,1043.63) 3900.79,1043.63 ccw(c3919.42,1043.63) D2.3@3906.24,1030.46 ; D1.1@3895.33,1112.14 cw(c3882.16,1098.97) 3900.79,1098.97 cw(c3919.42,1098.97) D1.1@3906.24,1112.14 ; D1.1@3900.79,1117.6 3900.79,1075 ; D2.3@3907.23,1019.54 cw(c3920.4,1006.37) 3920.4,1025 cw(c3920.4,1043.63) D2.3@3907.23,1030.46 ; D2.3@3910.06,1016.72 cw(c3930.06,996.71) 3930.06,1025 cw(c3930.06,1053.29) D2.3@3910.06,1033.28 ; D2.3@3912.88,1013.89 cw(c3939.71,987.06) 3939.71,1025 cw(c3939.72,1062.94) D2.3@3912.88,1036.11 ; R37.2@4159.91,956.08 ccw(c4144,971.99) 4166.5,971.99 ccw(c4189,971.99) R37.2@4173.09,956.08 ; R37.2@4162.74,953.25 ccw(c4153.66,962.33) 4166.5,962.33 ccw(c4179.34,962.33) R37.2@4170.26,953.25 ; R37.2@4166.5,949 4166.5,1013.5 4155,1025 D2.3@3900.79,1025 3900.79,1075
NetC43_1: C43.1 R48.2 R49.2 | length 335.6
  Bottom Layer w4: C43.1@2145.67,6045 C43.1@2146.3,6044.37
  Bottom Layer w12: C43.1@2146.3,6044.37 R49.2@2210,6044.37 R48.2@2303.31,6044.37 ; C43.1@2149.78,6040.89 cw(c2158.18,6032.49) 2158.18,6044.37 ; C43.1@2149.78,6049.11 ccw(c2161.22,6060.55) 2161.22,6044.37 ; R49.2@2195.4,6034.69 ccw(c2172.04,6011.33) 2172.04,6044.37 ccw(c2172.04,6077.41) R49.2@2195.4,6054.05 ; R49.2@2224.6,6034.69 cw(c2247.96,6011.33) 2247.96,6044.37 cw(c2247.96,6077.41) R49.2@2224.6,6054.05 ; R48.2@2288.71,6034.69 ccw(c2265.35,6011.33) 2265.35,6044.37 ccw(c2265.35,6077.41) R48.2@2288.71,6054.05
NetC48_2: C48.2 R54.1 R55.1 | length 357.7
  Bottom Layer w4: C48.2@2568.7,6044.37 2571.83,6047.5 C48.2@2574.33,6050
  Bottom Layer w12: R54.1@2396.69,6044.37 R55.1@2490,6044.37 C48.2@2568.7,6044.37 ; R54.1@2411.29,6034.69 cw(c2434.65,6011.33) 2434.65,6044.37 cw(c2434.65,6077.41) R54.1@2411.29,6054.05 ; R55.1@2475.4,6034.69 ccw(c2452.04,6011.33) 2452.04,6044.37 ccw(c2452.04,6077.41) R55.1@2475.4,6054.05 ; R55.1@2504.6,6034.69 cw(c2527.96,6011.33) 2527.96,6044.37 cw(c2527.96,6077.41) R55.1@2504.6,6054.05 ; 2558.78,6044.37 ccw(c2558.78,6060.55) C48.2@2570.22,6049.11 ; 2561.82,6044.37 cw(c2561.82,6032.49) C48.2@2570.22,6040.89
NetC97_2: C97.2 U21.39 | length 151.1
  Bottom Layer w4: C97.2@5054.33,5795.19 cw(c5054.33,5771.5) 5071.08,5788.25 cw(c5087.83,5805) C97.2@5064.14,5805 ; C97.2@5054.33,5799.19 cw(c5054.33,5785.16) 5064.25,5795.08 cw(c5074.17,5805) C97.2@5060.14,5805 ; C97.2@5054.33,5805 5076.1,5783.23 U21.39@5076.1,5737.32 ; U21.39@5073.27,5763.68 ccw(c5066.45,5770.51) 5076.1,5770.51 ccw(c5085.76,5770.51) U21.39@5078.93,5763.68
NetC100_1: C100.1 U21.37 | length 214.2
  Bottom Layer w4: C100.1@4920.67,5680 4977.99,5737.32 U21.37@5036.73,5737.32 ; C100.1@4920.67,5685.81 ccw(c4920.67,5699.84) 4930.59,5689.92 ccw(c4940.51,5680) C100.1@4926.48,5680 ; C100.1@4920.67,5689.81 ccw(c4920.67,5713.5) 4937.42,5696.75 ccw(c4954.17,5680) C100.1@4930.48,5680 ; U21.37@5033.9,5734.49 ccw(c5027.08,5727.67) 5027.08,5737.32 ccw(c5027.08,5746.98) U21.37@5033.9,5740.15
NetC101_1: C101.1 R133.2 U24.7 U25.5 | length 1544.9
  Top Layer w4: R133.2@1720.46,5267.08 ccw(c1704.55,5282.99) 1727.05,5282.99 ccw(c1749.54,5282.99) R133.2@1733.64,5267.08 ; R133.2@1723.29,5264.25 ccw(c1714.21,5273.33) 1727.05,5273.33 ccw(c1739.89,5273.33) R133.2@1730.81,5264.25 ; R133.2@1727.05,5260 1727.05,5322.94 v2(1768.8,5364.68) U24.7@1824.29,5364.68 ; v2@1758.99,5364.68 cw(c1735.3,5364.68) 1752.05,5347.94 cw(c1768.8,5331.19) v2@1768.8,5354.87 ; v2@1762.99,5364.68 cw(c1748.96,5364.68) 1758.88,5354.76 cw(c1768.8,5344.84) v2@1768.8,5358.87 ; v2@1772.91,5360.58 cw(c1782.83,5350.66) 1782.83,5364.68 cw(c1782.83,5378.71) v2@1772.91,5368.79 ; v2@1775.73,5357.75 cw(c1792.48,5341) 1792.48,5364.68 cw(c1792.48,5388.37) v2@1775.73,5371.62 ; U24.7@1794,5361.86 ccw(c1787.17,5355.03) 1787.17,5364.68 ccw(c1787.17,5374.34) U24.7@1794,5367.51 ; v2(2065,5505) 2105.19,5505 2130.19,5480 2130.19,5443.24 2140.62,5432.81 2145.85,5432.81 2178.79,5399.87 2258.54,5399.87 2273.73,5384.68 2273.73,5356.27 2285.59,5344.41 ; v2@2069.11,5500.89 cw(c2079.03,5490.97) 2079.03,5505 cw(c2079.03,5519.03) v2@2069.11,5509.11 ; v2@2071.94,5498.06 cw(c2088.69,5481.31) 2088.69,5505 cw(c2088.69,5528.69) v2@2071.94,5511.94 ; U25.5@2294.65,5340.43 ccw(c2285.59,5332.1) 2285.59,5344.41 ; U25.5@2294.65,5348.39 cw(c2285.59,5356.72) 2285.59,5344.41 ; U25.5@2320.85,5340.26 cw(c2330.87,5330.23) 2330.87,5344.41 cw(c2330.88,5358.59) U25.5@2320.85,5348.56 ; C101.1@2378.26,5408.06 cw(c2361.51,5391.31) 2385.2,5391.31 cw(c2408.88,5391.32) C101.1@2392.13,5408.06 ; C101.1@2381.09,5410.89 cw(c2371.17,5400.97) 2385.2,5400.97 cw(c2399.22,5400.97) C101.1@2389.31,5410.89 ; C101.1@2385.2,5415 2385.2,5356.08 2373.53,5344.41 U25.5@2307.83,5344.41 2285.59,5344.41
  MidLayer1 w4: v2(1768.8,5364.68) 1791.92,5387.81 2017.81,5387.81 2030,5400 2030,5495 2040,5505 v2(2065,5505) ; v2@1768.8,5370.5 ccw(c1768.8,5384.52) 1778.72,5374.6 ccw(c1788.64,5364.68) v2@1774.61,5364.68 ; v2@1768.8,5374.5 ccw(c1768.8,5398.18) 1785.55,5381.43 ccw(c1802.29,5364.68) v2@1778.61,5364.68 ; v2@2058.06,5498.06 ccw(c2041.31,5481.31) 2041.31,5505 ccw(c2041.31,5528.69) v2@2058.06,5511.94 ; v2@2060.89,5500.89 ccw(c2050.97,5490.97) 2050.97,5505 ccw(c2050.97,5519.03) v2@2060.89,5509.11
NetC102_1: C102.1 R134.2 U24.6 U25.4 | length 1685.4
  Top Layer w4: R134.2@1720.46,5407.92 cw(c1704.55,5392.01) 1727.05,5392.01 cw(c1749.54,5392.01) R134.2@1733.64,5407.92 ; R134.2@1723.29,5410.75 cw(c1714.21,5401.67) 1727.05,5401.67 cw(c1739.89,5401.67) R134.2@1730.81,5410.75 ; R134.2@1727.05,5415 1727.05,5390 1735,5382.05 ; v2@1728.43,5367.29 ccw(c1715.14,5382.05) 1735,5382.05 ; v2@1731.11,5364.32 ccw(c1723.23,5373.06) 1735,5373.06 ccw(c1746.77,5373.06) v2@1738.89,5364.32 ; v2@1735,5365.81 ccw(c1735,5379.84) 1744.92,5369.92 ccw(c1754.84,5360) v2@1740.81,5360 ; v2@1735,5369.81 ccw(c1735,5393.5) 1751.75,5376.75 ccw(c1768.5,5360) v2@1744.81,5360 ; v2@1741.57,5367.29 cw(c1754.86,5382.05) 1735,5382.05 ; U24.6@1794,5381.54 ccw(c1787.17,5374.71) 1787.17,5384.37 ccw(c1787.17,5394.03) U24.6@1794,5387.2 ; U24.6@1824.29,5384.37 1759.37,5384.37 v2(1735,5360) 1735,5382.05 ; v2@1928.06,5346.94 ccw(c1911.31,5363.69) 1935,5363.69 ccw(c1958.69,5363.69) v2@1941.94,5346.94 ; v2@1930.89,5344.11 ccw(c1920.97,5354.03) 1935,5354.03 ccw(c1949.03,5354.03) v2@1939.11,5344.11 ; v2(1935,5340) 1935,5390 1945,5400 2043.07,5400 2072.37,5429.29 2075.88,5432.81 2103.49,5432.81 2107,5429.3 2107,5408.43 2123.56,5391.87 2255.22,5391.87 2265.73,5381.37 2265.73,5352.95 2299.87,5318.82 U25.4@2307.83,5318.82 2388.08,5318.82 2406.86,5300.04 2406.86,5245.71 2414.86,5237.71 2549.24,5237.71 C102.1@2571.54,5260 ; 2288.32,5330.37 cw(c2276.77,5318.82) U25.4@2293.1,5318.82 ; 2290.47,5328.22 ccw(c2298.98,5336.72) U25.4@2298.98,5324.69 ; U25.4@2320.85,5314.67 cw(c2330.87,5304.64) 2330.87,5318.82 cw(c2330.87,5333) U25.4@2320.85,5322.97 ; C102.1@2561.72,5260 cw(c2538.04,5260) 2554.79,5243.25 cw(c2571.54,5226.5) C102.1@2571.54,5250.19 ; C102.1@2565.72,5260 cw(c2551.7,5260) 2561.62,5250.08 cw(c2571.54,5240.16) C102.1@2571.54,5254.19
  MidLayer2 w4: v2@1735,5350.19 cw(c1735,5326.5) 1751.75,5343.25 cw(c1768.5,5360) v2@1744.81,5360 ; v2@1735,5354.19 cw(c1735,5340.16) 1744.92,5350.08 cw(c1754.84,5360) v2@1740.81,5360 ; v2(1735,5360) 1755,5340 v2(1935,5340) ; v2@1928.06,5333.06 ccw(c1911.31,5316.31) 1911.31,5340 ccw(c1911.31,5363.69) v2@1928.06,5346.94 ; v2@1930.89,5335.89 ccw(c1920.97,5325.97) 1920.97,5340 ccw(c1920.97,5354.03) v2@1930.89,5344.11
NetC103_1: C103.1 R135.2 U24.5 U25.3 | length 754.5
  Top Layer w4: U24.5@1985.71,5384.37 2089.69,5384.39 R135.2@2089.68,5415 2099,5405.68 R135.2@2099,5405.11 ; U24.5@2016,5381.54 cw(c2022.84,5374.7) 2022.84,5384.38 cw(c2022.82,5394.02) U24.5@2016,5387.2 ; R135.2@2083.1,5407.92 cw(c2067.19,5392.01) 2089.69,5392.01 cw(c2112.18,5392.01) R135.2@2096.27,5407.92 ; R135.2@2085.92,5410.75 cw(c2076.84,5401.67) 2089.69,5401.67 cw(c2102.53,5401.67) R135.2@2093.45,5410.75 ; R135.2@2089.68,5405.19 cw(c2089.68,5382.87) 2105.47,5398.65 ; R135.2@2089.68,5409.19 cw(c2089.68,5396.53) R135.2@2098.64,5405.48 ; R135.2@2095,5414.51 ccw(c2108.02,5414.51) R135.2@2098.82,5405.3 ; 2103.22,5400.9 2120.24,5383.87 2251.91,5383.87 2257.73,5378.05 2257.73,5349.64 2265.19,5342.18 2265.19,5327.04 2257.97,5319.82 ; U25.3@2235,5318.82 2256.97,5318.82 ; U25.3@2248.24,5314.91 cw(c2256.97,5307.13) 2256.97,5318.82 ; U25.3@2248.24,5322.73 ccw(c2256.97,5330.51) 2256.97,5318.82 ; 2368.45,5243.25 ccw(c2351.7,5260) C103.1@2375.39,5260 ; 2368.45,5243.25 cw(c2385.2,5226.5) C103.1@2385.2,5250.19 ; C103.1@2379.39,5260 cw(c2365.35,5260) 2375.28,5250.08 cw(c2385.2,5240.16) C103.1@2385.2,5254.19 ; C103.1@2385.2,5260 2366.91,5241.71 2336.08,5241.71 2257.97,5319.82 ; 2256.97,5318.82 2257.97,5319.82
NetC104_1: C104.1 R136.2 U24.4 U25.1 | length 1496.3
  Top Layer w4: U24.4@1985.71,5364.68 2089.69,5364.68 ; U24.4@2016,5361.86 cw(c2022.83,5355.03) 2022.83,5364.68 cw(c2022.83,5374.34) U24.4@2016,5367.51 ; v1(2066.19,5233.37) 2089.68,5256.87 R136.2@2089.68,5260 2087.19,5262.5 2087.19,5362.19 2089.69,5364.68 ; v1@2066.19,5238.87 ccw(c2066.19,5252.15) 2075.58,5242.76 ccw(c2084.97,5233.37) v1@2071.69,5233.37 ; v1@2066.19,5242.87 ccw(c2066.19,5265.81) 2082.41,5249.59 ccw(c2098.63,5233.37) v1@2075.69,5233.37 ; 2078.28,5245.47 cw(c2089.68,5234.06) R136.2@2089.68,5250.19 ; 2078.74,5245.92 ccw(c2065.16,5259.51) R136.2@2084.37,5259.51 ; R136.2@2083.1,5267.08 ccw(c2073.21,5276.96) 2087.19,5276.96 ; 2087.19,5279.36 ccw(c2108.55,5279.36) R136.2@2093.45,5264.25 ; 2087.19,5289.02 ccw(c2118.21,5289.02) R136.2@2096.27,5267.08 ; U25.1@2221.99,5365.85 ccw(c2211.96,5355.82) 2211.96,5370 ccw(c2211.96,5384.18) U25.1@2221.99,5374.15 ; U25.1@2235,5370 2112.17,5370 2106.86,5364.68 2089.69,5364.68 ; C104.1@2571.54,5405.19 cw(c2571.53,5381.5) 2588.28,5398.25 cw(c2605.03,5415) C104.1@2581.35,5415 ; C104.1@2571.54,5409.19 cw(c2571.53,5395.16) 2581.45,5405.08 cw(c2591.38,5415) C104.1@2577.35,5415 ; C104.1@2571.54,5415 2590.19,5396.34 v1(2590.19,5350.04) ; v1@2583.47,5356.76 ccw(c2567.26,5372.98) 2590.19,5372.98 ccw(c2613.13,5372.98) v1@2596.91,5356.76 ; v1@2586.3,5353.93 ccw(c2576.91,5363.32) 2590.19,5363.32 ccw(c2603.47,5363.32) v1@2594.08,5353.93
  MidLayer2 w4: v1(2066.19,5233.37) 2535,5233.37 2563.37,5233.37 2590.19,5260.19 v1(2590.19,5350.04) ; v1@2070.08,5229.49 cw(c2079.47,5220.1) 2079.47,5233.37 cw(c2079.47,5246.65) v1@2070.08,5237.26 ; v1@2072.91,5226.66 cw(c2089.13,5210.44) 2089.13,5233.37 cw(c2089.13,5256.31) v1@2072.91,5240.09 ; v1@2583.47,5343.32 cw(c2567.26,5327.11) 2590.19,5327.11 cw(c2613.13,5327.11) v1@2596.91,5343.32 ; v1@2586.3,5346.15 cw(c2576.91,5336.76) 2590.19,5336.76 cw(c2603.47,5336.76) v1@2594.08,5346.15
NetC108_1: C108.1 U26.13 | length 805.7
  Top Layer w4: v1(-91.81,5050.04) -76.48,5050.04 ; -78.26,5050.04 ccw(c-78.26,5063.93) U26.13@-68.44,5054.11 ; U26.13@-73.93,5052.03 cw(c-76.43,5052.56) -76.43,5050 ; U26.13@-73.91,5052.1 cw(c-76.48,5052.66) -76.48,5050.04 ; U26.13@-30.87,5050 -76.43,5050 ; -76.48,5050.04 cw(c-76.48,5047.44) -73.93,5047.98 ccw(c-76.43,5047.44) -76.43,5050 ; -76.48,5050.04 -76.43,5050
  MidLayer2 w4: v1(-91.81,5050.04) 65.19,5050.04 90.19,5075.04 90.19,5365 95.19,5370 v1(135,5370) v1@135,5370.15 ; v1@-87.92,5046.15 cw(c-78.53,5036.76) -78.53,5050.04 cw(c-78.53,5063.32) v1@-87.92,5053.93 ; v1@-85.09,5043.32 cw(c-68.87,5027.11) -68.87,5050.04 cw(c-68.87,5072.98) v1@-85.09,5056.76 ; v1@128.28,5363.28 ccw(c112.06,5347.06) 112.06,5370 ccw(c112.06,5392.93) v1@128.28,5376.72 ; v1@131.11,5366.11 ccw(c121.72,5356.72) 121.72,5370 ccw(c121.72,5383.28) v1@131.11,5373.89
  Bottom Layer w4: C108.1@116.77,5372.94 cw(c116.77,5354.53) v1@130.81,5366.44 ; C108.1@119.16,5372.94 ccw(c119.16,5385.84) v1@128.28,5376.72 ; v1@127.76,5363.85 ccw(c108.13,5347.2) C108.1@108.13,5372.94 132.06,5372.94 v1(135,5370) v1@135,5370.15
NetC109_2: C109.2 R143.2 R146.1 | length 763.8
  MidLayer1 w4: v1@128.28,5302.65 ccw(c112.06,5286.43) 112.06,5309.37 ccw(c112.06,5332.3) v1@128.28,5316.09 ; v1@131.11,5305.48 ccw(c121.72,5296.09) 121.72,5309.37 ccw(c121.72,5322.65) v1@131.11,5313.26 ; v1(135,5309.37) 104.37,5309.37 95,5300 95,5138.65 116.94,5116.71 v1(149.52,5116.71) v1@151.52,5116.71 ; v1@142.81,5109.99 ccw(c126.59,5093.77) 126.59,5116.71 ccw(c126.59,5139.64) v1@142.81,5123.43 ; v1@145.64,5112.82 ccw(c136.25,5103.43) 136.25,5116.71 ccw(c136.25,5129.99) v1@145.64,5120.6
  Bottom Layer w4: C109.2@101.19,5062.02 ccw(c84.44,5078.77) 108.13,5078.77 ccw(c131.81,5078.77) C109.2@115.07,5062.02 ; R143.2@102.05,5111.57 cw(c86.14,5095.66) 108.64,5095.66 cw(c131.14,5095.66) R143.2@115.23,5111.57 ; C109.2@104.02,5059.19 ccw(c94.1,5069.11) 108.13,5069.11 ccw(c122.16,5069.11) C109.2@112.24,5059.19 ; R143.2@104.88,5114.4 cw(c95.8,5105.32) 108.64,5105.32 cw(c121.48,5105.32) R143.2@112.4,5114.4 ; C109.2@108.13,5055.08 108.13,5083.37 108.64,5083.89 R143.2@108.64,5118.65 135.52,5118.65 137.47,5116.71 v1(149.52,5116.71) ; R146.1@108.64,5309.37 v1(135,5309.37) ; R143.2@112.4,5114.89 cw(c121.48,5105.81) 121.48,5118.65 cw(c121.48,5131.5) R143.2@112.4,5122.41 ; R146.1@112.4,5305.61 cw(c121.48,5296.53) 121.48,5309.37 cw(c121.48,5322.21) R146.1@112.4,5313.13 ; R143.2@115.23,5112.06 cw(c131.14,5096.16) 131.14,5118.65 cw(c131.14,5141.15) R143.2@115.23,5125.24 ; v1@128.28,5302.65 ccw(c112.06,5286.43) 112.06,5309.37 ccw(c112.06,5332.3) v1@128.28,5316.09 ; v1@131.11,5305.48 ccw(c121.72,5296.09) 121.72,5309.37 ccw(c121.72,5322.65) v1@131.11,5313.26
NetC110_1: C110.1 R144.2 R145.2 | length 666
  Bottom Layer w4: C110.1@-161.36,5055.08 -124.92,5055.08 -80.81,5099.19 -80.81,5204.19 ; R145.2@-160.85,5165.08 -119.92,5165.08 -80.81,5204.19 ; R144.2@-160.85,5332.58 -102.58,5332.58 -80.81,5310.81 -80.81,5204.19 ; C110.1@-157.25,5050.97 cw(c-147.33,5041.05) -147.33,5055.08 cw(c-147.33,5069.11) C110.1@-157.25,5059.19 ; R145.2@-157.09,5161.32 cw(c-148.01,5152.24) -148.01,5165.08 cw(c-148.01,5177.92) R145.2@-157.09,5168.84 ; R144.2@-157.09,5328.82 cw(c-148.01,5319.74) -148.01,5332.58 cw(c-148.01,5345.42) R144.2@-157.09,5336.34 ; C110.1@-154.42,5048.14 cw(c-137.67,5031.4) -137.67,5055.08 cw(c-137.67,5078.77) C110.1@-154.42,5062.02 ; R145.2@-154.26,5158.49 cw(c-138.35,5142.58) -138.35,5165.08 cw(c-138.35,5187.58) R145.2@-154.26,5171.67 ; R144.2@-154.26,5325.99 cw(c-138.35,5310.08) -138.35,5332.58 cw(c-138.35,5355.08) R144.2@-154.26,5339.17
NetC115_1: C115.1 C116.1 D8.3 R148.1 U27.14 | length 3410.6
  Top Layer w4: C116.1@3615.19,4854.52 C116.1@3615.67,4855
  Top Layer w12: C115.1@3588.41,5012.47 cw(c3522.61,4946.66) 3615.67,4946.66 ; C115.1@3596.9,5020.95 cw(c3551.58,4975.63) 3615.67,4975.63 ; v1@3611.3,4830.6 ccw(c3600.76,4841.14) 3615.67,4841.14 ; C116.1@3611.56,4859.11 ccw(c3601.64,4869.03) 3615.67,4869.03 ccw(c3629.7,4869.03) C116.1@3619.78,4859.11 ; C116.1@3612.01,4858.66 C116.1@3615.67,4855 ; C115.1@3612.01,5002.69 cw(c3612.01,4912.63) 3675.7,4976.31 ; C115.1@3612.01,5014.69 cw(c3612.01,4953.6) 3655.21,4996.8 ; C115.1@3612.01,5040 C115.1@3615.67,5036.34 ; v1@3615.67,4827.19 C116.1@3615.67,4855 ; 3615.67,4838.83 ccw(c3627.31,4838.83) v1@3619.08,4830.6 ; 3615.67,4964.34 cw(c3683.73,4964.34) C115.1@3635.6,5012.47 ; 3615.67,4993.31 cw(c3654.76,4993.31) C115.1@3627.12,5020.95 ; C115.1@3633.38,5036.06 ccw(c3675.47,5036.06) C115.1@3645.71,5006.3 ; C115.1@3645.38,5036.06 ccw(c3716.44,5036.06) 3666.19,4985.82 ; U27.14@3817.2,4386.77 3853.63,4386.77 ; U27.14@3843.78,4387.66 ccw(c3843.78,4413.59) 3862.11,4395.26 ; v1@3861.3,4821.15 cw(c3851.91,4811.76) 3865.19,4811.76 cw(c3878.47,4811.76) v1@3869.08,4821.15 ; v1(3865.19,4825.04) 3865.19,4398.33 3853.63,4386.77 ; R148.1@3910.06,4299.25 ccw(c3900.98,4308.33) 3913.82,4308.33 ccw(c3926.66,4308.33) R148.1@3917.58,4299.25 ; R148.1@3913.82,4295 3913.82,4378.77 3905.82,4386.77 3853.63,4386.77 ; v1@4268.97,4946.15 ccw(c4259.58,4936.76) 4259.58,4950.04 ccw(c4259.58,4963.32) v1@4268.97,4953.93 ; v1(4272.86,4950.04) 4246.67,4950.04 4205,4991.71 4099.14,4991.71 4089.03,5001.81 3930.28,5001.81 3886.96,4958.5 3693.51,4958.5 C115.1@3615.67,5036.34 ; v1@4343.02,4874.37 cw(c4329.75,4874.37) 4339.14,4864.99 cw(c4348.52,4855.6) v1@4348.52,4868.87 ; v1(4348.52,4874.37) 4317.51,4843.36 4317.51,4677.92 4288.5,4648.91 4288.5,4516.91 4321.5,4483.91 4321.5,4391.7 4403.7,4309.5 4584.07,4309.5 D8.3@4590,4315.43 ; 4576.04,4309.5 cw(c4576.04,4293.75) D8.3@4587.17,4304.89 ; C116.1@3615.67,4855 C115.1@3615.67,5036.34
  MidLayer2 w12: v1(4272.86,4950.04) 4272.86,4946.8 4304.63,4915.02 4313.95,4915.02 4348.52,4880.45 v1(4348.52,4874.37) ; v1@4278.36,4950.04 ccw(c4299.46,4950.04) 4284.54,4935.12 ; 4334.84,4894.13 cw(c4315.09,4874.37) v1@4343.02,4874.37
  Bottom Layer w12: v1(3615.19,4826.71) v1@3863.52,4826.71 ; v1@3619.08,4822.82 cw(c3628.47,4813.43) 3628.47,4826.71 cw(c3628.47,4839.99) v1@3619.08,4830.6 ; 3847.89,4826.71 cw(c3847.89,4807.74) v1@3861.3,4821.15
NetC157_2: C157.2 U61.11 Y5.1 | length 1047.9
  Top Layer w12: v1@5445.64,1965.26 ccw(c5407.74,2003.16) Y5.1@5461.33,2003.16 ; Y5.1@5447.3,2035.7 ccw(c5413.42,2069.58) 5461.33,2069.58 ; v1(5449.52,1961.37) 5461.33,1973.18 C157.2@5461.33,2085 ; v1@5454.12,1956.78 ccw(c5436.71,1974.19) 5461.33,1974.19 ; C157.2@5457.22,2080.89 cw(c5447.3,2070.97) 5461.33,2070.97 cw(c5475.36,2070.97) C157.2@5465.44,2080.89 ; C157.2@5461.33,2075.23 ccw(c5517.23,2075.23) Y5.1@5477.7,2035.7 ; v1@5761.11,2281.11 cw(c5747.26,2267.26) 5766.85,2267.26 ; v1(5765,2285) 5766.85,2283.15 U61.11@5766.85,2240
  MidLayer2 w12: v1(5449.52,1961.37) 5476.37,1961.37 5515.19,2000.19 5515.19,2223.71 v1(5541.52,2250.04) ; v1@5453.41,1957.49 cw(c5462.8,1948.1) 5462.8,1961.37 cw(c5462.8,1974.65) v1@5453.41,1965.26 ; v1@5536.02,2250.04 cw(c5522.75,2250.04) 5532.14,2240.65 cw(c5541.52,2231.26) v1@5541.52,2244.54
  Bottom Layer w12: v1(5541.52,2250.04) 5543.38,2248.19 5625,2248.19 5633.3,2239.89 5729.04,2239.89 5754.89,2239.89 5765,2250 v1(5765,2285) v1@5770.9,2285 ; v1@5545.41,2253.93 ccw(c5559.27,2267.79) 5559.27,2248.19 ; v1@5761.11,2281.11 cw(c5751.72,2271.72) 5765,2271.72 cw(c5778.28,2271.72) v1@5768.89,2281.11
NetC169_2: C169.2 U61.12 Y5.3 | length 1087
  Top Layer w12: C169.2@5539.33,2079.19 cw(c5539.33,2065.16) 5549.25,2075.08 cw(c5559.17,2085) C169.2@5545.14,2085 ; C169.2@5539.33,2085 5561.14,2063.19 5606,2063.19 v1(5609.19,2066.37) 5609.19,1973.6 5560.5,1924.91 5560.5,1856.5 Y5.3@5557.5,1853.5 ; Y5.3@5542.3,1872.7 ccw(c5498.35,1916.65) 5560.5,1916.65 ; Y5.3@5550.78,1864.22 ccw(c5527.32,1887.68) 5560.5,1887.68 ; 5560.5,1902.16 ccw(c5602.16,1902.16) Y5.3@5572.7,1872.7 ; v1@5605.3,2062.49 cw(c5595.91,2053.1) 5609.19,2053.1 cw(c5622.47,2053.1) v1@5613.08,2062.49 ; U61.12@5786.53,2240 5786.53,2273.8 5787.73,2275 5787.73,2298.14 5817.97,2328.37 v1(5820.19,2328.37) ; 5807.01,2317.42 cw(c5820.19,2304.23) v1@5820.19,2322.87
  Bottom Layer w12: v1(5609.19,2066.37) 5609.19,2079.19 5618.21,2088.21 ; v1@5614.27,2068.48 cw(c5631.02,2075.39) 5618.21,2088.21 ; v1@5825.6,2327.38 ccw(c5844.35,2323.92) 5830.87,2310.43 ; v1@5826.63,2328.37 v1(5820.19,2328.37) 5820.19,2321.11 5834.5,2306.8 5834.5,2230.73 5840.69,2224.54 5840.69,2215.9 5768.31,2143.52 5768.31,2089.48 5762.2,2083.37 5664.26,2083.37 5659.43,2088.21 5618.21,2088.21
NetC186_1: C186.1 U61.124 | length 146.3
  Top Layer w4: C186.1@5445,2370.67 5473.52,2370.67 5473.57,2370.72 U61.124@5516.83,2370.72 ; C186.1@5449.11,2366.56 cw(c5459.03,2356.64) 5459.03,2370.67 cw(c5459.03,2384.7) C186.1@5449.11,2374.78 ; C186.1@5451.94,2363.73 cw(c5468.68,2346.98) 5468.68,2370.67 cw(c5468.69,2394.36) C186.1@5451.94,2377.61 ; U61.124@5500.81,2367.89 ccw(c5493.98,2361.06) 5493.98,2370.72 ccw(c5493.98,2380.37) U61.124@5500.81,2373.54
NetC186_2: C186.2 U61.125 | length 155.2
  Top Layer w4: C186.2@5445,2329.33 5466.7,2351.03 U61.125@5516.83,2351.03 ; C186.2@5445,2335.14 ccw(c5445,2349.17) 5454.92,2339.25 ccw(c5464.84,2329.33) C186.2@5450.81,2329.33 ; C186.2@5445,2339.14 ccw(c5445,2362.83) 5461.75,2346.08 ; C186.2@5454.81,2329.33 cw(c5478.5,2329.33) 5461.75,2346.08 ; U61.125@5500.81,2348.2 ccw(c5493.98,2341.37) 5493.98,2351.03 ccw(c5493.98,2360.69) U61.125@5500.81,2353.86
NetC187_1: C187.1 U61.5 | length 815
  Top Layer w4: v1@5629.18,2292.81 cw(c5629.18,2269.88) 5645.4,2286.09 cw(c5661.62,2302.31) v1@5638.68,2302.31 ; v1@5629.18,2296.81 cw(c5629.18,2283.53) 5638.57,2292.92 cw(c5647.96,2302.31) v1@5634.68,2302.31 ; v1(5629.18,2302.31) 5648.74,2282.75 U61.5@5648.74,2240 ; U61.5@5645.91,2256.02 ccw(c5639.08,2262.85) 5648.74,2262.85 ccw(c5658.4,2262.85) U61.5@5651.57,2256.02 ; v2(5650,2025) 5720,2025 5728.08,2033.08 C187.1@5728.08,2085 ; v2@5654.11,2020.89 cw(c5664.03,2010.97) 5664.03,2025 cw(c5664.03,2039.03) v2@5654.11,2029.11 ; v2@5656.94,2018.06 cw(c5673.69,2001.31) 5673.69,2025 cw(c5673.69,2048.69) v2@5656.94,2031.94 ; C187.1@5721.14,2078.06 cw(c5704.39,2061.31) 5728.08,2061.31 cw(c5751.76,2061.31) C187.1@5735.01,2078.06 ; C187.1@5723.97,2080.89 cw(c5714.05,2070.97) 5728.08,2070.97 cw(c5742.1,2070.97) C187.1@5732.18,2080.89
  MidLayer1 w4: v1@5629.18,2292.81 cw(c5629.18,2269.88) 5645.4,2286.09 cw(c5661.62,2302.31) v1@5638.68,2302.31 ; v1@5629.18,2296.81 cw(c5629.18,2283.53) 5638.57,2292.92 cw(c5647.96,2302.31) v1@5634.68,2302.31 ; v1(5629.18,2302.31) 5637.81,2293.68 5647.41,2284.09 5647.41,2088.34 5637.81,2078.74 ; v2@5640.19,2025 ccw(c5616.5,2025) 5633.25,2041.75 ccw(c5650,2058.5) v2@5650,2034.81 ; v2@5644.19,2025 ccw(c5630.16,2025) 5640.08,2034.92 ccw(c5650,2044.84) v2@5650,2030.81 ; v2(5650,2025) 5633.02,2041.98 5633.02,2073.96 ; 5633.02,2073.96 5637.81,2078.74 ; 5633.02,2073.96 5637.81,2078.74
NetC336_1: C336.1 C340.1 U61.9 | length 768.4
  Top Layer w12: v1@5716.11,2291.11 cw(c5688.66,2263.66) 5727.48,2263.66 ; v1(5720,2295) 5718.48,2293.48 5718.48,2288.42 5727.48,2279.42 U61.9@5727.48,2240
  Bottom Layer w12: C340.1@5510,2532.99 5516.34,2539.33 C336.1@5610,2539.33 5610,2455.3 5661.38,2403.93 5661.38,2365 ; C340.1@5529.05,2517.88 cw(c5580.83,2466.1) 5580.83,2539.33 ; C340.1@5537.53,2509.4 cw(c5609.8,2437.13) C336.1@5609.8,2539.33 ; C340.1@5537.53,2556.59 ccw(c5579.2,2598.25) 5579.2,2539.33 ; C336.1@5605.89,2543.44 cw(c5595.97,2553.36) 5595.97,2539.33 cw(c5595.97,2525.3) 5605.89,2535.22 cw(c5595.97,2525.3) 5610,2525.3 cw(c5624.03,2525.3) C336.1@5614.11,2535.22 ; v1@5716.11,2291.11 ccw(c5706.72,2281.72) 5706.72,2295 ccw(c5706.72,2308.28) v1@5716.11,2298.89 ; v1(5720,2295) 5711.9,2295 5690,2295 5661.38,2323.62 5661.38,2345.52 ; 5661.38,2345.52 5661.38,2365 ; 5661.38,2345.52 5661.38,2365
NetC337_1: C337.1 C341.1 U61.118 | length 817.2
  Top Layer w12: U61.118@5516.83,2488.83 5571.17,2488.83 5628.63,2431.37 5648.63,2431.37 5665.19,2414.81 5665.19,2381.37 v1(5638.19,2354.37) ; v1@5638.19,2359.87 ccw(c5638.19,2373.15) 5647.58,2363.76 ccw(c5656.97,2354.37) v1@5643.69,2354.37
  Bottom Layer w4: v1@5638.15,2354.33 v1(5638.19,2354.37)
  Bottom Layer w12: C341.1@5473.94,2123.95 ccw(c5462.01,2120.6) 5462.01,2132.99 ; C341.1@5473.94,2142.03 cw(c5462.01,2145.39) 5462.01,2132.99 ; C341.1@5510,2132.99 5462.01,2132.99 ; 5587.99,2357.64 cw(c5587.99,2332.32) C337.1@5605.89,2350.22 ; 5624.81,2354.33 ccw(c5624.81,2367.76) v1@5634.3,2358.26 ; 5625.02,2354.33 cw(c5625.02,2341.2) v1@5634.3,2350.49 ; v1@5638.15,2354.33 C337.1@5610,2354.33 5606.69,2357.64 5454.49,2357.64 5440,2343.14 5440,2155 5462.01,2132.99
NetC338_1: C338.1 C342.1 U61.85 | length 1360.8
  Top Layer w12: U61.85@5904.65,2837.34 5904.65,2807.4 5915.19,2796.85 5915.19,2681.41 5907.44,2673.66 5907.44,2587.76 5923.52,2571.67 v1(5923.52,2535.71) ; v1@5919.64,2539.6 ccw(c5910.25,2548.99) 5923.52,2548.99 ccw(c5936.8,2548.99) v1@5927.41,2539.6
  Bottom Layer w12: C338.1@5610,2139.33 5637.14,2139.33 5650,2152.19 5650,2205 5668.89,2223.89 5768.89,2223.89 5797.69,2252.69 5797.69,2271.9 5788.5,2281.09 5788.5,2298.91 5797.69,2308.1 5797.69,2353.51 5794.36,2356.84 5794.36,2525.06 5805,2535.71 ; C338.1@5614.11,2135.22 cw(c5624.03,2125.3) 5624.03,2139.33 cw(c5624.03,2153.36) C338.1@5614.11,2143.44 ; C342.1@5715,2532.99 5717.72,2535.71 5805,2535.71 ; C342.1@5734.05,2548.1 ccw(c5763.97,2578.03) 5763.97,2535.71 ; C342.1@5734.18,2518.01 cw(c5776.38,2476.54) 5776.38,2535.71 ; C342.1@5742.53,2556.59 ccw(c5792.94,2607) 5792.94,2535.71 ; C342.1@5742.74,2509.6 cw(c5805,2448.42) 5805,2535.71 ; 5900.34,2539.81 cw(c5900.34,2512.52) v1@5919.64,2531.82 ; v1(5923.52,2535.71) 5919.42,2539.81 5809.1,2539.81 5805,2535.71