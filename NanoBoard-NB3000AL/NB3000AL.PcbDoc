# Altium PCB NB3000AL.PcbDoc (part 62 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetLED24_4: LED24.4 R190.1 | length 5253.8
  Top Layer w4: v1@4564.02,3310.04 cw(c4541.09,3310.04) 4557.31,3293.82 cw(c4573.52,3277.61) v1@4573.52,3300.54 ; v1@4568.02,3310.04 cw(c4554.75,3310.04) 4564.14,3300.65 cw(c4573.52,3291.26) v1@4573.52,3304.54 ; v1(4573.52,3310.04) 4506.52,3243.04 4506.52,3188.04 4524.02,3170.55 4524.02,3164.22 4524.02,3053.28 4524.02,2682.88 4669.72,2537.18 4690.52,2516.37 4690.52,1984.48 4680.71,1974.66 4680.71,1184.52 v1(4831.86,1033.37) ; v1@4822.36,1033.37 ccw(c4799.42,1033.37) 4815.64,1049.59 ccw(c4831.86,1065.81) v1@4831.86,1042.87 ; v1@4826.36,1033.37 ccw(c4813.08,1033.37) 4822.47,1042.76 ccw(c4831.86,1052.15) v1@4831.86,1038.87 ; v1(6415.19,325.04) 6429.96,325.04 LED24.4@6430.79,324.21 ; LED24.4@6439.55,319.96 ccw(c6430.79,313.05) LED24.4@6430.79,324.21 ; LED24.4@6439.55,328.45 cw(c6430.79,335.36) LED24.4@6430.79,324.21 ; LED24.4@6444.94,324.21 LED24.4@6430.79,324.21
  MidLayer2 w4: v1(4831.86,1033.37) 5080,1033.37 5095,1048.37 5095,1075 5103.37,1083.37 5267.56,1083.37 5282.19,1068.75 5282.19,864.67 5299.86,847 5956.92,847 5964.36,839.56 5964.36,826.13 5974.61,815.87 5989.11,815.87 5999.12,815.88 6048.65,766.35 6048.65,521.58 6078.52,491.71 6263.86,491.71 6280.52,508.37 6446.86,508.37 6456.86,498.37 6456.86,366.71 v1(6415.19,325.04) ; v1@4835.75,1029.49 cw(c4845.14,1020.1) 4845.14,1033.37 cw(c4845.14,1046.65) v1@4835.75,1037.26 ; v1@4838.57,1026.66 cw(c4854.79,1010.44) 4854.79,1033.37 cw(c4854.79,1056.31) v1@4838.57,1040.09 ; v1@6415.19,330.54 ccw(c6415.19,343.82) 6424.58,334.43 ccw(c6433.97,325.04) v1@6420.69,325.04 ; v1@6415.19,334.54 ccw(c6415.19,357.48) 6431.41,341.26 ccw(c6447.63,325.04) v1@6424.69,325.04
  Bottom Layer w4: v1(4573.52,3310.04) 4580.19,3310.04 4582.65,3312.5 R190.1@4613.82,3312.5 ; v1@4577.41,3306.15 cw(c4592.74,3290.83) 4592.74,3312.5 ; v1@4580.24,3303.32 cw(c4602.4,3281.17) 4602.4,3312.5 ; v1@4580.24,3316.76 ccw(c4590.52,3327.04) 4590.52,3312.5 ; R190.1@4607.23,3305.91 ccw(c4591.32,3290) 4591.32,3312.5 ccw(c4591.32,3335) R190.1@4607.23,3319.09 ; R190.1@4610.06,3308.74 ccw(c4600.98,3299.66) 4600.98,3312.5 ccw(c4600.98,3325.34) R190.1@4610.06,3316.26
NetLED25_1: LED25.1 R191.1 | length 5444.6
  Top Layer w4: LED25.1@6583.28,324.21 6583.28,348.19 6585.13,350.04 ; 6583.28,345.69 ccw(c6599.84,345.69) LED25.1@6588.13,333.98 ; v1@6599.88,343.59 ccw(c6585.13,329.95) 6585.13,350.04 ; v1@6599.88,356.49 cw(c6585.13,370.13) 6585.13,350.04 ; v1@6602.82,346.31 ccw(c6594.28,338.41) 6594.28,350.04 ccw(c6594.28,361.67) v1@6602.82,353.78 ; v1(6606.86,350.04) 6585.13,350.04
  MidLayer1 w4: v1@4575.14,3525.66 cw(c4558.92,3509.44) 4581.86,3509.44 cw(c4604.79,3509.44) v1@4588.57,3525.66 ; v1@4577.97,3528.49 cw(c4568.58,3519.1) 4581.86,3519.1 cw(c4595.14,3519.1) v1@4585.75,3528.49 ; v1(4581.86,3532.37) 4581.86,3508.37 4665.91,3424.32 4665.91,3420.86 4706.86,3379.91 v1(4706.86,3316.71) ; v1@4700.14,3323.43 ccw(c4683.92,3339.64) 4706.86,3339.64 ccw(c4729.79,3339.64) v1@4713.57,3323.43 ; v1@4702.97,3320.6 ccw(c4693.58,3329.99) 4706.86,3329.99 ccw(c4720.14,3329.99) v1@4710.75,3320.6 ; v1@4756.86,3290.54 cw(c4756.86,3267.61) 4773.07,3283.82 cw(c4789.29,3300.04) v1@4766.36,3300.04 ; v1@4756.86,3294.54 cw(c4756.86,3281.26) 4766.25,3290.65 cw(c4775.64,3300.04) v1@4762.36,3300.04 ; v1(4756.86,3300.04) 4823.52,3233.37 4823.52,2769.08 4723.19,2668.75 4723.19,1966.84 4724.34,1965.69 4724.34,1944.31 4723.19,1943.16 4723.19,1345.02 5208.21,860 6078.69,860 6165.19,773.5 6165.19,425.04 6240.19,350.04 v1(6606.86,350.04) ; v1@6600.14,343.32 ccw(c6583.92,327.11) 6583.92,350.04 ccw(c6583.92,372.98) v1@6600.14,356.76 ; v1@6602.97,346.15 ccw(c6593.58,336.76) 6593.58,350.04 ccw(c6593.58,363.32) v1@6602.97,353.93
  MidLayer2 w4: v1(4706.86,3316.71) 4740.19,3316.71 v1(4756.86,3300.04) ; v1@4710.75,3312.82 cw(c4720.14,3303.43) 4720.14,3316.71 cw(c4720.14,3329.99) v1@4710.75,3320.6 ; v1@4713.57,3309.99 cw(c4729.79,3293.77) 4729.79,3316.71 cw(c4729.79,3339.64) v1@4713.57,3323.43 ; v1@4747.36,3300.04 ccw(c4724.42,3300.04) 4740.64,3316.26 ccw(c4756.86,3332.48) v1@4756.86,3309.54 ; v1@4751.36,3300.04 ccw(c4738.08,3300.04) 4747.47,3309.43 ccw(c4756.86,3318.82) v1@4756.86,3305.54
  Bottom Layer w4: v1@4579.78,3533.76 cw(c4591.42,3526.01) 4591.42,3540 ; v1(4581.86,3532.37) 4581.86,3533.37 4588.48,3540 R191.1@4613.82,3540 ccw(c4613.82,3511.11) v1@4589.77,3527.11 ; v1@4583.11,3531.54 cw(c4598.89,3521.05) 4598.89,3540 ; v1@4586.44,3529.33 cw(c4606.35,3516.08) R191.1@4606.35,3540 ; R191.1@4610.06,3536.24 ccw(c4600.98,3527.16) 4600.98,3540 ccw(c4600.98,3552.84) R191.1@4610.06,3543.76
NetLED25_3: LED25.3 R192.1 | length 6499.9
  Top Layer w4: v1(6515.19,225.04) LED25.3@6535,225.04 ; v1@6522.6,219.09 cw(c6535,209.14) 6535,225.04 cw(c6535,240.94) v1@6522.6,230.99 ; LED25.3@6536.35,223.69 LED25.3@6535,225.04 ; LED25.3@6551.23,215.96 ccw(c6539.53,204.25) 6539.53,220.81 ccw(c6539.53,237.36) LED25.3@6551.23,225.66 ; LED25.3@6556.08,220.81 6539.23,220.81 LED25.3@6535,225.04
  MidLayer1 w4: v1@4581.86,3409.21 cw(c4581.86,3386.27) 4598.07,3402.49 cw(c4614.29,3418.71) v1@4591.36,3418.71 ; v1@4581.86,3413.21 cw(c4581.86,3399.93) 4591.25,3409.32 cw(c4600.64,3418.71) v1@4587.36,3418.71 ; v1(4581.86,3418.71) 4623.52,3377.04 4623.52,3211.35 4656.86,3178.02 4656.86,3141.71 4706.86,3091.71 4706.86,3075.04 4696.82,3065 4665,3065 4631.86,3098.14 4631.86,3125.04 4615.19,3141.71 4565.19,3141.71 4548.52,3125.04 4548.52,3026.48 4585.19,2989.81 4585.19,2938.39 4455.19,2808.39 4455.19,2450.35 4394.81,2389.97 4394.81,1222.18 4294,1121.37 4294,246.04 4315,225.04 v1(4623.52,225.04) ; v1@4616.81,218.32 ccw(c4600.59,202.11) 4600.59,225.04 ccw(c4600.59,247.98) v1@4616.81,231.76 ; v1@4619.64,221.15 ccw(c4610.25,211.76) 4610.25,225.04 ccw(c4610.25,238.32) v1@4619.64,228.93
  MidLayer2 w4: v1(4623.52,225.04) 4631.86,225.04 4814.63,407.81 4955.05,407.81 5127.67,235.19 5202.06,235.19 5236.88,200.37 5401.84,200.37 5435.17,233.71 6476.33,233.71 6485,225.04 v1(6515.19,225.04) ; v1@4623.52,226.54 ccw(c4623.52,250.28) 4640.31,233.49 ; v1@4623.52,230.54 ccw(c4623.52,263.94) 4647.14,240.32 ; v1@4623.52,234.54 ccw(c4623.52,277.59) 4653.97,247.15 ; v1@6508.47,218.32 ccw(c6492.26,202.11) 6492.26,225.04 ccw(c6492.26,247.98) v1@6508.47,231.76 ; v1@6511.3,221.15 ccw(c6501.91,211.76) 6501.91,225.04 ccw(c6501.91,238.32) v1@6511.3,228.93
  Bottom Layer w4: v1(4581.86,3418.71) 4588.19,3425.04 R192.1@4613.82,3425.04 ; v1@4583.05,3417.8 cw(c4597.67,3406.67) 4597.67,3425.04 ; v1@4586.23,3415.38 cw(c4605.74,3400.52) R192.1@4605.74,3425.04 ; v1@4589.42,3412.95 cw(c4613.82,3394.37) R192.1@4613.82,3425.04 ; 4599.25,3425.04 ccw(c4599.25,3440.33) R192.1@4610.06,3429.52 ; R192.1@4613.82,3426.25 R192.1@4613.82,3425.04
NetLED25_4: LED25.4 R193.1 | length 6047.5
  Top Layer w4: v1@6543.2,366.51 cw(c6536.41,356.48) 6548.52,356.48 ; v1(6548.52,374.37) 6548.52,356.48 ; LED25.4@6551.33,333.98 ccw(c6539.63,345.69) 6556.18,345.69 ; v1@6553.85,366.51 ccw(c6560.63,356.48) 6548.52,356.48 ; LED25.4@6556.18,324.21 6556.18,348.82 6548.52,356.48 ; LED25.4@6556.86,321.33 LED25.4@6556.86,324.21
  MidLayer1 w4: v1@4581.86,3473.87 cw(c4581.86,3450.94) 4598.07,3467.16 cw(c4614.29,3483.37) v1@4591.36,3483.37 ; v1@4581.86,3477.87 cw(c4581.86,3464.6) 4591.25,3473.99 cw(c4600.64,3483.37) v1@4587.36,3483.37 ; v1(4581.86,3483.37) 4665.19,3400.04 4665.19,3325 4692.86,3297.33 4692.86,3272.37 v1(4692.86,3258.37) ; v1@4722.36,216.71 ccw(c4699.42,216.71) 4715.64,232.93 ccw(c4731.86,249.14) v1@4731.86,226.21 ; v1@4726.36,216.71 ccw(c4713.08,216.71) 4722.47,226.1 ccw(c4731.86,235.49) v1@4731.86,222.21 ; v1(4731.86,216.71) 4632.6,315.97 4598.52,350.04 4598.52,2578.02 4799.52,2779.02 4799.52,3090.71 v1(4756.86,3133.37) ; v1@4756.86,3123.87 cw(c4756.86,3100.94) 4773.07,3117.16 cw(c4789.29,3133.37) v1@4766.36,3133.37 ; v1@4756.86,3127.87 cw(c4756.86,3114.6) 4766.25,3123.99 cw(c4775.64,3133.37) v1@4762.36,3133.37
  MidLayer2 w4: v1@4692.86,3248.87 cw(c4692.86,3225.94) 4709.07,3242.16 cw(c4725.29,3258.37) v1@4702.36,3258.37 ; v1@4692.86,3252.87 cw(c4692.86,3239.6) 4702.25,3248.99 cw(c4711.64,3258.37) v1@4698.36,3258.37 ; v1(4692.86,3258.37) 4723.52,3227.71 4736.23,3215 4760,3215 4775,3200 4775,3151.52 v1(4756.86,3133.37) ; v1@4756.86,3138.87 ccw(c4756.86,3152.15) 4766.25,3142.76 ccw(c4775.64,3133.37) v1@4762.36,3133.37 ; v1@4756.86,3142.87 ccw(c4756.86,3165.81) 4773.07,3149.59 ccw(c4789.29,3133.37) v1@4766.36,3133.37
  Bottom Layer w4: v1(4581.86,3483.37) 4613.15,3483.37 4613.61,3482.92 4613.82,3482.71 4613.82,3482.63 R193.1@4613.82,3483.12 ; v1@4585.75,3479.49 cw(c4595.14,3470.1) 4595.14,3483.37 cw(c4595.14,3496.65) v1@4585.75,3487.26 ; v1@4588.57,3476.66 cw(c4604.79,3460.44) 4604.79,3483.37 cw(c4604.79,3506.31) v1@4588.57,3490.09 ; 4600.39,3483.37 ccw(c4600.39,3497.04) R193.1@4610.06,3487.38 ; 4601.56,3483.37 cw(c4601.56,3471.36) R193.1@4610.06,3479.86 ; v1@4725.14,223.43 ccw(c4708.92,239.64) 4731.86,239.64 ccw(c4754.79,239.64) v1@4738.57,223.43 ; v1@4727.97,220.6 ccw(c4718.58,229.99) 4731.86,229.99 ccw(c4745.14,229.99) v1@4735.75,220.6 ; v1(4731.86,216.71) 4731.86,258.4 4752.64,279.19 5150.69,279.19 5163.21,291.71 5635,291.71 5654.21,272.5 5677.75,272.5 5709.32,272.5 5795.19,358.37 6460,358.37 6476,374.37 v1(6548.52,374.37) ; v1@6541.81,367.66 ccw(c6525.59,351.44) 6525.59,374.37 ccw(c6525.59,397.31) v1@6541.81,381.09 ; v1@6544.64,370.49 ccw(c6535.25,361.1) 6535.25,374.37 ccw(c6535.25,387.65) v1@6544.64,378.26
NetQ4_1: Q4.1 R96.2 | length 284.7
  Top Layer w4: R96.2@4733.41,5262.23 cw(c4717.5,5246.32) 4740,5246.32 cw(c4762.5,5246.32) R96.2@4746.59,5262.23 ; R96.2@4736.24,5265.06 cw(c4727.16,5255.98) 4740,5255.98 cw(c4752.84,5255.98) R96.2@4743.76,5265.06 ; R96.2@4740,5268.82 4740,5233.79 4748,5225.79 Q4.1@4797.6,5225.79 ; Q4.1@4786.49,5214.67 ccw(c4759.66,5187.85) 4759.66,5225.79 ccw(c4759.65,5263.73) Q4.1@4786.49,5236.9 ; Q4.1@4789.31,5217.5 ccw(c4769.31,5197.5) 4769.31,5225.79 ccw(c4769.31,5254.07) Q4.1@4789.31,5234.07 ; Q4.1@4792.14,5220.33 ccw(c4778.97,5207.16) 4778.97,5225.79 ccw(c4778.97,5244.42) Q4.1@4792.14,5231.24
NetQ6_1: Q6.1 R125.2 | length 231.7
  Top Layer w4: R125.2@5330,5268.82 5366.18,5268.82 5372.6,5262.4 ; R125.2@5334.25,5265.06 cw(c5343.33,5255.98) 5343.33,5268.82 cw(c5343.33,5281.66) R125.2@5334.25,5272.58 ; R125.2@5337.08,5262.23 cw(c5352.99,5246.32) 5352.99,5268.82 cw(c5352.99,5291.32) R125.2@5337.08,5275.41 ; Q6.1@5362,5238.38 ccw(c5340.07,5262.4) 5372.6,5262.4 ; Q6.1@5364.7,5235.42 ccw(c5348.35,5253.33) 5372.6,5253.33 ccw(c5396.85,5253.33) Q6.1@5380.5,5235.42 ; Q6.1@5372.6,5225.79 5372.6,5262.4 ; Q6.1@5383.19,5238.38 cw(c5405.12,5262.4) 5372.6,5262.4
NetQ7_1: Q7.1 R127.2 | length 205.1
  Top Layer w4: R127.2@5910,5268.82 5948.78,5268.82 5962.6,5255 Q7.1@5962.6,5225.79 ; R127.2@5914.25,5265.06 cw(c5923.33,5255.98) 5923.33,5268.82 cw(c5923.33,5281.66) R127.2@5914.25,5272.58 ; R127.2@5917.08,5262.23 cw(c5932.99,5246.32) 5932.99,5268.82 cw(c5932.99,5291.32) R127.2@5917.08,5275.41 ; Q7.1@5954.32,5240.13 ccw(c5945.11,5255) 5962.6,5255 ccw(c5980.09,5255) Q7.1@5970.88,5240.13 ; Q7.1@5956.43,5236.73 ccw(c5949.56,5247.81) 5962.6,5247.81 ccw(c5975.64,5247.81) Q7.1@5968.77,5236.73
NetQ8_1: Q8.1 R129.2 | length 197.2
  Top Layer w4: R129.2@6505,5268.82 6539.6,5268.82 6547.6,5260.82 ; R129.2@6509.25,5265.06 cw(c6518.33,5255.98) 6518.33,5268.82 cw(c6518.33,5281.66) R129.2@6509.25,5272.58 ; R129.2@6512.08,5262.23 cw(c6527.99,5246.32) 6527.99,5268.82 cw(c6527.99,5291.32) R129.2@6512.08,5275.41 ; Q8.1@6539,5244.93 ccw(c6528.62,5260.82) 6547.6,5260.82 ; Q8.1@6541.19,5241.58 ccw(c6533.45,5253.43) 6547.6,5253.43 ccw(c6561.75,5253.42) Q8.1@6554.01,5241.58 ; Q8.1@6547.6,5230.79 6547.6,5260.82 ; Q8.1@6556.2,5244.93 cw(c6566.58,5260.82) 6547.6,5260.82
NetQ11_1: Q11.1 R214.1 | length 342.5
  Top Layer w4: R214.1@6831.18,2615 6860,2615 6890.79,2645.79 Q11.1@7027.6,2645.79 ; Q11.1@7016.49,2634.67 ccw(c6989.66,2607.85) 6989.66,2645.79 ccw(c6989.65,2683.73) Q11.1@7016.49,2656.9 ; Q11.1@7019.31,2637.5 ccw(c6999.31,2617.5) 6999.31,2645.79 ccw(c6999.31,2674.07) Q11.1@7019.31,2654.07 ; Q11.1@7022.14,2640.33 ccw(c7008.97,2627.16) 7008.97,2645.79 ccw(c7008.97,2664.42) Q11.1@7022.14,2651.24
NetR9_2: R9.2 R10.1 | length 168.7
  Bottom Layer w4: R10.1@-278.82,4017.73 R9.2@-221.18,4017.73 ; R10.1@-275.06,4013.97 cw(c-265.98,4004.89) -265.98,4017.73 cw(c-265.98,4030.57) R10.1@-275.06,4021.49 ; R10.1@-272.23,4011.14 cw(c-256.32,3995.23) -256.32,4017.73 cw(c-256.32,4040.23) R10.1@-272.23,4024.32 ; R9.2@-227.77,4011.14 ccw(c-243.68,3995.23) -243.68,4017.73 ccw(c-243.68,4040.23) R9.2@-227.77,4024.32 ; R9.2@-224.94,4013.97 ccw(c-234.02,4004.89) -234.02,4017.73 ccw(c-234.02,4030.57) R9.2@-224.94,4021.49
NetR16_1: R16.1 U1.4 | length 234
  Top Layer w4: U1.4@-320,2759.41 -275.59,2759.41 -260,2775 -260,2799.85 v1(-259.81,2800.04) ; U1.4@-300.26,2755.81 cw(c-291.58,2747.13) -291.58,2759.41 cw(c-291.58,2771.69) U1.4@-300.26,2763.01 ; v1@-266.53,2793.32 cw(c-282.29,2777.56) -260,2777.56 ; v1@-263.7,2796.15 cw(c-272.63,2787.22) -260,2787.22 ; -260,2776.65 cw(c-236.42,2776.65) v1@-253.09,2793.32 ; -260,2786.3 cw(c-246.07,2786.3) v1@-255.92,2796.15
  Bottom Layer w4: R16.1@-298.82,2795 -280.48,2795 ; R16.1@-291.29,2789.5 cw(c-280.48,2781.61) -280.48,2795 ; R16.1@-291.29,2800.5 ccw(c-280.48,2808.39) -280.48,2795 ; v1(-259.81,2800.04) -275.43,2800.04 -280.48,2795
NetR17_1: R17.1 U1.1 | length 356.2
  Top Layer w4: U1.1@-320,2835 -285,2835 v1(-265,2855) v1@-264.77,2855 ; U1.1@-300.26,2831.4 cw(c-291.58,2822.72) -291.58,2835 cw(c-291.58,2847.28) U1.1@-300.26,2838.6 ; v1@-274.5,2855 cw(c-297.44,2855) -281.22,2838.78 cw(c-265,2822.56) v1@-265,2845.5 ; v1@-270.5,2855 cw(c-283.78,2855) -274.39,2845.61 cw(c-265,2836.22) v1@-265,2849.5
  Bottom Layer w4: R17.1@-295.06,2841.24 cw(c-285.98,2832.16) -285.98,2845 cw(c-285.98,2857.84) R17.1@-295.06,2848.76 ; R17.1@-292.23,2838.41 cw(c-276.32,2822.5) -276.32,2845 cw(c-276.32,2867.5) R17.1@-292.23,2851.59 ; R17.1@-291.88,2845 ccw(c-291.88,2870.56) v1@-269.76,2857.76 ; -284.94,2845 ccw(c-284.94,2866.54) v1@-266.3,2855.75 ; -278.01,2845 ccw(c-278.01,2862.53) v1@-262.84,2853.75 ; v1@-273.22,2859.76 cw(c-298.82,2874.57) R17.1@-298.82,2845 -265,2845 -264.85,2845 -259.93,2849.93 -259.81,2850.04 -264.77,2855 v1(-265,2855) ; -271.07,2845 ccw(c-271.07,2858.51) v1@-259.37,2851.74
NetR18_2: R18.2 U1.2 | length 346.2
  Top Layer w4: U1.2@-320,2809.8 -286.11,2809.8 -260.16,2835.75 -254.25,2835.75 -247.5,2842.5 -247.5,2868.23 -254.27,2875 -266.18,2875 -283.98,2892.79 -283.98,2917.54 ; U1.2@-300.26,2806.21 cw(c-291.58,2797.52) -291.58,2809.8 cw(c-291.58,2822.08) U1.2@-300.26,2813.4 ; v1@-277.31,2933.69 cw(c-300.07,2933.63) -283.98,2917.54 ; v1@-273.31,2933.7 cw(c-286.48,2933.67) -277.17,2924.35 cw(c-267.85,2915.03) v1@-267.82,2928.21 ; v1@-267.83,2924.21 ccw(c-267.88,2901.45) -283.98,2917.54 ; v1(-267.81,2933.71) -283.98,2917.54
  Bottom Layer w4: R18.2@-298.82,2945 -279.1,2945 ; R18.2@-291.62,2939.08 cw(c-279.1,2928.8) -279.1,2945 ; R18.2@-291.62,2950.92 ccw(c-279.1,2961.2) -279.1,2945 ; v1(-267.81,2933.71) -279.1,2945
NetR19_1: R19.1 R21.2 U1.7 | length 458.8
  Top Layer w4: U1.7@-320,2683.82 -273.82,2683.82 -245,2655 v1(-245,2635) ; U1.7@-300.26,2680.22 cw(c-291.58,2671.54) -291.58,2683.82 cw(c-291.58,2696.1) U1.7@-300.26,2687.42 ; v1@-251,2642.36 ccw(c-261.3,2655) -245,2655 ccw(c-228.7,2655) v1@-239,2642.36 ; v1@-248.47,2639.26 ccw(c-254.44,2646.58) -245,2646.58 ccw(c-235.56,2646.58) v1@-241.53,2639.26
  Bottom Layer w4: R19.1@-305.41,2552.08 ccw(c-321.32,2567.99) -298.82,2567.99 ccw(c-276.32,2567.99) R19.1@-292.23,2552.08 ; R21.2@-305.41,2587.92 cw(c-321.32,2572.01) -298.82,2572.01 cw(c-276.32,2572.01) R21.2@-292.23,2587.92 ; R19.1@-302.58,2549.25 ccw(c-311.66,2558.33) -298.82,2558.33 ccw(c-285.98,2558.33) R19.1@-295.06,2549.25 ; R21.2@-302.58,2590.75 cw(c-311.66,2581.67) -298.82,2581.67 cw(c-285.98,2581.67) R21.2@-295.06,2590.75 ; R19.1@-298.82,2545 R21.2@-298.82,2595 -268.82,2625 -255,2625 v1(-245,2635) ; R21.2@-298.82,2600.81 ccw(c-298.82,2614.84) R21.2@-288.9,2604.92 ; R21.2@-298.82,2604.81 ccw(c-298.82,2628.5) -282.07,2611.75 ; R21.2@-293.5,2595.49 cw(c-281.85,2595.49) R21.2@-290.09,2603.73 ; R21.2@-289.5,2595.49 cw(c-268.19,2595.49) -283.26,2610.56
NetR20_2: R20.2 U1.3 | length 378
  Top Layer w4: U1.3@-300.26,2781.01 cw(c-290.63,2771.38) -290.63,2785 ; U1.3@-300.26,2788.2 ccw(c-292.53,2795.94) -292.53,2785 ; v1@-266.48,2890.54 cw(c-266.48,2871.29) -252.86,2884.9 ; v1(-266.48,2900.04) -266.48,2898.52 -239.5,2871.54 -239.5,2838.25 -250,2827.75 -256.85,2827.75 -280,2804.6 -280,2790 -285,2785 U1.3@-319.61,2785 ; v1@-260.98,2900.04 ccw(c-244.02,2900.04) -256.01,2888.05 ; v1@-256.98,2900.04 ccw(c-230.36,2900.04) -249.18,2881.22 ; U1.3@-319.61,2785 U1.3@-320,2784.61 U1.3@-319.61,2785
  Bottom Layer w4: R20.2@-295.06,2891.24 cw(c-285.98,2882.16) -285.98,2895 cw(c-285.98,2907.84) R20.2@-295.06,2898.76 ; R20.2@-289.92,2895 ccw(c-289.92,2920.84) v1@-270.59,2903.69 ; -281.02,2895 ccw(c-281.02,2912.95) v1@-267.6,2901.04 ; -277.24,2895 cw(c-277.24,2889.28) v1@-273.19,2893.32 ; v1@-273.58,2906.35 cw(c-298.82,2928.74) R20.2@-298.82,2895 -271.52,2895 v1(-266.48,2900.04)
NetR23_2: R23.2 U1.22 | length 289
  Top Layer w4: U1.22@-79.84,2784.61 12.42,2784.61 v1(61.52,2833.71) ; U1.22@-60.1,2781.01 cw(c-51.42,2772.33) -51.42,2784.61 cw(c-51.42,2796.89) U1.22@-60.1,2788.2 ; v1@52.02,2833.71 cw(c29.09,2833.71) 45.31,2817.49 cw(c61.52,2801.27) v1@61.52,2824.21 ; v1@56.02,2833.71 cw(c42.75,2833.71) 52.14,2824.32 cw(c61.52,2814.93) v1@61.52,2828.21
  Bottom Layer w4: v1(61.52,2833.71) 72.82,2845 ; R23.2@80.71,2840.4 ccw(c72.82,2835.92) 72.82,2845 ; R23.2@80.71,2849.6 cw(c72.82,2854.08) 72.82,2845 ; R23.2@88.82,2845 72.82,2845
NetR24_2: R24.2 U1.23 | length 452.8
  Top Layer w4: U1.23@-79.84,2809.8 9.8,2809.8 48.52,2848.52 v1(48.52,2925.71) ; U1.23@-60.1,2806.21 cw(c-51.42,2797.52) -51.42,2809.8 cw(c-51.42,2822.08) U1.23@-60.1,2813.4 ; v1@41.81,2918.99 cw(c25.59,2902.77) 48.52,2902.77 cw(c71.46,2902.77) v1@55.24,2918.99 ; v1@44.64,2921.82 cw(c35.25,2912.43) 48.52,2912.43 cw(c61.8,2912.43) v1@52.41,2921.82
  Bottom Layer w4: v1(48.52,2925.71) 67.82,2945 ; v1@48.52,2931.21 ccw(c48.52,2944.49) 57.91,2935.1 ccw(c67.3,2925.71) v1@54.02,2925.71 ; v1@48.52,2935.21 ccw(c48.52,2958.14) 64.74,2941.93 ccw(c80.96,2925.71) v1@58.02,2925.71 ; R24.2@81.91,2938.75 ccw(c67.82,2925.99) 67.82,2945 ; R24.2@81.91,2951.25 cw(c67.82,2964.01) 67.82,2945 ; R24.2@84.88,2941.43 ccw(c76.83,2934.15) 76.83,2945 ccw(c76.83,2955.85) R24.2@84.88,2948.57 ; R24.2@88.82,2945 67.82,2945
NetR31_1: R31.1 U3.8 | length 870.4
  MidLayer2 w4: v1(4240.19,1050.04) 4265.19,1075.04 4265.19,1233.37 4274.52,1242.71 4320,1242.71 4327,1235.71 v1(4462.86,1235.71) ; v1@4240.19,1055.54 ccw(c4240.19,1068.82) 4249.58,1059.43 ccw(c4258.97,1050.04) v1@4245.69,1050.04 ; v1@4240.19,1059.54 ccw(c4240.19,1082.48) 4256.41,1066.26 ccw(c4272.63,1050.04) v1@4249.69,1050.04 ; v1@4456.14,1228.99 ccw(c4439.92,1212.77) 4439.92,1235.71 ccw(c4439.92,1258.64) v1@4456.14,1242.43 ; v1@4458.97,1231.82 ccw(c4449.58,1222.43) 4449.58,1235.71 ccw(c4449.58,1248.99) v1@4458.97,1239.6
  Bottom Layer w4: U3.8@4076.5,1046.46 4118.52,1046.46 4122.11,1050.04 v1(4240.19,1050.04) ; U3.8@4105.8,1043.63 cw(c4112.63,1036.8) 4112.63,1046.46 cw(c4112.63,1056.12) U3.8@4105.8,1049.29 ; v1@4233.47,1043.32 ccw(c4217.26,1027.11) 4217.26,1050.04 ccw(c4217.26,1072.98) v1@4233.47,1056.76 ; v1@4236.3,1046.15 ccw(c4226.91,1036.76) 4226.91,1050.04 ccw(c4226.91,1063.32) v1@4236.3,1053.93 ; v1@4462.86,1226.21 cw(c4462.86,1203.27) 4479.07,1219.49 cw(c4495.29,1235.71) v1@4472.36,1235.71 ; v1@4462.86,1230.21 cw(c4462.86,1216.93) 4472.25,1226.32 cw(c4481.64,1235.71) v1@4468.36,1235.71 ; v1(4462.86,1235.71) 4480,1218.56 ; R31.1@4474.84,1208.94 ccw(c4468.45,1218.56) 4480,1218.56 ; R31.1@4480,1201.18 4480,1218.56 ; R31.1@4485.16,1208.94 cw(c4491.55,1218.56) 4480,1218.56
NetR31_2: R31.2 R32.1 | length 173.7
  Bottom Layer w4: R32.1@4473.41,1102.77 ccw(c4457.5,1118.68) 4480,1118.68 ccw(c4502.5,1118.68) R32.1@4486.59,1102.77 ; R31.2@4473.41,1152.23 cw(c4457.5,1136.32) 4480,1136.32 cw(c4502.5,1136.32) R31.2@4486.59,1152.23 ; R32.1@4476.24,1099.94 ccw(c4467.16,1109.02) 4480,1109.02 ccw(c4492.84,1109.02) R32.1@4483.76,1099.94 ; R31.2@4476.24,1155.06 cw(c4467.16,1145.98) 4480,1145.98 cw(c4492.84,1145.98) R31.2@4483.76,1155.06 ; R32.1@4480,1096.18 R31.2@4480,1158.82
NetR32_2: R32.2 R33.2 T1.4 | length 1510.1
  MidLayer1 w4: v1@4503.28,1393.28 cw(c4487.06,1377.06) 4510,1377.06 cw(c4532.93,1377.06) v1@4516.72,1393.28 ; v1@4506.11,1396.11 cw(c4496.72,1386.72) 4510,1386.72 cw(c4523.28,1386.72) v1@4513.89,1396.11 ; v1(4510,1400) 4510,1361.81 4498.19,1350 4498.19,1121.81 4530,1090 4530,1060 v1(4515,1045)
  Bottom Layer w4: R33.2@4421.59,956.08 ccw(c4405.68,971.99) 4428.18,971.99 ccw(c4450.68,971.99) R33.2@4434.77,956.08 ; R33.2@4424.42,953.25 ccw(c4415.34,962.33) 4428.18,962.33 ccw(c4441.02,962.33) R33.2@4431.94,953.25 ; R33.2@4428.18,949 4428.18,1048.18 4433.82,1053.82 R32.2@4480,1053.82 4488.82,1045 v1(4515,1045) ; R32.2@4472.92,1047.23 ccw(c4457.01,1031.32) 4457.01,1053.82 ccw(c4457.01,1076.32) R32.2@4472.92,1060.41 ; R32.2@4475.75,1050.06 ccw(c4466.67,1040.98) 4466.67,1053.82 ccw(c4466.67,1066.66) R32.2@4475.75,1057.58 ; R32.2@4478.28,1052.3 ccw(c4492.17,1061.86) 4492.17,1045 ; R32.2@4481.58,1054.57 ccw(c4499.78,1067.1) 4499.78,1045 ; v1@4508.28,1038.28 ccw(c4492.06,1022.06) 4492.06,1045 ccw(c4492.06,1067.93) v1@4508.28,1051.72 ; v1(4510,1400) 4550,1400 4565,1385 4960,1385 4968,1393 ; v1@4511.11,1041.11 ccw(c4501.72,1031.72) 4501.72,1045 ccw(c4501.72,1058.28) v1@4511.11,1048.89 ; v1@4513.89,1396.11 cw(c4523.28,1386.72) 4523.28,1400 cw(c4523.28,1413.28) v1@4513.89,1403.89 ; v1@4516.72,1393.28 cw(c4532.93,1377.06) 4532.93,1400 cw(c4532.93,1422.93) v1@4516.72,1406.72 ; T1.4@4957.35,1410.57 cw(c4948.18,1393) 4968,1393 ; T1.4@4959.2,1414.12 cw(c4951.62,1399.6) 4968,1399.6 cw(c4984.38,1399.6) T1.4@4976.8,1414.12 ; T1.4@4968,1466 4968,1393 ; T1.4@4978.65,1410.57 ccw(c4987.82,1393) 4968,1393
NetR33_1: R33.1 R34.1 | length 194.1
  Bottom Layer w4: R34.1@4318.52,939.19 cw(c4318.52,915.5) 4335.27,932.25 ; R34.1@4318.52,943.19 cw(c4318.52,929.16) R34.1@4328.44,939.08 ; R34.1@4318.52,949 4337.52,930 4366.82,930 R33.1@4385.82,949 ; R34.1@4323.84,948.51 ccw(c4335.49,948.51) R34.1@4327.25,940.27 ; R34.1@4327.84,948.51 ccw(c4349.15,948.51) 4334.08,933.44 ; 4369.07,932.25 cw(c4385.82,915.5) R33.1@4385.82,939.19 ; 4370.26,933.44 ccw(c4355.19,948.51) R33.1@4376.5,948.51 ; R33.1@4375.9,939.08 cw(c4385.82,929.16) R33.1@4385.82,943.19 ; R33.1@4377.09,940.27 ccw(c4368.85,948.51) R33.1@4380.5,948.51
NetR35_1: R35.1 R37.1 U3.1 | length 1146.3
  MidLayer1 w4: v1(4355,950) 4423.52,1018.52 v1(4423.52,1192.37) ; v1@4355,955.5 ccw(c4355,968.78) 4364.39,959.39 ccw(c4373.78,950) v1@4360.5,950 ; v1@4355,959.5 ccw(c4355,982.43) 4371.22,966.22 ccw(c4387.43,950) v1@4364.5,950 ; v1@4416.81,1185.66 cw(c4400.59,1169.44) 4423.52,1169.44 cw(c4446.46,1169.44) v1@4430.24,1185.66 ; v1@4419.64,1188.49 cw(c4410.25,1179.1) 4423.52,1179.1 cw(c4436.8,1179.1) v1@4427.41,1188.49
  MidLayer2 w4: v1(4240,950) v1(4355,950) ; v1@4243.89,946.11 cw(c4253.28,936.72) 4253.28,950 cw(c4253.28,963.28) v1@4243.89,953.89 ; v1@4246.72,943.28 cw(c4262.93,927.06) 4262.93,950 cw(c4262.93,972.93) v1@4246.72,956.72 ; v1@4348.28,943.28 ccw(c4332.06,927.06) 4332.06,950 ccw(c4332.06,972.93) v1@4348.28,956.72 ; v1@4351.11,946.11 ccw(c4341.72,936.72) 4341.72,950 ccw(c4341.72,963.28) v1@4351.11,953.89
  Bottom Layer w4: R37.1@4208.86,949 4209.86,950 v1(4240,950) ; R37.1@4212.62,945.73 cw(c4222.93,935.42) 4222.93,950 ; R37.1@4212.62,953.25 ccw(c4220.48,961.11) 4220.48,950 ; v1@4233.28,943.28 ccw(c4217.06,927.06) 4217.06,950 ccw(c4217.06,972.93) v1@4233.28,956.72 ; v1@4236.11,946.11 ccw(c4226.72,936.72) 4226.72,950 ccw(c4226.72,963.28) v1@4236.11,953.89 ; U3.1@4295,1200 4340.19,1200 4341.37,1201.18 4414.72,1201.18 ; U3.1@4324.31,1197.17 cw(c4331.14,1190.34) 4331.14,1200 cw(c4331.14,1209.66) U3.1@4324.31,1202.83 ; 4379.33,1201.18 cw(c4379.33,1148.18) v1@4416.81,1185.66 ; R35.1@4387.92,1194.59 ccw(c4372.01,1178.68) 4372.01,1201.18 ccw(c4372.01,1223.68) R35.1@4387.92,1207.77 ; R35.1@4388.99,1201.18 cw(c4388.99,1157.84) v1@4419.64,1188.49 ; R35.1@4390.75,1197.42 ccw(c4381.67,1188.34) 4381.67,1201.18 ccw(c4381.67,1214.02) R35.1@4390.75,1204.94 ; R35.1@4398.64,1201.18 cw(c4398.64,1167.49) v1@4422.46,1191.31 ; R35.1@4401.23,1201.18 cw(c4401.23,1182.16) v1@4418.52,1190.08 ; 4407.47,1201.18 cw(c4407.47,1185.02) v1@4422.16,1191.75 ; 4408.3,1201.18 cw(c4408.3,1177.15) v1@4425.29,1194.14 ; 4413.7,1201.18 cw(c4413.7,1187.87) v1@4425.8,1193.42 ; v1@4414.89,1188.42 ccw(c4395,1179.31) R35.1@4395,1201.18 4414.72,1201.18 ; v1(4423.52,1192.37) 4414.72,1201.18
NetR35_2: R35.2 R38.2 U3.2 U3.3 | length 547.3
  Bottom Layer w4: 4261.86,1148.67 cw(c4294.26,1148.67) U3.2@4271.35,1171.58 ; 4261.86,1155.21 ccw(c4274.85,1155.21) U3.3@4265.7,1145.98 ; 4261.86,1158.33 cw(c4284.6,1158.33) U3.2@4268.52,1174.41 ; 4261.86,1164.81 ccw(c4284.37,1164.81) U3.3@4268.52,1148.82 ; 4261.86,1167.98 cw(c4274.95,1167.98) U3.2@4265.69,1177.24 ; U3.3@4271.34,1151.66 cw(c4293.89,1174.41) 4261.86,1174.41 ; U3.2@4295,1174.41 4261.86,1174.41 ; U3.3@4324.31,1145.99 cw(c4331.14,1139.16) 4331.14,1148.82 cw(c4331.14,1158.48) U3.3@4324.31,1151.65 ; R35.2@4387.92,1152.23 ccw(c4372.01,1136.32) 4372.01,1158.82 ccw(c4372.01,1181.32) R35.2@4387.92,1165.41 ; R38.2@4388.41,1102.77 ccw(c4372.5,1118.68) 4395,1118.68 ccw(c4417.5,1118.68) R38.2@4401.59,1102.77 ; R35.2@4388.41,1152.23 cw(c4372.5,1136.32) 4395,1136.32 cw(c4417.5,1136.32) R35.2@4401.59,1152.23 ; R35.2@4390.75,1155.06 ccw(c4381.67,1145.98) 4381.67,1158.82 ccw(c4381.67,1171.66) R35.2@4390.75,1162.58 ; R38.2@4391.24,1099.94 ccw(c4382.16,1109.02) 4395,1109.02 ccw(c4407.84,1109.02) R38.2@4398.76,1099.94 ; R35.2@4391.24,1155.06 cw(c4382.16,1145.98) 4395,1145.98 cw(c4407.84,1145.98) R35.2@4398.76,1155.06 ; R38.2@4395,1096.18 R35.2@4395,1158.82 4351.63,1158.82 4341.64,1148.82 U3.3@4295,1148.82 4261.86,1148.82 4261.86,1174.41
NetR40_1: R40.1 U4.4 | length 877.9
  MidLayer1 w4: v1@7870,2495.5 cw(c7870,2472.56) 7886.22,2488.78 cw(c7902.44,2505) v1@7879.5,2505 ; v1@7870,2499.5 cw(c7870,2486.22) 7879.39,2495.61 cw(c7888.78,2505) v1@7875.5,2505 ; v1(7870,2505) 7940.19,2434.81 7940.19,2293.04 7974.86,2258.37 7974.86,2109.86 ; v1(7890,2089) 7954,2089 7956.71,2091.71 ; v1@7893.89,2085.11 cw(c7903.28,2075.72) 7903.28,2089 cw(c7903.28,2102.28) v1@7893.89,2092.89 ; v1@7896.72,2082.28 cw(c7912.94,2066.06) 7912.94,2089 cw(c7912.94,2111.93) v1@7896.72,2095.72 ; 7956.71,2091.71 7974.86,2109.86 ; 7956.71,2091.71 7974.86,2109.86
  Bottom Layer w4: v1@7863.28,2498.28 cw(c7847.06,2482.06) 7870,2482.06 cw(c7892.94,2482.06) v1@7876.72,2498.28 ; v1@7866.11,2501.11 cw(c7856.72,2491.72) 7870,2491.72 cw(c7883.28,2491.72) v1@7873.89,2501.11 ; v1(7870,2505) 7870,2458.64 7873.53,2455.12 ; U4.4@7884.62,2449.41 ccw(c7873.52,2441.48) 7873.52,2455.12 ; U4.4@7884.62,2460.82 cw(c7873.53,2468.75) 7873.53,2455.12 ; v1@7890,2090 R40.1@7908.82,2090 ; U4.4@7892.6,2455.12 7873.53,2455.12 ; v1@7894.68,2086.11 cw(c7901.65,2081.81) R40.1@7901.65,2090 ; v1@7897.13,2095.28 ccw(c7908.82,2105.58) R40.1@7908.82,2090 ; R40.1@7898.08,2084.01 cw(c7908.82,2077.39) R40.1@7908.82,2090
NetR53_1: R53.1 R56.2 | length 90.3
  Bottom Layer w12: R53.1@2275.06,5734.25 ccw(c2265.98,5743.33) 2278.82,5743.33 ccw(c2291.66,5743.33) R53.1@2282.58,5734.25 ; R56.2@2275.06,5775.75 cw(c2265.98,5766.67) 2278.82,5766.67 cw(c2291.66,5766.67) R56.2@2282.58,5775.75 ; R53.1@2278.82,5730 R56.2@2278.82,5780
NetR53_2: R53.2 U5.28 | length 96.8
  Bottom Layer w12: U5.28@2311.65,5657.32 2311.65,5705.47 2321.18,5715 R53.2@2321.18,5730 ; R53.2@2317.42,5725.75 cw(c2308.34,5716.67) 2321.18,5716.67 cw(c2334.02,5716.67) R53.2@2324.94,5725.75
NetR79_1: R79.1 U8.N7 | length 5209.7
  Top Layer w4: v3(5075.04,4268.74) U8.N7@5094.72,4249.05 ; U8.N7@5087.38,4249.05 ccw(c5069.66,4249.05) 5082.19,4261.59 ccw(c5094.72,4274.12) U8.N7@5094.72,4256.4 ; 5087.84,4255.94 cw(c5100.65,4268.74) 5082.54,4268.74 ccw(c5100.65,4268.74) 5087.84,4255.94 ; 5087.84,4255.94 ccw(c5075.04,4243.13) 5075.04,4261.24 cw(c5075.04,4243.13) 5087.84,4255.94
  MidLayer1 w4: v2@4200.05,4001.61 ccw(c4183.3,4018.36) 4206.99,4018.36 ccw(c4230.67,4018.36) v2@4213.92,4001.61 ; v2@4202.88,3998.79 ccw(c4192.96,4008.71) 4206.99,4008.71 ccw(c4221.01,4008.71) v2@4211.09,3998.79 ; v2(4206.99,3994.68) 4206.99,4038.27 4192.75,4052.5 4187.75,4052.5 4177.5,4062.75 4177.5,4077.25 4203.44,4103.19 4216.63,4103.19 4241.65,4128.21 4401.64,4128.21 4408.24,4134.81 4478.24,4134.81 4510.63,4167.2 4565.42,4167.2 4578.12,4154.5 4593.25,4154.5 4617.75,4130 v2(4648,4130) ; v2@4641.06,4123.06 ccw(c4624.31,4106.31) 4624.31,4130 ccw(c4624.31,4153.69) v2@4641.06,4136.94 ; v2@4643.89,4125.89 ccw(c4633.97,4115.97) 4633.97,4130 ccw(c4633.97,4144.03) v2@4643.89,4134.11 ; v1@5811.28,3293.28 cw(c5795.06,3277.06) 5818,3277.06 cw(c5840.93,3277.06) v1@5824.72,3293.28 ; v1@5814.11,3296.11 cw(c5804.72,3286.72) 5818,3286.72 cw(c5831.28,3286.72) v1@5821.89,3296.11 ; v1(5818,3300) 5818,3263.65 5824.5,3257.15 5841.02,3240.62 5841.02,3214.79 5814.69,3188.46 5814.69,3063.31 5834.5,3043.5 5834.5,3017.5 5834.5,2948.5 v1@5852,2931 ; 5835.08,2947.92 cw(c5817.15,2930) v1@5842.5,2930 ; 5837.49,2945.51 ccw(c5852,2960.02) v1@5852,2939.5 ; 5841.9,2941.1 cw(c5830.81,2930) v1@5846.5,2930 ; 5844.32,2938.68 ccw(c5852,2946.36) v1@5852,2935.5
  MidLayer2 w4: v2(4206.99,3994.68) 4269.68,3994.68 4275,4000 4395,4000 4401.5,3993.5 4401.5,3951.12 4425.41,3927.21 4466.94,3927.21 4506.27,3966.54 4625.98,3966.54 4666.27,3926.26 4666.27,3912.42 4681.19,3897.5 4696.19,3897.5 4715,3878.69 4715,3845 4728,3832 4772.75,3832 4800.01,3804.74 4807.81,3796.94 4807.81,3702.62 4788.5,3683.31 4788.5,3666.12 4768.88,3646.5 4730,3607.62 4730,3580 v2(4750,3560) ; v2@4211.09,3990.57 cw(c4221.01,3980.65) 4221.01,3994.68 cw(c4221.01,4008.71) v2@4211.09,3998.79 ; v2@4213.92,3987.74 cw(c4230.67,3970.99) 4230.67,3994.68 cw(c4230.67,4018.36) v2@4213.92,4001.61 ; v1(4640.16,4217.34) 4651.82,4229 4695,4229 4700,4234 4715,4234 4720,4229 4745.44,4229 4755.44,4239 4781,4239 4787.81,4232.19 4803.38,4232.19 4813.81,4242.62 4813.81,4278.81 4819.25,4284.25 4832.75,4284.25 4838.82,4284.25 4957.99,4284.25 5051.53,4284.25 cw(c5051.53,4270.2) 5061.46,4280.13 ; v2@4740.19,3560 ccw(c4716.5,3560) 4733.25,3576.75 ccw(c4750,3593.5) v2@4750,3569.81 ; v2@4744.19,3560 ccw(c4730.16,3560) 4740.08,3569.92 ccw(c4750,3579.84) v2@4750,3565.81 ; v3@5067.57,4268.09 ccw(c5049.53,4266.51) 5061.17,4280.38 ccw(c5072.81,4294.25) v3@5074.39,4276.21
  Bottom Layer w4: v1(4640.16,4217.34) 4640.34,4217.34 4652.5,4229.5 4695,4229.5 4700,4234.5 4714.25,4234.5 4726.5,4222.25 4726.5,4207.75 4721.5,4202.75 4721.5,4161.44 4706.56,4146.5 4664.5,4146.5 v2(4648,4130) ; v2@4648.06,4135.81 ccw(c4648.21,4149.34) 4657.77,4139.77 ccw(c4667.34,4130.21) v2@4653.81,4130.06 ; v2@4648.1,4139.81 ccw(c4648.35,4162.65) 4664.5,4146.5 ccw(c4680.65,4130.35) v2@4657.81,4130.1 ; v2@4750,3550.19 cw(c4750,3533.99) 4761.45,3545.44 ; v2@4750,3556.9 4781.36,3525.54 4792.42,3525.54 4848.97,3468.99 4848.97,3361.28 4917.75,3292.5 4932.25,3292.5 4935.96,3296.21 ; v2@4755.81,3560 ccw(c4777.33,3560) 4762.11,3544.79 ; v2@4759.81,3560 ccw(c4790.98,3560) 4768.94,3537.96 ; 5022.96,3296.21 4935.96,3296.21 ; 5553.6,3264.55 5546.25,3257.2 ; v1@5808.5,3300 cw(c5785.56,3300) 5801.78,3283.78 cw(c5818,3267.56) v1@5818,3290.5 ; v1@5812.5,3300 cw(c5799.22,3300) 5808.61,3290.61 cw(c5818,3281.22) v1@5818,3294.5 ; v1(5818,3300) 5818,3298 5816,3298 5755.5,3237.5 5726.75,3237.5 5693.81,3270.44 5693.81,3289.38 5683.38,3299.81 5667.56,3299.81 5643.25,3275.5 5564.55,3275.5 5546.25,3257.2 ; v1@5845.28,2936.72 ccw(c5829.06,2952.93) 5852,2952.93 ccw(c5874.93,2952.93) v1@5858.72,2936.72 ; v1@5848.11,2933.89 ccw(c5838.72,2943.28) 5852,2943.28 ccw(c5865.28,2943.28) v1@5855.89,2933.89 ; v1(5852,2930) 5852,3041.18 R79.1@5885.82,3075 ; 5869.07,3058.25 cw(c5885.82,3041.5) R79.1@5885.82,3065.19 ; 5870.26,3059.44 ccw(c5855.19,3074.51) R79.1@5876.5,3074.51 ; R79.1@5875.9,3065.08 cw(c5885.82,3055.16) R79.1@5885.82,3069.19 ; R79.1@5877.09,3066.27 ccw(c5868.85,3074.51) R79.1@5880.5,3074.51 ; 4935.96,3296.21 5082.38,3296.21 5162.38,3216.21 5217.42,3216.21 5220.71,3219.5 5275.71,3219.5 5288.89,3232.68 5329.7,3232.68 5347.21,3250.2 5444.14,3250.2 5446.24,3248.1 5528.35,3248.1 5537.45,3257.2 5546.25,3257.2
NetR98_1: R98.1 U45.3 | length 449.3
  Bottom Layer w4: U45.3@-213.97,2083.28 ccw(c-240.8,2110.11) -202.85,2110.11 ccw(c-164.91,2110.11) U45.3@-191.74,2083.28 ; U45.3@-211.14,2080.45 ccw(c-231.14,2100.45) -202.85,2100.45 ccw(c-174.57,2100.45) U45.3@-194.57,2080.45 ; U45.3@-208.31,2077.62 ccw(c-221.48,2090.79) -202.85,2090.79 ccw(c-184.23,2090.79) U45.3@-197.4,2077.62 ; U45.3@-202.85,2063.31 -202.85,2130.52 -183.68,2149.69 ; -183.68,2149.69 R98.1@-183.68,2205 -183.68,2149.69 ; -183.68,2182.01 ccw(c-206.18,2182.01) -190.27,2197.92 cw(c-206.18,2182.01) -183.68,2182.01 ; -183.68,2182.01 cw(c-161.18,2182.01) -177.09,2197.92 ccw(c-161.18,2182.01) -183.68,2182.01 ; -183.68,2191.67 ccw(c-196.52,2191.67) -187.44,2200.75 cw(c-196.52,2191.67) -183.68,2191.67 ; -183.68,2191.67 cw(c-170.84,2191.67) -179.92,2200.75 ccw(c-170.84,2191.67) -183.68,2191.67
NetR110_2: R110.2 U18.5 | length 169.8
  Bottom Layer w4: U18.5@7447.24,495 7472,495 ; U18.5@7463.74,489.84 cw(c7472,485.81) 7472,495 ; U18.5@7463.74,500.16 ccw(c7472,504.19) 7472,495 ; 7477.07,451.75 ccw(c7493.82,468.5) R110.2@7493.82,444.81 ; 7478.26,450.56 cw(c7463.19,435.49) R110.2@7484.5,435.49 ; R110.2@7483.9,444.92 ccw(c7493.82,454.84) R110.2@7493.82,440.81 ; R110.2@7485.09,443.73 cw(c7476.85,435.49) R110.2@7488.5,435.49 ; R110.2@7493.82,435 7475,453.82 7475,492 7472,495
NetR112_2: R112.2 U19.13 | length 339.6
  MidLayer2 w4: v1(7224.19,591.71) 7284.36,591.71 v4(7311.73,564.34) ; v1@7228.08,587.82 cw(c7237.47,578.43) 7237.47,591.71 cw(c7237.47,604.99) v1@7228.08,595.6 ; v1@7230.91,584.99 cw(c7247.13,568.77) 7247.13,591.71 cw(c7247.13,614.64) v1@7230.91,598.43 ; v4@7303.73,564.34 ccw(c7284.42,564.34) 7298.08,578 ccw(c7311.73,591.65) v4@7311.73,572.34
  Bottom Layer w4: R112.2@7199.94,591.24 cw(c7209.02,582.16) 7209.02,595 cw(c7209.02,607.84) R112.2@7199.94,598.76 ; R112.2@7204.94,595 cw(c7204.94,575.03) v1@7220.03,588.11 ; 7209.2,595 ccw(c7209.2,606.7) v1@7217.47,598.43 ; v1@7217.01,585.49 ccw(c7196.18,567.44) R112.2@7196.18,595 7220.9,595 v1(7224.19,591.71)
  Bottom Layer w8: v4@7307.49,568.58 ccw(c7297.25,578.82) 7311.73,578.82 ccw(c7326.22,578.82) v4@7315.97,568.58 ; v4(7311.73,564.34) U19.13@7311.73,595.67
NetR113_2: R113.2 U19.15 | length 254.1
  Bottom Layer w4: R113.2@7147.23,702.92 cw(c7131.32,687.01) 7153.82,687.01 cw(c7176.32,687.01) R113.2@7160.41,702.92 ; R113.2@7150.06,705.75 cw(c7140.98,696.67) 7153.82,696.67 cw(c7166.66,696.67) R113.2@7157.58,705.75 ; R113.2@7153.82,710 7153.82,650.08 7181.86,622.05 U19.15@7265.67,622.05 ; U19.15@7251.91,619.22 ccw(c7245.08,612.39) 7245.08,622.05 ccw(c7245.08,631.7) U19.15@7251.91,624.88
NetR114_2: R114.2 U19.16 | length 297.7
  Bottom Layer w8: R114.2@7153.82,812.19 cw(c7153.82,793.33) 7167.15,806.67 ; R114.2@7153.82,820 7175,798.82 7175,655 7188.27,641.73 U19.16@7265.67,641.73 ; R114.2@7161.14,819.51 ccw(c7177.62,819.51) 7165.97,807.85
NetR116_2: R116.2 U21.38 | length 260.3
  Bottom Layer w4: R116.2@4921.18,5740 4961.18,5780 5048.12,5780 5056.42,5771.71 U21.38@5056.42,5737.32 ; R116.2@4921.18,5745.81 ccw(c4921.18,5759.84) R116.2@4931.1,5749.92 ; R116.2@4921.18,5749.81 ccw(c4921.18,5773.5) 4937.93,5756.75 ; R116.2@4926.5,5740.49 cw(c4938.15,5740.49) R116.2@4929.91,5748.73 ; R116.2@4930.5,5740.49 cw(c4951.81,5740.49) 4936.74,5755.56 ; U21.38@5053.59,5763.68 ccw(c5046.76,5770.51) 5056.42,5770.51 ccw(c5066.07,5770.51) U21.38@5059.25,5763.68
NetR142_1: R142.1 U26.12 | length 688.2
  Top Layer w4: U26.12@-30.87,5000 40,5000 60,4980 86.82,4980 v1(106.86,5000.04) ; U26.12@6.71,4995.89 cw(c16.63,4985.97) 16.63,5000 cw(c16.63,5014.03) U26.12@6.71,5004.11 ; U26.12@9.54,4993.06 cw(c26.28,4976.31) 26.28,5000 cw(c26.28,5023.69) U26.12@9.54,5006.94 ; v1@97.36,5000.04 cw(c74.42,5000.04) 90.64,4983.82 cw(c106.86,4967.61) v1@106.86,4990.54 ; v1@101.36,5000.04 cw(c88.08,5000.04) 97.47,4990.65 cw(c106.86,4981.26) v1@106.86,4994.54
  MidLayer2 w4: v1@100.14,5006.76 ccw(c83.92,5022.98) 106.86,5022.98 ccw(c129.79,5022.98) v1@113.57,5006.76 ; v1@102.97,5003.93 ccw(c93.58,5013.32) 106.86,5013.32 ccw(c120.14,5013.32) v1@110.75,5003.93 ; v1(106.86,5000.04) 106.86,5176.86 125,5195 ; v1@119,5207.64 cw(c108.7,5195) 125,5195 ; v1@121.53,5210.74 cw(c115.56,5203.42) 125,5203.42 cw(c134.44,5203.42) v1@128.47,5210.74 ; v1(125,5215) 125,5195 ; v1@131,5207.64 ccw(c141.3,5195) 125,5195
  Bottom Layer w4: R142.1@108.64,5245.8 125,5229.44 v1(125,5215) ; R142.1@108.7,5235.99 cw(c108.84,5212.79) 125.25,5229.19 ; R142.1@108.67,5239.99 cw(c108.76,5226.24) R142.1@118.48,5235.96 ; R142.1@113.96,5245.3 ccw(c125.61,5245.3) R142.1@117.37,5237.06 ; R142.1@117.96,5245.3 ccw(c139.27,5245.3) 124.2,5230.24
NetR149_2: R149.2 U28.2 U29.5 | length 1233.7
  Top Layer w4: R149.2@369.59,5407.92 cw(c353.68,5392.01) 376.18,5392.01 cw(c398.68,5392.01) R149.2@382.77,5407.92 ; R149.2@372.42,5410.75 cw(c363.34,5401.67) 376.18,5401.67 cw(c389.02,5401.67) R149.2@379.94,5410.75 ; v1@378.28,5356.72 ccw(c362.06,5372.93) 385,5372.93 ccw(c407.93,5372.93) v1@391.72,5356.72 ; R149.2@379.94,5411.24 cw(c389.02,5402.16) 389.02,5415 cw(c389.02,5427.84) R149.2@379.94,5418.76 ; v1@381.11,5353.89 ccw(c371.72,5363.28) 385,5363.28 ccw(c398.28,5363.28) v1@388.89,5353.89 ; R149.2@382.77,5408.41 cw(c398.68,5392.5) 398.68,5415 cw(c398.68,5437.5) R149.2@382.77,5421.59 ; v1(385,5350) 385,5380 376.18,5388.82 R149.2@376.18,5415 421.54,5415 456.86,5379.68 U28.2@509.29,5379.69 ; U28.2@479,5376.86 ccw(c472.17,5370.03) 472.17,5379.68 ccw(c472.17,5389.34) U28.2@479,5382.51 ; U29.5@867.83,5354.41 880.59,5354.41 v1(905,5330) ; U29.5@876.69,5348.54 cw(c876.69,5324.94) 893.37,5341.63 ; U29.5@876.69,5352.54 cw(c876.69,5338.6) 886.55,5348.45 ; U29.5@882.57,5354.41 ccw(c887.34,5354.41) U29.5@883.96,5351.04 ; v1@895.5,5330 ccw(c872.56,5330) 888.78,5346.22 ccw(c905,5362.43) v1@905,5339.5 ; v1@899.5,5330 ccw(c886.22,5330) 895.61,5339.39 ccw(c905,5348.78) v1@905,5335.5
  MidLayer1 w4: v1(385,5350) 800,5350 865,5285 890,5285 905,5300 v1(905,5330) ; v1@388.89,5346.11 cw(c398.28,5336.72) 398.28,5350 cw(c398.28,5363.28) v1@388.89,5353.89 ; v1@391.72,5343.28 cw(c407.93,5327.06) 407.93,5350 cw(c407.93,5372.93) v1@391.72,5356.72 ; v1@898.28,5323.28 cw(c882.06,5307.06) 905,5307.06 cw(c927.93,5307.06) v1@911.72,5323.28 ; v1@901.11,5326.11 cw(c891.72,5316.72) 905,5316.72 cw(c918.28,5316.72) v1@908.89,5326.11
NetR150_2: R150.2 U28.3 U29.4 | length 1239.4
  Top Layer w4: v2(440,5370) 450,5360 U28.3@509.29,5360 ; U28.3@479,5357.17 ccw(c472.17,5350.34) 472.17,5360 ccw(c472.17,5369.66) U28.3@479,5362.83 ; U29.4@864.34,5324.1 cw(c859.21,5317.17) 867.83,5317.17 ; U29.4@867.83,5328.82 867.83,5317.17 ; U29.4@871.33,5324.1 ccw(c876.46,5317.17) 867.83,5317.17 ; v2(880,5305) 867.83,5317.17 ; R150.2@1021.05,5407.92 cw(c1005.14,5392.01) 1027.64,5392.01 cw(c1050.14,5392.01) R150.2@1034.23,5407.92 ; R150.2@1023.88,5410.75 cw(c1014.8,5401.67) 1027.64,5401.67 cw(c1040.48,5401.67) R150.2@1031.4,5410.75 ; R150.2@1027.64,5415 1027.64,5372.36 1030,5370 v2(1080,5370) ; v2@1073.06,5363.06 ccw(c1056.31,5346.31) 1056.31,5370 ccw(c1056.31,5393.69) v2@1073.06,5376.94 ; v2@1075.89,5365.89 ccw(c1065.97,5355.97) 1065.97,5370 ccw(c1065.97,5384.03) v2@1075.89,5374.11
  MidLayer1 w4: v2(440,5370) 850,5370 ; v2@444.11,5365.89 cw(c454.03,5355.97) 454.03,5370 cw(c454.03,5384.03) v2@444.11,5374.11 ; v2@446.94,5363.06 cw(c463.69,5346.31) 463.69,5370 cw(c463.69,5393.69) v2@446.94,5376.94 ; v2@870.19,5305 ccw(c846.5,5305) 863.25,5321.75 ccw(c880,5338.5) v2@880,5314.81 ; v2@874.19,5305 ccw(c860.16,5305) 870.08,5314.92 ccw(c880,5324.84) v2@880,5310.81 ; v2(880,5305) 850,5335 850,5370 ; v2@1073.06,5363.06 ccw(c1056.31,5346.31) 1056.31,5370 ccw(c1056.31,5393.69) v2@1073.06,5376.94 ; v2@1075.89,5365.89 ccw(c1065.97,5355.97) 1065.97,5370 ccw(c1065.97,5384.03) v2@1075.89,5374.11 ; v2(1080,5370) 850,5370
NetR151_2: R151.2 U28.4 U29.3 | length 1293.9
  Top Layer w4: U28.4@509.29,5340.31 574.69,5340.31 580,5335 v2(580,5280) ; U28.4@539.58,5337.49 cw(c546.41,5330.66) 546.41,5340.31 cw(c546.41,5349.97) U28.4@539.58,5343.14 ; v2@573.06,5286.94 ccw(c556.31,5303.69) 580,5303.69 ccw(c603.69,5303.69) v2@586.94,5286.94 ; v2@575.89,5284.11 ccw(c565.97,5294.03) 580,5294.03 ccw(c594.03,5294.03) v2@584.11,5284.11 ; U29.3@790.85,5324.67 cw(c780.82,5314.64) 795,5314.64 cw(c809.18,5314.64) U29.3@799.15,5324.67 ; U29.3@795,5328.82 795,5305 805,5295 v1(805,5255) ; v1@798.28,5261.72 ccw(c782.06,5277.93) 805,5277.93 ccw(c827.93,5277.93) v1@811.72,5261.72 ; v1@801.11,5258.89 ccw(c791.72,5268.28) 805,5268.28 ccw(c818.28,5268.28) v1@808.89,5258.89 ; v1@1016.81,5223.43 ccw(c1000.59,5239.64) 1023.52,5239.64 ccw(c1046.46,5239.64) v1@1030.24,5223.43 ; v1@1019.64,5220.6 ccw(c1010.25,5229.99) 1023.52,5229.99 ccw(c1036.8,5229.99) v1@1027.41,5220.6 ; R151.2@1021.05,5277.92 cw(c1005.14,5262.01) 1027.64,5262.01 cw(c1050.13,5262.01) R151.2@1034.23,5277.92 ; v1(1023.52,5216.71) 1023.52,5250.89 1027.64,5255 R151.2@1027.64,5285 ; R151.2@1023.88,5280.75 cw(c1014.8,5271.67) 1027.64,5271.67 cw(c1040.48,5271.67) R151.2@1031.4,5280.75
  MidLayer1 w4: v2(580,5280) 615,5315 785,5315 805,5295 v1(805,5255) ; v2@580,5285.81 ccw(c580,5299.84) 589.92,5289.92 ccw(c599.84,5280) v2@585.81,5280 ; v2@580,5289.81 ccw(c580,5313.5) 596.75,5296.75 ccw(c613.5,5280) v2@589.81,5280 ; v1@798.28,5261.72 ccw(c782.06,5277.93) 805,5277.93 ccw(c827.93,5277.93) v1@811.72,5261.72 ; v1@801.11,5258.89 ccw(c791.72,5268.28) 805,5268.28 ccw(c818.28,5268.28) v1@808.89,5258.89
  MidLayer2 w4: v1(805,5255) 830,5255 835,5250 990.23,5250 v1(1023.52,5216.71) ; v1@808.89,5251.11 cw(c818.28,5241.72) 818.28,5255 cw(c818.28,5268.28) v1@808.89,5258.89 ; v1@811.72,5248.28 cw(c827.93,5232.06) 827.93,5255 cw(c827.93,5277.93) v1@811.72,5261.72 ; v1@1014.02,5216.71 ccw(c991.09,5216.71) 1007.31,5232.93 ccw(c1023.52,5249.14) v1@1023.52,5226.21 ; v1@1018.02,5216.71 ccw(c1004.75,5216.71) 1014.14,5226.1 ccw(c1023.52,5235.49) v1@1023.52,5222.21
NetR152_2: R152.2 U28.5 U29.1 | length 1326.4
  Top Layer w4: v1@368.65,5257.59 ccw(c352.43,5273.81) 375.37,5273.81 ccw(c398.3,5273.81) v1@382.08,5257.59 ; v1@371.48,5254.76 ccw(c362.09,5264.15) 375.37,5264.15 ccw(c388.65,5264.15) v1@379.26,5254.76 ; v1(375.37,5250.87) 375.37,5284.19 R152.2@376.18,5285 ; 375.37,5269.7 cw(c390.99,5269.7) R152.2@379.94,5280.75 ; v1@491.47,5256.76 ccw(c475.26,5272.98) 498.19,5272.98 ccw(c521.13,5272.98) v1@504.91,5256.76 ; v1@494.3,5253.93 ccw(c484.91,5263.32) 498.19,5263.32 ccw(c511.47,5263.32) v1@502.08,5253.93 ; v1(498.19,5250.04) 498.19,5273.9 509.29,5285 U28.5@509.29,5320.63 ; U28.5@506.46,5317.8 cw(c499.63,5310.97) 509.29,5310.97 cw(c518.95,5310.97) U28.5@512.12,5317.8 ; U29.1@795,5380 823.86,5380 831.86,5372 831.86,5255 820,5243.14 ; U29.1@808.01,5375.85 cw(c818.04,5365.82) 818.04,5380 cw(c818.04,5394.18) U29.1@808.01,5384.15 ; v2@814.63,5233.21 ccw(c808.13,5243.14) 820,5243.14 ; v2(820,5225) 820,5243.14 ; v2@825.37,5233.21 cw(c831.87,5243.14) 820,5243.14
  MidLayer1 w4: v1@373.52,5252.72 v1(375.37,5250.87) 444.11,5250.87 445.44,5249.54 498.19,5249.54 v1(498.19,5250.04) 498.19,5303.19 530,5335 795,5335 822.5,5307.5 822.5,5227.5 v2(820,5225) ; v1@379.26,5246.99 cw(c388.65,5237.6) 388.65,5250.87 cw(c388.65,5264.15) v1@379.26,5254.76 ; v1@382.08,5244.16 cw(c398.3,5227.94) 398.3,5250.87 cw(c398.3,5273.81) v1@382.08,5257.59 ; 474.05,5249.54 ccw(c474.05,5274.18) 491.47,5256.76 ccw(c475.26,5272.98) 498.19,5272.98 ccw(c521.13,5272.98) v1@504.91,5256.76 ; 476.46,5249.54 cw(c476.46,5228.31) v1@491.47,5243.32 ; 483.7,5249.54 ccw(c483.7,5264.53) 494.3,5253.93 ccw(c484.91,5263.32) 498.19,5263.32 ccw(c511.47,5263.32) v1@502.08,5253.93 ; 486.12,5249.54 cw(c486.12,5237.97) v1@494.3,5246.15 ; v2@813.06,5231.94 ccw(c790.28,5254.72) 822.5,5254.72 ; v2@815.89,5229.11 ccw(c799.94,5245.06) 822.5,5245.06 ; 822.5,5242.65 ccw(c837.65,5242.65) v2@826.94,5231.94
NetR161_2: R161.2 U30.F4 | length 3967.1
  Top Layer w4: v2@6463.06,2071.06 cw(c6446.31,2054.31) 6470,2054.31 cw(c6493.69,2054.31) v2@6476.94,2071.06 ; v2@6465.89,2073.89 cw(c6455.97,2063.97) 6470,2063.97 cw(c6484.03,2063.97) v2@6474.11,2073.89 ; v2(6470,2078) 6470,1947.1 6462.9,1940 6462.9,1854.46 6462.19,1853.75 6462.19,1836.62 6462.9,1835.91 6462.9,1754.46 6437.5,1729.06 6437.5,1685.46 6464.86,1658.1 6464.86,1593.95 6493,1565.81 6502.69,1565.81 6521.81,1546.69 6521.81,1532.28 6532.5,1521.59 6532.5,1063.43 6567.73,1028.21 7104.21,1028.21 7146.9,1070.9 7146.9,1093.1 7146.9,1105 7146.9,1185.9 7158,1197 7188,1227 7192.59,1231.59 7605.79,1231.59 7755,1380.8 v2(7755,1411) ; v3(6813.15,1983.11) U30.F4@6832.83,1963.43 ; U30.F4@6825.49,1963.43 ccw(c6807.77,1963.43) 6820.3,1975.96 ccw(c6832.83,1988.49) U30.F4@6832.83,1970.77 ; v2@7748.06,1404.06 cw(c7731.31,1387.31) 7755,1387.31 cw(c7778.69,1387.31) v2@7761.94,1404.06 ; v2@7750.89,1406.89 cw(c7740.97,1396.97) 7755,1396.97 cw(c7769.03,1396.97) v2@7759.11,1406.89 ; 6825.95,1970.31 cw(c6838.76,1983.11) 6820.65,1983.11 ccw(c6838.76,1983.11) 6825.95,1970.31 ; 6825.95,1970.31 ccw(c6813.15,1957.5) 6813.15,1975.61 cw(c6813.15,1957.5) 6825.95,1970.31
  MidLayer1 w4: v2(6470,2078) 6518,2078 6525,2071 6531.33,2064.67 6590,2006 6615.19,2006 6625.81,2016.62 6625.81,2021 6639,2034.19 6649,2034.19 6661.81,2021.38 6661.81,2010.83 6665.67,2006.97 6676.15,2006.97 6750.27,2006.97 ; v2@6474.11,2073.89 cw(c6484.03,2063.97) 6484.03,2078 cw(c6484.03,2092.03) v2@6474.11,2082.11 ; v2@6476.94,2071.06 cw(c6493.69,2054.31) 6493.69,2078 cw(c6493.69,2101.69) v2@6476.94,2084.94 ; 6736.34,2006.97 6750.27,2006.97 ; v3@6805.76,1981.81 ccw(c6787.93,1978.66) 6798.32,1993.5 ; v3@6811.85,1990.5 cw(c6808.7,2008.33) 6798.32,1993.5 ; v2(7755,1411) 7905,1561 7905,1650.86 7954.14,1700 7954.14,1806.86 7943.46,1817.54 7920.46,1817.54 7916,1822 v2(7916,1856) ; v2@7755,1416.81 ccw(c7755,1430.84) 7764.92,1420.92 ccw(c7774.84,1411) v2@7760.81,1411 ; v2@7755,1420.81 ccw(c7755,1444.5) 7771.75,1427.75 ccw(c7788.5,1411) v2@7764.81,1411 ; v2@7909.06,1849.06 cw(c7892.31,1832.31) 7916,1832.31 cw(c7939.69,1832.31) v2@7922.94,1849.06 ; v2@7911.89,1851.89 cw(c7901.97,1841.97) 7916,1841.97 cw(c7930.03,1841.97) v2@7920.11,1851.89 ; 6750.27,2006.97 6773.52,2006.97 cw(c6773.52,1983.2) 6789.74,2000.58 6798.32,1993.5
  Bottom Layer w4: v2(7916,1856) 7918,1858 v2@7926,1858