# Altium PCB NB3000AL.PcbDoc (part 27 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_JTAG.SOFT.TDI: U8.AD21 U30.L9 | length 5703.4
  Top Layer w4: U8.AD21@5645.91,3808.64 cw(c5645.91,3790.92) 5658.44,3803.45 cw(c5670.97,3815.98) U8.AD21@5653.25,3815.98 ; U8.AD21@5645.91,3815.98 v3(5665.59,3796.3) ; v2@6212.58,1944.75 ccw(c6195.84,1961.5) 6219.52,1961.5 ccw(c6243.21,1961.5) v2@6226.46,1944.75 ; v2@6215.41,1941.92 ccw(c6205.49,1951.84) 6219.52,1951.84 ccw(c6233.55,1951.84) v2@6223.63,1941.92 ; v2(6219.52,1937.81) 6219.52,1998.61 6264,2043.09 6264,2058.75 6230.75,2092 6222.85,2092 6203.92,2110.93 6203.92,2125.92 6218,2140 6230.25,2140 6242.75,2127.5 6265.5,2127.5 6282,2144 v2(6282,2188) ; v2@6275.06,2181.06 cw(c6258.31,2164.31) 6282,2164.31 cw(c6305.69,2164.31) v2@6288.94,2181.06 ; v2@6277.89,2183.89 cw(c6267.97,2173.97) 6282,2173.97 cw(c6296.03,2173.97) v2@6286.11,2183.89 ; v2@6536.68,1893.31 cw(c6519.94,1876.56) 6543.62,1876.56 cw(c6567.31,1876.56) v2@6550.56,1893.31 ; v2@6539.51,1896.14 cw(c6529.59,1886.22) 6543.62,1886.22 cw(c6557.65,1886.22) v2@6547.73,1896.14 ; v2(6543.62,1900.25) 6543.62,1834.38 6559.81,1818.19 6559.81,1746.62 6549,1735.81 6548.62,1735.81 6538.19,1725.38 6538.19,1710.62 6541.35,1707.46 6544.19,1704.62 6544.19,1588.31 6544.19,1580 6544.19,1564.69 6539.5,1560 6539.5,1537.22 6548.5,1528.22 6548.5,1070.06 6573.87,1044.69 6817.92,1044.69 6845,1071.77 6845,1134.12 6845.88,1135 6900.88,1190 6905,1190 6947.88,1190 6961.34,1203.47 6961.34,1215 6961.34,1218.22 6961.34,1261.78 6977.81,1278.25 6977.81,1309.34 7036,1367.53 v2(7036,1372) ; 7016.09,1347.63 ccw(c6991.72,1372) v2@7026.19,1372 ; 7022.92,1354.46 ccw(c7005.38,1372) v2@7030.19,1372 ; 7026.88,1358.41 cw(c7036,1349.29) v2@7036,1362.19 ; U30.L9@7029.68,1759.23 cw(c7029.68,1741.51) 7042.22,1754.04 cw(c7054.75,1766.57) U30.L9@7037.03,1766.57 ; U30.L9@7029.69,1766.57 v3(7049.37,1746.89) ; 7029.75,1361.28 ccw(c7019.03,1372) v2@7034.19,1372 ; 5652.79,3809.1 cw(c5639.98,3796.3) 5658.09,3796.3 ccw(c5639.98,3796.3) 5652.79,3809.1 ; 5652.79,3809.1 ccw(c5665.59,3821.91) 5665.59,3803.8 cw(c5665.59,3821.91) 5652.79,3809.1 ; 7036.57,1759.69 cw(c7023.76,1746.89) 7041.87,1746.89 ccw(c7023.76,1746.89) 7036.57,1759.69 ; 7036.57,1759.69 ccw(c7049.37,1772.5) 7049.37,1754.39 cw(c7049.37,1772.5) 7036.57,1759.69
  MidLayer1 w4: v3@5664.94,3788.83 cw(c5663.36,3770.79) 5677.23,3782.43 cw(c5691.1,3794.07) v3@5673.06,3795.65 ; 5676.98,3782.72 cw(c5667.05,3772.79) 5681.1,3772.79 5681.1,3679.25 5681.1,3638.82 5681.1,3630.82 5681.1,3610.41 5658.02,3587.34 5658.02,3544.72 5680,3522.75 5680,3504.27 5690.5,3493.77 5690.5,3411.66 5672.19,3393.35 5672.19,3344.33 5709.81,3306.71 5709.81,3268 5707.5,3265.68 5707.5,2936.98 5737.59,2906.89 5737.59,2891.28 5737.59,2875 5737.59,2824.67 5749,2813.26 5749,2711.56 5806.86,2653.71 5806.86,2438.14 5821.81,2423.19 5883.19,2423.19 5885.04,2425.04 v1(5915.19,2425.04) v1@5913.34,2423.19 ; v1@5908.47,2418.32 ccw(c5892.26,2402.11) 5892.26,2425.04 ccw(c5892.26,2447.98) v1@5908.47,2431.76 ; v1@5911.3,2421.15 ccw(c5901.91,2411.76) 5901.91,2425.04 ccw(c5901.91,2438.32) v1@5911.3,2428.93
  MidLayer2 w4: v1@5915.19,2415.54 cw(c5915.19,2392.61) 5931.41,2408.82 cw(c5947.63,2425.04) v1@5924.69,2425.04 ; v1@5915.19,2419.54 cw(c5915.19,2406.26) 5924.58,2415.65 cw(c5933.97,2425.04) v1@5920.69,2425.04 ; v1(5915.19,2425.04) 5940.19,2400.04 5940.19,2341.71 6023.52,2258.37 6200,2258.37 6221.73,2258.37 6261.63,2258.37 6282,2238 6282,2198.99 v2(6282,2188) ; v2@6275.06,2194.94 ccw(c6258.31,2211.69) 6282,2211.69 ccw(c6305.69,2211.69) v2@6288.94,2194.94 ; v2@6277.89,2192.11 ccw(c6267.97,2202.03) 6282,2202.03 ccw(c6296.03,2202.03) v2@6286.11,2192.11 ; v2@7029.06,1378.94 ccw(c7012.31,1395.69) 7036,1395.69 ccw(c7059.69,1395.69) v2@7042.94,1378.94 ; v2@7031.89,1376.11 ccw(c7021.97,1386.03) 7036,1386.03 ccw(c7050.03,1386.03) v2@7040.11,1376.11 ; v2(7036,1372) 7036,1396.81 7026.19,1406.62 7026.19,1424.88 7059.75,1458.44 7077.81,1476.5 7077.81,1510.19 7073.23,1514.77 7073.23,1609.89 7073.23,1610.95 7073.23,1684.01 7073.23,1703.51 ccw(c7031.5,1703.51) 7061.01,1733.02 ; v3@7048.72,1739.42 cw(c7047.14,1721.38) 7061.01,1733.02 ; v3@7056.84,1746.24 ccw(c7074.88,1744.66) 7061.01,1733.02
  Bottom Layer w4: v2@6221.52,1939.81 6261.13,1939.81 6326.11,1874.83 6475,1874.83 ; v2@6223.63,1933.7 cw(c6238.38,1918.95) 6238.38,1939.81 cw(c6238.38,1956.67) v2@6226.46,1944.75 ; v2@6226.46,1930.87 cw(c6248.04,1909.3) 6248.04,1939.81 ; 6514.83,1874.83 6475,1874.83 ; v2@6533.81,1900.25 cw(c6510.13,1900.25) 6526.87,1883.5 cw(c6543.62,1866.75) v2@6543.62,1890.43 ; v2@6537.81,1900.25 cw(c6523.78,1900.25) 6533.7,1890.33 cw(c6543.62,1880.41) v2@6543.62,1894.43 ; v2@6540.25,1900.25 v2(6543.62,1900.25) 6518.21,1874.83 6475,1874.83
DB_JTAG.SOFT.TDO: U8.AC21 U30.B5 | length 3924.3
  Top Layer w4: U8.AC21@5645.91,3848.01 cw(c5645.91,3830.29) 5658.44,3842.82 cw(c5670.97,3855.35) U8.AC21@5653.25,3855.35 ; U8.AC21@5645.91,3855.35 v3(5665.59,3835.67) ; v1(5831.86,2616.71) 5880.19,2665.04 v1(5880.19,2783.37) ; v1@5831.86,2622.21 ccw(c5831.86,2635.49) 5841.25,2626.1 ccw(c5850.64,2616.71) v1@5837.36,2616.71 ; v1@5831.86,2626.21 ccw(c5831.86,2649.14) 5848.07,2632.93 ccw(c5864.29,2616.71) v1@5841.36,2616.71 ; v1@5873.47,2776.66 cw(c5857.26,2760.44) 5880.19,2760.44 cw(c5903.13,2760.44) v1@5886.91,2776.66 ; v1@5876.3,2779.49 cw(c5866.91,2770.1) 5880.19,2770.1 cw(c5893.47,2770.1) v1@5884.08,2779.49 ; v1(6573.52,2283.37) 6623.37,2283.37 6687.19,2283.37 6703.42,2299.61 6734.69,2330.87 6784.31,2330.87 6856.81,2258.38 6856.81,2241.62 6856.7,2241.51 6856.7,2140.62 ; v1@6577.41,2279.49 cw(c6586.8,2270.1) 6586.8,2283.37 cw(c6586.8,2296.65) v1@6577.41,2287.26 ; v1@6580.24,2276.66 cw(c6596.46,2260.44) 6596.46,2283.37 cw(c6596.46,2306.31) v1@6580.24,2290.09 ; 5652.79,3848.47 cw(c5639.98,3835.67) 5658.09,3835.67 ccw(c5639.98,3835.67) 5652.79,3848.47 ; 5652.79,3848.47 ccw(c5665.59,3861.28) 5665.59,3843.17 cw(c5665.59,3861.28) 5652.79,3848.47 ; 6856.7,2140.62 ccw(c6866.85,2140.62) 6859.67,2133.44 ; 6856.7,2140.62 ccw(c6866.85,2140.62) 6859.67,2133.44 ; 6859.67,2133.44 ccw(c6872.2,2145.97) 6872.2,2128.25 cw(c6872.2,2145.97) 6859.67,2133.44 ; 6859.67,2133.44 cw(c6847.14,2120.91) 6864.86,2120.91 ccw(c6847.14,2120.91) 6859.67,2133.44
  MidLayer1 w4: v3@5664.94,3828.2 cw(c5663.36,3810.16) 5677.23,3821.8 ; v3@5673.06,3835.02 ccw(c5691.1,3833.44) 5677.23,3821.8 ; 5689.45,3758.86 5689.45,3772.79 ; v1@5825.14,2623.43 ccw(c5808.92,2639.64) 5831.86,2639.64 ccw(c5854.79,2639.64) v1@5838.57,2623.43 ; v1@5827.97,2620.6 ccw(c5818.58,2629.99) 5831.86,2629.99 ccw(c5845.14,2629.99) v1@5835.75,2620.6 ; v1(5831.86,2616.71) 5831.86,2640.02 5824.86,2647.02 5757,2714.88 5757,2816.58 5745.59,2827.98 5745.59,2870 ; 5677.23,3821.8 cw(c5647.72,3792.29) 5689.45,3792.29 5689.45,3772.79 ; 5689.45,3772.79 5689.45,3698.67 5689.45,3679.25 5689.45,3638.82 5689.45,3630.82 5689.45,3607.45 5666.02,3584.02 5666.02,3548.04 5698.03,3516.03 5698.03,3497.56 5698.5,3497.08 5698.5,3408.35 5681.86,3391.71 5681.86,3375.71 5688.05,3369.52 5697.38,3369.52 5717.81,3349.09 5717.81,3264.68 5715.5,3262.37 5715.5,2940.3 ; 5715.5,2940.3 5745.59,2910.2 ; 5715.5,2940.3 5745.59,2910.2 ; 5745.59,2870 5745.59,2887.97 ; 5745.59,2870 5745.59,2887.97 ; 5745.59,2887.97 5745.59,2910.2
  MidLayer2 w4: v1(5880.19,2783.37) 5896.82,2800 5925,2800 ; v1@5880.19,2788.87 ccw(c5880.19,2802.15) 5889.58,2792.76 ccw(c5898.97,2783.37) v1@5885.69,2783.37 ; v1@5880.19,2792.87 ccw(c5880.19,2815.81) 5896.41,2799.59 ccw(c5912.63,2783.37) v1@5889.69,2783.37 ; v1(6573.52,2283.37) 6597.37,2283.37 6624,2310 6624,2334.52 6613.52,2345 6585.15,2345 6573.02,2332.87 6543.13,2332.87 6437.13,2332.87 6415,2355 6415,2445 6425,2455 6425,2503.81 ; v1@6577.41,2279.49 cw(c6586.8,2270.1) 6586.8,2283.37 cw(c6586.8,2296.65) v1@6577.41,2287.26 ; v1@6580.24,2276.66 cw(c6596.46,2260.44) 6596.46,2283.37 cw(c6596.46,2306.31) v1@6580.24,2290.09 ; 5925,2800 5948.31,2800 ; 5925,2800 5948.31,2800 ; 5948.31,2800 5957,2800 6115.29,2641.71 ; 6115.29,2641.71 6168,2641.71 ; 6115.29,2641.71 6168,2641.71 ; 6168,2641.71 6275,2641.71 ; 6275,2641.71 6306.86,2641.71 ; 6275,2641.71 6306.86,2641.71 ; 6306.86,2641.71 6320,2641.71 ; 6320,2641.71 6348.29,2641.71 ; 6320,2641.71 6348.29,2641.71 ; 6348.29,2641.71 6404.69,2585.31 6404.69,2543.87 ; 6404.69,2524.12 6404.69,2535 ; 6404.69,2524.12 6425,2503.81 ; 6404.69,2524.12 6425,2503.81 ; 6404.69,2535 6404.69,2543.87 ; 6404.69,2535 6404.69,2543.87
DB_JTAG.SOFT.TMS: U8.AE22 U30.E5 | length 3392.1
  Top Layer w4: U8.AE22@5685.28,3769.27 cw(c5685.28,3751.55) 5697.81,3764.08 cw(c5710.34,3776.61) U8.AE22@5692.62,3776.61 ; U8.AE22@5685.28,3776.61 v3(5704.96,3756.93) ; v3(6852.52,2022.48) U30.E5@6872.2,2002.8 ; U30.E5@6864.86,2002.79 ccw(c6847.14,2002.79) 6859.67,2015.33 ccw(c6872.2,2027.86) U30.E5@6872.2,2010.14 ; 5692.16,3769.73 cw(c5679.35,3756.93) 5697.46,3756.93 ccw(c5679.35,3756.93) 5692.16,3769.73 ; 5692.16,3769.73 ccw(c5704.96,3782.54) 5704.96,3764.43 cw(c5704.96,3782.54) 5692.16,3769.73 ; 6865.32,2009.68 cw(c6878.13,2022.48) 6860.02,2022.48 ccw(c6878.13,2022.48) 6865.32,2009.68 ; 6865.32,2009.68 ccw(c6852.52,1996.87) 6852.52,2014.98 cw(c6852.52,1996.87) 6865.32,2009.68
  MidLayer1 w4: v3@5699.77,3751.74 cw(c5687.23,3739.2) 5704.96,3739.2 cw(c5722.69,3739.2) v3@5710.15,3751.74 ; v3(5704.96,3756.93) 5704.96,3679.25 5704.96,3638.82 5704.96,3630.82 5704.96,3585.04 5722,3568 5756.81,3568 5782.62,3542.19 5832.4,3542.19 5895,3479.58 5896.5,3478.09 5896.5,3414.81 5908,3403.31 5908,3357.23 5915.19,3350.04 5957.86,3307.37 5962,3303.23 5962,3297.1 5948.52,3283.63 5948.52,3261.15 5914.19,3226.82 5914.19,3034.37 5934.19,3014.37 5934.19,2969.88 5908,2943.69 5908,2790.23 5906.69,2788.92 5906.69,2773.81 5898.52,2765.65 5898.52,2642.32 5973.52,2567.32 5973.52,2491.71 6131.86,2333.37 v1(6165.19,2333.37) ; v1@6158.47,2326.66 ccw(c6142.26,2310.44) 6142.26,2333.37 ccw(c6142.26,2356.31) v1@6158.47,2340.09 ; v1@6161.3,2329.49 ccw(c6151.91,2320.1) 6151.91,2333.37 ccw(c6151.91,2346.65) v1@6161.3,2337.26 ; 5704.96,3738.82 cw(c5723.07,3738.82) 5710.26,3751.63 ccw(c5723.07,3738.82) 5704.96,3738.82 ; 5704.96,3738.82 ccw(c5686.85,3738.82) 5699.66,3751.63 cw(c5686.85,3738.82) 5704.96,3738.82
  Bottom Layer w4: v1(6165.19,2333.37) 6178.02,2320.54 6178.02,2148.14 6190.05,2136.12 6235.13,2136.12 6244.19,2127.06 6302.88,2127.06 6307.44,2122.5 6353.37,2122.5 6539.36,2308.49 6539.36,2365.62 6539.54,2365.81 6539.54,2366.06 6549.52,2376.04 6642.02,2376.04 6701.87,2316.19 6715.75,2316.19 6734.19,2297.75 6734.19,2253.81 6750.01,2237.99 6750.01,2198.85 6750.01,2140.59 ccw(c6773.78,2140.59) 6773.78,2116.82 cw(c6773.78,2101.22) 6789.38,2101.22 ccw(c6813.15,2101.22) 6813.15,2077.45 cw(c6813.15,2061.85) 6828.75,2061.85 ccw(c6852.52,2061.85) 6835.71,2045.04 6842.13,2037.31 ; v3@6845.13,2023.78 ccw(c6827.3,2026.93) 6842.13,2037.31 ; v3@6853.82,2029.87 cw(c6856.97,2047.7) 6842.13,2037.31
DB_MEM.BUS_A1: U7.E2 U8.AF17 U61.82 | length 6929.8
  Top Layer w4: v1@5444.4,3447.18 v1(5444.4,3441.9) 5459.9,3457.4 5459.9,3515.95 5459.9,3534.29 5469.2,3543.59 5469.2,3550.95 5500.3,3582.05 5500.3,3596.42 5512.29,3608.4 5512.29,3630.82 5512.29,3638.82 5512.29,3697.36 ccw(c5473.61,3697.36) 5500.96,3724.71 ; U8.AF17@5488.42,3729.9 cw(c5488.42,3712.18) 5500.96,3724.71 ; U8.AF17@5495.77,3737.24 ccw(c5513.49,3737.24) 5500.96,3724.71 ; U61.82@5960.87,2821.32 cw(c5950.45,2810.89) 5965.19,2810.89 ; U61.82@5962.33,2854.29 ccw(c5960.84,2858.37) 5965.19,2858.37 ; U61.82@5963.7,2850.53 cw(c5979.04,2850.53) 5968.19,2861.38 ; 5965.19,2818.09 cw(c5969.76,2818.09) U61.82@5966.53,2821.32 ; U61.82@5965.19,2837.34 5965.19,2775.04 5981.86,2758.37 5998.52,2758.37 6073.52,2683.37 6109.23,2683.37 6160.36,2734.5 6183.25,2734.5 6191.75,2743 6214,2743 6272.71,2801.71 v1(6280.19,2801.71) ; U61.82@5965.19,2838.83 5965.19,2858.37 ; 5965.19,2856.59 ccw(c5969.76,2856.59) U61.82@5966.53,2853.36 ; U61.82@5967.7,2850.53 cw(c5992.7,2850.53) 5975.02,2868.21 ; 5969.42,2862.61 cw(c5986.07,2845.96) v1@5986.07,2869.5 ; 5970.03,2863.21 ccw(c5954.24,2879) v1@5976.57,2879 ; 5976.25,2869.43 cw(c5986.07,2859.62) v1@5986.07,2873.5 ; 5976.85,2870.04 ccw(c5967.89,2879) v1@5980.57,2879 ; v1@5985.94,2879.13 5981.86,2875.04 5965.19,2858.37
  Top Layer w8: v5@7810.63,4594.11 cw(c7810.63,4572.38) 7825.99,4587.75 cw(c7841.36,4603.11) v5@7819.63,4603.11 ; v5(7810.63,4603.11) U7.E2@7830.32,4583.43
  MidLayer1 w4: v1(7772.69,3270.71) 7745,3298.4 7745,3605.48 7799.19,3659.67 7799.19,4187.34 7840.19,4228.34 7840.19,4573.55 v5(7810.63,4603.11) ; 7756.47,3286.92 cw(c7740.26,3270.71) 7763.19,3270.71 ccw(c7740.26,3270.71) 7756.47,3286.92 ; 7756.47,3286.92 ccw(c7772.69,3303.14) 7772.69,3280.21 cw(c7772.69,3303.14) 7756.47,3286.92 ; 7763.3,3280.09 cw(c7753.91,3270.71) 7767.19,3270.71 ccw(c7753.91,3270.71) 7763.3,3280.09 ; 7763.3,3280.09 ccw(c7772.69,3289.48) 7772.69,3276.21 cw(c7772.69,3289.48) 7763.3,3280.09 ; 7822.58,4591.16 cw(c7834.53,4603.11) 7817.63,4603.11 ccw(c7834.53,4603.11) 7822.58,4591.16 ; 7822.58,4591.16 ccw(c7810.63,4579.21) 7810.63,4596.11 cw(c7810.63,4579.21) 7822.58,4591.16 ; 7829.41,4584.33 cw(c7848.19,4603.11) 7821.63,4603.11 ccw(c7848.19,4603.11) 7829.41,4584.33 ; 7829.41,4584.33 ccw(c7810.63,4565.56) 7810.63,4592.11 cw(c7810.63,4565.56) 7829.41,4584.33
  MidLayer2 w4: v1@5437.68,3435.18 cw(c5415.67,3413.17) 5446.8,3413.17 ; v1@5440.51,3438.01 cw(c5425.33,3422.83) 5446.8,3422.83 ; v1(5444.4,3441.9) 5446.8,3439.5 5446.8,3337.82 5432.43,3323.44 5432.43,3308.94 5441.67,3299.7 5441.67,3233.72 5436.62,3228.67 5436.62,3190 5436.62,3179.91 5436.62,3168.55 5448.69,3156.48 5567.87,3037.3 5844.76,3037.3 5956.5,2925.56 5956.5,2906.75 v1@5984.25,2879 ; 5446.8,3424.76 cw(c5461.54,3424.76) v1@5451.12,3435.18 ; 5966.75,2896.5 ccw(c5986.07,2915.82) v1@5986.07,2888.5 ; 5971.13,2892.12 cw(c5958.01,2879) v1@5976.57,2879 ; 5973.58,2889.67 ccw(c5986.07,2902.16) v1@5986.07,2884.5
  Bottom Layer w4: v1(6280.19,2801.71) 6312.92,2801.71 6327.08,2787.54 6423.92,2787.54 6428.08,2791.71 6668.29,2791.71 6676.58,2800 6725,2800 6834.84,2800.04 6909.84,2875.04 6976.27,2875.04 6982.81,2868.5 7148.5,2868.5 7181.02,2901.02 7181.02,2989.62 7191.28,2999.87 7205.77,2999.87 7214.77,2990.87 7448.77,2990.87 7475.02,3017.13 7475.02,3031.62 7473.2,3033.45 7473.2,3076.8 7437.19,3112.81 7255.88,3112.81 7235,3133.69 7235,3271.9 7198.52,3308.37 7198.52,3341.71 7215.19,3358.37 7486.63,3358.37 7547,3298 7547,3257.17 7591.96,3212.21 7606.44,3212.21 7616.69,3201.96 7616.69,3157.13 7639.69,3134.13 7740.91,3134.13 7800,3075.04 7823.52,3075.04 7840.19,3091.71 7840.19,3235.81 7806,3270 v1@7773.4,3270 ; 6293.47,2801.71 cw(c6293.47,2814.99) 6284.08,2805.6 ccw(c6293.47,2814.99) 6293.47,2801.71 ; 6293.47,2801.71 ccw(c6293.47,2788.43) 6284.08,2797.82 cw(c6293.47,2788.43) 6293.47,2801.71 ; 6303.13,2801.71 cw(c6303.13,2824.64) 6286.91,2808.43 ccw(c6303.13,2824.64) 6303.13,2801.71 ; 6303.13,2801.71 ccw(c6303.13,2778.77) 6286.91,2794.99 cw(c6303.13,2778.77) 6303.13,2801.71 ; v1@7776.58,3266.82 cw(c7784.27,3259.13) 7784.27,3270 ccw(c7784.27,3259.13) v1@7776.58,3266.82 ; v1@7776.58,3274.59 ccw(c7787.67,3285.69) 7787.67,3270 cw(c7787.67,3285.69) v1@7776.58,3274.59 ; v1@7779.41,3263.99 cw(c7793.92,3249.47) 7793.92,3270 ccw(c7793.92,3249.47) v1@7779.41,3263.99 ; v1@7779.41,3277.42 ccw(c7797.33,3295.34) 7797.33,3270 cw(c7797.33,3295.34) v1@7779.41,3277.42
  other v1: 5986.07,2879
DB_MEM.BUS_A2: U7.D2 U8.C13 U12.23 U13.23 U16.1 U17.1 U61.84 | length 9139.6
  Top Layer w4: U8.C13@5323.6,4642.76 ccw(c5305.88,4642.76) 5318.41,4655.29 ; U8.C13@5330.95,4650.1 cw(c5330.95,4667.82) 5318.41,4655.29 ; v1@5376.62,4975.45 cw(c5370.18,4965.71) 5381.86,4965.71 ; v1(5381.86,4983.37) 5381.86,4965.71 ; v1@5387.1,4975.45 ccw(c5393.53,4965.71) 5381.86,4965.71 ; U61.84@5921.5,2853.36 ccw(c5914.67,2860.19) 5924.33,2860.19 ccw(c5933.99,2860.19) U61.84@5927.16,2853.36 ; U61.84@5924.33,2837.34 5924.33,2864.53 5913.36,2875.5 5913.36,2889.88 5916.78,2893.3 5923.52,2900.04 5963.21,2900.04 5966.75,2896.5 5981.25,2896.5 6020.98,2896.5 6024.52,2900.04 ; v1@6107.36,2983.37 cw(c6084.42,2983.37) 6100.64,2967.16 cw(c6116.86,2950.94) v1@6116.86,2973.87 ; v1@6107.86,2983.37 v1(6116.86,2983.37) 6094.14,2960.66 6085.14,2960.66 6027.1,2902.62 ; v1@6111.36,2983.37 cw(c6098.08,2983.37) 6107.47,2973.99 cw(c6116.86,2964.6) v1@6116.86,2977.87 ; v1@6111.52,4987.21 cw(c6111.52,4964.27) 6127.74,4980.49 cw(c6143.96,4996.71) v1@6121.02,4996.71 ; v1@6111.52,4991.21 cw(c6111.52,4977.93) 6120.91,4987.32 cw(c6130.3,4996.71) v1@6117.02,4996.71 ; v1(6111.52,4996.71) 6137.53,4970.71 ; U17.1@6146.51,4966.07 ccw(c6137.53,4959.68) 6137.53,4970.71 ; U17.1@6146.51,4975.34 cw(c6137.53,4981.73) 6137.53,4970.71 ; U13.23@6170.59,3481.54 6206.35,3481.53 ; U17.1@6170.59,4970.71 6137.53,4970.71 ; U13.23@6194.04,3476.13 cw(c6206.35,3464.83) 6206.35,3481.53 ; U13.23@6194.04,3486.94 ccw(c6206.35,3498.23) 6206.35,3481.53 ; 6214.67,3488.04 cw(c6214.67,3464.48) v1@6231.33,3481.14 ; 6215.56,3488.04 ccw(c6215.56,3510.35) v1@6231.33,3494.58 ; 6224.33,3488.04 cw(c6224.33,3474.14) v1@6234.16,3483.97 ; 6225.21,3488.04 ccw(c6225.21,3500.69) v1@6234.16,3491.75 ; v1(6238.05,3487.86) 6237.87,3488.04 6212.86,3488.04 6206.35,3481.53 ; v1(6749.52,5022.37) 6749.52,5008.37 6787.19,4970.71 U16.1@6845.59,4970.71 ; U16.1@6822.37,4965.05 ccw(c6808.72,4951.4) 6808.72,4970.71 ccw(c6808.72,4990.02) U16.1@6822.37,4976.37 ; U12.23@6845.59,3481.54 6912.35,3481.53 v1(6923.52,3492.71) ; U12.23@6868.81,3475.88 cw(c6882.46,3462.22) 6882.46,3481.53 cw(c6882.46,3500.85) U12.23@6868.81,3487.19 ; 5318.41,4655.29 cw(c5345.76,4682.64) 5307.08,4682.64 5307.08,4741.18 5307.08,4777.73 5287.19,4797.62 5287.19,4812.38 5355,4880.19 5355,4938.85 5381.86,4965.71 ; 6024.52,2900.04 6027.1,2902.62 ; 6024.52,2900.04 6027.1,2902.62
  Top Layer w8: U7.D2@7869.69,4583.43 v5(7889.37,4603.11) ; v5@7880.37,4603.11 cw(c7858.64,4603.11) 7874.01,4587.75 cw(c7889.37,4572.38) v5@7889.37,4594.11
  MidLayer1 w4: v1@6104.81,5003.43 ccw(c6088.59,5019.64) 6111.52,5019.64 ccw(c6134.46,5019.64) v1@6118.24,5003.43 ; v1@6107.64,5000.6 ccw(c6098.25,5009.99) 6111.52,5009.99 ccw(c6124.8,5009.99) v1@6115.41,5000.6 ; v1(6111.52,4996.71) 6111.52,5038.48 6110,5040 6095,5055 6095,5076.87 6101.51,5083.37 6198.19,5083.37 ; v1@6297.25,3006.18 ccw(c6285.07,3020.04) 6303.52,3020.04 ; v1@6299.89,3003.17 ccw(c6292.84,3011.2) 6303.52,3011.2 ccw(c6314.21,3011.2) v1@6307.16,3003.17 ; v1(6303.52,2999.04) 6303.52,3020.04 ; v1@6309.8,3006.18 cw(c6321.98,3020.04) 6303.52,3020.04 ; v1@6741.68,5017.02 ccw(c6731.54,5010.11) 6731.54,5022.37 ; v1@6741.68,5027.73 cw(c6731.54,5034.64) 6731.54,5022.37 ; v1(6749.52,5022.37) 6731.54,5022.37 ; v1@7758.47,3451.72 ccw(c7742.26,3467.93) 7765.19,3467.93 ccw(c7788.13,3467.93) v1@7771.91,3451.72 ; v1@7761.3,3448.89 ccw(c7751.91,3458.28) 7765.19,3458.28 ccw(c7778.47,3458.28) v1@7769.08,3448.89 ; v1(7765.19,3445) 7765.19,3545 ; v5@7889.37,4592.11 cw(c7889.37,4565.55) 7908.15,4584.33 cw(c7926.93,4603.11) v5@7900.37,4603.11 ; v5@7889.37,4596.11 cw(c7889.37,4579.21) 7901.32,4591.16 cw(c7913.27,4603.11) v5@7896.37,4603.11 ; v5(7889.37,4603.11) 7908.52,4583.96 7908.52,4555.71 7897.52,4544.71 7865.19,4544.71 7848.52,4528.04 7848.52,4225.36 7807.19,4184.02 7807.19,3656.35 7789.17,3638.34 ; 6198.19,5083.37 6225,5083.37 ; 6198.19,5083.37 6225,5083.37 ; 6225,5083.37 6515.19,5083.37 6541.63,5083.37 6578.96,5046.04 6707.88,5046.04 6731.54,5022.37 ; 6238.05,3472.15 v1(6238.05,3487.86) 6238.05,3472.15 ; 6238.05,3472.15 6238.05,3464.49 6308.35,3394.19 ; 6303.52,3020.04 6281.86,3041.71 6281.86,3066.71 6292,3076.85 6292,3343.2 6308.35,3359.56 ; 6308.35,3359.56 6308.35,3394.19 ; 6308.35,3359.56 6308.35,3394.19 ; 7765.19,3545 7765.19,3553.69 ; 7765.19,3545 7765.19,3553.69 ; 7765.19,3553.69 7765.19,3614.35 ; 7765.19,3614.35 7789.17,3638.34 ; 7765.19,3614.35 7789.17,3638.34
  MidLayer2 w4: v1(5381.86,4983.37) 5398.52,4983.37 ; v1@5390.03,4978.53 cw(c5398.52,4973.51) 5398.52,4983.37 ; v1@5390.03,4988.22 ccw(c5398.52,4993.24) 5398.52,4983.37 ; v1@6102.02,4996.71 ccw(c6079.09,4996.71) 6095.31,5012.93 ccw(c6111.52,5029.14) v1@6111.52,5006.21 ; v1@6106.02,4996.71 ccw(c6092.75,4996.71) 6102.14,5006.1 ccw(c6111.52,5015.49) v1@6111.52,5002.21 ; v1@6110.14,2990.09 ccw(c6093.92,3006.31) 6116.86,3006.31 ccw(c6139.79,3006.31) v1@6123.57,2990.09 ; v1(6111.52,4996.71) 6091.02,5017.21 5637.1,5017.21 5628.27,5008.37 5423.52,5008.37 5398.52,4983.37 ; v1@6112.97,2987.26 ccw(c6103.58,2996.65) 6116.86,2996.65 ccw(c6130.14,2996.65) v1@6120.75,2987.26 ; v1(6116.86,2983.37) 6116.86,3021.86 6125,3030 6272.56,3030 v1(6303.52,2999.04) ; v1@6294.02,2999.04 ccw(c6271.09,2999.04) 6287.31,3015.26 ccw(c6303.52,3031.48) v1@6303.52,3008.54 ; v1@6298.02,2999.04 ccw(c6284.75,2999.04) 6294.14,3008.43 ccw(c6303.52,3017.82) v1@6303.52,3004.54 ; v1@6742.81,5015.66 cw(c6726.59,4999.44) 6749.52,4999.44 cw(c6772.46,4999.44) v1@6756.24,5015.66 ; v1@6745.64,5018.49 cw(c6736.25,5009.1) 6749.52,5009.1 cw(c6762.8,5009.1) v1@6753.41,5018.49 ; v1(6749.52,5022.37) 6749.52,4940.71 6801.36,4888.87 6809.4,4888.87 6845.07,4853.21 6975.71,4853.21 7006.38,4883.88 7044.62,4883.88 7053.28,4892.54 7130.67,4892.54 7148,4875.21 7244.15,4875.21 7252.15,4883.21 7540.02,4883.21 7540.19,4883.37 7556.86,4900.04 7558.63,4901.81 7821.75,4901.81 7848.52,4875.04 7848.52,4700.04 7865.19,4683.37 7865.19,4627.29 v5(7889.37,4603.11) ; v5@7878.37,4603.11 ccw(c7851.82,4603.11) 7870.59,4621.89 ccw(c7889.37,4640.67) v5@7889.37,4614.11 ; v5@7882.37,4603.11 ccw(c7865.47,4603.11) 7877.42,4615.06 ccw(c7889.37,4627.01) v5@7889.37,4610.11
  Bottom Layer w4: v1(6238.05,3487.86) 6258.36,3487.86 ; v1@6242.27,3484.33 cw(c6249.81,3478.04) 6249.81,3487.86 cw(c6249.81,3497.68) v1@6242.27,3491.38 ; v1@6245.34,3481.77 cw(c6258.36,3470.9) 6258.36,3487.86 ; v1@6245.34,3493.95 ccw(c6258.36,3504.82) 6258.36,3487.86 ; 6291.19,3500.04 6290.86,3499.71 ; v1@6927.41,3488.82 cw(c6936.8,3479.43) 6936.8,3492.71 cw(c6936.8,3505.99) v1@6927.41,3496.6 ; v1@6930.24,3485.99 cw(c6946.46,3469.77) 6946.46,3492.71 cw(c6946.46,3515.64) v1@6930.24,3499.43 ; v1@7758.47,3451.72 ccw(c7742.26,3467.93) 7765.19,3467.93 ccw(c7788.13,3467.93) v1@7771.91,3451.72 ; v1@7761.3,3448.89 ccw(c7751.91,3458.28) 7765.19,3458.28 ccw(c7778.47,3458.28) v1@7769.08,3448.89 ; v1(7765.19,3445) 7765.19,3475.04 7748.52,3491.71 7340.19,3491.71 7281.02,3550.87 7266.02,3550.87 ; 6258.36,3487.86 6270.21,3499.71 ; 6270.21,3499.71 6290.86,3499.71 ; 6270.21,3499.71 6290.86,3499.71 ; 6290.86,3499.71 6300,3499.71 6340,3539.71 6350.67,3550.37 6606.52,3550.37 6640.19,3516.71 6725.52,3516.71 6733.86,3508.37 6907.86,3508.37 v1(6923.52,3492.71) 7171.54,3492.71 7201.39,3522.55 7201.39,3535.99 7216.28,3550.87 ; 7216.28,3550.87 7266.02,3550.87 ; 7216.28,3550.87 7266.02,3550.87
DB_MEM.BUS_A3: U7.C2 U8.C15 U12.24 U13.24 U16.2 U17.2 U61.86 | length 9774.6
  Top Layer w4: v1@5395,4885.5 cw(c5395,4862.56) 5411.22,4878.78 cw(c5427.43,4895) v1@5404.5,4895 ; v1@5395,4889.5 cw(c5395,4876.22) 5404.39,4885.61 cw(c5413.78,4895) v1@5400.5,4895 ; v1(5395,4895) 5426.19,4863.81 5426.19,4780.62 5433.55,4773.26 5433.55,4741.18 5433.55,4682.64 cw(c5394.87,4682.64) 5422.22,4655.29 ; U8.C15@5409.68,4650.1 ccw(c5409.68,4667.82) 5422.22,4655.29 ; U8.C15@5417.03,4642.76 cw(c5434.75,4642.76) 5422.22,4655.29 ; U61.86@5882.13,2821.32 cw(c5875.3,2814.49) 5884.96,2814.49 cw(c5894.62,2814.49) U61.86@5887.79,2821.32 ; U61.86@5884.96,2837.34 5884.96,2808.37 5898.52,2794.81 5898.52,2681.72 5895.44,2678.63 5895.44,2528.13 5915.19,2508.37 5925,2508.37 5948.92,2508.37 6041.86,2601.32 v1(6041.86,2689.71) ; v1@6035.14,2682.99 cw(c6018.92,2666.77) 6041.86,2666.77 cw(c6064.79,2666.77) v1@6048.57,2682.99 ; v1@6037.97,2685.82 cw(c6028.58,2676.43) 6041.86,2676.43 cw(c6055.14,2676.43) v1@6045.75,2685.82 ; v1@6119.47,3366.09 ccw(c6103.26,3382.31) 6126.19,3382.31 ccw(c6149.13,3382.31) v1@6132.91,3366.09 ; v1@6122.3,3363.26 ccw(c6112.91,3372.65) 6126.19,3372.65 ccw(c6139.47,3372.65) v1@6130.08,3363.26 ; v1(6123.52,4943.04) 6127.35,4939.21 U17.2@6170.59,4939.21 ; v1@6124.58,4944.1 ccw(c6136.38,4955.9) 6136.38,4939.21 ; v1(6126.19,3359.37) 6126.19,3417.26 6158.97,3450.04 U13.24@6170.59,3450.04 6240.19,3450.04 6256.86,3466.71 ; v1@6127.41,4946.93 ccw(c6146.04,4965.56) U17.2@6146.04,4939.21 ; v1@6130.24,4936.32 cw(c6137.22,4929.34) 6137.22,4939.21 ; v1@6130.24,4949.76 ccw(c6155.7,4975.21) U17.2@6155.7,4939.21 ; 6135.17,3426.24 ccw(c6111.38,3450.04) U13.24@6145.03,3450.04 ; 6142,3433.07 ccw(c6125.03,3450.04) U13.24@6149.03,3450.04 ; 6148.83,3439.9 ccw(c6138.69,3450.04) U13.24@6153.03,3450.04 ; U13.24@6149.51,3440.58 cw(c6153.03,3437.07) U13.24@6153.03,3442.04 ; U13.24@6193.81,3444.38 cw(c6207.46,3430.73) 6207.46,3450.04 cw(c6207.46,3469.35) U13.24@6193.81,3455.7 ; v1@6265.35,3461.87 ccw(c6256.86,3456.84) 6256.86,3466.71 ; v1@6265.35,3471.55 cw(c6256.86,3476.58) 6256.86,3466.71 ; v1(6273.52,3466.71) 6256.86,3466.71 ; U12.24@6845.59,3450.04 6874.19,3450.04 ; U16.2@6845.59,4939.21 6881.15,4939.21 ; U12.24@6863.15,3450.04 ccw(c6868.51,3458.36) 6875.51,3451.36 ; U16.2@6869.09,4933.85 cw(c6881.15,4922.96) 6881.15,4939.21 ; U16.2@6869.09,4944.57 ccw(c6881.15,4955.46) 6881.15,4939.21 ; U12.24@6870.75,3447.55 cw(c6874.19,3446.42) 6874.19,3450.04 ; U12.24@6870.75,3452.53 ccw(c6874.19,3453.65) 6874.19,3450.04 ; 6874.65,3450.5 cw(c6883.5,3441.64) v1@6888.15,3453.27 ; 6878.94,3454.79 cw(c6885.95,3447.77) v1@6889.63,3456.98 ; v1(6890.19,3458.37) 6882.52,3458.37 6874.19,3450.04 ; v1@6947.36,4950.04 cw(c6924.42,4950.04) 6940.64,4933.82 cw(c6956.86,4917.61) v1@6956.86,4940.54 ; v1@6951.36,4950.04 cw(c6938.08,4950.04) 6947.47,4940.65 cw(c6956.86,4931.26) v1@6956.86,4944.54 ; v1(6956.86,4950.04) 6931.86,4925.04 6895.32,4925.04 6881.15,4939.21
  Top Layer w8: U7.C2@7909.06,4583.43 v5(7928.74,4603.11) ; v5@7919.74,4603.11 cw(c7898.01,4603.11) 7913.38,4587.75 cw(c7928.74,4572.38) v5@7928.74,4594.11
  MidLayer1 w4: v1@6035.14,2696.43 ccw(c6018.92,2712.64) 6041.86,2712.64 ccw(c6064.79,2712.64) v1@6048.57,2696.43 ; v1@6037.97,2693.6 ccw(c6028.58,2702.99) 6041.86,2702.99 ccw(c6055.14,2702.99) v1@6045.75,2693.6 ; v1(6041.86,2689.71) 6041.86,2720.75 6048.52,2727.41 6048.52,2739.34 6048.52,2750 6048.52,2835.71 6062.86,2850.04 6062.86,2908.31 6067.81,2913.27 6067.81,2971.32 6062.86,2976.27 6062.86,3087.36 6160.5,3185 6160.5,3262.14 6158.19,3264.45 6158.19,3327.37 v1(6126.19,3359.37) ; v1@6123.52,4933.54 cw(c6123.52,4910.61) 6139.74,4926.82 cw(c6155.96,4943.04) v1@6133.02,4943.04 ; v1@6123.52,4937.54 cw(c6123.52,4924.26) 6132.91,4933.65 cw(c6142.3,4943.04) v1@6129.02,4943.04 ; v1(6123.52,4943.04) 6149.06,4917.5 6352.37,4917.5 6367.68,4932.81 6402.32,4932.81 6415.94,4919.19 6695.5,4919.19 6740.52,4964.21 6942.69,4964.21 v1(6956.86,4950.04) 6956.86,4923.14 6965,4915 v1(6965,4880) 7035,4810 7195,4810 7210,4795 7210,4655 ; v1@6126.19,3349.87 cw(c6126.19,3326.94) 6142.41,3343.16 cw(c6158.63,3359.37) v1@6135.69,3359.37 ; v1@6126.19,3353.87 cw(c6126.19,3340.6) 6135.58,3349.99 cw(c6144.97,3359.37) v1@6131.69,3359.37 ; v1(6890.19,3458.37) 6938.56,3458.37 6950.19,3470 6957.19,3477 ; v1@6894.08,3454.49 cw(c6903.47,3445.1) 6903.47,3458.37 cw(c6903.47,3471.65) v1@6894.08,3462.26 ; v1@6896.91,3451.66 cw(c6913.13,3435.44) 6913.13,3458.37 cw(c6913.13,3481.31) v1@6896.91,3465.09 ; v1@6950.14,4943.32 cw(c6933.92,4927.11) 6956.86,4927.11 cw(c6979.79,4927.11) v1@6963.57,4943.32 ; v1@6952.97,4946.15 cw(c6943.58,4936.76) 6956.86,4936.76 cw(c6970.14,4936.76) v1@6960.75,4946.15 ; v1@6958.28,4886.72 ccw(c6942.06,4902.93) 6965,4902.93 ccw(c6987.93,4902.93) v1@6971.72,4886.72 ; v1@6961.11,4883.89 ccw(c6951.72,4893.28) 6965,4893.28 ccw(c6978.28,4893.28) v1@6968.89,4883.89 ; v1@6965,4870.5 cw(c6965,4847.56) 6981.22,4863.78 cw(c6997.43,4880) v1@6974.5,4880 ; v1@6965,4874.5 cw(c6965,4861.22) 6974.39,4870.61 cw(c6983.78,4880) v1@6970.5,4880 ; 6957.19,3477 6957.19,3520.02 ; 6957.19,3477 6957.19,3520.02 ; 6957.19,3520.02 7097.86,3660.69 ; 6957.19,3520.02 7097.86,3660.69 ; 7097.86,3660.69 7097.86,3808.61 7097.86,3975 ; 7097.86,3975 7097.86,3992.86 ; 7097.86,3975 7097.86,3992.86 ; 7097.86,3992.86 7097.86,4016.54 7128,4046.69 ; 7128,4046.69 7128,4065 ; 7128,4046.69 7128,4065 ; 7128,4065 7128,4142.6 7131.86,4146.45 7215.19,4229.79 7215.19,4390 7200.19,4405 7180,4405 7170,4395 7170,4380 7195,4355 7195,4335 7185,4325 7165,4325 7150,4340 7150,4396.53 7123.19,4423.34 7123.19,4503.19 7140.19,4520.19 ; 7140.19,4520.19 7140.19,4585.19 ; 7140.19,4520.19 7140.19,4585.19 ; 7140.19,4585.19 7210,4655 ; 7140.19,4585.19 7210,4655
  MidLayer2 w4: v1(5395,4895) 5395,4897.85 5462,4964.85 5476.52,4979.37 ; v1@5395,4904.5 ccw(c5395,4920.55) 5406.35,4909.2 ; v1@5400.5,4895 cw(c5420.66,4895) 5406.4,4909.26 ; v1@5404.5,4895 cw(c5434.32,4895) 5413.23,4916.08 ; 6040,5000 6039.8,5000.2 ; v1(6123.52,4943.04) 6066.36,5000.2 6039.8,5000.2 ; v1(6965,4880) 6978.04,4893.04 7022.58,4893.04 7023.41,4892.21 7041.64,4892.21 7049.97,4900.54 7133.98,4900.54 7151.31,4883.21 7240.84,4883.21 7248.84,4891.21 7281.26,4891.21 7322.09,4932.04 7380.52,4932.04 7398.52,4950.04 ; 7396.8,4948.32 7413.48,4965 7616.9,4965 7631.86,4950.04 7648.52,4933.37 7649.02,4933.87 7845.05,4933.87 7948.52,4830.39 7948.52,4622.89 v5(7928.74,4603.11) ; v5@7928.74,4610.11 ccw(c7928.74,4627.01) 7940.69,4615.06 ccw(c7952.64,4603.11) v5@7935.74,4603.11 ; v5@7928.74,4614.11 ccw(c7928.74,4640.67) 7947.52,4621.89 ccw(c7966.3,4603.11) v5@7939.74,4603.11 ; 5476.52,4979.37 5520,4979.37 ; 5476.52,4979.37 5520,4979.37 ; 5520,4979.37 5621.9,4979.37 5643.73,5001.21 6038.79,5001.21 6039.8,5000.2
  Bottom Layer w4: v1@6273.52,3472.21 ccw(c6273.52,3485.49) 6282.91,3476.1 ccw(c6292.3,3466.71) v1@6279.02,3466.71 ; v1@6273.52,3476.21 ccw(c6273.52,3499.14) 6289.74,3482.93 ccw(c6305.96,3466.71) v1@6283.02,3466.71 ; v1@6274.82,3468 v1(6273.52,3466.71) v1@6274.82,3468 ; v1@6274.82,3468 6298.52,3491.71 6305.48,3491.71 ; 6305.48,3491.71 6310.52,3496.75 ; 6305.48,3491.71 6310.52,3496.75 ; 6310.52,3496.75 6337.48,3523.71 6356.15,3542.37 6603.21,3542.37 ; 6603.21,3542.37 6636.88,3508.71 ; 6603.21,3542.37 6636.88,3508.71 ; 6636.88,3508.71 6680,3508.71 ; 6680,3508.71 6710.9,3508.71 ; 6680,3508.71 6710.9,3508.71 ; 6710.9,3508.71 6722.21,3508.71 ; 6722.21,3508.71 6730.54,3500.37 ; 6722.21,3508.71 6730.54,3500.37 ; 6730.54,3500.37 6848.19,3500.37 6856.86,3491.71 ; 6856.86,3491.71 v1(6890.19,3458.37) 6856.86,3491.71 ; 6873.97,3474.59 cw(c6857.76,3458.37) 6880.69,3458.37 ccw(c6857.76,3458.37) 6873.97,3474.59 ; 6873.97,3474.59 ccw(c6890.19,3490.81) 6890.19,3467.87 cw(c6890.19,3490.81) 6873.97,3474.59 ; 6880.8,3467.76 cw(c6871.41,3458.37) 6884.69,3458.37 ccw(c6871.41,3458.37) 6880.8,3467.76 ; 6880.8,3467.76 ccw(c6890.19,3477.15) 6890.19,3463.87 cw(c6890.19,3477.15) 6880.8,3467.76
DB_MEM.BUS_A4: U7.A2 U8.A17 U12.25 U13.25 U16.3 U17.3 U61.87 | length 9970.6
  Top Layer w4: 5415.19,4978.71 5441.52,4952.37 ; 5415.69,4979.2 5415.69,5035.5 5429.26,5049.07 5429.26,5092.97 v1(5504,5167.71) ; 5441.65,4952.5 5474.4,4952.5 ; 5474.52,4952.37 5481.86,4945.04 ; 5482.5,4944.4 5482.5,4927.75 5470.75,4916 5461.15,4916 5450.9,4905.75 5450.9,4889.29 5488.42,4851.76 5488.42,4748.42 5488.42,4741.18 U8.A17@5488.43,4721.5 ; U8.A17@5483.23,4726.69 ccw(c5470.7,4739.22) 5488.42,4739.22 ccw(c5506.15,4739.22) U8.A17@5493.62,4726.69 ; v1@5494.5,5167.71 cw(c5471.56,5167.71) 5487.78,5151.49 cw(c5504,5135.27) v1@5504,5158.21 ; v1@5498.5,5167.71 cw(c5485.22,5167.71) 5494.61,5158.32 cw(c5504,5148.93) v1@5504,5162.21 ; U61.87@5862.45,2853.36 ccw(c5855.82,2859.98) 5865.19,2859.98 ; U61.87@5865.19,2850.53 5865.19,2873.19 5876,2884 v1(5890,2884) v1@5884.19,2884 ; 5865.19,2860.39 ccw(c5875.14,2860.39) U61.87@5868.1,2853.36 ; U13.25@6170.59,3418.54 6208.69,3418.54 v1(6215.12,3424.97) ; U17.3@6170.59,4907.72 6361.55,4907.72 6423.86,4970.02 v1(6423.86,5012.04) ; U13.25@6176.67,3418.54 ccw(c6176.67,3463.43) v1@6208.41,3431.69 ; U13.25@6186.32,3418.54 ccw(c6186.32,3453.78) v1@6211.23,3428.86 ; U17.3@6193.81,4902.06 cw(c6207.46,4888.4) 6207.46,4907.72 cw(c6207.46,4927.03) U17.3@6193.81,4913.37 ; U13.25@6195.98,3418.54 ccw(c6195.98,3444.12) v1@6214.06,3426.03 ; v1@6417.14,5005.32 cw(c6400.92,4989.11) 6423.86,4989.11 cw(c6446.79,4989.11) v1@6430.57,5005.32 ; v1@6419.97,5008.15 cw(c6410.58,4998.76) 6423.86,4998.76 cw(c6437.14,4998.76) v1@6427.75,5008.15 ; v1(6740.19,3310.71) 6811.52,3382.04 6811.52,3416.88 6813.19,3418.54 ; v1@6740.19,3316.21 ccw(c6740.19,3329.49) 6749.58,3320.1 ccw(c6758.97,3310.71) v1@6745.69,3310.71 ; v1@6740.19,3320.21 ccw(c6740.19,3343.14) 6756.41,3326.93 ccw(c6772.63,3310.71) v1@6749.69,3310.71 ; v1@6789.52,4916.87 cw(c6789.52,4893.94) 6805.74,4910.16 cw(c6821.96,4926.37) v1@6799.02,4926.37 ; v1@6789.52,4920.87 cw(c6789.52,4907.6) 6798.91,4916.99 cw(c6808.3,4926.37) v1@6795.02,4926.37 ; v1(6789.52,4926.37) 6808.18,4907.72 U16.3@6845.59,4907.72 ; U12.25@6821.35,3422.94 cw(c6813.19,3428.31) 6813.19,3418.54 ; U12.25@6821.35,3414.15 ccw(c6813.19,3408.78) 6813.19,3418.54 ; U16.3@6822.37,4902.06 ccw(c6808.72,4888.4) 6808.72,4907.72 ccw(c6808.72,4927.03) U16.3@6822.37,4913.37 ; U12.25@6868.81,3412.89 cw(c6882.46,3399.23) 6882.46,3418.54 cw(c6882.46,3437.86) U12.25@6868.81,3424.2 ; v1@6950.14,3559.99 cw(c6933.92,3543.77) 6956.86,3543.77 cw(c6979.79,3543.77) v1@6963.57,3559.99 ; v1@6952.97,3562.82 cw(c6943.58,3553.43) 6956.86,3553.43 cw(c6970.14,3553.43) v1@6960.75,3562.82 ; v1(6956.86,3566.71) 6956.86,3448.37 6933.52,3425.04 6923.52,3425.04 6917.03,3418.54 6813.19,3418.54
  Top Layer w8: U7.A2@7987.8,4583.43 v5(8007.48,4603.11) ; v5@7998.48,4603.11 cw(c7976.75,4603.11) 7992.12,4587.75 cw(c8007.48,4572.38) v5@8007.48,4594.11
  MidLayer1 w4: v1@5883.28,2890.72 ccw(c5867.06,2906.93) 5890,2906.93 ccw(c5912.93,2906.93) v1@5896.72,2890.72 ; v1@5886.11,2887.89 ccw(c5876.72,2897.28) 5890,2897.28 ccw(c5903.28,2897.28) v1@5893.89,2887.89 ; v1(5890,2884) 5890,2937 5923.81,2970.81 5926.19,2973.19 5926.19,3011.06 5906.19,3031.06 5906.19,3182.67 5890.86,3198 5890.86,3259.04 5912.27,3280.46 5920.46,3280.46 5940.04,3300.04 v1(5940.19,3300.04) ; 5923.72,3283.72 cw(c5940.19,3267.25) v1@5940.19,3290.54 ; 5924.08,3284.08 ccw(c5908.12,3300.04) v1@5930.69,3300.04 ; 5930.55,3290.55 cw(c5940.19,3280.9) v1@5940.19,3294.54 ; 5930.91,3290.91 ccw(c5921.77,3300.04) v1@5934.69,3300.04
  MidLayer2 w4: v1@5504.29,5168 5610.69,5168 5611.69,5167 5763.8,5167 5772.17,5175.37 6445.21,5175.37 6457.19,5163.39 6457.19,5045.37 v1(6423.86,5012.04) ; v1@5507.89,5163.82 cw(c5517.98,5153.72) 5517.98,5168 ; v1@5507.89,5171.6 ccw(c5516.57,5180.28) 5516.57,5168 ; v1@5510.72,5160.99 cw(c5527.64,5144.07) 5527.64,5168 ; v1@5510.72,5174.43 ccw(c5526.23,5189.94) 5526.23,5168 ; v1@6423.86,5017.54 ccw(c6423.86,5030.82) 6433.25,5021.43 ccw(c6442.64,5012.04) v1@6429.36,5012.04 ; v1@6423.86,5021.54 ccw(c6423.86,5044.48) 6440.07,5028.26 ccw(c6456.29,5012.04) v1@6433.36,5012.04 ; v1@6789.52,4916.87 cw(c6789.52,4893.94) 6805.74,4910.16 cw(c6821.96,4926.37) v1@6799.02,4926.37 ; v1@6789.52,4920.87 cw(c6789.52,4907.6) 6798.91,4916.99 cw(c6808.3,4926.37) v1@6795.02,4926.37 ; v1(6789.52,4926.37) 6854.69,4861.21 6917.42,4861.21 6957.25,4901.04 7025.9,4901.04 7026.72,4900.21 7038.32,4900.21 7039.15,4901.04 7046.65,4908.54 7137.29,4908.54 7154.63,4891.21 7237.52,4891.21 7245.52,4899.21 7277.94,4899.21 7379.27,5000.54 7801.01,5000.54 8031.86,4769.69 8031.86,4627.49 v5(8007.48,4603.11) ; v1(7174.86,3916.71) 7190.15,3932 7319.17,3932 7320.54,3933.37 7412.21,4025.04 7706.86,4025.04 7973.52,4291.71 8031.86,4291.71 v1(8065.19,4325.04) ; v5@8007.48,4610.11 ccw(c8007.48,4627.01) 8019.43,4615.06 ccw(c8031.38,4603.11) v5@8014.48,4603.11 ; v5@8007.48,4614.11 ccw(c8007.48,4640.67) 8026.26,4621.89 ccw(c8045.03,4603.11) v5@8018.48,4603.11 ; v1@8055.69,4325.04 cw(c8032.76,4325.04) 8048.97,4308.82 cw(c8065.19,4292.61) v1@8065.19,4315.54 ; v1@8059.69,4325.04 cw(c8046.41,4325.04) 8055.8,4315.65 cw(c8065.19,4306.26) v1@8065.19,4319.54
  Bottom Layer w4: v1(5940.19,3300.04) 5998.52,3358.37 6046.37,3358.37 6063.04,3341.71 6148.92,3341.71 6157.08,3349.87 6193.06,3349.87 6215.19,3372 ; v1@5940.19,3305.54 ccw(c5940.19,3318.82) 5949.58,3309.43 ccw(c5958.97,3300.04) v1@5945.69,3300.04 ; v1@5940.19,3309.54 ccw(c5940.19,3332.48) 5956.41,3316.26 ccw(c5972.63,3300.04) v1@5949.69,3300.04 ; v1@6208.41,3418.26 cw(c6192.03,3401.88) 6215.19,3401.88 ; v1@6211.23,3421.08 cw(c6201.69,3411.53) 6215.19,3411.53 ; 6215.19,3402.2 cw(c6237.9,3402.2) v1@6221.84,3418.26 ; 6215.19,3411.85 cw(c6228.24,3411.85) v1@6219.01,3421.08 ; v1@6215.19,3424.91 6215.19,3372 ; v1(6423.86,5012.04) 6470.19,5058.37 6621.21,5058.37 6662.88,5016.71 6699.19,5016.71 v1(6789.52,4926.37) ; v1@6423.86,5017.54 ccw(c6423.86,5030.82) 6433.25,5021.43 ccw(c6442.64,5012.04) v1@6429.36,5012.04 ; v1@6423.86,5021.54 ccw(c6423.86,5044.48) 6440.07,5028.26 ccw(c6456.29,5012.04) v1@6433.36,5012.04 ; v1@6733.47,3303.99 ccw(c6717.26,3287.77) 6717.26,3310.71 ccw(c6717.26,3333.64) v1@6733.47,3317.43 ; v1@6736.3,3306.82 ccw(c6726.91,3297.43) 6726.91,3310.71 ccw(c6726.91,3323.99) v1@6736.3,3314.6 ; v1(6740.19,3310.71) 6714.67,3310.71 6705,3320.37 6581.69,3320.37 6535.06,3367 6462.15,3367 6436.85,3341.71 6279.13,3341.71 6270.96,3349.87 6235.32,3349.87 6215.19,3370 6215.19,3372 ; v1@6780.02,4926.37 ccw(c6757.09,4926.37) 6773.31,4942.59 ccw(c6789.52,4958.81) v1@6789.52,4935.87 ; v1@6784.02,4926.37 ccw(c6770.75,4926.37) 6780.14,4935.76 ccw(c6789.52,4945.15) v1@6789.52,4931.87 ; v1(6956.86,3566.71) 7006.86,3616.71 7226.22,3616.71 7267.73,3575.2 7279.32,3575.2 7319.53,3535 7359.86,3535 7375,3550.14 7375,3609.08 7359.54,3624.54 7290,3624.54 7265.52,3649.02 7265.52,3898.63 7268.02,3901.13 7268.02,3915.62 7257.77,3925.87 7243.28,3925.87 7234.11,3916.71 v1(7174.86,3916.71) ; v1@6956.86,3572.21 ccw(c6956.86,3585.49) 6966.25,3576.1 ccw(c6975.64,3566.71) v1@6962.36,3566.71 ; v1@6956.86,3576.21 ccw(c6956.86,3599.14) 6973.07,3582.93 ccw(c6989.29,3566.71) v1@6966.36,3566.71 ; v1@7178.75,3912.82 cw(c7188.14,3903.43) 7188.14,3916.71 cw(c7188.14,3929.99) v1@7178.75,3920.6 ; v1@7181.57,3909.99 cw(c7197.79,3893.77) 7197.79,3916.71 cw(c7197.79,3939.64) v1@7181.57,3923.43 ; v5@8007.48,4592.11 cw(c8007.48,4565.55) 8026.26,4584.33 cw(c8045.04,4603.11) v5@8018.48,4603.11 ; v5@8007.48,4596.11 cw(c8007.48,4579.21) 8019.43,4591.16 cw(c8031.38,4603.11) v5@8014.48,4603.11 ; v5(8007.48,4603.11) 8065.19,4545.4 v1(8065.19,4325.04) ; v1@8058.47,4331.76 ccw(c8042.26,4347.98) 8065.19,4347.98 ccw(c8088.13,4347.98) v1@8071.91,4331.76 ; v1@8061.3,4328.93 ccw(c8051.91,4338.32) 8065.19,4338.32 ccw(c8078.47,4338.32) v1@8069.08,4328.93
DB_MEM.BUS_A5: U7.B2 U8.C17 U12.26 U13.26 U16.4 U17.4 U61.89 | length 9117.8
  Top Layer w4: U8.C17@5488.42,4650.1 ccw(c5488.42,4667.82) 5500.96,4655.29 ; U8.C17@5495.77,4642.76 cw(c5513.49,4642.76) 5500.96,4655.29 ; 5606.86,5199.37 5581.19,5225.04 ; 5770.63,5191.37 5791,5191.37 ; U61.89@5823.08,2853.36 ccw(c5816.25,2860.19) 5825.91,2860.19 ccw(c5835.56,2860.19) U61.89@5828.73,2853.36 ; U61.89@5825.9,2837.34 5825.91,2861.71 5827.57,2863.37 5844.06,2863.37 5845.69,2865 5912.19,2931.5 5981.25,2931.5 5992.54,2920.21 6028.69,2920.21 6065.19,2956.71 6065.19,3073.71 6073.52,3082.04 6155.19,3082.04 6160.5,3087.35 6160.5,3255.5 6175,3270 6244.48,3270 v1(6265.19,3290.71) ; U13.26@6170.59,3387.05 6209.53,3387.05 6213.2,3383.37 v1(6247.52,3383.37) ; U17.4@6170.59,4876.22 6214.01,4876.22 6222.82,4867.41 v1@6222.95,4867.29 ; U17.4@6179.05,4876.22 cw(c6179.05,4823.64) v1@6216.23,4860.82 ; U17.4@6188.7,4876.22 cw(c6188.7,4833.29) v1@6219.06,4863.65 ; U13.26@6193.81,3381.39 cw(c6207.46,3367.73) 6207.46,3387.05 cw(c6207.46,3406.36) U13.26@6193.81,3392.7 ; U17.4@6193.81,4870.56 cw(c6207.46,4856.91) 6207.46,4876.22 cw(c6207.46,4895.53) U17.4@6193.81,4881.88 ; 6198.36,4876.22 cw(c6198.36,4842.95) v1@6221.89,4866.48 ; 6208.02,4876.22 cw(c6208.02,4852.61) v1@6224.71,4869.3 ; v1(6222.95,4867.54) v1@6222.95,4867.29 ; v1@6240.81,3376.66 ccw(c6224.59,3360.44) 6224.59,3383.37 ccw(c6224.59,3406.31) v1@6240.81,3390.09 ; v1@6243.64,3379.49 ccw(c6234.25,3370.1) 6234.25,3383.37 ccw(c6234.25,3396.65) v1@6243.64,3387.26 ; v1@6255.69,3290.71 cw(c6232.76,3290.71) 6248.97,3274.49 cw(c6265.19,3258.27) v1@6265.19,3281.21 ; v1@6259.69,3290.71 cw(c6246.41,3290.71) 6255.8,3281.32 cw(c6265.19,3271.93) v1@6265.19,3285.21 ; 6697.52,5191.71 6773.52,5115.71 6773.52,5090.37 6715.19,5032.04 6715.19,4967.89 6806.86,4876.22 U16.4@6845.59,4876.22 6876.35,4876.22 ; 6706.29,5182.94 6686.52,5202.71 6483.37,5202.71 6472.04,5191.37 5791,5191.37 ; U16.4@6822.37,4870.56 ccw(c6808.72,4856.91) 6808.72,4876.22 ccw(c6808.72,4895.53) U16.4@6822.37,4881.88 ; U12.26@6845.59,3387.05 6894.86,3387.05 v1(6906.86,3375.04) 6990.19,3458.37 6990.19,4033.37 7031.86,4075.04 7031.86,4166.71 7031.86,4198.33 7073.52,4240 7073.52,4425.04 7076.86,4428.37 7076.86,4775.04 7051.86,4800.04 6921.86,4800.04 v1(6906.86,4815.04) 6906.86,4845.71 6876.35,4876.22 ; U12.26@6868.81,3381.39 cw(c6882.46,3367.73) 6882.46,3387.05 cw(c6882.46,3406.36) U12.26@6868.81,3392.7 ; U16.4@6870.24,4872.52 cw(c6876.34,4869.34) 6876.34,4876.22 ; U16.4@6870.24,4879.92 ccw(c6876.34,4883.1) 6876.34,4876.22 ; v1@6900.14,4821.76 ccw(c6883.92,4837.98) 6906.86,4837.98 ccw(c6929.79,4837.98) v1@6913.57,4821.76 ; v1@6902.97,4818.93 ccw(c6893.58,4828.32) 6906.86,4828.32 ccw(c6920.14,4828.32) v1@6910.75,4818.93 ; v1@6906.86,3380.54 ccw(c6906.86,3393.82) 6916.25,3384.43 ccw(c6925.64,3375.04) v1@6912.36,3375.04 ; v1@6906.86,3384.54 ccw(c6906.86,3407.48) 6923.07,3391.26 ccw(c6939.29,3375.04) v1@6916.36,3375.04 ; 5500.96,4655.29 ccw(c5473.61,4682.64) 5512.29,4682.64 5512.29,4741.18 5512.29,4751.18 5512.29,4756.25 5501,4767.54 5501,4829.21 5540.19,4868.4 5540.19,5078 5566.52,5104.33 5566.52,5173.48 5556.86,5183.14 5556.86,5217.37 5564.52,5225.04 5581.19,5225.04 ; 5581.19,5225.04 5607.23,5199 5736.65,5199 5744.27,5191.37 5791,5191.37 ; v1@6222.95,4867.29 6223.52,4866.71 v1@6222.95,4867.29
  Top Layer w8: U7.B2@7948.43,4583.43 v5(7968.11,4603.11) ; v5@7959.11,4603.11 cw(c7937.38,4603.11) 7952.75,4587.75 cw(c7968.11,4572.38) v5@7968.11,4594.11
  MidLayer1 w4: v1(6222.95,4867.54) 6222.95,4867.29 6223.52,4866.71 6223.65,4866.83 6249.02,4892.2 6361.01,4892.2 6377.62,4908.81 6392.38,4908.81 ; v1@6222.95,4873.04 ccw(c6222.95,4889.71) 6234.74,4877.92 ; v1@6222.95,4877.04 ccw(c6222.95,4903.37) 6241.56,4884.75 ; v1@6232.45,4867.54 cw(c6251.99,4867.54) 6238.17,4881.35 ; v1@6240.81,3376.66 cw(c6224.59,3360.44) 6247.52,3360.44 cw(c6270.46,3360.44) v1@6254.24,3376.66 ; v1@6243.64,3379.49 cw(c6234.25,3370.1) 6247.52,3370.1 cw(c6260.8,3370.1) v1@6251.41,3379.49 ; v1(6247.52,3383.37) 6247.52,3308.37 v1(6265.19,3290.71) ; v1@6255.69,3290.71 ccw(c6232.76,3290.71) 6248.97,3306.93 ccw(c6265.19,3323.14) v1@6265.19,3300.21 ; v1@6259.69,3290.71 ccw(c6246.41,3290.71) 6255.8,3300.1 ccw(c6265.19,3309.49) v1@6265.19,3296.21 ; v1@6897.36,4815.04 ccw(c6874.42,4815.04) 6890.64,4831.26 ccw(c6906.86,4847.48) v1@6906.86,4824.54 ; v1@6901.36,4815.04 ccw(c6888.08,4815.04) 6897.47,4824.43 ccw(c6906.86,4833.82) v1@6906.86,4820.54 ; v1(6906.86,4815.04) 6839.4,4882.5 6695.75,4882.5 6673.99,4860.74 6651.91,4860.74 ; v1@7769.19,4828.21 cw(c7769.19,4805.27) 7785.41,4821.49 cw(c7801.63,4837.71) v1@7778.69,4837.71 ; v1@7769.19,4832.21 cw(c7769.19,4818.93) 7778.58,4828.32 cw(c7787.97,4837.71) v1@7774.69,4837.71 ; v1(7769.19,4837.71) 7948.52,4658.37 7948.52,4622.7 v5(7968.11,4603.11) ; v5@7957.11,4603.11 ccw(c7930.55,4603.11) 7949.33,4621.89 ccw(c7968.11,4640.67) v5@7968.11,4614.11 ; v5@7961.11,4603.11 ccw(c7944.21,4603.11) 7956.16,4615.06 ccw(c7968.11,4627.01) v5@7968.11,4610.11 ; 6392.38,4908.81 6406,4895.19 ; 6392.38,4908.81 6406,4895.19 ; 6406,4895.19 6617.46,4895.19 6620.45,4892.2 ; 6620.45,4892.2 6651.91,4860.74 ; 6620.45,4892.2 6651.91,4860.74
  MidLayer2 w4: v1(6906.86,4815.04) 6922.4,4799.5 7114.8,4799.5 7174.51,4859.21 7250.78,4859.21 7257.94,4866.37 7486.5,4866.37 7505.69,4847.19 7532.38,4847.19 7576.9,4891.71 7715.19,4891.71 v1(7769.19,4837.71) ; v1@7759.69,4837.71 ccw(c7736.76,4837.71) 7752.97,4853.93 ccw(c7769.19,4870.14) v1@7769.19,4847.21 ; v1@7763.69,4837.71 ccw(c7750.41,4837.71) 7759.8,4847.1 ccw(c7769.19,4856.49) v1@7769.19,4843.21
  Bottom Layer w4: v1(6247.52,3383.37) 6297.52,3433.37 6645,3433.37 ; v1@6247.52,3388.87 ccw(c6247.52,3402.15) 6256.91,3392.76 ccw(c6266.3,3383.37) v1@6253.02,3383.37 ; v1@6247.52,3392.87 ccw(c6247.52,3415.81) 6263.74,3399.59 ccw(c6279.96,3383.37) v1@6257.02,3383.37 ; v1@6900.14,3368.32 ccw(c6883.92,3352.11) 6883.92,3375.04 ccw(c6883.92,3397.98) v1@6900.14,3381.76 ; v1@6902.97,3371.15 ccw(c6893.58,3361.76) 6893.58,3375.04 ccw(c6893.58,3388.32) v1@6902.97,3378.93 ; v1(6906.86,3375.04) 6770,3375.04 ; 6645,3433.37 6654.77,3433.37 ; 6645,3433.37 6654.77,3433.37 ; 6654.77,3433.37 6657.52,3433.37 6658.35,3432.54 6665.85,3425.04 ; 6665.85,3425.04 6676.51,3425.04 ; 6665.85,3425.04 6676.51,3425.04 ; 6676.51,3425.04 6726.51,3375.04 6732.52,3375.04 ; 6732.52,3375.04 6770,3375.04 ; 6732.52,3375.04 6770,3375.04