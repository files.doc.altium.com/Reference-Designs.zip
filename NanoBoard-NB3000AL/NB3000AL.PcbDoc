# Altium PCB NB3000AL.PcbDoc (part 31 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_MEM.BUS_D3: U7.H4 U8.U28 U12.7 U16.10 U61.41 | length 6137.2
  Top Layer w4: U8.U28@5921.5,4091.57 5941.18,4091.57 5946.57,4091.57 ; U8.U28@5926.69,4086.38 cw(c5939.22,4073.85) 5939.22,4091.57 cw(c5939.22,4109.3) U8.U28@5926.69,4096.77 ; 5946.61,4091.54 5973.2,4091.54 5981.2,4083.54 6040.29,4083.54 6043.64,4080.19 6064.69,4080.19 6077.31,4092.81 6092.38,4092.81 6115,4070.19 v1(6115,4069.2) ; 6098.08,4087.11 cw(c6080.18,4069.2) v1@6105.5,4069.2 ; 6100.47,4084.72 ccw(c6115,4099.25) v1@6115,4078.7 ; 6104.91,4080.28 cw(c6093.84,4069.2) v1@6109.5,4069.2 ; 6107.3,4077.89 ccw(c6115,4085.59) v1@6115,4074.7 ; U61.41@6356.86,2333.37 6423.52,2333.37 v1(6470.52,2380.37) ; U61.41@6367.95,2328.52 cw(c6379.68,2316.79) 6379.68,2333.37 ; v1@6461.02,2380.37 cw(c6438.09,2380.37) 6454.31,2364.16 cw(c6470.52,2347.94) v1@6470.52,2370.87 ; v1@6465.02,2380.37 cw(c6451.75,2380.37) 6461.14,2370.99 cw(c6470.52,2361.6) v1@6470.52,2374.87 ; U12.7@6845.59,3985.47 6911.52,3985.47 ; U16.10@6845.59,4687.24 6946.66,4687.24 6950.52,4683.37 v1(6981.86,4683.37) ; U12.7@6868.81,3979.82 cw(c6882.46,3966.16) 6882.46,3985.47 cw(c6882.46,4004.79) U12.7@6868.81,3991.13 ; U16.10@6868.81,4681.59 cw(c6882.46,4667.93) 6882.46,4687.24 cw(c6882.46,4706.56) U16.10@6868.81,4692.9 ; 6913.9,3983.09 cw(c6897.52,3966.71) v1@6920.69,3966.71 ; 6914.14,3982.86 ccw(c6930.19,3998.91) v1@6930.19,3976.21 ; 6920.73,3976.26 cw(c6911.18,3966.71) v1@6924.69,3966.71 ; 6920.97,3976.03 ccw(c6930.19,3985.25) v1@6930.19,3972.21 ; v1@6930.19,3966.8 6911.52,3985.47 ; v1@6937.69,4352.37 cw(c6914.76,4352.37) 6930.97,4336.16 cw(c6947.19,4319.94) v1@6947.19,4342.87 ; v1@6941.69,4352.37 cw(c6928.41,4352.37) 6937.8,4342.99 cw(c6947.19,4333.6) v1@6947.19,4346.87 ; v1(6947.19,4352.37) 6920,4325.18 6920,4250 6928.9,4241.1 6928.9,4213.75 6915.19,4200.04 6915.19,4140.71 6948.52,4107.37 6948.52,4079.71 6931.86,4063.04 6931.86,4005.8 6911.52,3985.47 ; v1@6975.14,4676.66 ccw(c6958.92,4660.44) 6958.92,4683.37 ccw(c6958.92,4706.31) v1@6975.14,4690.09 ; v1@6977.97,4679.49 ccw(c6968.58,4670.1) 6968.58,4683.37 ccw(c6968.58,4696.65) v1@6977.97,4687.26
  Top Layer w8: v5@7692.52,4515.37 cw(c7692.52,4493.64) 7707.88,4509.01 cw(c7723.25,4524.37) v5@7701.52,4524.37 ; v5(7692.52,4524.37) U7.H4@7712.2,4504.69
  MidLayer1 w4: v1@6461.02,2380.37 ccw(c6438.09,2380.37) 6454.31,2396.59 ccw(c6470.52,2412.81) v1@6470.52,2389.87 ; v1@6465.02,2380.37 ccw(c6451.75,2380.37) 6461.14,2389.76 ccw(c6470.52,2399.15) v1@6470.52,2385.87 ; v1(6470.52,2380.37) 6443.86,2407.04 6425,2407.04 6381.86,2407.04 6356.86,2432.04 6356.86,2520 6356.86,2556.36 6384,2583.5 6442.56,2583.5 6450.35,2575.71 6474.19,2575.71 6573.52,2675.04 6573.52,2850.04 6640.19,2916.71 6640.19,3091.71 6690.19,3141.71 6690.19,3283.37 6631.7,3341.87 6631.7,3699.53 6775,3842.83 6775,3860 6795,3880 6843.48,3880 v1(6930.19,3966.71) ; v1@6920.69,3966.71 cw(c6897.76,3966.71) 6913.97,3950.49 cw(c6930.19,3934.27) v1@6930.19,3957.21 ; v1@6924.69,3966.71 cw(c6911.41,3966.71) 6920.8,3957.32 cw(c6930.19,3947.93) v1@6930.19,3961.21 ; v1@6981.86,4673.87 cw(c6981.86,4650.94) 6998.07,4667.16 cw(c7014.29,4683.37) v1@6991.36,4683.37 ; v1@6981.86,4677.87 cw(c6981.86,4664.6) 6991.25,4673.99 cw(c7000.64,4683.37) v1@6987.36,4683.37 ; v1(6981.86,4683.37) 7032.52,4632.71 v1(7032.52,4568.37) ; v1@7025.81,4575.09 ccw(c7009.59,4591.31) 7032.52,4591.31 ccw(c7055.46,4591.31) v1@7039.24,4575.09 ; v1@7028.64,4572.26 ccw(c7019.25,4581.65) 7032.52,4581.65 ccw(c7045.8,4581.65) v1@7036.41,4572.26
  MidLayer2 w4: v1(6115,4069.2) 6129.2,4055 6225.23,4055 6253.85,4026.37 6375.88,4026.37 6386.5,4037 6470.38,4037 6474.59,4041.21 6533.79,4041.21 6607,3968 6752,3968 6782,3938 6901.48,3938 v1(6930.19,3966.71) ; v1@6920.69,3966.71 cw(c6897.76,3966.71) 6913.97,3950.49 cw(c6930.19,3934.27) v1@6930.19,3957.21 ; v1@6924.69,3966.71 cw(c6911.41,3966.71) 6920.8,3957.32 cw(c6930.19,3947.93) v1@6930.19,3961.21 ; v1(7032.52,4568.37) 7032.65,4568.5 7199.73,4568.5 7199.86,4568.37 7215.19,4553.04 7215.19,4512.04 7231.86,4495.37 7253.19,4495.37 7335.52,4577.71 7524.61,4577.71 7577.94,4524.37 v5(7692.52,4524.37) ; v1@7036.41,4564.49 cw(c7046.1,4554.79) 7046.1,4568.5 ; v1@7036.41,4572.26 ccw(c7045.5,4581.35) 7045.5,4568.5 ; v1@7039.24,4561.66 cw(c7055.76,4545.14) 7055.76,4568.5 ; v1@7039.24,4575.09 ccw(c7055.16,4591.01) 7055.16,4568.5 ; v5@7684.74,4516.59 ccw(c7665.96,4497.82) 7665.96,4524.37 ccw(c7665.96,4550.93) v5@7684.74,4532.15 ; v5@7687.57,4519.42 ccw(c7675.62,4507.47) 7675.62,4524.37 ccw(c7675.62,4541.27) v5@7687.57,4529.32
  Bottom Layer w4: v1(6947.19,4352.37) 7020.37,4352.37 7068.36,4400.36 7068.36,4532.54 v1(7032.52,4568.37) ; v1@6951.08,4348.49 cw(c6960.47,4339.1) 6960.47,4352.37 cw(c6960.47,4365.65) v1@6951.08,4356.26 ; v1@6953.91,4345.66 cw(c6970.13,4329.44) 6970.13,4352.37 cw(c6970.13,4375.31) v1@6953.91,4359.09 ; v1@7032.52,4558.87 cw(c7032.52,4535.94) 7048.74,4552.16 cw(c7064.96,4568.37) v1@7042.02,4568.37 ; v1@7032.52,4562.87 cw(c7032.52,4549.6) 7041.91,4558.99 cw(c7051.3,4568.37) v1@7038.02,4568.37
DB_MEM.BUS_D4: U7.H5 U8.U25 U12.8 U16.13 U61.42 | length 5868.2
  Top Layer w4: U8.U25@5803.39,4084.23 cw(c5803.39,4066.51) 5815.92,4079.04 cw(c5828.45,4091.57) U8.U25@5810.73,4091.57 ; U8.U25@5803.39,4091.57 v3(5823.07,4071.89) ; v1@6183.47,2609.99 cw(c6167.26,2593.77) 6190.19,2593.77 cw(c6213.13,2593.77) v1@6196.91,2609.99 ; v1@6186.3,2612.82 cw(c6176.91,2603.43) 6190.19,2603.43 cw(c6203.47,2603.43) v1@6194.08,2612.82 ; v1(6190.19,2616.71) 6190.19,2583.37 6148.52,2541.71 6148.52,2408.37 6205.87,2351.03 U61.42@6351.49,2351.03 ; U61.42@6335.91,2348.2 ccw(c6329.08,2341.37) 6329.08,2351.03 ccw(c6329.08,2360.69) U61.42@6335.91,2353.86 ; U12.8@6845.59,3953.98 6856.86,3953.98 6856.86,3958.37 v1@6891.52,3958.37 ; U16.13@6845.59,4592.76 6957.48,4592.76 v1(6981.86,4568.37) ; U12.8@6863.15,3953.98 cw(c6873.22,3944.66) 6873.22,3958.37 ; U12.8@6864.82,3958.37 cw(c6864.82,3926.33) v1@6887.47,3948.99 ; U16.13@6868.81,4587.1 cw(c6882.46,4573.44) 6882.46,4592.76 cw(c6882.46,4612.07) U16.13@6868.81,4598.41 ; 6874.47,3958.37 cw(c6874.47,3935.99) v1@6890.3,3951.82 ; 6877.69,3958.37 ccw(c6877.69,3972.2) v1@6887.47,3962.43 ; v1@6972.36,4568.37 ccw(c6949.42,4568.37) 6965.64,4584.59 ccw(c6981.86,4600.81) v1@6981.86,4577.87 ; v1@6976.36,4568.37 ccw(c6963.08,4568.37) 6972.47,4577.76 ccw(c6981.86,4587.15) v1@6981.86,4573.87 ; 5810.27,4084.69 cw(c5797.46,4071.89) 5815.57,4071.89 ccw(c5797.46,4071.89) 5810.27,4084.69 ; 5810.27,4084.69 ccw(c5823.07,4097.5) 5823.07,4079.39 cw(c5823.07,4097.5) 5810.27,4084.69
  Top Layer w8: v5(7692.52,4445.63) U7.H5@7712.2,4465.32 ; v5@7692.52,4454.63 ccw(c7692.52,4476.36) 7707.88,4460.99 ccw(c7723.25,4445.63) v5@7701.52,4445.63
  MidLayer1 w4: v3(5823.07,4071.89) 5900.75,4071.89 5941.18,4071.89 5951.18,4071.89 5981.86,4071.89 5990.19,4063.56 5990.19,4060.06 6001.75,4048.5 6016.25,4048.5 6019.55,4051.8 6047.12,4051.8 6071.22,4027.7 6105,4027.7 6126.78,4027.7 6142.88,4027.7 6256.94,3913.64 6256.94,3888.06 6270.63,3874.37 v1(6270.63,3859.04) 6270.63,3822.56 6283.53,3809.66 6283.53,3772.38 6306.19,3749.73 6306.19,3665 6306.19,3656 6306.19,3650.4 6308.02,3648.56 6308.02,3612.17 6220.55,3524.69 6220.55,3490 6220.55,3470.68 6299.52,3391.71 6299.52,3362.04 6287.19,3349.71 6284,3346.52 6284,3080.16 6273.52,3069.69 6273.52,3034.37 6285.86,3022.04 6285.86,2955.02 6245.69,2914.85 6245.69,2738.87 6244.86,2738.04 6190.19,2683.37 v1(6190.19,2616.71) ; v3@5828.26,4066.7 cw(c5840.8,4054.16) 5840.8,4071.89 cw(c5840.8,4089.62) v3@5828.26,4077.08 ; v3@5828.37,4066.59 cw(c5841.18,4053.78) 5841.18,4071.89 cw(c5841.18,4090) v3@5828.37,4077.19 ; v1@6183.47,2623.43 ccw(c6167.26,2639.64) 6190.19,2639.64 ccw(c6213.13,2639.64) v1@6196.91,2623.43 ; v1@6186.3,2620.6 ccw(c6176.91,2629.99) 6190.19,2629.99 ccw(c6203.47,2629.99) v1@6194.08,2620.6 ; v1@6263.91,3852.32 cw(c6247.7,3836.11) 6270.63,3836.11 cw(c6293.57,3836.11) v1@6277.35,3852.32 ; v1@6266.74,3855.15 cw(c6257.35,3845.76) 6270.63,3845.76 cw(c6283.91,3845.76) v1@6274.52,3855.15 ; v1(6894.19,3955.71) 6940.19,4001.71 6940.19,4052.35 6958.86,4071.02 6958.86,4224.37 6941.91,4241.32 6941.91,4275 6941.91,4300 6941.91,4311.03 6972.69,4341.81 6972.69,4379.16 6998.52,4405 v1(6998.52,4433.37) ; v1@6894.19,3961.21 ccw(c6894.19,3974.49) 6903.58,3965.1 ccw(c6912.97,3955.71) v1@6899.69,3955.71 ; v1@6894.19,3965.21 ccw(c6894.19,3988.14) 6910.41,3971.93 ccw(c6926.63,3955.71) v1@6903.69,3955.71 ; v1@6991.81,4426.66 cw(c6975.59,4410.44) 6998.52,4410.44 cw(c7021.46,4410.44) v1@7005.24,4426.66 ; v1@6994.64,4429.49 cw(c6985.25,4420.1) 6998.52,4420.1 cw(c7011.8,4420.1) v1@7002.41,4429.49
  MidLayer2 w4: v1(6998.52,4433.37) 7261.47,4433.37 7287.8,4459.71 7585.29,4459.71 7594.96,4450.04 v1(7620.86,4450.04) ; v1@7002.41,4429.49 cw(c7011.8,4420.1) 7011.8,4433.37 cw(c7011.8,4446.65) v1@7002.41,4437.26 ; v1@7005.24,4426.66 cw(c7021.46,4410.44) 7021.46,4433.37 cw(c7021.46,4456.31) v1@7005.24,4440.09 ; v1@7614.14,4443.32 ccw(c7597.92,4427.11) 7597.92,4450.04 ccw(c7597.92,4472.98) v1@7614.14,4456.76 ; v1@7616.97,4446.15 ccw(c7607.58,4436.76) 7607.58,4450.04 ccw(c7607.58,4463.32) v1@7616.97,4453.93
  Bottom Layer w4: v1(6270.63,3859.04) 6305.78,3894.19 6354.99,3894.19 6419.5,3958.71 6567.84,3958.71 6609.84,3916.71 6855.19,3916.71 v1(6894.19,3955.71) ; v1@6270.63,3864.54 ccw(c6270.63,3877.82) 6280.02,3868.43 ccw(c6289.41,3859.04) v1@6276.13,3859.04 ; v1@6270.63,3868.54 ccw(c6270.63,3891.48) 6286.85,3875.26 ; v1@6280.13,3859.04 cw(c6303.07,3859.04) 6286.85,3875.26 ; v1@6884.69,3955.71 cw(c6861.76,3955.71) 6877.97,3939.49 cw(c6894.19,3923.27) v1@6894.19,3946.21 ; v1@6888.69,3955.71 cw(c6875.41,3955.71) 6884.8,3946.32 cw(c6894.19,3936.93) v1@6894.19,3950.21 ; v1@6981.86,4558.87 cw(c6981.86,4535.94) 6998.07,4552.16 cw(c7014.29,4568.37) v1@6991.36,4568.37 ; v1@6981.86,4562.87 cw(c6981.86,4549.6) 6991.25,4558.99 cw(c7000.64,4568.37) v1@6987.36,4568.37 ; v1(6981.86,4568.37) 7024.36,4525.87 7024.36,4484.21 6998.52,4458.37 v1(6998.52,4433.37) ; v1@6991.81,4440.09 ccw(c6975.59,4456.31) 6998.52,4456.31 ccw(c7021.46,4456.31) v1@7005.24,4440.09 ; v1@6994.64,4437.26 ccw(c6985.25,4446.65) 6998.52,4446.65 ccw(c7011.8,4446.65) v1@7002.41,4437.26 ; v1(7620.86,4450.04) 7628.19,4450.04 7632.6,4445.63 v5(7692.52,4445.63) ; v1@7621.92,4451.1 ccw(c7635.13,4464.31) 7635.13,4445.63 ; v1@7624.75,4453.93 ccw(c7644.78,4473.97) 7644.78,4445.63 ; v1@7627.57,4443.32 cw(c7633.14,4437.75) 7633.14,4445.63 ; v1@7627.57,4456.76 ccw(c7654.44,4483.62) 7654.44,4445.63 ; v5@7684.74,4437.85 ccw(c7665.96,4419.07) 7665.96,4445.63 ccw(c7665.96,4472.19) v5@7684.74,4453.41 ; v5@7687.57,4440.68 ccw(c7675.62,4428.73) 7675.62,4445.63 ccw(c7675.62,4462.53) v5@7687.57,4450.58
DB_MEM.BUS_D5: U7.E5 U8.V25 U12.10 U16.14 U61.43 | length 6680.9
  Top Layer w4: U8.V25@5803.39,4044.86 cw(c5803.39,4027.14) 5815.92,4039.67 cw(c5828.45,4052.2) U8.V25@5810.73,4052.2 ; U8.V25@5803.39,4052.2 v3(5823.07,4032.52) ; U61.43@6351.93,2370.72 6411.18,2370.72 6415.19,2366.71 6442.86,2366.71 6452.19,2376.04 6452.19,2470 6465.69,2483.5 6465.69,2617.21 v1(6465.19,2617.71) ; U61.43@6367.95,2367.89 cw(c6374.78,2361.06) 6374.78,2370.72 cw(c6374.78,2380.37) U61.43@6367.95,2373.54 ; v1@6458.47,2610.99 cw(c6441.06,2593.58) 6465.69,2593.58 ; v1@6461.3,2613.82 cw(c6450.72,2603.23) 6465.69,2603.23 ; 6465.69,2595.97 cw(c6486.93,2595.97) v1@6471.91,2610.99 ; 6465.69,2605.63 cw(c6477.27,2605.63) v1@6469.08,2613.82 ; v1@6781.86,3957.21 cw(c6781.86,3934.27) 6798.07,3950.49 cw(c6814.29,3966.71) v1@6791.36,3966.71 ; v1@6781.86,3961.21 cw(c6781.86,3947.93) 6791.25,3957.32 cw(c6800.64,3966.71) v1@6787.36,3966.71 ; v1(6781.86,3966.71) 6806.86,3941.71 6806.86,3898.98 6814.86,3890.98 ; U12.10@6820.93,3887.29 ccw(c6814.86,3884.14) 6814.86,3890.98 ; U12.10@6820.93,3894.67 cw(c6814.86,3897.83) 6814.86,3890.98 ; U12.10@6845.59,3890.98 6814.86,3890.98 ; U16.14@6845.59,4561.26 6863.15,4561.26 6875.7,4548.71 ; U16.14@6863.64,4553.27 cw(c6864.6,4537.61) 6875.7,4548.71 ; U16.14@6871.13,4560.77 ccw(c6886.78,4559.8) 6875.7,4548.71 ; v1@6963.47,3948.43 ccw(c6947.26,3964.64) 6970.19,3964.64 ccw(c6993.13,3964.64) v1@6976.91,3948.43 ; v1@6966.3,3945.6 ccw(c6956.91,3954.99) 6970.19,3954.99 ccw(c6983.47,3954.99) v1@6974.08,3945.6 ; v1(6970.19,3941.71) 6970.19,4011.71 6948.52,4033.37 6948.52,4051.37 7023.52,4126.37 7023.52,4257.04 7056.86,4290.37 7056.86,4421.37 7032.19,4446.04 7032.19,4475.37 7040.19,4483.37 7040.19,4533.37 7024.86,4548.71 6875.7,4548.71 ; 5810.27,4045.32 cw(c5797.46,4032.52) 5815.57,4032.52 ccw(c5797.46,4032.52) 5810.27,4045.32 ; 5810.27,4045.32 ccw(c5823.07,4058.13) 5823.07,4040.02 cw(c5823.07,4058.13) 5810.27,4045.32
  Top Layer w8: v5(7810.63,4445.63) U7.E5@7830.32,4465.32 ; v5@7810.63,4454.63 ccw(c7810.63,4476.36) 7825.99,4460.99 ccw(c7841.36,4445.63) v5@7819.63,4445.63
  MidLayer1 w4: v3(5823.07,4032.52) 5900.75,4032.52 5941.18,4032.52 5951.18,4032.52 6007.03,4032.52 6022.75,4016.8 6080.74,4016.8 6083.64,4019.7 6100,4019.7 6123.46,4019.7 6139.57,4019.7 6215.19,3944.08 v1(6215.19,3899.38) ; v3@5828.26,4027.33 cw(c5840.8,4014.79) 5840.8,4032.52 cw(c5840.8,4050.25) v3@5828.26,4037.71 ; v3@5828.37,4027.22 cw(c5841.18,4014.41) 5841.18,4032.52 cw(c5841.18,4050.63) v3@5828.37,4037.82 ; v1@6208.47,3906.09 ccw(c6192.26,3922.31) 6215.19,3922.31 ccw(c6238.12,3922.31) v1@6221.91,3906.09 ; v1@6211.3,3903.26 ccw(c6201.91,3912.65) 6215.19,3912.65 ccw(c6228.47,3912.65) v1@6219.08,3903.26 ; v1(6465.19,2617.71) 6487.19,2639.71 6487.19,2662.38 6506.86,2682.05 6506.86,2819.69 6515.19,2828.02 6515.19,3130 ; v1@6465.19,2623.21 ccw(c6465.19,2636.49) 6474.58,2627.1 ccw(c6483.97,2617.71) v1@6470.69,2617.71 ; v1@6465.19,2627.21 ccw(c6465.19,2650.14) 6481.41,2633.93 ccw(c6497.63,2617.71) v1@6474.69,2617.71 ; v1@6772.36,3966.71 ccw(c6749.42,3966.71) 6765.64,3982.93 ccw(c6781.86,3999.14) v1@6781.86,3976.21 ; v1@6776.36,3966.71 ccw(c6763.08,3966.71) 6772.47,3976.1 ccw(c6781.86,3985.49) v1@6781.86,3972.21 ; v1(6781.86,3966.71) 6697.19,4051.37 6664.19,4051.37 6606.86,3994.04 6599.7,3986.88 6599.7,3298.59 6581.69,3280.58 6581.69,3250 6581.69,3222.21 6581.69,3219.52 6515.19,3153.02 6515.19,3147.06 ; v1@7675.14,4171.76 ccw(c7658.92,4187.98) 7681.86,4187.98 ccw(c7704.79,4187.98) v1@7688.57,4171.76 ; v1@7677.97,4168.93 ccw(c7668.58,4178.32) 7681.86,4178.32 ccw(c7695.14,4178.32) v1@7685.75,4168.93 ; v1(7681.86,4165.04) 7681.86,4233.14 7668,4247 7668,4466.54 7683.28,4481.82 7803.18,4481.82 7810.63,4474.37 v5(7810.63,4445.63) ; v5@7802.85,4453.41 ccw(c7784.07,4472.19) 7810.63,4472.19 ccw(c7837.19,4472.19) v5@7818.41,4453.41 ; v5@7805.68,4450.58 ccw(c7793.73,4462.53) 7810.63,4462.53 ccw(c7827.53,4462.53) v5@7815.58,4450.58 ; 6515.19,3130 6515.19,3147.06 ; 6515.19,3130 6515.19,3147.06
  Bottom Layer w4: v1(6215.19,3899.38) 6215.86,3899.38 6230.69,3914.21 6292.6,3914.21 6304.62,3902.19 6351.67,3902.19 6416.19,3966.71 v1(6781.86,3966.71) 6865.19,3966.71 6897.49,3999.01 6929.56,3999.01 6950,3999.01 6961.37,3999.01 ; v1@6775.14,3959.99 ccw(c6758.92,3943.77) 6758.92,3966.71 ccw(c6758.92,3989.64) v1@6775.14,3973.43 ; v1@6777.97,3962.82 ccw(c6768.58,3953.43) 6768.58,3966.71 ccw(c6768.58,3979.99) v1@6777.97,3970.6 ; v1@6785.75,3962.82 cw(c6795.14,3953.43) 6795.14,3966.71 cw(c6795.14,3979.99) v1@6785.75,3970.6 ; v1@6788.57,3959.99 cw(c6804.79,3943.77) 6804.79,3966.71 cw(c6804.79,3989.64) v1@6788.57,3973.43 ; v1@6963.47,3948.43 ccw(c6947.26,3964.64) 6970.19,3964.64 ccw(c6993.13,3964.64) v1@6976.91,3948.43 ; v1@6966.3,3945.6 ccw(c6956.91,3954.99) 6970.19,3954.99 ccw(c6983.47,3954.99) v1@6974.08,3945.6 ; v1(6970.19,3941.71) 6970.19,3990.19 6961.37,3999.01 ; 7010.21,4081.52 7023.89,4095.21 ; v1@7672.36,4165.04 cw(c7649.42,4165.04) 7665.64,4148.82 cw(c7681.86,4132.61) v1@7681.86,4155.54 ; v1@7676.36,4165.04 cw(c7663.08,4165.04) 7672.47,4155.65 cw(c7681.86,4146.26) v1@7681.86,4159.54 ; v1(7681.86,4165.04) 7638.82,4122 7390.21,4122 7390.09,4121.87 7368.96,4121.87 7368.84,4122 7279.55,4122 7257.09,4099.54 7235.96,4099.54 7235.31,4099.54 7201.65,4065.87 7165,4065.87 7144.28,4065.87 7114.94,4095.21 7023.89,4095.21 ; 6961.37,3999.01 6995,4032.64 6998.36,4035.99 6998.36,4069.67 7023.89,4095.21
DB_MEM.BUS_D6: U7.H6 U8.Y26 U12.11 U16.15 U61.45 | length 6626.7
  Top Layer w4: U8.Y26@5842.76,3966.12 cw(c5842.76,3948.4) 5855.29,3960.93 ; U8.Y26@5850.1,3973.46 ccw(c5867.82,3973.46) 5855.29,3960.93 ; 6081.12,3899.32 ccw(c6100,3918.2) v1@6100,3891.5 ; 6084.89,3895.55 cw(c6071.33,3882) v1@6090.5,3882 ; 6087.95,3892.49 ccw(c6100,3904.55) v1@6100,3887.5 ; v1@6098.44,3882 6071.3,3909.14 6068.7,3911.74 ; v1(6298.52,2391.71) 6316.9,2410.09 U61.45@6351.93,2410.09 ; v1@6298.52,2397.21 ccw(c6298.52,2410.49) 6307.91,2401.1 ccw(c6317.3,2391.71) v1@6304.02,2391.71 ; v1@6298.52,2401.21 ccw(c6298.52,2424.14) 6314.74,2407.93 ccw(c6330.96,2391.71) v1@6308.02,2391.71 ; U61.45@6335.91,2407.26 ccw(c6329.08,2400.43) 6329.08,2410.09 ccw(c6329.08,2419.74) U61.45@6335.91,2412.91 ; U12.11@6845.59,3859.49 6900,3859.49 6905.22,3864.71 v1(6954.52,3864.71) v1@6948.19,3858.37 ; U16.15@6845.59,4529.76 6878.5,4529.76 6888.77,4540.04 7022.21,4540.04 7032.19,4530.06 7032.19,4486.69 7024.19,4478.69 7024.19,4425.71 v1(7037.86,4412.04) ; U12.11@6868.81,3853.83 cw(c6882.46,3840.18) 6882.46,3859.49 cw(c6882.46,3878.8) U12.11@6868.81,3865.15 ; v1@6947.81,3857.99 ccw(c6931.59,3841.77) 6931.59,3864.71 ccw(c6931.59,3887.64) v1@6947.81,3871.43 ; v1@6950.64,3860.82 ccw(c6941.25,3851.43) 6941.25,3864.71 ccw(c6941.25,3877.99) v1@6950.64,3868.6 ; 5855.29,3960.93 ccw(c5882.64,3988.28) 5882.64,3949.6 5941.18,3949.6 5949.18,3949.6 5994.21,3949.6 6018.62,3925.19 6033.38,3925.19 6038.09,3929.91 6041.9,3933.71 6056.9,3933.71 6058.52,3932.09 6058.61,3932.09 6068.7,3922 ; 6068.7,3911.74 6068.7,3922 ; 6068.7,3911.74 6068.7,3922
  Top Layer w8: v5(7692.52,4406.26) U7.H6@7712.2,4425.94 ; v5@7692.52,4415.26 ccw(c7692.52,4436.99) 7707.88,4421.62 ccw(c7723.25,4406.26) v5@7701.52,4406.26
  MidLayer1 w4: v1@6298.52,2382.21 cw(c6298.52,2359.27) 6314.74,2375.49 cw(c6330.96,2391.71) v1@6308.02,2391.71 ; v1@6298.52,2386.21 cw(c6298.52,2372.93) 6307.91,2382.32 cw(c6317.3,2391.71) v1@6304.02,2391.71 ; v1(6298.52,2391.71) 6340.19,2350.04 6497.19,2350.04 6537.81,2390.66 6537.81,2414.69 6537.19,2415.31 6537.19,2472.04 6733.86,2668.71 6733.86,2765.98 7131.86,3163.98 7131.86,3488.04 v1(7223.52,3579.71) ; v1@6954.52,3870.21 ccw(c6954.52,3883.49) 6963.91,3874.1 ccw(c6973.3,3864.71) v1@6960.02,3864.71 ; v1@6954.52,3871.71 v1@6954.52,3867.35 ; v1@6954.52,3874.21 ccw(c6954.52,3897.14) 6970.74,3880.93 ccw(c6986.96,3864.71) v1@6964.02,3864.71 ; v1@7033.69,4407.87 7029.52,4412.04 v1(7037.86,4412.04) 7073.52,4376.37 7073.52,4368.04 ; v1@7037.86,4402.54 cw(c7037.86,4379.61) 7054.07,4395.82 cw(c7070.29,4412.04) v1@7047.36,4412.04 ; v1@7037.86,4406.54 cw(c7037.86,4393.26) 7047.25,4402.65 cw(c7056.64,4412.04) v1@7043.36,4412.04 ; v1@7042.81,4151.32 cw(c7026.59,4135.11) 7049.52,4135.11 cw(c7072.46,4135.11) v1@7056.24,4151.32 ; v1@7042.81,4164.76 ccw(c7026.59,4180.98) 7049.52,4180.98 ccw(c7072.46,4180.98) v1@7056.24,4164.76 ; v1@7045.64,4154.15 cw(c7036.25,4144.76) 7049.52,4144.76 cw(c7062.8,4144.76) v1@7053.41,4154.15 ; v1@7045.64,4161.93 ccw(c7036.25,4171.32) 7049.52,4171.32 ccw(c7062.8,4171.32) v1@7053.41,4161.93 ; v1@7214.02,3579.71 cw(c7191.09,3579.71) 7207.31,3563.49 cw(c7223.52,3547.27) v1@7223.52,3570.21 ; v1@7218.02,3579.71 cw(c7204.75,3579.71) 7214.14,3570.32 cw(c7223.52,3560.93) v1@7223.52,3574.21 ; v1(6954.52,3864.71) v1@6954.52,3867.35 ; v1(6954.52,3864.71) v1@6954.52,3867.35 ; v1(6954.52,3864.71) 7044.34,3954.52 7049.52,3959.71 ; 7049.52,3959.71 7049.52,3980 ; 7049.52,3959.71 7049.52,3962.35 7049.52,3966.71 ; 7049.52,3966.71 7049.52,3980 ; 7049.52,3966.71 7049.52,3980 ; 7049.52,3980 7049.52,4005 ; 7049.52,3980 7049.52,4005 ; 7049.52,4005 v1(7049.52,4158.04) 7049.52,4206 7073.52,4230 7073.52,4365 ; 7073.52,4365 7073.52,4368.04 ; 7073.52,4365 7073.52,4368.04
  MidLayer2 w4: v1(6954.52,3864.71) 7077.9,3864.71 7132.6,3810 7250,3810 7256.86,3803.14 7256.86,3741.71 ; v1@6958.41,3860.82 cw(c6967.8,3851.43) 6967.8,3864.71 cw(c6967.8,3877.99) v1@6958.41,3868.6 ; v1@6961.24,3857.99 cw(c6977.46,3841.77) 6977.46,3864.71 cw(c6977.46,3887.64) v1@6961.24,3871.43 ; v1(7049.52,4158.04) 7078.04,4158.04 7086.71,4166.71 7200.9,4166.71 7306.86,4166.71 7431.86,4291.71 7526.71,4291.71 7641.26,4406.26 7656.08,4406.26 v5(7692.52,4406.26) ; v1@7053.41,4154.15 cw(c7062.8,4144.76) 7062.8,4158.04 cw(c7062.8,4171.32) v1@7053.41,4161.93 ; v1@7056.24,4151.32 cw(c7072.46,4135.11) 7072.46,4158.04 cw(c7072.46,4180.98) v1@7056.24,4164.76 ; v1(7223.52,3579.71) 7256.86,3613.04 7256.86,3730 ; v1@7223.52,3585.21 ccw(c7223.52,3598.49) 7232.91,3589.1 ccw(c7242.3,3579.71) v1@7229.02,3579.71 ; v1@7223.52,3589.21 ccw(c7223.52,3612.14) 7239.74,3595.93 ccw(c7255.96,3579.71) v1@7233.02,3579.71 ; v5@7684.74,4398.48 ccw(c7665.96,4379.7) 7665.96,4406.26 ccw(c7665.96,4432.82) v5@7684.74,4414.04 ; v5@7687.57,4401.31 ccw(c7675.62,4389.36) 7675.62,4406.26 ccw(c7675.62,4423.16) v5@7687.57,4411.21 ; 7256.86,3730 7256.86,3741.71 ; 7256.86,3730 7256.86,3741.71
  Bottom Layer w4: v1@6100,3872.5 cw(c6100,3852.29) 6114.29,3866.58 ; v1@6100,3880.87 6156.86,3824.01 ; v1@6105.5,3882 ccw(c6121.51,3882) 6110.19,3870.68 ; v1@6109.5,3882 ccw(c6135.16,3882) 6117.02,3863.85 ; 6558.19,3816.71 6543.91,3802.43 ; v1@6947.81,3857.99 ccw(c6931.59,3841.77) 6931.59,3864.71 ccw(c6931.59,3887.64) v1@6947.81,3871.43 ; v1@6950.64,3860.82 ccw(c6941.25,3851.43) 6941.25,3864.71 ccw(c6941.25,3877.99) v1@6950.64,3868.6 ; v1(6954.52,3864.71) 6930,3864.71 ; 6156.86,3800.04 6156.86,3824.01 ; 6156.86,3800.04 6156.86,3824.01 ; 6156.86,3800.04 6190.19,3766.71 6262.21,3766.71 6300.5,3805 6303.88,3808.37 6398.52,3808.37 6448.52,3758.37 6499.86,3758.37 6543.91,3802.43 ; 6543.91,3802.43 6559.52,3818.04 6835.67,3818.04 6882.34,3864.71 6896.52,3864.71 ; 6896.52,3864.71 6930,3864.71 ; 6896.52,3864.71 6930,3864.71
  other v1: 6100,3882
DB_MEM.BUS_D7: U7.E6 U8.G26 U12.13 U16.16 U61.46 | length 7116.4
  Top Layer w4: v1@6069.14,4893.32 cw(c6052.92,4877.11) 6075.86,4877.11 cw(c6098.79,4877.11) v1@6082.57,4893.32 ; v1@6071.97,4896.15 cw(c6062.58,4886.76) 6075.86,4886.76 cw(c6089.14,4886.76) v1@6079.75,4896.15 ; v1@6073.52,4897.71 v1(6075.86,4900.04) 6075.86,4866.17 6074.69,4865 6074.69,4835.79 6060,4821.1 6060,4754.96 6081.52,4733.44 6081.52,4658.71 6136.69,4603.54 6136.69,4535.48 6107.02,4505.81 6084.9,4505.81 6051.59,4472.5 6015,4472.5 6009.87,4472.5 6004.47,4477.91 5973.23,4509.14 5949.18,4509.14 5941.18,4509.14 5882.64,4509.14 ; U61.46@6351.93,2429.77 6378.52,2429.77 6383.25,2425.04 v1(6390.19,2425.04) ; U61.46@6355.84,2429.77 cw(c6355.84,2390.69) v1@6383.47,2418.32 ; U61.46@6365.49,2429.77 cw(c6365.49,2400.34) v1@6386.3,2421.15 ; U61.46@6367.95,2426.94 cw(c6374.78,2420.11) 6374.78,2429.77 cw(c6374.78,2439.43) U61.46@6367.95,2432.6 ; 6375.15,2429.77 cw(c6375.15,2410) v1@6389.13,2423.98 ; 6378.67,2429.77 ccw(c6378.67,2436.56) v1@6383.47,2431.76 ; U12.13@6845.59,3796.5 6919.74,3796.5 v1(6931.86,3784.37) 6973.52,3826.04 6973.52,3908.37 6948.52,3933.37 6948.52,4008.37 6940.19,4016.71 6940.19,4055.04 7005,4119.85 7005,4180 6985,4200 6985,4235 7048.86,4298.86 7048.86,4366.37 7031.86,4383.37 7016.19,4399.04 7016.19,4460 7006.86,4469.33 ; U16.16@6845.59,4498.27 6970,4498.27 6976.56,4491.71 v1(7006.86,4491.71) 7006.86,4469.33 ; U12.13@6868.81,3790.84 cw(c6882.46,3777.18) 6882.46,3796.5 cw(c6882.46,3815.81) U12.13@6868.81,3802.15 ; U16.16@6868.81,4492.61 cw(c6882.46,4478.95) 6882.46,4498.27 cw(c6882.46,4517.58) U16.16@6868.81,4503.92 ; v1@6931.86,3789.87 ccw(c6931.86,3803.15) 6941.25,3793.76 ccw(c6950.64,3784.37) v1@6937.36,3784.37 ; v1@6931.86,3793.87 ccw(c6931.86,3816.81) 6948.07,3800.59 ccw(c6964.29,3784.37) v1@6941.36,3784.37 ; v1@7000.14,4484.99 ccw(c6983.92,4468.77) 6983.92,4491.71 ccw(c6983.92,4514.64) v1@7000.14,4498.43 ; v1@7000.26,4484.87 cw(c6985.26,4469.33) 7006.86,4469.33 ; v1@7002.97,4487.82 ccw(c6993.58,4478.43) 6993.58,4491.71 ccw(c6993.58,4504.99) v1@7002.97,4495.6 ; v1@7003.04,4487.75 cw(c6994.35,4478.75) 7006.86,4478.75 cw(c7019.36,4478.75) v1@7010.68,4487.75 ; v1@7013.45,4484.87 ccw(c7028.45,4469.33) 7006.86,4469.33 ; 5855.29,4497.81 cw(c5882.64,4470.46) 5882.64,4509.14 ; 5855.29,4497.81 cw(c5882.64,4470.46) 5882.64,4509.14 ; 5855.29,4497.81 cw(c5842.76,4510.34) 5842.76,4492.62 ccw(c5842.76,4510.34) 5855.29,4497.81 ; 5855.29,4497.81 ccw(c5867.82,4485.28) 5850.1,4485.28 cw(c5867.82,4485.28) 5855.29,4497.81
  Top Layer w8: v5(7810.63,4406.26) U7.E6@7830.32,4425.94 ; v5@7810.63,4415.26 ccw(c7810.63,4436.99) 7825.99,4421.62 ccw(c7841.36,4406.26) v5@7819.63,4406.26
  MidLayer1 w4: v1(6075.86,4900.04) 6076.35,4899.55 6134.34,4899.55 6135,4900.2 6357.7,4900.2 6374.31,4916.81 6395.69,4916.81 6409.31,4903.19 6620.77,4903.19 6655.22,4868.74 6669.72,4868.74 6749.18,4948.21 6870.11,4948.21 6945,4873.31 v1(6945,4825) v1@6940.19,4829.81 ; v1@6079.75,4896.15 cw(c6087.94,4887.96) 6087.94,4899.55 ; v1@6079.75,4903.93 ccw(c6090.33,4914.51) 6090.33,4899.55 ; v1@6082.57,4893.32 cw(c6097.6,4878.3) 6097.6,4899.55 ; v1@6082.57,4906.76 ccw(c6099.99,4924.17) 6099.99,4899.55 ; 6379.52,2567.71 6365.19,2553.37 ; v1@6380.69,2425.04 ccw(c6357.76,2425.04) 6373.97,2441.26 ccw(c6390.19,2457.48) v1@6390.19,2434.54 ; v1@6384.69,2425.04 ccw(c6371.41,2425.04) 6380.8,2434.43 ccw(c6390.19,2443.82) v1@6390.19,2430.54 ; v1(6390.19,2425.04) 6365.19,2450.04 6365.19,2553.37 ; v1@6925.14,3777.66 ccw(c6908.92,3761.44) 6908.92,3784.37 ccw(c6908.92,3807.31) v1@6925.14,3791.09 ; v1@6927.97,3780.49 ccw(c6918.58,3771.1) 6918.58,3784.37 ccw(c6918.58,3797.65) v1@6927.97,3788.26 ; v1(6931.86,3784.37) 6874.37,3784.37 6864.86,3774.86 6864.86,3686.37 ; v1@6938.28,4831.72 ccw(c6922.06,4847.93) 6945,4847.93 ccw(c6967.93,4847.93) v1@6951.72,4831.72 ; v1@6941.11,4828.89 ccw(c6931.72,4838.28) 6945,4838.28 ccw(c6958.28,4838.28) v1@6948.89,4828.89 ; 6365.19,2553.37 6387.32,2575.5 6439.25,2575.5 6447.87,2566.88 6482.03,2566.88 6623.52,2708.37 6623.52,2858.63 6697.77,2932.87 6698.02,2932.87 6706.86,2941.71 6706.86,3384.37 6699.52,3391.71 6699.52,3442.71 6723.52,3466.71 6723.52,3483.37 6698.52,3508.37 6679.52,3508.37 6656.86,3531.04 6656.36,3531.54 6656.36,3613.86 6679.37,3636.87 6714.36,3636.87 6715.19,3636.04 6759.52,3591.71 6806.86,3591.71 6823.52,3608.37 6823.52,3645.04 ; 6823.52,3645.04 6864.86,3686.37 ; 6823.52,3645.04 6864.86,3686.37
  MidLayer2 w4: v1(7006.86,4491.71) 7056.86,4491.71 7107.19,4441.37 7258.15,4441.37 7284.48,4467.71 7822.52,4467.71 7831.86,4458.37 7831.86,4425.04 ; v1@7010.75,4487.82 cw(c7020.14,4478.43) 7020.14,4491.71 cw(c7020.14,4504.99) v1@7010.75,4495.6 ; v1@7013.57,4484.99 cw(c7029.79,4468.77) 7029.79,4491.71 cw(c7029.79,4514.64) v1@7013.57,4498.43 ; v5(7810.63,4406.26) 7810.63,4408.37 7815.19,4408.37 7831.86,4425.04 ; v5@7811.05,4413.25 ccw(c7812.19,4432.13) 7825.57,4418.75 ; v5@7811.29,4417.24 ccw(c7812.91,4443.99) 7831.86,4425.04 ; v5@7821.63,4406.26 cw(c7842.28,4406.26) 7827.68,4420.86
  Bottom Layer w4: v1@6938.28,4818.28 cw(c6922.06,4802.06) 6945,4802.06 cw(c6967.93,4802.06) v1@6951.72,4818.28 ; v1@6941.11,4821.11 cw(c6931.72,4811.72) 6945,4811.72 cw(c6958.28,4811.72) v1@6948.89,4821.11 ; v1(6945,4825) 6945,4553.56 v1(7006.86,4491.71) ; v1@6997.36,4491.71 ccw(c6974.42,4491.71) 6990.64,4507.93 ccw(c7006.86,4524.14) v1@7006.86,4501.21 ; v1@7001.36,4491.71 ccw(c6988.08,4491.71) 6997.47,4501.1 ccw(c7006.86,4510.49) v1@7006.86,4497.21
DB_MEM.BUS_D8: U7.F3 U8.K27 U12.42 U16.29 U61.47 | length 6644.8
  Top Layer w4: v1@6125.14,4291.09 ccw(c6108.92,4307.31) 6131.86,4307.31 ccw(c6154.79,4307.31) v1@6138.57,4291.09 ; v1@6127.97,4288.26 ccw(c6118.58,4297.65) 6131.86,4297.65 ccw(c6145.14,4297.65) v1@6135.75,4288.26 ; U61.47@6356.86,2450.04 6420.04,2450.04 6456.86,2486.86 6456.86,2583.37 6440.19,2600.04 6440.19,2627.37 6471.19,2658.37 6471.19,2775 6471.19,2781.71 6471.19,2803.06 6501.84,2833.71 6565,2833.71 ; U61.47@6367.95,2446.63 cw(c6376.19,2438.39) 6376.19,2450.04 ; U61.47@6367.95,2452.28 ccw(c6373.37,2457.7) 6373.37,2450.04 ; v1(6838.86,2962.37) 6906.86,3030.37 6906.86,3055 6898.52,3063.33 6898.52,3150.04 6998.52,3250.04 6998.52,3983.37 7015.19,4000.04 7040.15,4025 7173.86,4025 ; v1@6838.86,2967.87 ccw(c6838.86,2981.15) 6848.25,2971.76 ccw(c6857.64,2962.37) v1@6844.36,2962.37 ; v1@6838.86,2971.87 ccw(c6838.86,2994.81) 6855.07,2978.59 ccw(c6871.29,2962.37) v1@6848.36,2962.37 ; v1@7103.28,4228.28 cw(c7087.06,4212.06) 7110,4212.06 cw(c7132.94,4212.06) v1@7116.72,4228.28 ; v1@7106.11,4231.11 cw(c7096.72,4221.72) 7110,4221.72 cw(c7123.28,4221.72) v1@7113.89,4231.11 ; v1@7230.69,4513.04 cw(c7207.76,4513.04) 7223.97,4496.82 cw(c7240.19,4480.61) v1@7240.19,4503.54 ; v1@7234.69,4513.04 cw(c7221.41,4513.04) 7230.8,4503.65 cw(c7240.19,4494.26) v1@7240.19,4507.54 ; v1@7240.33,4511.55 cw(c7242.12,4492.78) 7255.45,4506.11 ; v1@7240.71,4507.57 cw(c7243.17,4481.82) 7261.46,4500.11 ; U16.29@7269.85,4494.4 ccw(c7263.3,4490.79) 7263.3,4498.27 ; U16.29@7269.85,4502.13 cw(c7263.3,4505.75) 7263.3,4498.27 ; U12.42@7271.19,3790.84 ccw(c7257.54,3777.18) 7257.54,3796.5 ccw(c7257.54,3815.81) U12.42@7271.19,3802.15 ; U12.42@7294.41,3796.5 7139.86,3796.5 7131.86,3804.5 7131.86,3908.37 7131.86,3919.69 ; U16.29@7294.41,4498.27 7263.3,4498.27 ; 5894.66,4379.7 ccw(c5907.19,4367.16) 5889.47,4367.16 cw(c5907.19,4367.16) 5894.66,4379.7 ; 5894.66,4379.7 cw(c5882.13,4392.23) 5882.13,4374.51 ccw(c5882.13,4392.23) 5894.66,4379.7 ; 5894.66,4379.7 cw(c5901.84,4372.52) 5901.84,4382.67 ; 5894.66,4379.7 cw(c5901.84,4372.52) 5901.84,4382.67 ; 5901.84,4382.67 5941.18,4382.67 5950.67,4382.67 5979.44,4382.67 5985.12,4377 6014.75,4377 6030.5,4361.25 6030.5,4356 6054.5,4332 6076.43,4332 6089.31,4332 6123,4332 6131.86,4323.14 v1@6131.86,4289.46 ; v1@6131.86,4289.46 v1(6131.86,4284.37) v1@6131.86,4289.46 ; 6565,2833.71 6585.17,2833.71 ; 6565,2833.71 6585.17,2833.71 ; 6585.17,2833.71 6655.46,2904 6669.15,2904 ; 6669.15,2904 v1(6706,2904) 6669.15,2904 ; 6683.06,2904 cw(c6683.06,2881.06) 6699.28,2897.28 ccw(c6683.06,2881.06) 6683.06,2904 ; 6683.06,2904 ccw(c6683.06,2926.93) 6699.28,2910.72 cw(c6683.06,2926.93) 6683.06,2904 ; 6692.72,2904 cw(c6692.72,2890.72) 6702.11,2900.11 ccw(c6692.72,2890.72) 6692.72,2904 ; 6692.72,2904 ccw(c6692.72,2917.28) 6702.11,2907.89 cw(c6692.72,2917.28) 6692.72,2904 ; v1(7110,4235) 7110,4284.18 ; v1(7110,4235) 7110,4284.18 ; v1(7110,4235) 7110,4165 7173.86,4101.14 7173.86,3961.69 7170,3957.83 ; 7110,4248.28 cw(c7096.72,4248.28) 7106.11,4238.89 ccw(c7096.72,4248.28) 7110,4248.28 ; 7110,4248.28 ccw(c7123.28,4248.28) 7113.89,4238.89 cw(c7123.28,4248.28) 7110,4248.28 ; 7110,4257.93 cw(c7087.06,4257.93) 7103.28,4241.72 ccw(c7087.06,4257.93) 7110,4257.93 ; 7110,4257.93 ccw(c7132.94,4257.93) 7116.72,4241.72 cw(c7132.94,4257.93) 7110,4257.93 ; 7110,4284.18 7110,4305 7140.19,4335.19 7140.19,4365 7140.19,4413.04 v1(7240.19,4513.04) 7248.52,4513.04 7263.3,4498.27 ; 7131.86,3919.69 7170,3957.83 ; 7131.86,3919.69 7170,3957.83
  Top Layer w8: v5@7771.26,4554.74 cw(c7771.26,4533.01) 7786.62,4548.38 cw(c7801.99,4563.74) v5@7780.26,4563.74 ; v5(7771.26,4563.74) U7.F3@7790.95,4544.06
  MidLayer1 w4: v1(6131.86,4284.37) 6180.57,4333.08 ; v1@6131.86,4289.87 ccw(c6131.86,4303.15) 6141.25,4293.76 ccw(c6150.64,4284.37) v1@6137.36,4284.37 ; v1@6131.86,4293.87 ccw(c6131.86,4316.81) 6148.07,4300.59 ccw(c6164.29,4284.37) v1@6141.36,4284.37 ; 6244.34,4344 ccw(c6244.34,4387.56) v1@6275.14,4356.76 ; 6254,4344 ccw(c6254,4377.9) v1@6277.97,4353.93 ; 6263.65,4344 ccw(c6263.65,4368.25) v1@6280.8,4351.1 ; v1@6279.94,4350.04 6273.9,4344 6191.48,4344 ; 6180.57,4333.08 6191.48,4344 ; 6180.57,4333.08 6191.48,4344
  MidLayer2 w4: v1(7240.19,4513.04) 7316.14,4588.99 7316.14,4601.99 7331.86,4617.71 7370.61,4617.71 7394.61,4593.71 7531.23,4593.71 7541.57,4583.37 7751.63,4583.37 v5(7771.26,4563.74) ; v1@7240.19,4518.54 ccw(c7240.19,4531.82) 7249.58,4522.43 ccw(c7258.97,4513.04) v1@7245.69,4513.04 ; v1@7240.19,4522.54 ccw(c7240.19,4545.48) 7256.41,4529.26 ccw(c7272.63,4513.04) v1@7249.69,4513.04 ; v5@7760.26,4563.74 ccw(c7733.7,4563.74) 7752.48,4582.52 ccw(c7771.26,4601.3) v5@7771.26,4574.74 ; v5@7764.26,4563.74 ccw(c7747.36,4563.74) 7759.31,4575.69 ccw(c7771.26,4587.64) v5@7771.26,4570.74
  Bottom Layer w4: v1@6275.14,4343.32 cw(c6258.92,4327.11) 6281.86,4327.11 cw(c6304.79,4327.11) v1@6288.57,4343.32 ; v1@6277.97,4346.15 cw(c6268.58,4336.76) 6281.86,4336.76 cw(c6295.14,4336.76) v1@6285.75,4346.15 ; v1(6281.86,4350.04) 6281.86,4300.04 6298.52,4283.37 6315.71,4266.19 6602.38,4266.19 6634.19,4234.37 6777.88,4234.37 6778.37,4234.87 6783.34,4234.87 6818.17,4200.04 6952.13,4200.04 7010.46,4258.37 7040,4258.37 ; v1(6706,2904) 6781.54,2979.54 6785.71,2983.71 6805,2983.71 6817.52,2983.71 v1(6838.86,2962.37) ; v1@6706,2909.5 ccw(c6706,2922.78) 6715.39,2913.39 ccw(c6724.78,2904) v1@6711.5,2904 ; v1@6706,2913.5 ccw(c6706,2936.43) 6722.22,2920.22 ccw(c6738.43,2904) v1@6715.5,2904 ; v1@6829.36,2962.37 ccw(c6806.42,2962.37) 6822.64,2978.59 ccw(c6838.86,2994.81) v1@6838.86,2971.87 ; v1@6833.36,2962.37 ccw(c6820.08,2962.37) 6829.47,2971.76 ccw(c6838.86,2981.15) v1@6838.86,2967.87 ; v1@7100.5,4235 ccw(c7077.56,4235) 7093.78,4251.22 ccw(c7110,4267.43) v1@7110,4244.5 ; v1@7104.5,4235 ccw(c7091.22,4235) 7100.61,4244.39 ccw(c7110,4253.78) v1@7110,4240.5 ; v1(7110,4235) 7086.63,4258.37 7073.52,4258.37 ; 7040,4258.37 7073.52,4258.37 ; 7040,4258.37 7073.52,4258.37
DB_MEM.BUS_D9: U7.G3 U8.V28 U12.44 U16.30 U61.49 | length 6320.2
  Top Layer w4: U8.V28@5921.5,4052.2 5941.18,4052.2 5949.18,4052.2 5986.73,4052.2 6004.64,4034.3 v1(6030,4034.3) ; U8.V28@5926.69,4047.01 cw(c5939.22,4034.48) 5939.22,4052.2 cw(c5939.22,4069.93) U8.V28@5926.69,4057.4 ; v1@6023.28,4027.58 ccw(c6007.06,4011.36) 6007.06,4034.3 ccw(c6007.06,4057.23) v1@6023.28,4041.02 ; v1@6026.11,4030.41 ccw(c6016.72,4021.02) 6016.72,4034.3 ccw(c6016.72,4047.58) v1@6026.11,4038.19 ; v1@6312.98,2488.83 U61.49@6351.93,2488.83 ; v1@6315.08,2483.15 cw(c6328.78,2469.45) 6328.78,2488.83 ; v1@6317.91,2480.32 cw(c6338.43,2459.8) U61.49@6338.43,2488.83 ; v1@6317.91,2493.76 ccw(c6329.82,2505.67) 6329.82,2488.83 ; U61.49@6335.91,2486 ccw(c6329.08,2479.17) 6329.08,2488.83 ccw(c6329.08,2498.48) U61.49@6335.91,2491.65 ; v1(7181.86,3838.71) 7223.71,3838.71 7244.49,3859.49 U12.44@7294.41,3859.49 ; v1@7185.75,3834.82 cw(c7195.14,3825.43) 7195.14,3838.71 cw(c7195.14,3851.99) v1@7185.75,3842.6 ; v1@7188.57,3831.99 cw(c7204.79,3815.77) 7204.79,3838.71 cw(c7204.79,3861.64) v1@7188.57,3845.43 ; U12.44@7271.19,3853.83 ccw(c7257.54,3840.17) 7257.54,3859.49 ccw(c7257.54,3878.8) U12.44@7271.19,3865.15 ; U12.44@7291.3,3859.49 U12.44@7294.41,3859.49 ; U16.30@7294.41,4529.76 7337.58,4529.76 v1(7340.52,4532.71) ; U16.30@7310.48,4529.76 ccw(c7310.48,4562.75) v1@7333.81,4539.43 ; U12.44@7311.9,3859.49 cw(c7311.9,3832.75) v1@7330.81,3851.66 ; U12.44@7317.28,3859.49 ccw(c7317.28,3878.62) v1@7330.81,3865.09 ; U16.30@7320.14,4529.76 ccw(c7320.14,4553.09) v1@7336.64,4536.6 ; U12.44@7321.56,3859.49 cw(c7321.56,3842.41) v1@7333.64,3854.49 ; 7324.7,4529.76 cw(c7324.7,4516.88) v1@7333.81,4525.99 ; v1(7337.52,3858.37) 7333.64,3858.37 7332.52,3859.49 U12.44@7294.41,3859.49
  Top Layer w8: v5@7731.89,4554.74 cw(c7731.89,4533.01) 7747.25,4548.38 cw(c7762.62,4563.74) v5@7740.89,4563.74 ; v5(7731.89,4563.74) U7.G3@7751.58,4544.06
  MidLayer1 w4: v1@6304.47,2480.32 cw(c6288.26,2464.11) 6311.19,2464.11 cw(c6334.13,2464.11) v1@6317.91,2480.32 ; v1@6307.3,2483.15 cw(c6297.91,2473.76) 6311.19,2473.76 cw(c6324.47,2473.76) v1@6315.08,2483.15 ; v1(6311.19,2487.04) 6311.19,2438.81 6391.63,2358.37 ; 6381.4,2368.6 6391.96,2358.04 6493.88,2358.04 6529.81,2393.98 6529.81,2411.38 6529.19,2412 6529.19,2547.37 6665.19,2683.37 6665.19,2705.39 6685.17,2725.37 6712.84,2725.37 ; 6695.19,2725.04 6712.5,2725.04 6712.84,2725.37 ; v1@7181.86,3829.21 cw(c7181.86,3806.27) 7198.07,3822.49 cw(c7214.29,3838.71) v1@7191.36,3838.71 ; v1@7181.86,3833.21 cw(c7181.86,3819.93) 7191.25,3829.32 cw(c7200.64,3838.71) v1@7187.36,3838.71 ; v1(7181.86,3838.71) 7198.19,3822.37 7198.19,3656.81 7198.19,3638.39 7179.76,3619.96 7123.52,3563.73 7123.52,3166.96 6725.86,2769.29 6725.86,2738.39 6712.84,2725.37 ; v1(7456.86,3925.04) 7481.86,3950.04 7481.86,4484.71 v1(7527.86,4530.71) ; v1@7456.86,3930.54 ccw(c7456.86,3943.82) 7466.25,3934.43 ccw(c7475.64,3925.04) v1@7462.36,3925.04 ; v1@7456.86,3934.54 ccw(c7456.86,3957.48) 7473.07,3941.26 ccw(c7489.29,3925.04) v1@7466.36,3925.04 ; v1@7518.36,4530.71 cw(c7495.42,4530.71) 7511.64,4514.49 cw(c7527.86,4498.27) v1@7527.86,4521.21 ; v1@7522.36,4530.71 cw(c7509.08,4530.71) 7518.47,4521.32 cw(c7527.86,4511.93) v1@7527.86,4525.21
  MidLayer2 w4: v1@6030,4033.37 6181.63,4033.37 6204.63,4010.37 6382.52,4010.37 6393.15,4021 6477.01,4021 6481.22,4025.21 6504.71,4025.21 6526.02,4003.89 6526.02,3988.98 6536.28,3978.72 6547.69,3967.31 6555,3960 6746.9,3960 6776.9,3930 6825,3930 6871.63,3883.37 7070.54,3883.37 7095.21,3858.71 7161.86,3858.71 v1(7181.86,3838.71) ; v1@6033.89,4038.19 ccw(c6045.51,4049.81) 6045.51,4033.37 ; v1@6036.72,4027.58 cw(c6050.7,4013.6) 6050.7,4033.37 ; v1@6036.72,4041.02 ccw(c6055.17,4059.47) 6055.17,4033.37 ; v1@7172.36,3838.71 ccw(c7149.42,3838.71) 7165.64,3854.93 ccw(c7181.86,3871.14) v1@7181.86,3848.21 ; v1@7176.36,3838.71 ccw(c7163.08,3838.71) 7172.47,3848.1 ccw(c7181.86,3857.49) v1@7181.86,3844.21 ; v1(7340.52,4532.71) 7432.52,4532.71 7434.52,4530.71 v1(7527.86,4530.71) ; v1@7344.41,4528.82 cw(c7353.8,4519.43) 7353.8,4532.71 cw(c7353.8,4545.99) v1@7344.41,4536.6 ; v1@7347.24,4525.99 cw(c7363.46,4509.77) 7363.46,4532.71 cw(c7363.46,4555.64) v1@7347.24,4539.43 ; v1@7521.14,4523.99 ccw(c7504.92,4507.77) 7504.92,4530.71 ccw(c7504.92,4553.64) v1@7521.14,4537.43 ; v1@7523.97,4526.82 ccw(c7514.58,4517.43) 7514.58,4530.71 ccw(c7514.58,4543.99) v1@7523.97,4534.6
  Bottom Layer w4: v1(7337.52,3858.37) 7390.19,3858.37 v1(7456.86,3925.04) ; v1@7341.41,3854.49 cw(c7350.8,3845.1) 7350.8,3858.37 cw(c7350.8,3871.65) v1@7341.41,3862.26 ; v1@7344.24,3851.66 cw(c7360.46,3835.44) 7360.46,3858.37 cw(c7360.46,3881.31) v1@7344.24,3865.09 ; v1@7447.36,3925.04 cw(c7424.42,3925.04) 7440.64,3908.82 cw(c7456.86,3892.61) v1@7456.86,3915.54 ; v1@7451.36,3925.04 cw(c7438.08,3925.04) 7447.47,3915.65 cw(c7456.86,3906.26) v1@7456.86,3919.54 ; v1@7521.14,4537.43 ccw(c7504.92,4553.64) 7527.86,4553.64 ccw(c7550.79,4553.64) v1@7534.57,4537.43 ; v1@7523.97,4534.6 ccw(c7514.58,4543.99) 7527.86,4543.99 ccw(c7541.14,4543.99) v1@7531.75,4534.6 ; v1(7527.86,4530.71) 7527.86,4712.71 7556.86,4741.71 7644.19,4741.71 7665.19,4720.71 7665.19,4597.71 7679.52,4583.37 7712.26,4583.37 v5(7731.89,4563.74) ; v5@7720.89,4563.74 ccw(c7694.33,4563.74) 7713.11,4582.52 ccw(c7731.89,4601.3) v5@7731.89,4574.74 ; v5@7724.89,4563.74 ccw(c7707.99,4563.74) 7719.94,4575.69 ccw(c7731.89,4587.64) v5@7731.89,4570.74
DB_MEM.BUS_D10: U7.F4 U8.U27 U12.45 U16.31 U61.51 | length 5981.4
  Top Layer w4: U8.U27@5882.13,4084.23 cw(c5882.13,4066.51) 5894.66,4079.04 ; U8.U27@5889.47,4091.57 ccw(c5907.19,4091.57) 5894.66,4079.04 ; v1(6009,4066) 5999.46,4075.54 5977.89,4075.54 5977.36,4076.07 5901.84,4076.07 cw(c5901.84,4086.22) 5894.66,4079.04 ; U61.51@6361.54,2528.2 ccw(c6361.54,2558.84) v1@6383.29,2537.25 ; 6371.15,2528.2 ccw(c6371.15,2549.3) v1@6386.13,2534.43 ; 6376.76,2528.2 cw(c6376.76,2522.94) v1@6380.47,2526.66 ; v1@6380.45,2540.07 cw(c6351.93,2568.37) U61.51@6351.93,2528.2 v1@6384.04,2528.2 ; v1(7190.19,3875.04) 7241.25,3875.04 7250.52,3884.32 ; v1@7194.08,3871.15 cw(c7203.47,3861.76) 7203.47,3875.04 cw(c7203.47,3888.32) v1@7194.08,3878.93 ; v1@7196.91,3868.32 cw(c7213.13,3852.11) 7213.13,3875.04 cw(c7213.13,3897.98) v1@7196.91,3881.76 ; v1@7243.81,3901.66 cw(c7227.59,3885.44) 7250.52,3885.44 cw(c7273.46,3885.44) v1@7257.24,3901.66 ; v1@7246.64,3904.49 cw(c7237.25,3895.1) 7250.52,3895.1 cw(c7263.8,3895.1) v1@7254.41,3904.49 ; v1(7250.52,3908.37) 7250.52,3884.32 ; U12.45@7271.19,3885.33 ccw(c7257.54,3871.67) 7257.54,3890.98 ccw(c7257.54,3910.3) U12.45@7271.19,3896.64 ; U12.45@7294.41,3890.98 7257.19,3890.98 7250.52,3884.32 ; U16.31@7299.86,4566.71 7340.52,4566.71 v1(7347.19,4560.04) ; U16.31@7308.16,4566.71 cw(c7308.16,4521.01) v1@7340.47,4553.32 ; U16.31@7311.97,4561.26 cw(c7323.54,4551.7) 7323.54,4566.71 ; U16.31@7315.05,4558.71 cw(c7332.03,4544.69) 7332.03,4566.71 ; U16.31@7317.82,4566.71 cw(c7317.82,4530.67) v1@7343.3,4556.15 ; 7327.47,4566.71 cw(c7327.47,4540.32) v1@7346.13,4558.98 ; 7337.13,4566.71 cw(c7337.13,4549.98) v1@7348.96,4561.81
  Top Layer w8: v5@7771.26,4515.37 cw(c7771.26,4493.64) 7786.62,4509.01 cw(c7801.99,4524.37) v5@7780.26,4524.37 ; v5(7771.26,4524.37) U7.F4@7790.95,4504.69
  MidLayer1 w4: v1(6387.19,2533.37) 6418.19,2533.37 ; v1@6391.08,2529.49 cw(c6400.47,2520.1) 6400.47,2533.37 cw(c6400.47,2546.65) v1@6391.08,2537.26 ; v1@6393.91,2526.66 cw(c6410.13,2510.44) 6410.13,2533.37 cw(c6410.13,2556.31) v1@6393.91,2540.09 ; v1@7182.9,3868.95 ccw(c7169.86,3858.03) 7169.86,3875.04 ; v1@7182.9,3881.14 cw(c7169.86,3892.05) 7169.86,3875.04 ; v1@7185.97,3871.51 ccw(c7178.42,3865.19) 7178.42,3875.04 ccw(c7178.42,3884.89) v1@7185.97,3878.57 ; v1(7190.19,3875.04) 7169.86,3875.04 ; v1(7250.52,3908.37) 7281.86,3939.71 7281.86,4303.33 7298.52,4320 7298.52,4541.71 7316.86,4560.04 v1(7347.19,4560.04) ; v1@7250.52,3913.87 ccw(c7250.52,3927.15) 7259.91,3917.76 ccw(c7269.3,3908.37) v1@7256.02,3908.37 ; v1@7250.52,3917.87 ccw(c7250.52,3940.81) 7266.74,3924.59 ccw(c7282.96,3908.37) v1@7260.02,3908.37 ; v1@7340.47,4553.32 ccw(c7324.26,4537.11) 7324.26,4560.04 ccw(c7324.26,4582.98) v1@7340.47,4566.76 ; v1@7343.3,4556.15 ccw(c7333.91,4546.76) 7333.91,4560.04 ccw(c7333.91,4573.32) v1@7343.3,4563.93 ; 6418.19,2533.37 6424.62,2539.81 ; 6418.19,2533.37 6424.62,2539.81 ; 6424.62,2539.81 6439.38,2539.81 6454.15,2525.04 6491.86,2525.04 6656.86,2690.04 6656.86,2708.37 6681.86,2733.37 6709.52,2733.37 6717.86,2741.71 6717.86,2745 ; 6717.86,2745 6717.86,2772.61 ; 6717.86,2745 6717.86,2772.61 ; 6717.86,2772.61 6856.86,2911.61 6856.86,2917.32 ; 6856.86,2917.32 6856.86,2955 ; 6856.86,2917.32 6856.86,2955 ; 6856.86,2955 6856.86,3108.37 7098.52,3350.04 7115.52,3367.04 7115.52,3567.04 ; 7115.52,3567.04 7190.19,3641.71 ; 7115.52,3567.04 7190.19,3641.71 ; 7169.86,3875.04 7136.52,3841.71 7136.52,3825.04 7190.19,3771.37 7190.19,3641.71
  MidLayer2 w4: v1(6264.19,4058.37) 6296.67,4058.37 6305,4066.71 6323.52,4066.71 6345.23,4045 6467.07,4045 6471.28,4049.21 6537.11,4049.21 6610.31,3976 6686,3976 6743.37,4033.37 6900,4033.37 6950,3983.37 ; v1@6268.08,4054.49 cw(c6277.47,4045.1) 6277.47,4058.37 cw(c6277.47,4071.65) v1@6268.08,4062.26 ; v1@6270.91,4051.66 cw(c6287.13,4035.44) 6287.13,4058.37 cw(c6287.13,4081.31) v1@6270.91,4065.09 ; v1@7182.06,3870.12 ccw(c7173.33,3864.84) 7173.33,3875.04 ; v1@7182.06,3879.96 cw(c7173.33,3885.25) 7173.33,3875.04 ; v1(7190.19,3875.04) 7173.33,3875.04 ; v1(7347.19,4560.04) 7421.86,4560.04 7441.52,4540.37 7497.19,4540.37 7515.04,4558.23 7532.77,4558.23 ; v1@7351.08,4556.15 cw(c7360.47,4546.76) 7360.47,4560.04 cw(c7360.47,4573.32) v1@7351.08,4563.93 ; v1@7353.91,4553.32 cw(c7370.13,4537.11) 7370.13,4560.04 cw(c7370.13,4582.98) v1@7353.91,4566.76 ; v5@7760.26,4524.37 cw(c7733.7,4524.37) 7752.48,4505.59 cw(c7771.26,4486.81) v5@7771.26,4513.37 ; v5@7764.26,4524.37 cw(c7747.36,4524.37) 7759.31,4512.42 cw(c7771.26,4500.47) v5@7771.26,4517.37 ; v5@7765.19,4524.37 v5@7765.19,4518.3 ; v5(7771.26,4524.37) v5@7765.19,4518.3 ; 6950,3970 6950,3983.37 ; 6950,3970 6950,3901.71 6960,3891.71 7073.52,3891.71 7098.52,3866.71 7165,3866.71 7173.33,3875.04 ; 6950,3970 6950,3983.37 ; 7532.77,4558.23 7585.96,4505.04 ; 7532.77,4558.23 7585.96,4505.04 ; 7585.96,4505.04 7590.96,4500.04 7746.93,4500.04 7751.93,4505.04 v5@7765.19,4518.3
  Bottom Layer w4: v1@6014,4066 6024,4066 ; v1@6254.69,4058.37 cw(c6231.76,4058.37) 6247.97,4042.16 cw(c6264.19,4025.94) v1@6264.19,4048.87 ; v1@6258.69,4058.37 cw(c6245.41,4058.37) 6254.8,4048.99 cw(c6264.19,4039.6) v1@6264.19,4052.87 ; v1(6264.19,4058.37) 6223.82,4018 6106.46,4018 6099.66,4024.8 6065.2,4024.8 6051.15,4038.85 6051.15,4058.85 6044,4066 6024,4066 ; 6024,4066 v1(6009,4066) 6024,4066