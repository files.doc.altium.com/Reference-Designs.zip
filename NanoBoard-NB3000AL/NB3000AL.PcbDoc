# Altium PCB NB3000AL.PcbDoc (part 48 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: (continued)
  Bottom Layer w4: 4765.19,3982.78 4765.19,3983.04 ; C335.2@4790,4169.33 C335.2@4790,4178.56 ; 4838.82,4056.38 4861.95,4056.38 4920.21,4056.38 4978.47,4056.38 5036.73,4056.38 5056.15,4056.38 5116.34,4056.38 5130.27,4056.38 ccw(c5130.27,4070.43) 5140.2,4060.5 ; 4838.82,4087.4 4861.95,4087.4 4920.21,4087.4 4978.47,4087.4 5036.73,4087.4 5056.15,4087.4 5130.27,4087.4 5149.77,4087.4 ccw(c5149.77,4129.13) 5179.28,4099.62 ; 4838.82,4284.25 4861.95,4284.25 4920.21,4284.25 4978.47,4284.25 5036.73,4284.25 5056.15,4284.25 5116.34,4284.25 5130.27,4284.25 cw(c5130.27,4270.2) 5140.2,4280.13 ; 4838.82,4331.97 4861.95,4331.97 4920.21,4331.97 4978.47,4331.97 5036.73,4331.97 5056.15,4331.97 5130.27,4331.97 5149.77,4331.97 cw(c5149.77,4290.24) 5179.28,4319.75 ; 4838.82,4362.99 4861.95,4362.99 4920.21,4362.99 4978.47,4362.99 5036.73,4362.99 5056.15,4362.99 5116.34,4362.99 5130.27,4362.99 cw(c5130.27,4348.94) 5140.2,4358.87 ; 4980.7,3638.82 4980.7,3640.41 4980.7,3698.67 4980.7,3756.93 cw(c4996.3,3756.93) 4996.3,3772.53 ccw(c4996.3,3796.3) 5020.07,3796.3 5020.07,3804.42 ; 4980.7,4741.18 4980.7,4739.59 4980.7,4681.33 4980.7,4623.07 ccw(c4996.3,4623.07) 4996.3,4607.47 cw(c4996.3,4583.7) 5020.07,4583.7 5020.07,4575.58 ; v1(4988.86,4815.04) 5031.3,4815.04 ; v1@4992.75,4811.15 cw(c5002.14,4801.76) 5002.14,4815.04 cw(c5002.14,4828.32) v1@4992.75,4818.93 ; v1@4995.57,4808.32 cw(c5011.79,4792.11) 5011.79,4815.04 cw(c5011.79,4837.98) v1@4995.57,4821.76 ; 5020.12,3804.47 cw(c5043.84,3806.08) 5025.24,3820.87 ; 5020.12,4575.53 ccw(c5043.84,4573.92) 5025.24,4559.13 ; v3@5028.28,3834.37 cw(c5010.45,3831.22) 5025.28,3820.84 cw(c5040.12,3810.45) v3@5036.97,3828.28 ; v3@5028.28,4545.63 ccw(c5010.45,4548.78) 5025.28,4559.16 ccw(c5040.12,4569.55) v3@5036.97,4551.72 ; C308.2@5050.53,4790.15 ccw(c5037.7,4790.49) 5046.77,4799.56 ccw(c5055.85,4808.64) C308.2@5056.19,4795.81 ; v1@5090.19,3591.71 v1(5090.19,3600.04) ; 5138.18,4741.18 5138.18,4739.59 5138.18,4681.33 5138.18,4465.59 ccw(c5153.78,4465.59) 5153.78,4449.99 cw(c5153.78,4426.22) 5177.55,4426.22 5177.55,4418.1 ; v3@5146.31,4072.54 cw(c5128.27,4074.12) 5139.91,4060.25 cw(c5151.55,4046.38) v3@5153.13,4064.42 ; v3@5146.31,4268.09 ccw(c5128.27,4266.51) 5139.91,4280.38 ccw(c5151.55,4294.25) v3@5153.13,4276.21 ; v3@5146.31,4346.83 ccw(c5128.27,4345.25) 5139.91,4359.12 ccw(c5151.55,4372.99) v3@5153.13,4354.95 ; v1@5162.81,4806.05 cw(c5156.54,4796.45) 5168,4796.45 cw(c5179.46,4796.45) v1@5173.19,4806.05 ; v1(5168,4814) 5168,4796.45 C292.2@5174.45,4790 ; 5177.6,4418.05 ccw(c5201.32,4416.44) 5182.72,4401.65 ; v3@5185.68,4111.91 cw(c5167.64,4113.49) 5179.28,4099.62 ; v3@5185.68,4307.46 ccw(c5167.64,4305.88) 5179.28,4319.75 ; v3@5185.76,4388.15 ccw(c5167.93,4391.3) 5182.76,4401.68 ccw(c5197.6,4412.07) v3@5194.45,4394.24 ; v3@5192.5,4103.79 ccw(c5190.92,4085.75) 5179.28,4099.62 ; v3@5192.5,4315.58 cw(c5190.92,4333.62) 5179.28,4319.75 ; 5208.66,3638.82 5208.66,3661.95 5208.66,3720.21 5208.66,3778.47 5208.66,3836.73 5208.66,3856.15 5208.66,3930.27 5208.66,3949.77 cw(c5250.39,3949.77) 5220.88,3979.28 ; 5217.01,3638.82 5217.01,3661.95 5217.01,3720.21 5217.01,3778.47 5217.01,3836.73 5217.01,3856.15 5217.01,3916.34 5217.01,3930.27 cw(c5231.06,3930.27) 5221.13,3940.2 ; 5217.01,4741.18 5217.01,4718.05 5217.01,4659.79 5217.01,4601.53 5217.01,4543.27 5217.01,4523.85 5217.01,4463.66 5217.01,4449.73 ccw(c5231.06,4449.73) 5221.13,4439.8 ; v3@5225.05,3953.13 cw(c5207.01,3951.55) 5220.88,3939.91 cw(c5234.75,3928.27) v3@5233.17,3946.31 ; v3@5225.05,3992.5 cw(c5207.01,3990.92) 5220.88,3979.28 ; v3@5225.05,4426.87 ccw(c5207.01,4428.45) 5220.88,4440.09 ccw(c5234.75,4451.73) v3@5233.17,4433.69 ; v3@5233.17,3985.68 ccw(c5234.75,3967.64) 5220.88,3979.28 ; 5248.03,4741.18 5248.03,4718.05 5248.03,4659.79 5248.03,4601.53 5248.03,4543.27 5248.03,4523.85 5248.03,4449.73 5248.03,4430.23 ccw(c5289.76,4430.23) 5260.25,4400.72 ; v3@5264.42,4387.5 ccw(c5246.38,4389.08) 5260.25,4400.72 ; v3@5272.54,4394.32 cw(c5274.12,4412.36) 5260.25,4400.72 ; 5287.4,3638.82 5287.4,3661.95 5287.4,3720.21 5287.4,3778.47 5287.4,3836.73 5287.4,3856.15 5287.4,3930.27 5287.4,3949.77 cw(c5329.13,3949.77) 5299.62,3979.28 ; v3@5303.79,3992.5 cw(c5285.75,3990.92) 5299.62,3979.28 ; v3@5311.91,3985.68 ccw(c5313.49,3967.64) 5299.62,3979.28 ; v3@5468.09,4394.32 ccw(c5466.51,4412.36) 5480.38,4400.72 ; v3@5476.21,4387.5 cw(c5494.25,4389.08) 5480.38,4400.72 ; 5492.6,4741.18 5492.6,4718.05 5492.6,4659.79 5492.6,4601.53 5492.6,4543.27 5492.6,4523.85 5492.6,4449.73 5492.6,4430.23 cw(c5450.87,4430.23) 5480.38,4400.72 ; v3@5507.46,3985.68 cw(c5505.88,3967.64) 5519.75,3979.28 ; v3@5515.58,3992.5 ccw(c5533.62,3990.92) 5519.75,3979.28 ; 5531.97,3638.82 5531.97,3661.95 5531.97,3720.21 5531.97,3778.47 5531.97,3836.73 5531.97,3856.15 5531.97,3930.27 5531.97,3949.77 ccw(c5490.24,3949.77) 5519.75,3979.28 ; v3@5546.83,3946.31 cw(c5545.25,3928.27) 5559.12,3939.91 cw(c5572.99,3951.55) v3@5554.95,3953.13 ; v3@5546.83,4394.32 ccw(c5545.25,4412.36) 5559.12,4400.72 ; v3@5546.83,4433.69 ccw(c5545.25,4451.73) 5559.12,4440.09 ccw(c5572.99,4428.45) v3@5554.95,4426.87 ; v3@5554.95,4387.5 cw(c5572.99,4389.08) 5559.12,4400.72 ; 5558.87,3940.2 cw(c5548.94,3930.27) 5562.99,3930.27 5562.99,3916.34 5562.99,3856.15 5562.99,3836.73 5562.99,3778.47 5562.99,3720.21 5562.99,3661.95 5562.99,3638.82 ; 5558.87,4439.8 ccw(c5548.94,4449.73) 5562.99,4449.73 5562.99,4463.66 5562.99,4523.85 5562.99,4543.27 5562.99,4601.53 5562.99,4659.79 5562.99,4718.05 5562.99,4741.18 ; 5571.34,4741.18 5571.34,4718.05 5571.34,4659.79 5571.34,4601.53 5571.34,4543.27 5571.34,4523.85 5571.34,4449.73 5571.34,4430.23 cw(c5529.61,4430.23) 5559.12,4400.72 ; v3@5585.55,3985.76 cw(c5582.4,3967.93) 5597.24,3978.32 cw(c5612.07,3988.7) v3@5594.24,3991.85 ; v3@5587.5,4064.42 cw(c5589.08,4046.38) 5600.72,4060.25 ; v3@5587.5,4276.21 ccw(c5589.08,4294.25) 5600.72,4280.38 ; v3@5587.5,4354.95 ccw(c5589.08,4372.99) 5600.72,4359.12 ; v3@5594.32,4072.54 ccw(c5612.36,4074.12) 5600.72,4060.25 ; v3@5594.32,4268.09 cw(c5612.36,4266.51) 5600.72,4280.38 ; v3@5594.32,4346.83 cw(c5612.36,4345.25) 5600.72,4359.12 ; 5597.28,3978.35 cw(c5578.68,3963.56) 5602.4,3961.95 ; 5602.45,3961.9 5602.45,3953.78 ccw(c5626.22,3953.78) 5626.22,3930.01 cw(c5626.22,3914.41) 5641.82,3914.41 5641.82,3698.67 5641.82,3640.41 5641.82,3638.82 ; v3@5626.87,4103.79 cw(c5628.45,4085.75) 5640.09,4099.62 cw(c5651.73,4113.49) v3@5633.69,4111.91 ; v3@5626.87,4315.58 ccw(c5628.45,4333.62) 5640.09,4319.75 ccw(c5651.73,4305.88) v3@5633.69,4307.46 ; 5639.8,4099.87 ccw(c5649.73,4109.8) 5649.73,4095.75 5663.66,4095.75 5723.85,4095.75 5743.27,4095.75 5801.53,4095.75 5859.79,4095.75 5918.05,4095.75 5941.18,4095.75 ; 5639.8,4319.5 cw(c5649.73,4309.57) 5649.73,4323.62 5663.66,4323.62 5723.85,4323.62 5743.27,4323.62 5801.53,4323.62 5859.79,4323.62 5918.05,4323.62 5941.18,4323.62 ; v3@5743.03,3828.28 cw(c5739.88,3810.45) 5754.72,3820.84 cw(c5769.55,3831.22) v3@5751.72,3834.37 ; v3@5743.03,4551.72 ccw(c5739.88,4569.55) 5754.72,4559.16 ccw(c5769.55,4548.78) v3@5751.72,4545.63 ; 5754.76,3820.87 cw(c5736.16,3806.08) 5759.88,3804.47 ; 5754.76,4559.13 ccw(c5736.16,4573.92) 5759.88,4575.53 ; 5759.93,3804.42 5759.93,3796.3 ccw(c5783.7,3796.3) 5783.7,3772.53 cw(c5783.7,3756.93) 5799.3,3756.93 5799.3,3698.67 5799.3,3640.41 5799.3,3638.82 ; 5759.93,4575.58 5759.93,4583.7 cw(c5783.7,4583.7) 5783.7,4607.47 ccw(c5783.7,4623.07) 5799.3,4623.07 5799.3,4681.33 5799.3,4739.59 5799.3,4741.18 ; 5941.18,4048.03 5918.05,4048.03 5859.79,4048.03 5801.53,4048.03 5743.27,4048.03 5723.85,4048.03 5649.73,4048.03 5630.23,4048.03 cw(c5630.23,4089.76) 5600.72,4060.25 ; 5941.18,4292.6 5918.05,4292.6 5859.79,4292.6 5801.53,4292.6 5743.27,4292.6 5723.85,4292.6 5649.73,4292.6 5630.23,4292.6 ccw(c5630.23,4250.87) 5600.72,4280.38 ; 5941.18,4371.34 5918.05,4371.34 5859.79,4371.34 5801.53,4371.34 5743.27,4371.34 5723.85,4371.34 5649.73,4371.34 5630.23,4371.34 ccw(c5630.23,4329.61) 5600.72,4359.12 ; 6115.19,4655.37 cw(c6133.18,4655.37) v1@6126.21,4671.95 ; 6115.19,4661.39 cw(c6130.65,4661.39) v1@6124.66,4675.64 ; 6115.19,4667.41 cw(c6128.12,4667.41) v1@6123.11,4679.33 ; 6115.9,4655.75 6115.19,4656.45 6115.19,4673.37 v1(6122.52,4680.71) ; 6131.86,4655.75 6170,4655.75 U14.34@6170.59,4655.75 ; U14.34@6147.37,4650.09 ccw(c6133.72,4636.43) 6133.72,4655.75 ccw(c6133.72,4675.06) U14.34@6147.37,4661.4 ; 6665.67,1810.12 6697.69,1810.12 6755.95,1810.12 6814.21,1810.12 6833.63,1810.12 6893.82,1810.12 6898.58,1810.12 ccw(c6898.75,1843.25) 6916.4,1815.21 ; 6665.67,1919.88 6697.69,1919.88 6755.95,1919.88 6814.21,1919.88 6833.63,1919.88 6893.82,1919.88 6898.58,1919.88 cw(c6898.75,1886.75) 6916.4,1914.79 ; 6750.01,1510.67 6750.01,1531.15 6750.01,1589.41 cw(c6773.78,1589.41) 6773.78,1613.18 ccw(c6773.78,1628.78) 6789.38,1628.78 cw(c6813.15,1628.78) 6813.15,1652.55 ccw(c6813.15,1668.15) 6828.75,1668.15 cw(c6852.52,1668.15) 6835.71,1684.96 6842.13,1692.69 ; v3@6845.13,1706.22 cw(c6827.3,1703.07) 6842.13,1692.69 ; v3@6853.82,1700.13 ccw(c6856.97,1682.3) 6842.13,1692.69 ; v3@6923.87,1826.93 cw(c6906.04,1830.08) 6916.43,1815.24 cw(c6926.81,1800.41) v3@6929.96,1818.24 ; v3@6923.87,1903.07 ccw(c6906.04,1899.92) 6916.43,1914.76 ccw(c6926.81,1929.59) v3@6929.96,1911.76 ; 6946.77,1510.67 6946.77,1552.69 6946.77,1610.95 6946.77,1669.21 6946.77,1688.63 6946.77,1762.75 6946.77,1782.25 cw(c6988.5,1782.25) 6958.99,1811.76 ; 6946.77,2219.33 6946.77,2177.31 6946.77,2119.05 6946.77,2060.79 6946.77,2041.37 6946.77,1967.25 6946.77,1947.75 ccw(c6988.5,1947.75) 6958.99,1918.24 ; v3@6963.16,1824.98 cw(c6945.12,1823.4) 6958.99,1811.76 ; v3@6963.16,1905.02 ccw(c6945.12,1906.6) 6958.99,1918.24 ; v3@6971.28,1818.16 ccw(c6972.86,1800.12) 6958.99,1811.76 ; v3@6971.28,1911.84 cw(c6972.86,1929.88) 6958.99,1918.24 ; v3@7048.72,1818.16 cw(c7047.14,1800.12) 7061.01,1811.76 ; v3@7048.72,1911.84 ccw(c7047.14,1929.88) 7061.01,1918.24 ; v3@7056.84,1824.98 ccw(c7074.88,1823.4) 7061.01,1811.76 ; v3@7056.84,1905.02 cw(c7074.88,1906.6) 7061.01,1918.24 ; 7073.23,1510.67 7073.23,1552.69 7073.23,1610.95 7073.23,1669.21 7073.23,1688.63 7073.23,1762.75 7073.23,1782.25 ccw(c7031.5,1782.25) 7061.01,1811.76 ; 7073.23,2219.33 7073.23,2177.31 7073.23,2119.05 7073.23,2060.79 7073.23,2041.37 7073.23,1967.25 7073.23,1947.75 cw(c7031.5,1947.75) 7061.01,1918.24 ; v3@7090.04,1818.24 cw(c7093.19,1800.41) 7103.57,1815.24 cw(c7113.96,1830.08) v3@7096.13,1826.93 ; v3@7090.04,1911.76 ccw(c7093.19,1929.59) 7103.57,1914.76 ccw(c7113.96,1899.92) v3@7096.13,1903.07 ; 7103.6,1815.21 ccw(c7121.25,1843.25) 7121.42,1810.12 7126.18,1810.12 7186.37,1810.12 7205.79,1810.12 7264.05,1810.12 7322.31,1810.12 7342,1810.12 ; 7103.6,1914.79 cw(c7121.25,1886.75) 7121.42,1919.88 7126.18,1919.88 7186.37,1919.88 7205.79,1919.88 7264.05,1919.88 7322.31,1919.88 7354.33,1919.88 ; v3@7166.18,2029.87 ccw(c7163.03,2047.7) 7177.87,2037.31 ; v3@7174.87,2023.78 cw(c7192.7,2026.93) 7177.87,2037.31 ; 7269.99,2219.33 7269.99,2198.85 7269.99,2140.59 cw(c7246.22,2140.59) 7246.22,2116.82 ccw(c7246.22,2101.22) 7230.62,2101.22 cw(c7206.85,2101.22) 7206.85,2077.45 ccw(c7206.85,2061.85) 7191.25,2061.85 cw(c7167.48,2061.85) 7184.29,2045.04 7177.87,2037.31
  Bottom Layer w5: v1@5782.02,2041.04 cw(c5782.02,2019.31) 5797.39,2034.68 cw(c5812.75,2050.04) v1@5791.02,2050.04 ; v1(5782.02,2050.04) 5802.06,2030 5845,2030 5868,2053 5868,2130.82 R288.1@5863.82,2135 ; v1@5855,1880 5853.2,1878.2 v1(5853.2,1877.69) 5902.69,1877.69 5906.18,1881.18 R284.1@5906.18,1905 ; v1@5859.57,1871.33 cw(c5874.93,1855.96) 5874.93,1877.69 cw(c5874.93,1899.42) v1@5859.57,1884.05 ; R285.1@5906.18,2285 5984.79,2285 J29.GND1@5991.12,2278.67
  Bottom Layer w8: v2@5334.48,2824.48 cw(c5303.79,2793.79) 5347.19,2793.79 ; v2@5340.13,2830.13 cw(c5323.1,2813.1) 5347.19,2813.1 ; v2@5346.28,2825.36 cw(c5365.39,2811.25) C218.2@5365.39,2835 5345,2835 v2(5340,2830) 5347.19,2822.81 5347.19,2733.2 C234.2@5365.39,2715 ; C234.2@5357.58,2715 ccw(c5338.72,2715) 5352.05,2728.33 ccw(c5365.39,2741.67) C234.2@5365.39,2722.81 ; v2@5478.82,2825.07 cw(c5493.53,2819.14) 5493.53,2835 ; v2(5479,2825) 5489,2835 C257.2@5505.39,2835 ; v2@5486.24,2822.08 cw(c5505.39,2814.36) C257.2@5505.39,2835 ; C257.2@5508,2837.61 C257.2@5505.39,2835 ; v4(6424.34,6203.9) U56.53@6455.67,6203.9 ; v4@6428.58,6199.66 cw(c6438.82,6189.41) 6438.82,6203.9 cw(c6438.82,6218.38) v4@6428.58,6208.14 ; U56.44@6455.67,6026.73 v4(6487,6026.73) ; v4@6482.76,6022.49 ccw(c6472.51,6012.25) 6472.51,6026.73 ccw(c6472.51,6041.22) v4@6482.76,6030.97 ; v4@6497.49,5953.58 ccw(c6487.25,5963.82) 6501.73,5963.82 ccw(c6516.22,5963.82) v4@6505.97,5953.58 ; v4(6501.73,5949.34) U56.41@6501.73,5980.67 ; v4@6576.23,6262.24 ccw(c6565.99,6272.49) 6580.47,6272.49 ccw(c6594.96,6272.49) v4@6584.72,6262.24 ; v4(6580.47,6258) U56.6@6580.47,6289.33 ; v4@6654.97,6262.24 ccw(c6644.73,6272.49) 6659.21,6272.49 ccw(c6673.7,6272.49) v4@6663.46,6262.24 ; v4(6659.21,6258) U56.10@6659.21,6289.33 ; v4@6694.34,6262.24 ccw(c6684.1,6272.49) 6698.58,6272.49 ccw(c6713.07,6272.49) v4@6702.83,6262.24 ; v4(6698.58,6258) U56.12@6698.58,6289.33 ; v4(6733,6046.42) U56.26@6764.33,6046.42 ; v4@6737.24,6042.17 cw(c6747.48,6031.93) 6747.48,6046.42 cw(c6747.48,6060.9) v4@6737.24,6050.66 ; NT6.2@7215,1370 7237.42,1370 7240,1367.42 7240,1332 7242.19,1329.81 ; 7242.21,1329.81 7253.81,1318.21 7253.81,1306.17 7285.17,1274.81 v2(7293.19,1274.81) ; 7266.17,1293.81 ccw(c7293.19,1320.83) v2@7293.19,1282.62 ; 7279.83,1280.16 ccw(c7293.19,1293.52) v2@7293.19,1274.62 ; v4@7327.17,622.76 cw(c7316.93,612.51) 7331.42,612.51 cw(c7345.9,612.51) v4@7335.66,622.76 ; U19.12@7331.42,595.67 v4(7331.42,627) ; v4@7366.54,622.76 cw(c7356.3,612.51) 7370.79,612.51 cw(c7385.27,612.51) v4@7375.03,622.76 ; U19.10@7370.79,595.67 v4(7370.79,627) ; v4@7445.28,622.76 cw(c7435.04,612.51) 7449.53,612.51 cw(c7464.01,612.51) v4@7453.77,622.76 ; U19.6@7449.53,595.67 v4(7449.53,627) ; v4@7524.03,931.42 cw(c7513.78,921.18) 7528.27,921.18 cw(c7542.75,921.18) v4@7532.51,931.42 ; U19.41@7528.27,904.33 v4@7528.27,935.37 ; v4(7543,858.27) U19.44@7574.33,858.27 ; v4@7547.24,854.03 cw(c7557.48,843.78) 7557.48,858.27 cw(c7557.49,872.75) v4@7547.24,862.51 ; U19.53@7574.33,681.1 v4(7605.66,681.1) ; v4@7601.42,676.86 ccw(c7591.18,666.62) 7591.18,681.1 ccw(c7591.18,695.59) v4@7601.42,685.34 ; U69.2@8068.87,4747.09 ccw(c8081.36,4746.34) 8072.51,4737.49 ; U69.2@8072.99,4755.7 8072.99,4737.01 8090,4720 8090,4719.8 8089.9,4719.7 8087.3,4719.7 v1(8085,4722) ; U19.26@7282.52,838.58 cw(c7282.52,824.1) 7292.76,834.34 ccw(c7282.52,824.1) U19.26@7282.52,838.58 ; U19.26@7282.52,838.58 ccw(c7282.52,853.07) 7292.76,842.83 cw(c7282.52,853.07) U19.26@7282.52,838.58 ; 8072.99,4737.49 ccw(c8063.63,4737.49) 8070.25,4744.1 cw(c8063.63,4737.49) 8072.99,4737.49 ; 8072.99,4737.49 cw(c8082.34,4737.49) 8075.73,4744.1 ccw(c8082.34,4737.49) 8072.99,4737.49 ; U19.26@7265.67,838.58 v4(7297,838.58) U19.26@7265.67,838.58
  Bottom Layer w10: C343.2@4997.28,4190 C344.2@5034.68,4190 ; C343.2@5002.1,4185.18 cw(c5013.73,4173.56) 5013.73,4190 cw(c5013.73,4206.44) C343.2@5002.1,4194.82 ; 5017.17,4187.17 5017.17,4135 5017.17,4129.76 v3(5035.67,4111.26) ; C344.2@5029.87,4185.18 ccw(c5018.24,4173.56) 5018.24,4190 ccw(c5018.24,4206.44) C344.2@5029.87,4194.82 ; v3@5031.17,4111.26 ccw(c5020.31,4111.26) 5027.99,4118.94 ccw(c5035.67,4126.62) v3@5035.67,4115.76 ; v3@5035.31,3994.25 ccw(c5055,3994.25) 5055,3974.56 5075.04,3974.56 cw(c5075.04,3954.88) 5094.72,3954.88 C346.2@5094.72,3934.72 ; v3@5035.31,4385.75 cw(c5055,4385.75) 5055,4405.44 5075.04,4405.44 ccw(c5075.04,4425.12) 5094.72,4425.12 C354.2@5094.72,4445.28 ; C354.2@5089.52,4440.84 cw(c5076.97,4428.29) 5094.73,4428.29 ; C346.2@5090.15,3938.53 ccw(c5079.12,3949.56) C346.2@5094.72,3949.56 ; 5094.72,3950.75 ccw(c5112.01,3950.75) C346.2@5099.79,3938.53 ; C354.2@5094.73,4430.14 cw(c5109.86,4430.14) C354.2@5099.16,4440.84 ; v3(5311.26,4544.33) 5329.76,4562.83 5387.17,4562.83 ; v3@5311.26,4548.83 ccw(c5311.26,4559.69) 5318.94,4552.01 ccw(c5326.62,4544.33) v3@5315.76,4544.33 ; C355.2@5385.18,3802.1 ccw(c5373.56,3813.73) 5390,3813.73 ccw(c5406.44,3813.73) C355.2@5394.82,3802.1 ; C356.2@5385.18,3829.87 cw(c5373.56,3818.24) 5390,3818.24 cw(c5406.44,3818.24) C356.2@5394.82,3829.87 ; C352.2@5385.18,4550.13 ccw(c5373.56,4561.76) 5390,4561.76 ccw(c5406.44,4561.76) C352.2@5394.82,4550.13 ; C351.2@5385.18,4577.9 cw(c5373.56,4566.27) 5390,4566.27 cw(c5406.44,4566.27) C351.2@5394.82,4577.9 ; C355.2@5390,3797.28 C356.2@5390,3834.68 ; C352.2@5390,4545.32 C351.2@5390,4582.72 ; 5392.83,3817.17 5450.24,3817.17 v3(5468.74,3835.67) ; v3@5464.24,3835.67 cw(c5453.38,3835.67) 5461.06,3827.99 cw(c5468.74,3820.31) v3@5468.74,3831.17 ; C350.2@5680.21,4441.47 cw(c5667.99,4429.25) 5685.27,4429.25 ; C358.2@5680.84,3939.16 ccw(c5670.14,3949.85) C358.2@5685.27,3949.85 ; C358.2@5685.27,3934.72 5685.27,3954.88 cw(c5704.96,3954.88) 5704.96,3974.56 5725,3974.56 ccw(c5725,3994.25) 5744.64,3992.85 ccw(c5725,3994.25) v3@5744.69,3994.25 ; 5685.27,3951.71 ccw(c5703.03,3951.71) C358.2@5690.48,3939.16 ; C350.2@5685.27,4430.44 cw(c5700.88,4430.44) C350.2@5689.85,4441.47 ; C350.2@5685.27,4445.28 5685.27,4425.12 ccw(c5704.96,4425.12) 5704.96,4405.44 5725,4405.44 cw(c5725,4385.75) v3@5744.69,4385.75 ; v3@5744.33,4264.24 cw(c5744.33,4253.38) 5752.01,4261.06 cw(c5759.69,4268.74) v3@5748.83,4268.74 ; v3(5744.33,4268.74) 5762.83,4250.24 5762.83,4192.83 ; C348.2@5745.32,4190 C347.2@5782.72,4190 ; C348.2@5750.13,4185.18 cw(c5761.76,4173.56) 5761.76,4190 cw(c5761.76,4206.44) C348.2@5750.13,4194.82 ; C347.2@5777.9,4185.18 ccw(c5766.27,4173.56) 5766.27,4190 ccw(c5766.27,4206.44) C347.2@5777.9,4194.82 ; v3(7206.85,2022.48) v3@7206.85,2023.11
  Bottom Layer w11.81: v1@6410.51,6421 cw(c6401.42,6408.8) 6416.63,6408.8 ; v1(6413.85,6425.49) 6416.63,6422.71 6416.63,6409.04 C166.2@6430,6395.67 C167.2@6490,6395.67 C167.2@6487.21,6398.46 ; 6416.63,6406.14 ccw(c6433.61,6406.14) C166.2@6428.07,6390.09 ; v1@6419.02,6423.35 ccw(c6436.69,6416.03) C166.2@6423.16,6402.5 ; C166.2@6424.09,6395.67 ccw(c6409.84,6395.67) 6419.92,6405.75 ccw(c6430,6415.83) C166.2@6430,6401.57 ; v4(6424.34,6203.9) 6404.86,6223.37 6403.86,6224.37 6403.86,6252.71 6417.86,6266.71 6438.52,6266.71 6438.52,6262.95 U56.56@6455.67,6262.95 ; C166.2@6434.18,6391.49 cw(c6444.26,6381.41) 6444.26,6395.67 cw(c6444.26,6409.93) C166.2@6434.18,6399.85 ; 6435.45,6266.71 cw(c6435.45,6253.66) U56.56@6444.67,6262.89 ; C167.2@6485.82,6391.49 ccw(c6475.74,6381.41) 6475.74,6395.67 ccw(c6475.74,6409.93) C167.2@6485.82,6399.85 ; v1@6720.98,6345.32 cw(c6720.98,6331.81) 6730.53,6341.36 cw(c6740.09,6350.91) v1@6726.58,6350.91 ; v1(6720.98,6350.91) 6740.19,6331.71 6740.19,6300.35 6737.95,6300.35 U56.14@6737.95,6289.33 6737.95,6287.37 6751.52,6287.37 6753.48,6289.33 6848.66,6289.33 C175.2@6885,6252.99 ; U56.14@6737.89,6300.33 ccw(c6732.32,6305.89) U56.14@6740.19,6305.89 ; 6775.07,6289.33 cw(c6775.07,6185.13) C175.2@6862.83,6241.32 ; 6795,6000.04 6854.29,6000.04 C177.2@6854.33,6000 C176.2@6854.33,5955 6854.33,5914.33 v1(6845,5905) ; 6796.66,6289.33 cw(c6796.66,6198.95) C175.2@6872.77,6247.68 ; 6818.25,6289.33 cw(c6818.25,6212.77) C175.2@6882.72,6254.05 ; 6839.83,6289.33 cw(c6839.83,6226.59) C175.2@6892.67,6260.42 ; 6839.98,6000.04 cw(c6839.98,5985.64) 6850.15,5995.82 cw(c6840.07,5985.74) 6854.33,5985.74 cw(c6868.59,5985.74) C177.2@6858.51,5995.82 ; 6840.17,6000.04 ccw(c6840.17,6014.16) C177.2@6850.15,6004.18 ; v1@6841.04,5908.96 ccw(c6808.97,5941.03) 6854.33,5941.03 ; v1@6849.4,5900.6 ccw(c6837.48,5912.52) 6854.33,5912.52 ; C176.2@6850.15,5950.82 cw(c6840.07,5940.74) 6854.33,5940.74 cw(c6868.59,5940.74) C176.2@6858.51,5950.82 ; C176.2@6850.15,5959.18 ccw(c6840.07,5969.26) 6854.33,5969.26 ccw(c6868.59,5969.26) C176.2@6858.51,5959.18 ; v1@7025.47,5836.72 cw(c7044.54,5833.09) 7044.54,5852.5 ; v1@7027.62,5839.51 ccw(c7018.07,5849.06) 7031.58,5849.06 ccw(c7045.09,5849.06) v1@7035.54,5839.51 ; v1(7031.58,5835.56) 7031.58,5851.58 7032.5,5852.5 R246.2@7058.82,5852.5 ccw(c7058.82,5830.37) v1@7037.08,5834.51 ; R246.2@7054.99,5848.67 ccw(c7045.75,5839.43) 7045.75,5852.5 ccw(c7045.75,5865.57) R246.2@7054.99,5856.33 ; v1(7181.86,883.37) 7235,883.37 7240.2,878.17 U19.28@7265.45,878.17 ; v1@7185.81,879.42 cw(c7195.36,869.87) 7195.36,883.37 cw(c7195.36,896.88) v1@7185.81,887.33 ; C95.2@7300.67,1115 7381.86,1115 7381.86,1039.04 ; C95.2@7304.85,1110.82 cw(c7314.93,1100.74) 7314.93,1115 cw(c7314.93,1129.26) C95.2@7304.85,1119.18 ; 7365.89,1115 ccw(c7365.89,1134.34) v1@7379.57,1120.66 ; 7381.86,1099.18 cw(c7401.05,1099.18) v1@7387.48,1112.75 ; C89.2@7445.29,1190.82 cw(c7420.25,1125.01) C88.1@7490.67,1125.01 ; C89.2@7449.49,1201.86 cw(c7426.77,1142.14) 7490.67,1142.14 ; C89.2@7452.99,1215 7490.67,1177.32 C88.1@7490.67,1115 7520.15,1115 7521.86,1116.71 ; C89.2@7453.69,1212.9 cw(c7433.29,1159.27) 7490.67,1159.27 ; C89.2@7457.89,1223.94 cw(c7439.8,1176.4) C89.2@7490.67,1176.4 ; C88.1@7486.49,1119.18 ccw(c7476.41,1129.26) 7490.67,1129.26 ccw(c7504.93,1129.26) 7494.85,1119.18 ccw(c7504.93,1129.26) 7504.93,1115 ccw(c7504.93,1100.74) C88.1@7494.85,1110.82 ; R109.2@7522.35,1049.32 ccw(c7513.11,1058.56) 7526.18,1058.56 ccw(c7539.25,1058.56) R109.2@7530.01,1049.32 ; R109.2@7526.18,1045 7526.18,1110.68 7521.86,1115 7521.86,1116.71 ; v1@7537.93,1138.37 cw(c7524.42,1138.37) 7533.97,1128.82 cw(c7543.52,1119.27) v1@7543.52,1132.78 ; v1(7543.52,1138.37) 7521.86,1116.71 ; U19.56@7574.33,622.05 7574.93,621.45 7643.79,621.45 7656.86,608.37 ; U19.28@7265.45,878.17 U19.28@7265.67,877.95 U19.28@7265.45,878.17