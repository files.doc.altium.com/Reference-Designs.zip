# Altium PCB NB3000AL.PcbDoc (part 26 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_CLOCKS.FPGA_CLK: R28.1 U8.A14 U8.A15 U8.J27 U30.E2 | length 16488.5
  Top Layer w4: U8.A14@5365.12,4726.69 ccw(c5352.59,4739.22) 5370.32,4739.22 ccw(c5388.04,4739.22) U8.A14@5375.51,4726.69 ; U8.A14@5370.31,4721.5 5370.32,4741.18 5370,4750 5370,4775 5396,4801 ; v1@5389.28,4819.28 cw(c5373.06,4803.06) 5396,4803.06 cw(c5418.93,4803.06) v1@5402.72,4819.28 ; v1@5392.11,4822.11 cw(c5382.72,4812.72) 5396,4812.72 cw(c5409.28,4812.72) v1@5399.89,4822.11 ; v1@5396,4824 5396,4801 ; U8.A15@5404.49,4726.69 ccw(c5391.96,4739.22) 5409.68,4739.22 ccw(c5427.41,4739.22) U8.A15@5414.88,4726.69 ; 5409.58,4750.06 5409.68,4741.18 U8.A15@5409.68,4721.5 ; 5409.58,4750.38 5396,4763.97 5396,4801 ; U8.J27@5882.13,4413.88 ccw(c5882.13,4431.6) 5894.66,4419.07 ; U8.J27@5889.47,4406.54 cw(c5907.19,4406.54) 5894.66,4419.07 ; v2(6057,4366) 6071.81,4351.19 6094.38,4351.19 6104.81,4361.62 6104.81,4376.38 6089.13,4392.06 6033.63,4392.06 6024.69,4401 5995.06,4401 5974.02,4422.04 5949.04,4422.04 5941.18,4422.04 5901.84,4422.04 ccw(c5901.84,4411.89) 5894.66,4419.07 ; v2@6309,4457.24 cw(c6299.52,4445) 6315,4445 ; v2@6309.06,3926.94 ccw(c6292.31,3943.69) 6316,3943.69 ccw(c6339.69,3943.69) v2@6322.94,3926.94 ; v2@6311.44,4460.4 cw(c6305.83,4453.15) 6315,4453.15 cw(c6324.17,4453.15) v2@6318.56,4460.4 ; v2@6311.89,3924.11 ccw(c6301.97,3934.03) 6316,3934.03 ccw(c6330.03,3934.03) v2@6320.11,3924.11 ; v2(6315,4465) 6315,4455.58 6315,4445 ; v2(6316,3920) 6316,3948.82 6295.36,3969.46 6295.36,4011.36 6311.16,4027.16 6321.91,4027.16 6332.5,4037.75 6332.5,4040.5 6332.5,4047.09 ; v2@6321,4457.24 ccw(c6330.48,4445) 6315,4445 ; v2@6378.06,4884.06 cw(c6361.31,4867.31) 6385,4867.31 cw(c6408.69,4867.31) v2@6391.94,4884.06 ; v2@6379.06,4697.94 ccw(c6362.31,4714.69) 6386,4714.69 ccw(c6409.69,4714.69) v2@6392.94,4697.94 ; v2@6380.89,4886.89 cw(c6370.97,4876.97) 6385,4876.97 cw(c6399.03,4876.97) v2@6389.11,4886.89 ; v2@6381.89,4695.11 ccw(c6371.97,4705.03) 6386,4705.03 ccw(c6400.03,4705.03) v2@6390.11,4695.11 ; v2(6385,4891) 6385,4828.98 6381.02,4825 6381.02,4739.98 6386,4735 v2(6386,4691) ; v2(6752,2262) 6738.13,2262 6707,2262 6702,2257 6697,2257 6633,2257 6563.31,2257 6559.29,2252.98 6559.29,2199.29 6550,2190 6548,2188 6548,2048 6554,2042 6564,2042 ; v2(6844,2416) 6863,2416 ; v2@6852,2410.32 cw(c6863,2402.51) 6863,2416 ; v2@6852,2421.68 ccw(c6863,2429.49) 6863,2416 ; v2@6953.06,2397.06 ccw(c6936.31,2380.31) 6936.31,2404 ccw(c6936.31,2427.69) v2@6953.06,2410.94 ; v2@6955.89,2399.89 ccw(c6945.97,2389.97) 6945.97,2404 ccw(c6945.97,2418.03) v2@6955.89,2408.11 ; v2(6960,2404) 6875,2404 6863,2416 ; v2@7100,2502.19 cw(c7100,2464.51) 7126.64,2491.15 ; v2@7100,2506.19 cw(c7100,2478.17) 7119.81,2497.98 ; v2@7100,2510.19 cw(c7100,2491.82) 7112.99,2504.81 ; v2(7100,2512) 7105.8,2512 7128.5,2489.3 7128.5,2465.5 v2(7148,2446) ; v2@7109.81,2512 ccw(c7119.5,2512) 7112.65,2505.15 ; v2@7138.19,2446 ccw(c7114.5,2446) 7131.25,2462.75 ccw(c7148,2479.5) v2@7148,2455.81 ; v2@7142.19,2446 ccw(c7128.16,2446) 7138.08,2455.92 ccw(c7148,2465.84) v2@7148,2451.81 ; v2@7484,2667.24 cw(c7474.52,2655) 7490,2655 ; v2@7486.44,2670.4 cw(c7480.83,2663.15) 7490,2663.15 cw(c7499.17,2663.15) v2@7493.56,2670.4 ; v2(7490,2675) 7490,2655 ; v2@7496,2667.24 ccw(c7505.48,2655) 7490,2655 ; 7549.81,2555.19 7500,2605 7500,2645 7490,2655 ; 7550,2555.19 7581.38,2555.19 7609.57,2527 7707,2527 v2(7720,2540) ; R28.1@8122.23,3517.92 cw(c8106.32,3502.01) 8128.82,3502.01 cw(c8151.32,3502.01) R28.1@8135.41,3517.92 ; R28.1@8125.06,3520.75 cw(c8115.98,3511.67) 8128.82,3511.67 cw(c8141.66,3511.67) R28.1@8132.58,3520.75 ; R28.1@8128.82,3525 8128.82,3458.37 8073.52,3403.08 8073.52,3275.04 8081.56,3267 8200,3267 8225,3242 8225,2950 v2(8253,2922) ; v2@8243.19,2922 ccw(c8219.5,2922) 8236.25,2938.75 ccw(c8253,2955.5) v2@8253,2931.81 ; v2@8247.19,2922 ccw(c8233.16,2922) 8243.08,2931.92 ccw(c8253,2941.84) v2@8253,2927.81 ; 6315,4445 6351,4409 6351,4403.63 ; 6332.36,4052.39 6332.36,4186.14 6330.5,4188 6330.5,4230 6330.5,4250.44 6379.5,4299.45 6379.5,4338.93 ; 6332.36,4052.39 6332.36,4047.23 6332.5,4047.09 ; 6332.36,4052.39 6332.5,4052.25 6332.5,4047.09 ; 6351,4367.43 6379.5,4338.93 ; 6351,4367.43 6379.5,4338.93 ; 6351,4367.43 6351,4390 ; 6351,4390 6351,4403.63 ; 6351,4390 6351,4403.63 ; 6564,2042 6575,2042 ; 6564,2042 6575,2042 ; 6575,2042 6618.81,2042 6629,2031.81 6651.38,2031.81 6664.89,2018.3 6695.04,2018.3 6734.38,2018.3 ; 6734.38,2018.3 cw(c6734.38,2008.15) 6741.56,2015.33 ; 6734.38,2018.3 cw(c6734.38,2008.15) 6741.56,2015.33 ; 6741.56,2015.33 cw(c6729.03,2002.79) 6746.75,2002.79 ccw(c6729.03,2002.79) 6741.56,2015.33 ; 6741.56,2015.33 ccw(c6754.09,2027.86) 6754.09,2010.14 cw(c6754.09,2027.86) 6741.56,2015.33
  MidLayer1 w4: v2(5459.24,2845.69) 5480.69,2845.69 ; v2@5463.63,2841.89 cw(c5471.94,2834.71) 5471.94,2845.69 cw(c5471.94,2856.67) v2@5463.63,2849.49 ; v2@5466.66,2839.27 cw(c5480.69,2827.15) 5480.69,2845.69 ; v2@5466.66,2852.11 ccw(c5480.69,2864.23) 5480.69,2845.69 ; v2@5475.06,3008.06 cw(c5458.31,2991.31) 5482,2991.31 cw(c5505.69,2991.31) v2@5488.94,3008.06 ; v2@5477.89,3010.89 cw(c5467.97,3000.97) 5482,3000.97 cw(c5496.03,3000.97) v2@5486.11,3010.89 ; v2@5486.5,3010.5 v2(5482,3015) 5482,2987.81 5494.81,2975 5494.81,2952.62 5490.12,2947.93 5490.12,2917 5490.12,2855.12 5480.69,2845.69 ; v2(5756,3440) 5754.92,3440 5731.42,3463.5 5716.75,3463.5 5706.5,3453.25 5706.5,3437.48 5728.98,3415 5743.69,3415 5776.41,3382.27 5776.41,3354.55 5776.41,3340 5776.41,3250.04 5748.02,3221.65 5748.02,3067.17 5800.68,3014.51 5800.68,2986.11 5792.06,2977.5 5768.75,2977.5 5758.5,2967.25 5758.5,2941.5 5779.09,2920.91 v1(5779.09,2874.09) ; v1@5772.38,2880.81 ccw(c5756.16,2897.03) 5779.09,2897.03 ccw(c5802.03,2897.03) v1@5785.81,2880.81 ; v1@5775.21,2877.98 ccw(c5765.82,2887.37) 5779.09,2887.37 ccw(c5792.37,2887.37) v1@5782.98,2877.98 ; v2(6057,4366) 6073,4350 ; v2@6057.19,4360.19 cw(c6057.6,4347.65) 6066.48,4356.52 cw(c6075.35,4365.4) v2@6062.81,4365.81 ; v2@6057.32,4356.19 cw(c6058.02,4335.02) 6073,4350 ; v2@6066.81,4365.68 ccw(c6087.98,4364.98) 6073,4350 ; v2@6089.06,3386.94 ccw(c6072.31,3403.69) 6096,3403.69 ccw(c6119.69,3403.69) v2@6102.94,3386.94 ; v2@6091.89,3384.11 ccw(c6081.97,3394.03) 6096,3394.03 ccw(c6110.03,3394.03) v2@6100.11,3384.11 ; v2(6096,3380) 6096,3406 6110.5,3420.5 6110.5,3435 6110.5,3529.98 6089.7,3550.79 6089.7,3626.7 6113.5,3650.5 v2(6113.5,3651.06) ; 6096.36,3633.36 ccw(c6078.65,3651.06) v2@6103.69,3651.06 ; 6097.71,3634.71 cw(c6113.5,3618.92) v2@6113.5,3641.25 ; 6103.18,3640.18 ccw(c6092.31,3651.06) v2@6107.69,3651.06 ; v2@6104,4482 6100,4482 6097,4485 v2(6097,4487) 6097,4502.87 6101.67,4507.54 6125.67,4507.54 6128,4509.87 6210.67,4592.54 6239.54,4592.54 6255,4592.54 6274.77,4592.54 6280.31,4587 v2(6306,4587) ; 6104.54,3641.54 cw(c6113.5,3632.58) v2@6113.5,3645.25 ; 6247.19,4463 6244.82,4460.63 ; v2@6299.06,4580.06 ccw(c6282.31,4563.31) 6282.31,4587 ccw(c6282.31,4610.69) v2@6299.06,4593.94 ; v2@6301.89,4582.89 ccw(c6291.97,4572.97) 6291.97,4587 ccw(c6291.97,4601.03) v2@6301.89,4591.11 ; v2@6308.06,4458.06 ccw(c6291.31,4441.31) 6291.31,4465 ccw(c6291.31,4488.69) v2@6308.06,4471.94 ; v2@6309,4463 6311,4461 v2@6315,4457 ; v2@6310.89,4460.89 ccw(c6300.97,4450.97) 6300.97,4465 ccw(c6300.97,4479.03) v2@6310.89,4469.11 ; v2(6315,4465) 6249.19,4465 6244.82,4460.63 ; v2@6953.06,2410.94 ccw(c6936.31,2427.69) 6960,2427.69 ccw(c6983.69,2427.69) v2@6966.94,2410.94 ; v2@6955.89,2408.11 ccw(c6945.97,2418.03) 6960,2418.03 ccw(c6974.03,2418.03) v2@6964.11,2408.11 ; v2(6960,2404) 6960,2490.25 ; 6977.25,2507.5 6960,2490.25 ; v2(7100,2512) 7085.19,2497.19 7062.62,2497.19 7060.25,2499.56 7019.63,2499.56 7005.38,2513.81 6983.56,2513.81 6960,2490.25 ; v2@7490,2673.5 v2(7490,2675) ; v2@7613.12,1983.4 ccw(c7607.71,1992.38) 7618.19,1992.38 ; v2@7623.26,1983.4 cw(c7628.67,1992.38) 7618.19,1992.38 ; v2@7625.81,1980.81 7620,1975 v2(7618.19,1975) 7618.19,1992.38 ; v2@7713.5,2532.65 cw(c7700.71,2518.21) 7720,2518.21 ; v2@7716.15,2535.65 cw(c7708.57,2527.09) 7720,2527.09 cw(c7731.43,2527.09) v2@7723.85,2535.65 ; v2(7720,2540) 7720,2518.21 ; v2@7726.5,2532.65 ccw(c7739.29,2518.21) 7720,2518.21 ; v2(8026,2312) 8152,2438 8152,2692 8253,2793 v2(8253,2922) ; v2@8026,2317.81 ccw(c8026,2331.84) 8035.92,2321.92 ccw(c8045.84,2312) v2@8031.81,2312 ; v2@8026,2321.81 ccw(c8026,2345.5) 8042.75,2328.75 ccw(c8059.5,2312) v2@8035.81,2312 ; v2@8246.06,2915.06 cw(c8229.31,2898.31) 8253,2898.31 cw(c8276.69,2898.31) v2@8259.94,2915.06 ; v2@8248.89,2917.89 cw(c8238.97,2907.97) 8253,2907.97 cw(c8267.03,2907.97) v2@8257.11,2917.89 ; 6073,4350 6134.19,4350 6244.82,4460.63 ; 7618.19,1992.38 7625.81,2000 7625.81,2026.69 7612.19,2040.31 7612.19,2054.69 7636,2078.5 7674.25,2078.5 7684.5,2088.75 7684.5,2111.69 7704.62,2131.81 7717.09,2131.81 7750.61,2165.33 7750.61,2188.83 7750.61,2397.18 7734.19,2413.59 7734.19,2504.02 7720,2518.21
  MidLayer2 w4: v1(5396,4826) 5391.19,4830.81 5391.19,4860.19 5441.24,4910.24 5448.5,4917.5 5457.75,4917.5 5472.25,4917.5 5482.5,4927.75 5526.12,4971.37 5555,4971.37 5625.21,4971.37 5647.04,4993.21 5963.65,4993.21 5973.86,4983 v2(6029,4983) ; v2(5459.24,2845.69) 5567.6,2845.69 5604.81,2808.48 5615.8,2808.48 5615.94,2808.63 5669.32,2808.63 5701.42,2776.52 5705.1,2776.52 5811.63,2670 5909.44,2670 5921.69,2682.25 5940.12,2682.25 6052.37,2570 6294.98,2570 6356.36,2508.62 6356.36,2408.87 6356.36,2400 6356.36,2286.33 v1(6394.31,2248.38) ; v2@5463.35,2841.58 cw(c5473.27,2831.66) 5473.27,2845.69 cw(c5473.27,2859.72) v2@5463.35,2849.8 ; v2@5466.18,2838.75 cw(c5482.92,2822) 5482.92,2845.69 cw(c5482.92,2869.37) v2@5466.18,2852.63 ; v2@5749.06,3446.94 ccw(c5732.31,3463.69) 5756,3463.69 ccw(c5779.69,3463.69) v2@5762.94,3446.94 ; v2@5751.89,3444.11 ccw(c5741.97,3454.03) 5756,3454.03 ccw(c5770.03,3454.03) v2@5760.11,3444.11 ; v2(5756,3440) 5756,3468.35 5768.88,3481.23 ; 5767.49,3479.78 5798.59,3510.87 5821.87,3510.87 5836.04,3496.71 5844.94,3487.81 6012.38,3487.81 6054.7,3445.49 6054.7,3425 6054.7,3413.55 6054.7,3404.18 6078.88,3380 ; v2@6022.06,4976.06 ccw(c6005.31,4959.31) 6005.31,4983 ccw(c6005.31,5006.69) v2@6022.06,4989.94 ; v2@6024.89,4978.89 ccw(c6014.97,4968.97) 6014.97,4983 ccw(c6014.97,4997.03) v2@6024.89,4987.11 ; v2@6058.98,3942.94 cw(c6042.45,3926.31) 6065.9,3926.31 ; v2@6061.8,3945.78 cw(c6052.01,3935.93) 6065.9,3935.93 cw(c6079.79,3935.93) v2@6070,3945.78 ; v2@6067.21,3948.59 v2(6065.9,3949.9) 6065.9,3926.31 ; v2@6072.82,3942.94 ccw(c6089.35,3926.31) 6065.9,3926.31 ; v2@6087.54,3375.04 ccw(c6078.88,3369.97) 6078.88,3380 ; v2@6087.54,3384.96 cw(c6078.88,3390.03) 6078.88,3380 ; v2(6096,3380) 6078.88,3380 ; v2@6307.26,3915.55 ccw(c6300,3911.86) 6300,3920 ; v2@6307.26,3924.45 cw(c6300,3928.14) 6300,3920 ; v2(6316,3920) 6300,3920 ; v1@6384.81,2248.38 ccw(c6361.88,2248.38) 6378.09,2264.6 ccw(c6394.31,2280.81) v1@6394.31,2257.88 ; v1@6388.81,2248.38 ccw(c6375.53,2248.38) 6384.92,2257.77 ccw(c6394.31,2267.16) v1@6394.31,2253.88 ; v2@7618.19,1980.81 ccw(c7618.19,1994.84) 7628.11,1984.92 ccw(c7638.03,1975) v2@7624,1975 ; v2@7618.19,1984.81 ccw(c7618.19,2008.5) 7634.94,1991.75 ccw(c7651.69,1975) v2@7628,1975 ; v2@7627,1975 v2(7618.19,1975) 7658.93,2015.74 7663,2019.81 7681,2037.81 7689.81,2037.81 7715,2037.81 7720,2037.81 7761.98,2037.81 7774.19,2037.81 v2(7800,2012) ; v2@7790.19,2012 ccw(c7766.5,2012) 7783.25,2028.75 ccw(c7800,2045.5) v2@7800,2021.81 ; v2@7794.19,2012 ccw(c7780.16,2012) 7790.08,2021.92 ccw(c7800,2031.84) v2@7800,2017.81 ; 6065.9,3926.31 6067.21,3925 6067.21,3913.23 6071.3,3909.14 6080.04,3900.4 6119.8,3900.4 6136.28,3916.88 6271.38,3916.88 6272.75,3915.5 6295.5,3915.5 6300,3920
  Bottom Layer w4: v2@5477.09,3006.5 cw(c5472.18,2998) 5482,2998 ; v2(5482,3015) 5482,2998 ; v2@5486.91,3006.5 ccw(c5491.82,2998) 5482,2998 ; 5762.3,2891.7 cw(c5744.7,2874.09) v1@5769.59,2874.09 ; 5764.26,2889.74 ccw(c5779.09,2904.57) v1@5779.09,2883.59 ; 5769.13,2884.87 cw(c5758.36,2874.09) v1@5773.59,2874.09 ; 5771.09,2882.91 ccw(c5779.09,2890.91) v1@5779.09,2879.59 ; v1@5779.5,2874.5 5748.81,2905.19 5670.04,2905.19 5610.12,2965.12 5601.02,2974.21 5572.54,2974.21 5505.79,2974.21 5482,2998 ; v2(6029,4983) 6071,5025 6071,5057 6071,5066 6097,5092 6150,5092 6180,5092 6212.17,5092 6304.46,4999.71 6335,4999.71 6352.29,4999.71 6384,4968 v2@6384,4892 ; v2@6029,4988.81 ccw(c6029,5002.84) 6038.92,4992.92 ccw(c6048.84,4983) v2@6034.81,4983 ; v2@6029,4992.81 ccw(c6029,5016.5) 6045.75,4999.75 ccw(c6062.5,4983) v2@6038.81,4983 ; 6036.96,4390.7 cw(c6012.26,4366) v2@6047.19,4366 ; 6043.79,4383.87 cw(c6025.91,4366) v2@6051.19,4366 ; 6048.2,4379.45 ccw(c6057,4388.25) v2@6057,4375.81 ; v2@6050,4364 6050,4377.66 5998.58,4429.08 5975.7,4429.08 5972.19,4432.59 5972.19,4461.19 5983.5,4472.5 6010,4472.5 6017.5,4480 6045,4480 6052.5,4487.5 6096.5,4487.5 v2(6097,4487) ; 6050.61,4377.04 cw(c6039.57,4366) v2@6055.19,4366 ; v2@6058.96,3956.84 ccw(c6042.21,3973.59) 6065.9,3973.59 ccw(c6089.59,3973.59) v2@6072.84,3956.84 ; v2@6061.79,3954.01 ccw(c6051.87,3963.93) 6065.9,3963.93 ccw(c6079.93,3963.93) v2@6070.01,3954.01 ; v2(6065.9,3949.9) 6065.9,4002.9 6060,4008.8 6041.95,4008.8 6027.45,4008.8 6008.19,3989.54 6008.19,3950 6008.19,3910.56 6045.25,3873.5 6055.5,3863.25 6055.5,3757 6096.29,3716.21 6117.42,3716.21 6118.25,3717.04 6133.71,3717.04 6143,3707.75 6143,3692.29 6143,3684.14 6113.5,3654.64 v2(6113.5,3651.06) ; v2@6113.5,3660.87 ccw(c6113.5,3675.93) 6124.15,3665.28 ; v2@6119.31,3651.06 cw(c6141.97,3651.06) 6125.95,3667.08 ; v2@6123.31,3651.06 cw(c6155.63,3651.06) 6132.78,3673.91 ; v2@6299.06,4593.94 ccw(c6282.31,4610.69) 6306,4610.69 ccw(c6329.69,4610.69) v2@6312.94,4593.94 ; v2@6301.89,4591.11 ccw(c6291.97,4601.03) 6306,4601.03 ccw(c6320.03,4601.03) v2@6310.11,4591.11 ; v2(6306,4587) 6306,4663 6306,4671 6326,4691 v2(6386,4691) ; v2@6378.06,4897.94 ccw(c6363.73,4912.27) 6384,4912.27 ; v2@6379.06,4684.06 ccw(c6362.31,4667.31) 6362.31,4691 ccw(c6362.31,4714.69) v2@6379.06,4697.94 ; v2@6381.89,4686.89 ccw(c6371.97,4676.97) 6371.97,4691 ccw(c6371.97,4705.03) v2@6381.89,4695.11 ; 6384,4907.44 ccw(c6401.44,4907.44) v2@6389.11,4895.11 ; 6384,4917.1 ccw(c6411.1,4917.1) v2@6391.94,4897.94 ; v1@6387.81,2248.38 cw(c6404.55,2248.38) 6392.71,2260.22 ; v1@6391.81,2248.38 cw(c6418.21,2248.38) 6399.54,2267.05 ; v1(6394.31,2248.38) 6394.31,2261.81 6458.54,2326.04 6488.21,2326.04 6508.15,2345.98 6527.51,2365.34 6546.21,2384.04 6552.84,2384.04 6590,2384.04 6664.44,2384.04 6696.67,2351.81 6717.38,2351.81 6752,2317.19 v2(6752,2262) ; v1@6395.81,2248.38 cw(c6431.87,2248.38) 6406.37,2273.88 ; v1@6399.81,2248.38 cw(c6445.52,2248.38) 6413.2,2280.7 ; v1@6403.81,2248.38 cw(c6459.18,2248.38) 6420.03,2287.53 ; 6664.24,2384.24 6700.4,2420.4 6719.63,2420.4 6724.22,2415.81 ; v2@6745.06,2268.94 ccw(c6728.31,2285.69) 6752,2285.69 ccw(c6775.69,2285.69) v2@6758.94,2268.94 ; v2@6747.89,2266.11 ccw(c6737.97,2276.03) 6752,2276.03 ccw(c6766.03,2276.03) v2@6756.11,2266.11 ; 6819.86,2415.81 ccw(c6819.86,2440.14) v2@6837.06,2422.94 ; 6820.77,2415.81 cw(c6820.77,2392.77) v2@6837.06,2409.06 ; 6829.51,2415.81 ccw(c6829.51,2430.49) v2@6839.89,2420.11 ; 6830.43,2415.81 cw(c6830.43,2402.43) v2@6839.89,2411.89 ; v2(6844,2416) 6843.81,2415.81 6747.38,2415.81 ; v2(7148,2446) 7298.31,2596.31 7320.17,2596.31 7398.57,2674.71 7487.29,2674.71 7488.5,2673.5 v2@7490,2672 ; v2@7148,2451.81 ccw(c7148,2465.84) 7157.92,2455.92 ccw(c7167.84,2446) v2@7153.81,2446 ; v2@7148,2455.81 ccw(c7148,2479.5) 7164.75,2462.75 ccw(c7181.5,2446) v2@7157.81,2446 ; 7465.61,2674.71 ccw(c7465.61,2699.39) v2@7483.06,2681.94 ; 7467.02,2674.71 cw(c7467.02,2652.02) v2@7483.06,2668.06 ; 7475.27,2674.71 ccw(c7475.27,2689.73) v2@7485.89,2679.11 ; 7476.68,2674.71 cw(c7476.68,2661.68) v2@7485.89,2670.89 ; v2@7488,2666 7490,2668 v2@7490,2672 ; v2(7490,2675) v2@7490,2672 ; v2(7800,2012) 7859.5,2071.5 7866.65,2071.5 7890,2071.5 7964.3,2071.5 7974.36,2081.56 7999.19,2106.39 7999.19,2285.19 ; v2@7800,2017.81 ccw(c7800,2031.84) 7809.92,2021.92 ccw(c7819.84,2012) v2@7805.81,2012 ; v2@7800,2021.81 ccw(c7800,2045.5) 7816.75,2028.75 ccw(c7833.5,2012) v2@7809.81,2012 ; 6724.22,2415.81 6747.38,2415.81 ; 6724.22,2415.81 6747.38,2415.81 ; 7999.19,2285.19 v2(8026,2312) 7999.19,2285.19 ; 8009.25,2295.25 cw(c8026,2278.5) 8026,2302.19 ccw(c8026,2278.5) 8009.25,2295.25 ; 8009.25,2295.25 ccw(c7992.5,2312) 8016.19,2312 cw(c7992.5,2312) 8009.25,2295.25 ; 8016.08,2302.08 cw(c8026,2292.16) 8026,2306.19 ccw(c8026,2292.16) 8016.08,2302.08 ; 8016.08,2302.08 ccw(c8006.16,2312) 8020.19,2312 cw(c8006.16,2312) 8016.08,2302.08
DB_CLOCKS.FPGA_CLK1: R153.2 U8.AG15 U8.B15 U8.J2 | length 8244.8
  Top Layer w4: v2@4346.15,4814.83 cw(c4329.4,4798.08) 4353.09,4798.08 cw(c4376.77,4798.08) v2@4360.02,4814.83 ; v2@4348.98,4817.66 cw(c4339.06,4807.74) 4353.09,4807.74 cw(c4367.12,4807.74) v2@4357.2,4817.66 ; v2(4353.09,4821.76) 4353.09,4696.87 4364.51,4685.45 4364.51,4648.12 4346.02,4629.63 4346.02,4546.94 4346.02,4532.45 4360.93,4517.54 4374.25,4517.54 4392.58,4499.21 4421.11,4499.21 4431.36,4509.46 4431.36,4510.86 4454.37,4533.87 4554.94,4533.87 4564.62,4524.19 4572.56,4524.19 4583.5,4513.25 4583.5,4461.75 4596.75,4448.5 4612.93,4448.5 4619.02,4454.59 4737.23,4454.59 4754.06,4437.77 4799,4437.77 ; 4815.02,4437.77 4799,4437.77 ; 4838.82,4422.04 4833.01,4422.04 4817.28,4437.77 4799,4437.77 ; 4839.96,4422.04 4878.16,4422.04 cw(c4878.16,4411.89) 4885.34,4419.07 ; U8.J2@4890.53,4406.54 ccw(c4872.81,4406.54) 4885.34,4419.07 ; U8.J2@4897.87,4413.88 cw(c4897.87,4431.6) 4885.34,4419.07 ; v1(5363.5,3505.5) 5363.5,3530 5363.5,3551.5 5425.42,3613.42 5425.42,3615 5425.42,3620 5425.42,3632.58 5425.2,3632.8 5425.19,3638.82 5425.19,3678.16 ccw(c5415.04,3678.16) 5422.22,3685.34 ; v1@5366.4,3502.6 v1@5369,3502.6 ; U8.AG15@5409.68,3690.53 cw(c5409.68,3672.8) 5422.22,3685.34 ; U8.B15@5409.68,4689.47 ccw(c5409.68,4707.19) 5422.22,4694.66 ; U8.AG15@5417.03,3697.87 ccw(c5434.75,3697.87) 5422.22,3685.34 ; U8.B15@5417.03,4682.13 cw(c5434.75,4682.13) 5422.22,4694.66 ; v12@5417.21,4764.4 5417.21,4764.27 5417.42,4764.06 5425,4756.49 5425,4750.58 5425.19,4741.18 5425.19,4701.84 cw(c5415.04,4701.84) 5422.22,4694.66 ; v1@6015,5145.5 cw(c6015,5122.56) 6031.22,5138.78 cw(c6047.43,5155) v1@6024.5,5155 ; v1@6015,5149.5 cw(c6015,5136.22) 6024.39,5145.61 cw(c6033.78,5155) v1@6020.5,5155 ; v1@6020,5155 v1(6015,5155) 6040,5130 6435,5130 6457.35,5107.65 6457.35,4968.28 6418.72,4929.65 6418.72,4743.97 6412.69,4737.94 6412.69,4476.58 6408.36,4472.25 6408.36,4444.5 6427.5,4425.36 6427.5,4392.75 6427.5,4279.56 6378.5,4230.56 6378.5,4209.44 6407.5,4180.44 6407.5,4072.75 ; v1(6380,3505) 6430,3555 6430,3823.65 6375,3878.65 6375,3987.5 6372.5,3990 6372.5,4037.75 6407.5,4072.75 ; v1@6380,3510.5 ccw(c6380,3523.78) 6389.39,3514.39 ccw(c6398.78,3505) v1@6385.5,3505 ; v1@6380,3514.5 ccw(c6380,3537.43) 6396.22,3521.22 ccw(c6412.43,3505) v1@6389.5,3505 ; 6397.25,4062.5 6407.5,4072.75
  MidLayer1 w4: v2@4793,4910.39 cw(c4776.26,4893.64) 4799.94,4893.64 cw(c4823.63,4893.64) v2@4806.88,4910.39 ; v2@4795.83,4913.22 cw(c4785.91,4903.3) 4799.94,4903.3 cw(c4813.97,4903.3) v2@4804.05,4913.22 ; v2@4797.07,4802.8 ccw(c4780.32,4819.55) 4804.01,4819.55 ccw(c4827.69,4819.55) v2@4810.95,4802.8 ; v2@4799.94,4799.93 v2(4804.01,4795.86) 4804.01,4855.93 4799.94,4860 v2(4799.94,4917.33) ; v2@4799.9,4799.97 ccw(c4789.98,4809.89) 4804.01,4809.89 ccw(c4818.04,4809.89) v2@4808.12,4799.97
  Bottom Layer w4: v2(4353.09,4821.76) 4423.86,4892.54 4594.11,4892.54 4601.65,4885 4713.82,4885 4761.01,4837.81 4762.06,4837.81 v2(4804.01,4795.86) ; v2@4353.09,4827.58 ccw(c4353.09,4841.6) 4363.01,4831.68 ccw(c4372.93,4821.76) v2@4358.9,4821.76 ; v2@4353.09,4831.58 ccw(c4353.09,4855.26) 4369.84,4838.51 ccw(c4386.58,4821.76) v2@4362.9,4821.76 ; v2@4794.2,4795.86 ccw(c4770.51,4795.86) 4787.26,4812.61 ccw(c4804.01,4829.36) v2@4804.01,4805.67 ; v2@4798.2,4795.86 ccw(c4784.17,4795.86) 4794.09,4805.78 ccw(c4804.01,4815.7) v2@4804.01,4801.67 ; v2(4799.94,4917.33) 4802.39,4914.87 4830,4914.87 4839.11,4914.87 4841.58,4917.34 4866.77,4942.54 4951.48,4942.54 4966,4942.54 5011.11,4942.54 5044.77,4908.87 5103.69,4908.87 5132.69,4937.87 5132.69,4943.75 5167.76,4978.82 5280.54,4978.82 5307.62,4951.75 5307.62,4836.8 5322.81,4821.61 5322.81,4787.88 5346,4764.69 v12(5418.04,4764.69) ; v2@4804.05,4921.44 ccw(c4819.89,4937.28) 4819.89,4914.87 ; v2@4806.88,4910.39 cw(c4817.71,4899.56) 4817.71,4914.87 ; v2@4806.88,4924.26 ccw(c4829.55,4946.93) 4829.55,4914.87 ; v1@5363.5,3496 cw(c5363.5,3470.53) 5381.51,3488.54 ; v1@5363.5,3500 cw(c5363.5,3484.19) 5374.68,3495.37 ; v1(5363.5,3505.5) 5364.55,3505.5 5394.8,3475.25 5394.8,3474.75 5410.15,3459.4 5451.65,3459.4 5461.9,3449.15 5461.9,3403.58 5549.61,3315.87 5573.69,3315.87 ; v1@5369,3505.5 ccw(c5379.75,3505.5) 5372.15,3497.9 ; v1@5373,3505.5 ccw(c5393.4,3505.5) 5378.98,3491.07 ; v12@5412.74,4759.39 ccw(c5399.94,4746.58) 5399.94,4764.69 ccw(c5399.94,4782.8) v12@5412.74,4769.99 ; v12@5416.67,4762.66 5418.04,4762.66 5451.85,4762.66 5483.5,4794.31 5483.5,4856.69 5467.38,4872.81 5458.03,4872.81 ; v12@5420.52,4767.16 ccw(c5431.4,4778.04) 5431.4,4762.66 ; v12@5423.35,4759.39 cw(c5431.25,4751.49) 5431.25,4762.66 ; v12@5423.35,4769.99 ccw(c5441.06,4787.7) 5441.06,4762.66 ; 5787.09,5063.14 cw(c5816.18,5034.04) R153.2@5816.18,5075.19 ; 5793.91,5069.97 cw(c5816.18,5047.7) R153.2@5816.18,5079.19 ; 5800.74,5076.79 cw(c5816.18,5061.36) R153.2@5816.18,5083.19 ; R153.2@5809.59,5092.08 ccw(c5793.68,5107.99) 5816.18,5107.99 ccw(c5838.68,5107.99) R153.2@5822.77,5092.08 ; R153.2@5812.42,5089.25 ccw(c5803.34,5098.33) 5816.18,5098.33 ccw(c5829.02,5098.33) R153.2@5819.94,5089.25 ; v1@6008.28,5148.28 ccw(c5992.06,5132.06) 5992.06,5155 ccw(c5992.06,5177.93) v1@6008.28,5161.72 ; v1@6011.11,5151.11 ccw(c6001.72,5141.72) 6001.72,5155 ccw(c6001.72,5168.28) v1@6011.11,5158.89 ; v1(6015,5155) 5851.31,5155 5816.18,5119.87 R153.2@5816.18,5085 5808.95,5085 5754.59,5030.64 5400.76,5030.64 5394.27,5037.12 5379.78,5037.12 5369.52,5026.87 5369.52,5012.38 5381.02,5000.87 5389.11,5000.87 5393.02,5000.87 5397.02,5004.87 5440.77,5004.87 ; v1(6380,3505) 6370,3495 6354.4,3495 6319.4,3460 6291.57,3460 6280.77,3449.21 6266.28,3449.21 6245.13,3470.36 6201.82,3470.36 6178.96,3447.5 5997.5,3447.5 5977.46,3467.54 5933.81,3467.54 5867.35,3401.08 5678.77,3401.08 5678.69,3401 5658.82,3401 5651.78,3393.96 5584.46,3326.65 5583.31,3325.49 ; 5439.5,4891.34 5458.03,4872.81 ; 5439.5,4891.34 5458.03,4872.81 ; 5439.5,4891.34 5439.5,4965.81 5439.5,4968.6 5451.02,4980.13 5451.02,4994.62 ; 5440.77,5004.87 5451.02,4994.62 ; 5440.77,5004.87 5451.02,4994.62 ; 5573.69,3315.87 5583.31,3325.49 ; 5573.69,3315.87 5583.31,3325.49
DB_CLOCKS.REF_CLK: R29.1 U30.M15 U70.1 | length 4540.4
  Top Layer w4: v1@7429,1701 7418.3,1711.7 7324.96,1711.7 7285.62,1711.7 ; R29.1@7829.59,3517.92 cw(c7813.68,3502.01) 7836.18,3502.01 cw(c7858.68,3502.01) R29.1@7842.77,3517.92 ; R29.1@7832.42,3520.75 cw(c7823.34,3511.67) 7836.18,3511.67 cw(c7849.02,3511.67) R29.1@7839.94,3520.75 ; R29.1@7836.18,3525 7836.18,3490 7846.52,3479.66 v1(7846.52,3438.37) ; v1@7839.81,3445.09 ccw(c7823.59,3461.31) 7846.52,3461.31 ccw(c7869.46,3461.31) v1@7853.24,3445.09 ; v1@7842.64,3442.26 ccw(c7833.25,3451.65) 7846.52,3451.65 ccw(c7859.8,3451.65) v1@7850.41,3442.26 ; 7278.44,1714.67 ccw(c7285.62,1721.85) 7285.62,1711.7 ; 7278.44,1714.67 ccw(c7285.62,1721.85) 7285.62,1711.7 ; 7278.44,1714.67 cw(c7290.97,1727.2) 7273.25,1727.2 ccw(c7290.97,1727.2) 7278.44,1714.67 ; 7278.44,1714.67 ccw(c7265.91,1702.14) 7265.91,1719.86 cw(c7265.91,1702.14) 7278.44,1714.67
  MidLayer1 w4: v1(7618.88,1587.12) 7737.12,1587.12 7848,1698 7848,1844 v1(7920,1916) ; v1@7622.77,1583.23 cw(c7632.16,1573.84) 7632.16,1587.12 cw(c7632.16,1600.4) v1@7622.77,1591.01 ; v1@7625.6,1580.4 cw(c7641.82,1564.18) 7641.82,1587.12 cw(c7641.82,1610.05) v1@7625.6,1593.84 ; v1@7910.5,1916 cw(c7887.56,1916) 7903.78,1899.78 cw(c7920,1883.56) v1@7920,1906.5 ; v1@7914.5,1916 cw(c7901.22,1916) 7910.61,1906.61 cw(c7920,1897.22) v1@7920,1910.5 ; v1@8190.28,3717.28 cw(c8170.39,3697.39) 8198.52,3697.39 ; v1@8191.81,3431.66 cw(c8175.59,3415.44) 8198.52,3415.44 cw(c8221.46,3415.44) v1@8205.24,3431.66 ; v1@8191.81,3445.09 ccw(c8175.59,3461.31) 8198.52,3461.31 ccw(c8221.46,3461.31) v1@8205.24,3445.09 ; v1@8193.11,3720.11 cw(c8180.04,3707.04) 8198.52,3707.04 ; v1@8194.64,3434.49 cw(c8185.25,3425.1) 8198.52,3425.1 cw(c8211.8,3425.1) v1@8202.41,3434.49 ; v1@8194.64,3442.26 ccw(c8185.25,3451.65) 8198.52,3451.65 ccw(c8211.8,3451.65) v1@8202.41,3442.26 ; 8198.52,3704.74 cw(c8216.26,3704.74) v1@8203.72,3717.28 ; v1@8198.52,3724 v1(8198.52,3438.37) 8198.52,3325.04 8240.19,3283.37 8240.19,3016.71 v1(8273.52,2983.37) ; v1@8264.02,2983.37 ccw(c8241.09,2983.37) 8257.31,2999.59 ccw(c8273.52,3015.81) v1@8273.52,2992.87 ; v1@8268.02,2983.37 ccw(c8254.75,2983.37) 8264.13,2992.76 ccw(c8273.52,3002.15) v1@8273.52,2988.87
  MidLayer2 w4: v1(7846.52,3438.37) v1(8198.52,3438.37) ; v1@7850.41,3434.49 cw(c7859.8,3425.1) 7859.8,3438.37 cw(c7859.8,3451.65) v1@7850.41,3442.26 ; v1@7853.24,3431.66 cw(c7869.46,3415.44) 7869.46,3438.37 cw(c7869.46,3461.31) v1@7853.24,3445.09 ; v1(7920,1916) 7962.69,1916 8007.19,1960.5 8007.19,2397.19 8090,2480 8090,2895 8178.37,2983.37 v1(8273.52,2983.37) ; v1@7923.89,1912.11 cw(c7933.28,1902.72) 7933.28,1916 cw(c7933.28,1929.28) v1@7923.89,1919.89 ; v1@7926.72,1909.28 cw(c7942.94,1893.06) 7942.94,1916 cw(c7942.94,1938.93) v1@7926.72,1922.72 ; v1@8191.81,3431.66 ccw(c8175.59,3415.44) 8175.59,3438.37 ccw(c8175.59,3461.31) v1@8191.81,3445.09 ; v1@8194.64,3434.49 ccw(c8185.25,3425.1) 8185.25,3438.37 ccw(c8185.25,3451.65) v1@8194.64,3442.26 ; v1@8266.81,2976.66 ccw(c8250.59,2960.44) 8250.59,2983.37 ccw(c8250.59,3006.31) v1@8266.81,2990.09 ; v1@8269.64,2979.49 ccw(c8260.25,2970.1) 8260.25,2983.37 ccw(c8260.25,2996.65) v1@8269.64,2987.26
  Bottom Layer w4: v1(7430,1700) 7467.66,1700 7477.66,1690 7477.66,1642.34 7532.88,1587.12 v1(7618.88,1587.12) ; v1@7433.89,1696.11 cw(c7443.28,1686.72) 7443.28,1700 cw(c7443.28,1713.28) v1@7433.89,1703.89 ; v1@7436.72,1693.28 cw(c7452.94,1677.06) 7452.94,1700 cw(c7452.94,1722.93) v1@7436.72,1706.72 ; v1@7612.16,1580.4 ccw(c7595.95,1564.18) 7595.95,1587.12 ccw(c7595.95,1610.05) v1@7612.16,1593.84 ; v1@7614.99,1583.23 ccw(c7605.6,1573.84) 7605.6,1587.12 ccw(c7605.6,1600.4) v1@7614.99,1591.01 ; U70.1@8111.26,3883.67 8161.33,3883.67 8177.33,3883.67 8186,3875 8186,3750.12 8197,3739.12 v1(8197,3724) v1@8195,3726
DB_JTAG.HARD.TCK: R69.1 U30.B6 | length 2559.1
  Top Layer w4: v2(6736,2436) 6750,2436 6774,2436 6786,2424 6786,2396.81 6786,2380 6786,2357.31 6801.11,2342.21 6844.75,2342.21 6895.73,2291.23 6895.73,2140.95 6896.07,2140.62 ; 6896.07,2140.62 ccw(c6906.22,2140.62) 6899.04,2133.44 ; 6896.07,2140.62 ccw(c6906.22,2140.62) 6899.04,2133.44 ; 6899.04,2133.44 ccw(c6911.57,2145.97) 6911.57,2128.25 cw(c6911.57,2145.97) 6899.04,2133.44 ; 6899.04,2133.44 cw(c6886.51,2120.91) 6904.23,2120.91 ccw(c6886.51,2120.91) 6899.04,2133.44
  MidLayer1 w4: v1@6100.95,2892.6 cw(c6091.26,2880.38) 6106.86,2880.38 ; v1@6107.69,2899.21 v1(6106.86,2900.04) 6106.86,2880.38 ; v1@6112.76,2892.6 ccw(c6122.46,2880.38) 6106.86,2880.38 ; 6630.45,2280.45 6615,2265 ; v2@6729.06,2429.06 ccw(c6712.31,2412.31) 6712.31,2436 ccw(c6712.31,2459.69) v2@6729.06,2442.94 ; v2@6731.89,2431.89 ccw(c6721.97,2421.97) 6721.97,2436 ccw(c6721.97,2450.03) v2@6731.89,2440.11 ; v2(6736,2436) 6696,2436 6630.65,2370.65 6630.65,2280.65 6615,2265 ; 6106.86,2880.38 6107.69,2879.54 6160.52,2826.71 6160.52,2761.27 6156.86,2757.61 6156.86,2645 6156.86,2618.14 6156.86,2506 6188.15,2474.71 6257.99,2474.71 6272.7,2460 6272.7,2354.81 6360.79,2266.71 6510,2266.71 6550.19,2266.71 6551.9,2265 6615,2265
  Bottom Layer w4: R69.1@5748.18,3075 5770,3075 5778,3075 5810,3075 5834,3051 5834,3019 ; R69.1@5751.94,3071.24 cw(c5761.02,3062.16) 5761.02,3075 cw(c5761.02,3087.84) R69.1@5751.94,3078.76 ; R69.1@5754.77,3068.41 cw(c5770.68,3052.5) 5770.68,3075 cw(c5770.68,3097.5) R69.1@5754.77,3081.59 ; 5834.5,2979.81 5834.5,3018.5 5834,3019 ; v1@6097.36,2900.04 ccw(c6074.42,2900.04) 6090.64,2916.26 ccw(c6106.86,2932.48) v1@6106.86,2909.54 ; v1@6101.36,2900.04 ccw(c6088.08,2900.04) 6097.47,2909.43 ccw(c6106.86,2918.82) v1@6106.86,2905.54 ; v1(6106.86,2900.04) 6076.9,2930 6001.31,2930 5985.14,2946.18 5958.8,2946.18 5925.12,2912.5 5874.93,2912.5 5860,2912.5 5844.75,2912.5 5834,2923.25 5834,3019
DB_JTAG.HARD.TDI: R72.1 U30.F8 | length 3044.4
  Top Layer w4: v1@5819.45,2762.45 v1@5818.98,2762.92 ; v2@5873.06,2503.06 ccw(c5856.31,2486.31) 5856.31,2510 ccw(c5856.31,2533.69) v2@5873.06,2516.94 ; v2@5875.89,2505.89 ccw(c5865.97,2495.97) 5865.97,2510 ccw(c5865.97,2524.03) v2@5875.89,2514.11 ; v2@5879.81,2510 v2(5880,2510) 5830,2510 5814.36,2525.64 5814.36,2680.61 5837.5,2703.75 5837.5,2718.25 5837.19,2718.56 5837.19,2751.81 v1(5823,2766) 5819.92,2762.92 v1@5818.98,2762.92 ; v2(6670,2485) 6683.87,2498.87 6796.56,2498.87 6806.14,2489.3 6806.14,2468.43 6817.57,2457 6872.19,2457 ; 6872,2457.19 6883,2457.19 6893,2447.19 v2(6918.81,2447.19) ; v2@6911.87,2440.25 ccw(c6895.13,2423.5) 6895.13,2447.19 ccw(c6895.13,2470.87) v2@6911.87,2454.13 ; v2@6914.7,2443.08 ccw(c6904.78,2433.16) 6904.78,2447.19 ccw(c6904.78,2461.22) v2@6914.7,2451.3 ; v3(6970.63,1983.11) U30.F8@6990.32,1963.43 ; U30.F8@6982.97,1963.42 ccw(c6965.25,1963.42) 6977.78,1975.96 ccw(c6990.31,1988.49) U30.F8@6990.31,1970.77 ; v1@5818.98,2762.92 5815,2766.9 5815,2765 5817.08,2762.92 v1@5818.98,2762.92 ; 6983.43,1970.31 cw(c6996.24,1983.11) 6978.13,1983.11 ccw(c6996.24,1983.11) 6983.43,1970.31 ; 6983.43,1970.31 ccw(c6970.63,1957.5) 6970.63,1975.61 cw(c6970.63,1957.5) 6983.43,1970.31
  MidLayer1 w4: v2@6273.51,2477.64 cw(c6260.83,2463.26) 6280,2463.26 ; v2@6276.16,2480.64 cw(c6268.65,2472.13) 6280,2472.13 cw(c6291.35,2472.13) v2@6283.84,2480.64 ; v2(6280,2485) 6280,2463.26 ; v2@6286.49,2477.64 ccw(c6299.17,2463.26) 6280,2463.26 ; v2@6660.19,2485 cw(c6636.5,2485) 6653.25,2468.25 cw(c6670,2451.5) v2@6670,2475.19 ; v2@6664.19,2485 cw(c6650.16,2485) 6660.08,2475.08 cw(c6670,2465.16) v2@6670,2479.19 ; v2(6670,2485) 6620,2435 6620,2310 6615,2305 6445,2305 6415,2335 6303.82,2335 6280.7,2358.12 6280.7,2462.57 6280,2463.26
  MidLayer2 w4: v2@6911.87,2440.25 cw(c6894.67,2423.05) 6919,2423.05 ; v2@6914.7,2443.08 cw(c6904.33,2432.7) 6919,2432.7 ; 6919,2423.96 cw(c6942.04,2423.96) v2@6925.75,2440.25 ; 6919,2433.62 cw(c6932.38,2433.62) v2@6922.92,2443.08 ; v2@6919,2445 6919,2350.27 6889.36,2320.62 6889.36,2269.64 6947,2212 6947,2204 ; 6946.77,2204 6946.77,2120.11 6946.77,2045.99 6946.77,2026.49 ccw(c6988.5,2026.49) 6958.99,1996.98 ; v3@6963.16,1983.76 ccw(c6945.12,1985.34) 6958.99,1996.98 ; v3@6971.28,1990.58 cw(c6972.86,2008.62) 6958.99,1996.98
  Bottom Layer w4: R72.1@5741.59,2827.92 cw(c5725.68,2812.01) 5748.18,2812.01 cw(c5770.68,2812.01) R72.1@5754.77,2827.92 ; R72.1@5744.42,2830.75 cw(c5735.34,2821.67) 5748.18,2821.67 cw(c5761.02,2821.67) R72.1@5751.94,2830.75 ; R72.1@5748.18,2835 5748.18,2783.93 5768.81,2763.3 5796.57,2763.3 5799.27,2766 v1(5823,2766) ; v1@5816.28,2759.28 ccw(c5800.06,2743.06) 5800.06,2766 ccw(c5800.06,2788.93) v1@5816.28,2772.72 ; v1@5819.11,2762.11 ccw(c5809.72,2752.72) 5809.72,2766 ccw(c5809.72,2779.28) v1@5819.11,2769.89 ; v2(5880,2510) 5940,2510 5975.21,2545.21 6194.79,2545.21 6255,2485 v2(6280,2485) ; v2@5884.11,2505.89 cw(c5894.03,2495.97) 5894.03,2510 cw(c5894.03,2524.03) v2@5884.11,2514.11 ; v2@5886.94,2503.06 cw(c5903.69,2486.31) 5903.69,2510 cw(c5903.69,2533.69) v2@5886.94,2516.94 ; v2@6273.06,2478.06 ccw(c6256.31,2461.31) 6256.31,2485 ccw(c6256.31,2508.69) v2@6273.06,2491.94 ; v2@6275.89,2480.89 ccw(c6265.97,2470.97) 6265.97,2485 ccw(c6265.97,2499.03) v2@6275.89,2489.11
DB_JTAG.HARD.TDO: R71.1 R73.1 U30.R10 | length 5946
  Top Layer w4: v2@6221.73,2108.5 cw(c6221.73,2084.81) 6238.48,2101.56 cw(c6255.23,2118.31) v2@6231.54,2118.31 ; v2@6221.73,2112.5 cw(c6221.73,2098.47) 6231.65,2108.39 cw(c6241.57,2118.31) v2@6227.54,2118.31 ; v2(6221.73,2118.31) 6248.88,2091.16 ; 6248.88,2091.71 6248.88,2091.16 ; 6252.25,1622.5 6266.02,1608.72 ; v2@6266.02,1512.02 6266.02,1608.72 ; v2@7087.06,1432.94 ccw(c7070.77,1449.23) 7093.81,1449.23 ; v2@7089.89,1430.11 ccw(c7080.43,1439.57) 7093.81,1439.57 ; v2@7093.81,1426.19 7093.81,1452.75 7079.19,1467.37 7079.19,1490.38 7085.41,1496.59 7085.41,1588.54 7084.56,1589.38 ; 7093.81,1440.49 ccw(c7108.49,1440.49) v2@7098.11,1430.11 ; 7093.81,1450.14 ccw(c7118.14,1450.14) v2@7100.94,1432.94 ; 6248.88,2091.16 6248.88,2085.87 6273.15,2061.6 6273.15,2040.34 6260.62,2027.81 6260.03,2027.81 6255.15,2022.93 6255.15,1990 6307.19,1937.96 6307.19,1920.81 6307.19,1895 6307.19,1744.44 6294.56,1731.81 6282.62,1731.81 6237.02,1686.21 6237.02,1637.72 6266.02,1608.72 ; 7081.59,1596.56 cw(c7074.41,1589.38) 7084.56,1589.38 ; 7081.59,1596.56 cw(c7074.41,1589.38) 7084.56,1589.38 ; 7081.59,1596.56 ccw(c7069.05,1584.03) 7069.05,1601.75 cw(c7069.05,1584.03) 7081.59,1596.56 ; 7081.59,1596.56 cw(c7094.12,1609.09) 7076.4,1609.09 ccw(c7094.12,1609.09) 7081.59,1596.56
  MidLayer1 w4: v1(5776,2960) v1@5778,2958 ; v1@5778,2957 v1@5778,2958 ; 5788.5,2944.5 5788.5,2940 ; v2(5855,2735) 5842.5,2747.5 5842.5,2760.75 5842.5,2770 5842.5,2781.25 5799.5,2824.25 5799.5,2912.44 5788.5,2923.44 5788.5,2940 ; v2@6254.19,1510 cw(c6230.5,1510) 6247.25,1493.25 cw(c6264,1476.5) v2@6264,1500.19 ; v2@6258.19,1510 cw(c6244.16,1510) 6254.08,1500.08 cw(c6264,1490.16) v2@6264,1504.19 ; v2(6264,1510) 6237.19,1483.19 6237.19,1391.62 6252,1376.81 6265.19,1376.81 v2(6360,1282) 6364,1282 v2@6358.23,1276.23 ; v2@6350.19,1282 ccw(c6326.5,1282) 6343.25,1298.75 ccw(c6360,1315.5) v2@6360,1291.81 ; v2@6354.19,1282 ccw(c6340.16,1282) 6350.08,1291.92 ccw(c6360,1301.84) v2@6360,1287.81 ; v2(7045,1275) 7068.19,1275 ; v2@7049.17,1270.95 cw(c7058.73,1261.68) 7058.73,1275 cw(c7058.73,1288.32) v2@7049.17,1279.05 ; v2@7052.04,1268.17 cw(c7068.19,1252.5) 7068.19,1275 ; v2@7052.04,1281.83 ccw(c7068.19,1297.5) 7068.19,1275 ; v2@7087.06,1419.06 cw(c7070.31,1402.31) 7094,1402.31 cw(c7117.69,1402.31) v2@7100.94,1419.06 ; v2@7089.89,1421.89 cw(c7079.97,1411.97) 7094,1411.97 cw(c7108.03,1411.97) v2@7098.11,1421.89 ; v2(7094,1426) 7094,1363 7110.81,1346.19 ; 7096,1361 7110.81,1346.19 ; v1@5778,2958 5788.5,2947.5 5788.5,2940 ; 7068.19,1275 7110.81,1317.62 7110.81,1346.19
  MidLayer2 w4: v1@5769.28,2953.28 cw(c5753.06,2937.06) 5776,2937.06 cw(c5798.93,2937.06) v1@5782.72,2953.28 ; v1@5772.11,2956.11 cw(c5762.72,2946.72) 5776,2946.72 cw(c5789.28,2946.72) v1@5779.89,2956.11 ; v1@5778,2957 5778,2958 v1(5776,2960) 5776,2898 5761.59,2883.59 5761.59,2866.85 5802.23,2826.21 6065,2826.21 ; 6060.83,2826.21 6065,2826.21 ; v2(6360,1282) v2@6364,1282 ; v2@6364.23,1278.02 cw(c6373.44,1269.37) 6373.44,1282 cw(c6373.44,1294.63) v2@6364.23,1285.98 ; v2@6367.15,1275.28 cw(c6382.68,1260.68) 6382.68,1282 ; v2@6367.15,1288.72 ccw(c6382.68,1303.32) 6382.68,1282 ; v1@6550.14,2365.09 ccw(c6531.16,2384.07) 6558,2384.07 ; v1@6552.97,2362.26 ccw(c6540.82,2374.41) 6558,2374.41 ; v1(6556.86,2358.37) 6558,2359.52 6558,2424.19 6573.52,2439.71 6573.52,2809.37 6541.19,2841.71 6391.52,2841.71 6366.52,2816.71 6348.52,2816.71 6339.02,2826.21 6140,2826.21 6065,2826.21 ; 6558,2378.55 ccw(c6577.03,2378.55) v1@6563.57,2365.09 ; v2@7038.06,1268.06 cw(c7021.31,1251.31) 7045,1251.31 cw(c7068.69,1251.31) v2@7051.94,1268.06 ; v2@7040.89,1270.89 cw(c7030.97,1260.97) 7045,1260.97 cw(c7059.03,1260.97) v2@7049.11,1270.89 ; v2(7045,1275) 7045,1230.19 7040.81,1226 7040.81,1210 7040.81,1196.31 7033.25,1188.75 7022.81,1178.31 7022.81,1167.62 7009.38,1154.19 6996.88,1154.19 6930.69,1088 6926,1088 6914,1088 6562,1088 6465.75,1184.25 6465.75,1198.94 6382.69,1282 ; v2@6364,1282 6366,1284 v2@6368,1282 ; v2@6364,1282 v2@6368,1282 ; v2@6368,1282 6382.69,1282
  Bottom Layer w4: R73.1@5547.24,2945.19 cw(c5547.24,2918) 5566.46,2937.23 ; R73.1@5547.24,2949.19 cw(c5547.24,2931.66) 5559.63,2944.05 ; R73.1@5547.24,2952.76 R73.1@5547.24,2955 ; R73.1@5548.07,2955.62 5603.15,2900.54 5660.81,2900.54 5684.45,2876.9 5684.45,2875.63 5694.7,2865.38 5709.2,2865.38 5749.42,2865.38 5765.5,2849.3 5765.5,2816.62 5756.86,2807.98 5756.86,2786.57 5772.13,2771.3 5793.25,2771.3 5805.98,2784.02 5836.56,2784.02 5855,2765.58 v2(5855,2735) ; R73.1@5556.56,2954.51 ccw(c5574.37,2954.51) 5561.77,2941.91 ; R71.1@5751.94,2951.24 cw(c5761.02,2942.16) 5761.02,2955 cw(c5761.02,2967.84) R71.1@5751.94,2958.76 ; R71.1@5755.86,2955 ccw(c5755.86,2974.07) v1@5771.49,2963.15 ; 5763.53,2955 ccw(c5763.53,2968.71) v1@5774.77,2960.86 ; 5765.14,2955 cw(c5765.14,2949.14) v1@5769.28,2953.28 ; v1@5768.21,2965.44 cw(c5748.18,2979.43) R71.1@5748.18,2955 5770.9,2955 v1@5775.45,2950.45 ; v1(5776,2960) 5778,2958 v1@5778,2957 ; v2@5848.06,2741.94 ccw(c5831.31,2758.69) 5855,2758.69 ccw(c5878.69,2758.69) v2@5861.94,2741.94 ; v2@5850.89,2739.11 ccw(c5840.97,2749.03) 5855,2749.03 ccw(c5869.03,2749.03) v2@5859.11,2739.11 ; v2(6221.73,2118.31) 6223.83,2116.21 6253.15,2116.21 6256,2119.06 6277.38,2119.06 6287.94,2108.5 6315,2108.5 6326.63,2108.5 6350.68,2108.5 6556.86,2314.67 6556.86,2326.86 6556.86,2330 v1(6556.86,2358.37) ; v2@6225.84,2122.42 ccw(c6240.83,2137.41) 6240.83,2116.21 ; v2@6228.67,2111.37 cw(c6240.35,2099.69) 6240.35,2116.21 ; v2@6228.67,2125.25 ccw(c6250.48,2147.06) 6250.48,2116.21 ; v1@6550.14,2351.66 cw(c6533.92,2335.44) 6556.86,2335.44 cw(c6579.79,2335.44) v1@6563.57,2351.66 ; v1@6552.97,2354.49 cw(c6543.58,2345.1) 6556.86,2345.1 cw(c6570.14,2345.1) v1@6560.75,2354.49
DB_JTAG.HARD.TMS: R68.1 U30.F6 | length 2497
  Top Layer w4: v3(6891.89,1983.11) U30.F6@6911.57,1963.43 ; U30.F6@6904.23,1963.42 ccw(c6886.51,1963.42) 6899.04,1975.96 ccw(c6911.57,1988.49) U30.F6@6911.57,1970.77 ; 6904.69,1970.31 cw(c6917.5,1983.11) 6899.39,1983.11 ccw(c6917.5,1983.11) 6904.69,1970.31 ; 6904.69,1970.31 ccw(c6891.89,1957.5) 6891.89,1975.61 cw(c6891.89,1957.5) 6904.69,1970.31
  MidLayer2 w4: v1(5802.19,3200.71) 5902.98,3200.71 6020.31,3083.37 6300,3083.37 6319.21,3083.37 6325.19,3083.37 6356.63,3083.37 6485.79,2954.21 6625.97,2954.21 6626.13,2954.37 6720.21,2954.37 6774.86,2899.73 6774.86,2554.67 6762.19,2542 6762.19,2514 6770,2506.18 6774.03,2502.16 6774.03,2445.78 6793.81,2426 6793.81,2404.28 6793.81,2391.21 6745,2342.4 6745,2325 6745,2285 6730,2270 6730,2250 6745,2235 6827.99,2235 6838.99,2224 6850,2224 6861,2224 6868.03,2216.97 6868.03,2139.53 6868.03,2120.11 6868.03,2045.99 6868.03,2022.74 ccw(c6891.8,2022.74) 6874.42,2006.52 6881.5,1997.94 ; v3@6884.5,1984.41 ccw(c6866.67,1987.56) 6881.5,1997.94 ; v3@6893.19,1990.5 cw(c6896.34,2008.33) 6881.5,1997.94
  Bottom Layer w4: R68.1@5748.18,3195 5796.57,3195 5800.57,3199 5800.57,3199.08 v1(5802.19,3200.71) ; R68.1@5751.94,3191.24 cw(c5761.02,3182.16) 5761.02,3195 cw(c5761.02,3207.84) R68.1@5751.94,3198.76 ; R68.1@5754.77,3188.41 cw(c5770.68,3172.5) 5770.68,3195 cw(c5770.68,3217.5) R68.1@5754.77,3201.59 ; 5765.47,3195 ccw(c5765.47,3237.42) v1@5795.47,3207.43 ; 5775.13,3195 ccw(c5775.13,3227.77) v1@5798.3,3204.6 ; 5784.79,3195 ccw(c5784.79,3218.11) v1@5801.13,3201.77
DB_JTAG.SOFT.TCK: U8.Y27 U30.T2 | length 7007.4
  Top Layer w4: U8.Y27@5882.13,3966.12 cw(c5882.13,3948.4) 5894.66,3960.93 ; U8.Y27@5889.47,3973.46 ccw(c5907.19,3973.46) 5894.66,3960.93 ; 6007.14,3953.34 ccw(c6015.32,3961.52) v2@6021.1,3951.5 ; 6010.83,3949.65 ccw(c6018.02,3956.84) v2@6023.1,3948.03 ; 6014.51,3945.96 ccw(c6020.71,3952.17) v2@6025.1,3944.57 ; v2(6026,3943) 6017.48,3943 6002.88,3957.6 5951.07,3957.6 5941.18,3957.96 5901.84,3957.96 cw(c5901.84,3968.11) 5894.66,3960.93 ; v1(6700,1512) 6720,1512 ; v1@6704.26,1508.53 cw(c6711.58,1502.56) 6711.58,1512 cw(c6711.58,1521.44) v1@6704.26,1515.47 ; v1@6707.36,1506 cw(c6720,1495.7) 6720,1512 ; v1@6707.36,1518 ccw(c6720,1528.3) 6720,1512 ; U30.T2@6748.9,1564.53 cw(c6736.37,1552) 6754.09,1552 cw(c6771.82,1552) U30.T2@6759.29,1564.53 ; U30.T2@6754.09,1569.72 6754.09,1498.09 6750,1494 6738,1494 6720,1512
  MidLayer1 w4: v1@5264.02,1925.04 ccw(c5241.09,1925.04) 5257.31,1941.26 ccw(c5273.52,1957.48) v1@5273.52,1934.54 ; v1@5268.02,1925.04 ccw(c5254.75,1925.04) 5264.14,1934.43 ccw(c5273.52,1943.82) v1@5273.52,1930.54 ; v1(5273.52,1925.04) 5208.4,1990.16 5208.4,2448.61 5273.81,2514.01 5273.81,2758.81 ; v1@5280.5,2774.99 cw(c5257.67,2774.96) 5273.81,2758.81 ; v1@5284.5,2774.99 cw(c5271.28,2774.98) 5280.63,2765.63 cw(c5289.98,2756.28) v1@5289.99,2769.5 ; v1@5289.99,2765.5 ccw(c5289.96,2742.67) 5273.81,2758.81 ; v1@5296,2775 v1(5290,2775) 5273.81,2758.81 ; v2@5669.06,3275.06 cw(c5652.31,3258.31) 5676,3258.31 cw(c5699.69,3258.31) v2@5682.94,3275.06 ; v2@5671.89,3277.89 cw(c5661.97,3267.97) 5676,3267.97 cw(c5690.03,3267.97) v2@5680.11,3277.89 ; v2@5682.35,3275.65 v2(5676,3282) 5676,3241.35 5682.35,3235 5682.35,2877.72 5712.12,2847.96 v2(5712.12,2802.33) ; v2@6236.38,3860.44 cw(c6219.63,3843.69) 6243.32,3843.69 cw(c6267.01,3843.69) v2@6250.26,3860.44 ; v2@6239.21,3863.27 cw(c6229.29,3853.35) 6243.32,3853.35 cw(c6257.35,3853.35) v2@6247.43,3863.27 ; v2(6243.32,3867.38) 6243.32,3838.56 6275.53,3806.34 6275.53,3769.07 6298.19,3746.42 6298.19,3647.09 6300.02,3645.25 6300.02,3615.48 ; v2(6250.43,3414.61) 6250.43,3429.48 6212.36,3467.56 6212.36,3527.81 ; v2@6597.06,1897.06 cw(c6580.31,1880.31) 6604,1880.31 cw(c6627.69,1880.31) v2@6610.94,1897.06 ; v2@6599.89,1899.89 cw(c6589.97,1889.97) 6604,1889.97 cw(c6618.03,1889.97) v2@6608.11,1899.89 ; v2(6604,1904) 6604,1854.81 6593.19,1844 6576.5,1844 6564.69,1832.19 6518.19,1832.19 6504,1818 6504,1753.19 6519.81,1737.38 6519.81,1714.19 6564,1670 6564,1642.81 6605,1601.81 6605,1545 6620,1530 6682,1530 v1@6698,1514 ; v1@6690.5,1512 ccw(c6667.56,1512) 6683.78,1528.22 ccw(c6700,1544.43) v1@6700,1521.5 ; v1@6694.5,1512 ccw(c6681.22,1512) 6690.61,1521.39 ccw(c6700,1530.78) v1@6700,1517.5 ; 6212.36,3527.81 6222.14,3537.59 6300.02,3615.48 ; 6212.36,3527.81 6300.02,3615.48
  MidLayer2 w4: v1@5273.52,1915.54 cw(c5273.52,1892.61) 5289.74,1908.82 cw(c5305.96,1925.04) v1@5283.02,1925.04 ; v1@5273.52,1919.54 cw(c5273.52,1906.26) 5282.91,1915.65 cw(c5292.3,1925.04) v1@5279.02,1925.04 ; v1(5273.52,1925.04) 5316.7,1881.87 5713.91,1881.87 5717.14,1885.1 5744.14,1885.1 5783.06,1924.01 ; 5766.28,1907.23 5783.06,1924.01 ; v2(6074,3842) 6100.69,3842 6106.69,3848 6158,3848 6183.88,3873.88 6220,3873.88 6226.5,3867.38 v2(6243.32,3867.38) ; v2@6078.11,3837.89 cw(c6088.03,3827.97) 6088.03,3842 cw(c6088.03,3856.03) v2@6078.11,3846.11 ; v2@6080.94,3835.06 cw(c6097.69,3818.31) 6097.69,3842 cw(c6097.69,3865.69) v2@6080.94,3848.94 ; v2@6234.78,3862.55 ccw(c6226.5,3857.86) 6226.5,3867.38 ccw(c6226.5,3876.89) v2@6234.78,3872.21 ; v2@6597.06,1897.06 ccw(c6580.31,1880.31) 6580.31,1904 ccw(c6580.31,1927.69) v2@6597.06,1910.94 ; v2@6599.89,1899.89 ccw(c6589.97,1889.97) 6589.97,1904 ccw(c6589.97,1918.03) v2@6599.89,1908.11 ; v2@6605,1912 6605,1905 v2(6604,1904) 6577.09,1904 6565.09,1916 6554.84,1916 6525.02,1945.81 6470.62,1945.81 6463,1938.19 6279,1938.19 6267.48,1949.71 6244.13,1949.71 6230.21,1963.62 6212.82,1963.62 6186.2,1937 5828.8,1937 5822.34,1930.54 5801.28,1930.54 5794.75,1924.01 5783.06,1924.01
  Bottom Layer w4: v1@5283.28,2781.72 ccw(c5267.06,2797.93) 5290,2797.93 ccw(c5312.93,2797.93) v1@5296.72,2781.72 ; v1@5286.11,2778.89 ccw(c5276.72,2788.28) 5290,2788.28 ccw(c5303.28,2788.28) v1@5293.89,2778.89 ; v2(5676,3282) 5676,3276.94 5723.44,3229.5 5774.69,3229.5 5837.81,3292.62 5837.81,3322.87 5856.23,3341.29 5878.1,3341.29 5968.31,3431.5 6150,3431.5 6185.59,3431.5 6204.56,3450.47 6225.69,3450.47 6250.43,3425.72 v2(6250.43,3414.61) ; v2@5705.18,2795.4 ccw(c5688.43,2778.65) 5688.43,2802.33 ccw(c5688.43,2826.02) v2@5705.18,2809.27 ; v2@5708.01,2798.22 ccw(c5698.09,2788.3) 5698.09,2802.33 ccw(c5698.09,2816.36) v2@5708.01,2806.44 ; v2(5712.12,2802.33) 5684.81,2802.33 5651.64,2835.5 5645.6,2841.54 5604.29,2841.54 5581.36,2864.48 5581.36,2884.39 5548.25,2917.5 5531.25,2917.5 5477.25,2863.5 5318.39,2863.5 5310.09,2871.8 5295.55,2871.8 5285.3,2861.55 5285.3,2840 5290,2835.3 v1@5290,2783.56 ; v2@6019.06,3936.06 cw(c6002.31,3919.31) 6026,3919.31 cw(c6049.69,3919.31) v2@6032.94,3936.06 ; v2@6021.89,3938.89 cw(c6011.97,3928.97) 6026,3928.97 cw(c6040.03,3928.97) v2@6030.11,3938.89 ; v2(6026,3943) 6026,3904.06 6063.5,3866.56 6074,3856.06 v2(6074,3842) ; 6225.83,3450.33 cw(c6190.1,3414.61) v2@6240.62,3414.61 ; 6232.65,3443.51 cw(c6203.76,3414.61) v2@6244.62,3414.61 ; 6239.48,3436.68 cw(c6217.41,3414.61) v2@6248.62,3414.61 ; 6246.31,3429.85 cw(c6231.07,3414.61) v2@6252.62,3414.61 ; v1@5290,2783.56 v1(5290,2775) 5296,2775 5296,2777.56 v1@5290,2783.56