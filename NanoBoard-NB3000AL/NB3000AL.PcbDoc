# Altium PCB NB3000AL.PcbDoc (part 75 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
VGA.BLUE3: U8.G12 U21.5 | length 1662.9
  Top Layer w4: v3(5271.89,4504.96) U8.G12@5291.57,4485.28 ; U8.G12@5284.23,4485.28 ccw(c5266.51,4485.28) 5279.04,4497.81 ccw(c5291.57,4510.34) U8.G12@5291.57,4492.62 ; 5284.69,4492.16 cw(c5297.5,4504.96) 5279.39,4504.96 ccw(c5297.5,4504.96) 5284.69,4492.16 ; 5284.69,4492.16 ccw(c5271.89,4479.35) 5271.89,4497.46 cw(c5271.89,4479.35) 5284.69,4492.16
  MidLayer1 w4: v1@5254.81,4945.09 ccw(c5238.59,4961.31) 5261.52,4961.31 ccw(c5284.46,4961.31) v1@5268.24,4945.09 ; v1@5257.64,4942.26 ccw(c5248.25,4951.65) 5261.52,4951.65 ccw(c5274.8,4951.65) v1@5265.41,4942.26 ; v1(5261.52,4938.37) 5261.52,4968.39 5273.52,4980.39 5273.52,5146.37 5298.52,5171.37 5305.52,5178.37 5305.52,5193 5313.15,5200.62 5313.15,5215 ; v1(5357.86,5583.37) 5396.37,5583.37 5407.5,5572.25 5407.5,5446.02 5342.19,5380.71 5342.19,5285.37 5313.15,5256.33 5313.15,5215.37 ; v1@5361.75,5579.49 cw(c5371.14,5570.1) 5371.14,5583.37 cw(c5371.14,5596.65) v1@5361.75,5587.26 ; v1@5364.57,5576.66 cw(c5380.79,5560.44) 5380.79,5583.37 cw(c5380.79,5606.31) v1@5364.57,5590.09 ; 5313.15,5215 5313.15,5215.37 ; 5313.15,5215 5313.15,5215.37
  MidLayer2 w4: v1@5254.81,4931.66 cw(c5238.59,4915.44) 5261.52,4915.44 cw(c5284.46,4915.44) v1@5268.24,4931.66 ; 5256.38,4542.4 5256.38,4528.47 ; 5256.38,4738.53 5256.38,4680.27 ; v1@5257.64,4934.49 cw(c5248.25,4925.1) 5261.52,4925.1 cw(c5274.8,4925.1) v1@5265.41,4934.49 ; 5260.5,4518.54 cw(c5270.43,4528.47) 5256.38,4528.47 ; v1(5261.52,4938.37) 5261.52,4883.37 5280.52,4864.37 5280.52,4830.52 5270,4820 5270,4790 5256.38,4776.38 5256.38,4763.62 5256.38,4749.18 5256.38,4741.18 5256.38,4680.27 ; v3@5264.42,4505.61 ccw(c5246.38,4507.19) 5260.25,4518.83 ccw(c5274.12,4530.47) v3@5272.54,4512.43 ; 5256.38,4528.47 5256.38,4622.01 5256.38,4680.27
  Bottom Layer w4: U21.5@5312.32,5599.53 5347.86,5599.53 5357.86,5589.53 v1(5357.86,5583.37) ; U21.5@5338.68,5596.7 cw(c5345.51,5589.87) 5345.51,5599.53 cw(c5345.51,5609.18) U21.5@5338.68,5602.36 ; 5349.45,5597.94 cw(c5340.38,5588.87) v1@5352.61,5585.03 ; 5352.14,5595.24 ccw(c5357.86,5600.96) v1@5357.86,5592.87
VGA.BLUE4: U8.B11 U21.4 | length 1733.3
  Top Layer w4: v1@5241.81,4834.66 cw(c5225.59,4818.44) 5248.52,4818.44 cw(c5271.46,4818.44) v1@5255.24,4834.66 ; v1@5244.64,4837.49 cw(c5235.25,4828.1) 5248.52,4828.1 cw(c5261.8,4828.1) v1@5252.41,4837.49 ; U8.B11@5244.86,4682.13 ccw(c5227.14,4682.13) 5239.67,4694.66 ; v1(5248.52,4841.37) 5248.52,4818.27 5227.5,4797.25 5227.5,4782.75 5236.7,4773.55 5236.7,4751.18 5236.7,4741.18 5236.7,4701.84 ccw(c5246.85,4701.84) 5239.67,4694.66 ; U8.B11@5252.2,4689.47 cw(c5252.2,4707.19) 5239.67,4694.66
  MidLayer1 w4: v1@5241.81,4848.09 ccw(c5225.59,4864.31) 5248.52,4864.31 ccw(c5271.46,4864.31) v1@5255.24,4848.09 ; v1@5244.64,4845.26 ccw(c5235.25,4854.65) 5248.52,4854.65 ccw(c5261.8,4854.65) v1@5252.41,4845.26 ; v1(5248.52,4841.37) 5248.52,4890.37 5281.52,4923.37 5281.52,5030.32 5331.86,5080.65 5331.86,5206.38 5432.19,5306.71 5432.19,5711.69 ; v1(5303.52,5766.71) 5377.17,5766.71 5431.86,5712.02 ; v1@5307.41,5762.82 cw(c5316.8,5753.43) 5316.8,5766.71 cw(c5316.8,5779.99) v1@5307.41,5770.6 ; v1@5310.24,5759.99 cw(c5326.46,5743.77) 5326.46,5766.71 cw(c5326.46,5789.64) v1@5310.24,5773.43
  Bottom Layer w4: U21.4@5285.97,5616.38 ccw(c5279.14,5609.56) 5279.14,5619.21 ccw(c5279.14,5628.87) U21.4@5285.97,5622.04 ; v1@5294.02,5766.71 cw(c5271.09,5766.71) 5287.31,5750.49 cw(c5303.52,5734.27) v1@5303.52,5757.21 ; v1@5298.02,5766.71 cw(c5284.75,5766.71) 5294.14,5757.32 cw(c5303.52,5747.93) v1@5303.52,5761.21 ; v1(5303.52,5766.71) 5265.52,5728.71 5265.52,5627.21 5273.52,5619.21 U21.4@5312.32,5619.21
VGA.BLUE5: U8.D10 U21.3 | length 1945.2
  Top Layer w4: v3(5193.15,4623.07) U8.D10@5212.83,4603.39 ; U8.D10@5205.49,4603.39 ccw(c5187.77,4603.39) 5200.3,4615.92 ccw(c5212.83,4628.45) U8.D10@5212.83,4610.73 ; 5205.95,4610.27 cw(c5218.76,4623.07) 5200.65,4623.07 ccw(c5218.76,4623.07) 5205.95,4610.27 ; 5205.95,4610.27 ccw(c5193.15,4597.46) 5193.15,4615.57 cw(c5193.15,4597.46) 5205.95,4610.27
  MidLayer1 w4: v3@5187.96,4628.26 ccw(c5175.42,4640.8) 5193.15,4640.8 ccw(c5210.88,4640.8) v3@5198.34,4628.26 ; v3(5193.15,4623.07) 5193.15,4700.75 5193.15,4741.18 5193.15,4749.18 5193.15,4791.77 5201.5,4800.12 5201.5,4811.5 5210,4820 5257.15,4820 5297.52,4860.37 5297.52,5023.69 5348.19,5074.35 5348.19,5200.09 5448.19,5300.09 5448.19,5750.37 v1(5440.19,5758.37) ; v1@5433.47,5751.66 cw(c5397.94,5716.13) 5448.19,5716.13 ; v1@5436.3,5754.49 cw(c5407.6,5725.78) 5448.19,5725.78 ; v1@5439.13,5757.31 cw(c5417.26,5735.44) 5448.19,5735.44 ; v1@5441.96,5760.14 cw(c5426.91,5745.1) 5448.19,5745.1 ; 5193.15,4641.18 cw(c5175.04,4641.18) 5187.85,4628.37 ccw(c5175.04,4641.18) 5193.15,4641.18 ; 5193.15,4641.18 ccw(c5211.26,4641.18) 5198.45,4628.37 cw(c5211.26,4641.18) 5193.15,4641.18
  Bottom Layer w4: U21.3@5285.97,5636.07 ccw(c5279.14,5629.24) 5279.14,5638.9 ccw(c5279.14,5648.55) U21.3@5285.97,5641.73 ; U21.3@5312.32,5638.9 5278.52,5638.9 5276.52,5640.9 5276.52,5713.71 5321.19,5758.37 v1(5440.19,5758.37) ; v1@5433.47,5751.66 ccw(c5417.26,5735.44) 5417.26,5758.37 ccw(c5417.26,5781.31) v1@5433.47,5765.09 ; v1@5436.3,5754.49 ccw(c5426.91,5745.1) 5426.91,5758.37 ccw(c5426.91,5771.65) v1@5436.3,5762.26
VGA.BLUE6: U8.G11 U21.2 | length 2058.6
  Top Layer w4: v1@5024.47,5051.66 cw(c5008.26,5035.44) 5031.19,5035.44 cw(c5054.13,5035.44) v1@5037.91,5051.66 ; v1@5027.3,5054.49 cw(c5017.91,5045.1) 5031.19,5045.1 cw(c5044.47,5045.1) v1@5035.08,5054.49 ; v1(5031.19,5058.37) 5031.19,5020.94 5017.5,5007.25 5017.5,4992.75 5048.52,4961.73 5048.52,4911.48 5060,4900 v1@5060,4880 ; v1@5053.28,4881.72 ccw(c5037.06,4897.93) 5060,4897.93 ccw(c5082.93,4897.93) v1@5066.72,4881.72 ; v1@5056.11,4878.89 ccw(c5046.72,4888.28) 5060,4888.28 ccw(c5073.28,4888.28) v1@5063.89,4878.89 ; v3(5232.52,4504.96) U8.G11@5252.2,4485.28 ; U8.G11@5244.86,4485.28 ccw(c5227.14,4485.28) 5239.67,4497.81 ccw(c5252.2,4510.34) U8.G11@5252.2,4492.62 ; 5245.32,4492.16 cw(c5258.13,4504.96) 5240.02,4504.96 ccw(c5258.13,4504.96) 5245.32,4492.16 ; 5245.32,4492.16 ccw(c5232.52,4479.35) 5232.52,4497.46 cw(c5232.52,4479.35) 5245.32,4492.16
  MidLayer2 w4: v1(5060,4875) 5085,4875 5095,4865 5159.75,4865 5195,4865 5217,4843 5217,4770.62 ; v1@5063.89,4871.11 cw(c5073.28,4861.72) 5073.28,4875 cw(c5073.28,4888.28) v1@5063.89,4878.89 ; v1@5066.72,4868.28 cw(c5082.93,4852.06) 5082.93,4875 cw(c5082.93,4897.93) v1@5066.72,4881.72 ; 5217.01,4542.4 5217.01,4528.47 ; 5221.13,4518.54 cw(c5231.06,4528.47) 5217.01,4528.47 ; v3@5225.05,4505.61 ccw(c5207.01,4507.19) 5220.88,4518.83 ccw(c5234.75,4530.47) v3@5233.17,4512.43 ; 5217.01,4528.47 5217.01,4622.01 5217.01,4765 ; 5217.01,4765 5217.01,4770.61 ; 5217.01,4765 5217.01,4770.61
  Bottom Layer w4: v1(5031.19,5058.37) 5068.5,5058.37 5080,5046.87 5130.77,5046.87 5150,5066.1 5150,5098.79 5167.92,5116.71 5171.55,5120.33 5341.52,5290.31 5341.52,5375.04 5374.86,5408.37 5415.52,5408.37 5417.19,5410.04 5417.19,5462.04 5431.86,5476.71 5431.86,5575.04 5415.19,5591.71 5376.86,5591.71 5373.52,5595.04 5373.52,5625.04 5340.19,5658.37 U21.2@5315.19,5658.37 ; v1@5035.08,5054.49 cw(c5044.47,5045.1) 5044.47,5058.37 cw(c5044.47,5071.65) v1@5035.08,5062.26 ; v1@5037.91,5051.66 cw(c5054.13,5035.44) 5054.13,5058.37 cw(c5054.13,5081.31) v1@5037.91,5065.09 ; U21.2@5335.85,5654.58 cw(c5335.85,5634.95) 5349.73,5648.83 ; U21.2@5335.85,5658.58 cw(c5335.85,5648.61) 5342.9,5655.66
VGA.BLUE7: U8.E10 U21.1 | length 1489.7
  Top Layer w4: v3(5193.15,4583.7) U8.E10@5212.83,4564.02 ; U8.E10@5205.49,4564.02 ccw(c5187.77,4564.02) 5200.3,4576.55 ccw(c5212.83,4589.08) U8.E10@5212.83,4571.36 ; 5205.95,4570.9 cw(c5218.76,4583.7) 5200.65,4583.7 ccw(c5218.76,4583.7) 5205.95,4570.9 ; 5205.95,4570.9 ccw(c5193.15,4558.09) 5193.15,4576.2 cw(c5193.15,4558.09) 5205.95,4570.9
  MidLayer1 w4: 5177.64,4621.14 5177.64,4607.21 ; 5181.76,4597.28 cw(c5191.69,4607.21) 5177.64,4607.21 ; v3@5185.68,4584.35 ccw(c5167.64,4585.93) 5181.51,4597.57 ccw(c5195.38,4609.21) v3@5193.8,4591.17 ; v1@5355.69,5662.04 cw(c5332.76,5662.04) 5348.97,5645.82 cw(c5365.19,5629.61) v1@5365.19,5652.54 ; v1@5359.69,5662.04 cw(c5346.41,5662.04) 5355.8,5652.65 cw(c5365.19,5643.26) v1@5365.19,5656.54 ; v1(5365.19,5662.04) 5240.19,5537.04 5240.19,5219.72 5190.19,5169.72 5190.19,4955 5190.19,4934.81 5190.19,4928.31 5193.5,4925 5193.5,4899.88 5193.5,4895 5193.5,4890 5193.5,4824.56 5193.5,4803.44 5177.64,4787.58 5177.64,4749.18 5177.64,4741.18 5177.64,4700.75 5177.64,4607.21
  Bottom Layer w4: U21.1@5312.32,5678.27 5348.96,5678.27 ; U21.1@5338.68,5675.44 cw(c5345.51,5668.61) 5345.51,5678.27 cw(c5345.51,5687.92) U21.1@5338.68,5681.1 ; v1@5355.69,5662.04 ccw(c5332.76,5662.04) 5348.97,5678.26 ; v1@5359.69,5662.04 ccw(c5346.41,5662.04) 5355.8,5671.43 ccw(c5365.19,5680.82) v1@5365.19,5667.54 ; v1(5365.19,5662.04) 5348.96,5678.27 ; v1@5365.19,5671.54 cw(c5365.19,5694.48) 5348.97,5678.26
VGA.GREEN0: U8.D9 U21.34 | length 1454.8
  Top Layer w4: v3(5153.78,4623.07) U8.D9@5173.46,4603.39 ; U8.D9@5166.12,4603.39 ccw(c5148.4,4603.39) 5160.93,4615.92 ccw(c5173.46,4628.45) U8.D9@5173.46,4610.73 ; 5166.58,4610.27 cw(c5179.39,4623.07) 5161.28,4623.07 ccw(c5179.39,4623.07) 5166.58,4610.27 ; 5166.58,4610.27 ccw(c5153.78,4597.46) 5153.78,4615.57 cw(c5153.78,4597.46) 5166.58,4610.27
  MidLayer1 w4: v1@5000.14,5318.32 cw(c4983.92,5302.11) 5006.86,5302.11 cw(c5029.79,5302.11) v1@5013.57,5318.32 ; v1@5002.97,5321.15 cw(c4993.58,5311.76) 5006.86,5311.76 cw(c5020.14,5311.76) v1@5010.75,5321.15 ; v1(5006.86,5325.04) 5006.86,5208.37 5105.52,5109.71 5105.52,5051.37 5131.86,5025.04 5131.86,4933.37 5159.73,4905.5 5165.25,4905.5 5175.5,4895.25 5175.5,4880 5158.26,4862.76 5146.5,4851 5146.5,4840 5146.5,4802.75 5153.78,4795.47 5153.78,4751.18 5153.78,4741.18 5153.78,4700.75 v3(5153.78,4623.07) ; v3@5148.48,4628.37 ccw(c5135.67,4641.18) 5153.78,4641.18 ccw(c5171.89,4641.18) v3@5159.08,4628.37 ; v3@5148.59,4628.26 ccw(c5136.05,4640.8) 5153.78,4640.8 ccw(c5171.51,4640.8) v3@5158.97,4628.26
  Bottom Layer w4: U21.34@4977.68,5638.9 5015.52,5638.9 5029.52,5624.9 5029.52,5441.37 5006.86,5418.71 v1(5006.86,5325.04) ; v1@5000.14,5331.76 ccw(c4983.92,5347.98) 5006.86,5347.98 ccw(c5029.79,5347.98) v1@5013.57,5331.76 ; v1@5002.97,5328.93 ccw(c4993.58,5338.32) 5006.86,5338.32 ccw(c5020.14,5338.32) v1@5010.75,5328.93 ; U21.34@5004.03,5636.07 cw(c5010.86,5629.24) 5010.86,5638.9 cw(c5010.86,5648.55) U21.34@5004.03,5641.73
VGA.GREEN1: U8.A8 U21.33 | length 1326
  Top Layer w4: v1(4931.86,5625.04) 4970.86,5625.04 5006,5589.9 5006,5392.56 5052.19,5346.37 5052.19,5166.71 ; v1@4935.75,5621.15 cw(c4945.14,5611.76) 4945.14,5625.04 cw(c4945.14,5638.32) v1@4935.75,5628.93 ; v1@4938.57,5618.32 cw(c4954.79,5602.11) 4954.79,5625.04 cw(c4954.79,5647.98) v1@4938.57,5631.76 ; U8.A8@5128.9,4726.69 ccw(c5116.37,4739.22) 5134.09,4739.22 ccw(c5151.82,4739.22) U8.A8@5139.29,4726.69 ; U8.A8@5134.09,4721.5 5134.09,4871.91 5101.19,4904.81 5101.19,4971.04 5073.52,4998.71 5073.52,5016.71 5102.5,5045.68 5102.5,5116.4 5098.52,5120.37 ; 5052.19,5166.71 5098.52,5120.37 ; 5052.19,5166.71 5098.52,5120.37
  Bottom Layer w4: v1(4931.86,5625.04) 4937.69,5619.21 U21.33@4977.68,5619.21 ; v1@4932.92,5626.1 ccw(c4949.55,5642.73) U21.33@4949.55,5619.21 ; v1@4935.75,5628.93 ccw(c4959.21,5652.39) U21.33@4959.21,5619.21 ; v1@4938.57,5631.76 ccw(c4968.86,5662.05) U21.33@4968.86,5619.21 ; U21.33@4951.32,5616.38 ccw(c4944.49,5609.56) 4944.49,5619.21 ccw(c4944.49,5628.87) U21.33@4951.32,5622.04
VGA.GREEN2: U8.D8 U21.32 | length 1497.1
  Top Layer w4: v3(5114.41,4623.07) U8.D8@5134.09,4603.39 ; U8.D8@5126.75,4603.39 ccw(c5109.03,4603.39) 5121.56,4615.92 ccw(c5134.09,4628.45) U8.D8@5134.09,4610.73 ; 5127.21,4610.27 cw(c5140.02,4623.07) 5121.91,4623.07 ccw(c5140.02,4623.07) 5127.21,4610.27 ; 5127.21,4610.27 ccw(c5114.41,4597.46) 5114.41,4615.57 cw(c5114.41,4597.46) 5127.21,4610.27
  MidLayer1 w4: v1@4991.81,5169.99 cw(c4975.59,5153.77) 4998.52,5153.77 cw(c5021.46,5153.77) v1@5005.24,5169.99 ; v1@4994.64,5172.82 cw(c4985.25,5163.43) 4998.52,5163.43 cw(c5011.8,5163.43) v1@5002.41,5172.82 ; v1(4998.52,5176.71) 4998.52,5136.04 5123.52,5011.04 5123.52,4803.52 5114.41,4794.41 5114.41,4749.18 5114.41,4741.18 5114.41,4700.75 v3(5114.41,4623.07) ; v3@5109.11,4628.37 ccw(c5096.3,4641.18) 5114.41,4641.18 ccw(c5132.52,4641.18) v3@5119.71,4628.37 ; v3@5109.22,4628.26 ccw(c5096.68,4640.8) 5114.41,4640.8 ccw(c5132.14,4640.8) v3@5119.6,4628.26
  Bottom Layer w4: U21.32@4951.32,5596.7 ccw(c4944.49,5589.87) 4944.49,5599.53 ccw(c4944.49,5609.18) U21.32@4951.32,5602.36 ; U21.32@4977.68,5599.53 4894.53,5599.53 4845,5550 4845,5432.23 4886.15,5391.09 4998.52,5278.71 v1(4998.52,5176.71) ; v1@4991.81,5183.43 ccw(c4975.59,5199.64) 4998.52,5199.64 ccw(c5021.46,5199.64) v1@5005.24,5183.43 ; v1@4994.64,5180.6 ccw(c4985.25,5189.99) 4998.52,5189.99 ccw(c5011.8,5189.99) v1@5002.41,5180.6
VGA.GREEN3: U8.C8 U21.31 | length 1525.5
  Top Layer w4: v1(5031.86,5283.37) 5042.81,5272.42 5042.81,5162.42 5057.86,5147.37 ; 5055.83,5149.4 5064.7,5140.54 ; 5065.19,5001.69 5065.19,5140.04 5064.7,5140.54 ; U8.C8@5126.75,4642.76 ccw(c5109.03,4642.76) 5121.56,4655.29 ; U8.C8@5134.09,4650.1 cw(c5134.09,4667.82) 5121.56,4655.29 ; 5064.7,4960 5064.7,4918.3 5115.19,4867.81 5115.19,4808.3 5110.23,4803.35 5110.23,4741.18 5110.23,4682.64 ccw(c5148.91,4682.64) 5121.56,4655.29 ; 5064.7,4960 5064.7,5001.19 5064.7,4960 ; 5064.7,4960 5064.7,5140.54
  Bottom Layer w4: 4856.86,5550.04 4886.66,5579.84 ; U21.31@4951.32,5577.01 ccw(c4944.49,5570.19) 4944.49,5579.84 ccw(c4944.49,5589.5) U21.31@4951.32,5582.67 ; U21.31@4977.68,5579.84 4886.66,5579.84 ; v1@5025.14,5276.66 ccw(c5008.92,5260.44) 5008.92,5283.37 ccw(c5008.92,5306.31) v1@5025.14,5290.09 ; v1@5027.97,5279.49 ccw(c5018.58,5270.1) 5018.58,5283.37 ccw(c5018.58,5296.65) v1@5027.97,5287.26 ; v1(5031.86,5283.37) 5005.17,5283.37 4853,5435.55 4853,5546.69 4886.16,5579.84 4886.66,5579.84
VGA.GREEN4: U8.D7 U21.30 | length 1523.4
  Top Layer w4: v3(5075.04,4623.07) U8.D7@5094.72,4603.39 ; U8.D7@5087.38,4603.39 ccw(c5069.66,4603.39) 5082.19,4615.92 ccw(c5094.72,4628.45) U8.D7@5094.72,4610.73 ; 5087.84,4610.27 cw(c5100.65,4623.07) 5082.54,4623.07 ccw(c5100.65,4623.07) 5087.84,4610.27 ; 5087.84,4610.27 ccw(c5075.04,4597.46) 5075.04,4615.57 cw(c5075.04,4597.46) 5087.84,4610.27
  MidLayer1 w4: v1@4888.81,5543.32 ccw(c4872.59,5527.11) 4872.59,5550.04 ccw(c4872.59,5572.98) v1@4888.81,5556.76 ; v1@4891.64,5546.15 ccw(c4882.25,5536.76) 4882.25,5550.04 ccw(c4882.25,5563.32) v1@4891.64,5553.93 ; v1(4895.52,5550.04) 4871.84,5550.04 4840.19,5518.39 4840.19,5347.37 4831.86,5339.04 4829.52,5336.71 4829.52,5191.67 4831.86,5189.34 4848.52,5172.67 4848.52,5089.32 4978.8,4959.04 5021.82,4959.04 5077.5,4903.36 5077.5,4855.33 5065,4842.83 5065,4790 5075.04,4779.96 5075.04,4749.18 5075.04,4741.18 5075.04,4700.75 v3(5075.04,4623.07) ; v3@5069.85,4628.26 ccw(c5057.31,4640.8) 5075.04,4640.8 ccw(c5092.77,4640.8) v3@5080.23,4628.26 ; 5075.04,4641.18 cw(c5056.93,4641.18) 5069.74,4628.37 ccw(c5056.93,4641.18) 5075.04,4641.18 ; 5075.04,4641.18 ccw(c5093.15,4641.18) 5080.34,4628.37 cw(c5093.15,4641.18) 5075.04,4641.18
  Bottom Layer w4: v1(4895.52,5550.04) 4912.19,5566.71 4934.97,5566.71 4941.52,5560.16 U21.30@4977.68,5560.16 ; v1@4895.52,5555.54 ccw(c4895.52,5568.82) 4904.91,5559.43 ccw(c4914.3,5550.04) v1@4901.02,5550.04 ; v1@4895.52,5559.54 ccw(c4895.52,5582.48) 4911.74,5566.26 ccw(c4927.96,5550.04) v1@4905.02,5550.04 ; U21.30@4951.32,5557.33 ccw(c4944.49,5550.5) 4944.49,5560.16 ccw(c4944.49,5569.82) U21.30@4951.32,5562.99
VGA.GREEN5: U8.E7 U21.29 | length 1504.8
  Top Layer w4: v3(5075.04,4583.7) U8.E7@5094.72,4564.02 ; U8.E7@5087.38,4564.02 ccw(c5069.66,4564.02) 5082.19,4576.55 ccw(c5094.72,4589.08) U8.E7@5094.72,4571.36 ; 5087.84,4570.9 cw(c5100.65,4583.7) 5082.54,4583.7 ccw(c5100.65,4583.7) 5087.84,4570.9 ; 5087.84,4570.9 ccw(c5075.04,4558.09) 5075.04,4576.2 cw(c5075.04,4558.09) 5087.84,4570.9
  MidLayer1 w4: 4840,5169.88 4840.52,5169.35 ; 4854.73,5071.8 4867.7,5058.83 ; v1@4922.02,5543.37 ccw(c4899.09,5543.37) 4915.31,5559.59 ccw(c4931.52,5575.81) v1@4931.52,5552.87 ; v1@4926.02,5543.37 ccw(c4912.75,5543.37) 4922.13,5552.76 ccw(c4931.52,5562.15) v1@4931.52,5548.87 ; v1(4931.52,5543.37) 4907.27,5567.63 ; 5063.65,4597.28 cw(c5073.58,4607.21) 5059.53,4607.21 5059.53,4700.75 5059.53,4741.18 5059.53,4749.18 5059.53,4780.47 5057,4783 5057,4839.86 5031.86,4865 5031.86,4937.69 5018.5,4951.04 4975.48,4951.04 4867.7,5058.83 ; v3@5067.57,4584.35 ccw(c5049.53,4585.93) 5063.4,4597.57 ccw(c5077.27,4609.21) v3@5075.69,4591.17 ; 4840.52,5169.35 4823.52,5186.35 4821.52,5188.35 4821.52,5320 4821.52,5340.02 4831.86,5350.36 4831.86,5352.37 4831.86,5380 4831.86,5521.37 4881.25,5570.77 4904.13,5570.77 4906.19,5568.71 ; 4840.52,5169.35 4840.52,5100 4840.52,5086 4867.7,5058.83 ; 4906.19,5568.71 4907.27,5567.63 ; 4906.19,5568.71 4907.27,5567.63
  Bottom Layer w4: v1(4931.52,5543.37) 4934.43,5540.47 U21.29@4977.68,5540.47 ; v1@4935.41,5547.26 ccw(c4951.81,5563.66) U21.29@4951.81,5540.47 ; v1@4938.24,5536.66 cw(c4947.45,5527.45) 4947.45,5540.47 ; v1@4938.24,5550.09 ccw(c4961.47,5573.32) U21.29@4961.47,5540.47
VGA.GREEN6: U8.F7 U21.28 | length 1661.5
  Top Layer w4: v3(5075.04,4544.33) U8.F7@5094.72,4524.65 ; U8.F7@5087.38,4524.65 ccw(c5069.66,4524.65) 5082.19,4537.18 ccw(c5094.72,4549.71) U8.F7@5094.72,4531.99 ; 5087.84,4531.53 cw(c5100.65,4544.33) 5082.54,4544.33 ccw(c5100.65,4544.33) 5087.84,4531.53 ; 5087.84,4531.53 ccw(c5075.04,4518.72) 5075.04,4536.83 cw(c5075.04,4518.72) 5087.84,4531.53
  MidLayer1 w4: v1@4806.81,5397.66 cw(c4790.59,5381.44) 4813.52,5381.44 cw(c4836.46,5381.44) v1@4820.24,5397.66 ; v1@4809.64,5400.49 cw(c4800.25,5391.1) 4813.52,5391.1 cw(c4826.8,5391.1) v1@4817.41,5400.49 ; v1(4813.52,5404.37) 4813.52,5185.04 4831.86,5166.71 4831.86,5083.35 4972.17,4943.04 5015.19,4943.04 5023.52,4934.71 5023.52,4861.48 5049,4836 5049,4776 5051.18,4773.82 5051.18,4749.18 5051.18,4741.18 5051.18,4700.75 5051.18,4681.33 5051.18,4607.21 ; 5051.18,4621.14 5051.18,4607.21 ; v3@5067.65,4545.63 ccw(c5049.82,4548.78) 5064.65,4559.16 ; v3@5076.34,4551.72 cw(c5079.49,4569.55) 5064.65,4559.16 ; 5051.18,4607.21 5051.18,4583.96 ccw(c5074.95,4583.96) 5057.57,4567.74 5064.65,4559.16
  MidLayer2 w4: v1@4806.81,5411.09 ccw(c4790.59,5427.31) 4813.52,5427.31 ccw(c4836.46,5427.31) v1@4820.24,5411.09 ; v1@4809.64,5408.26 ccw(c4800.25,5417.65) 4813.52,5417.65 ccw(c4826.8,5417.65) v1@4817.41,5408.26 ; v1(4813.52,5404.37) 4813.52,5441.67 4828.86,5457 v1(4877,5457) ; v1@4870.28,5450.28 ccw(c4854.06,5434.06) 4854.06,5457 ccw(c4854.06,5479.93) v1@4870.28,5463.72 ; v1@4873.11,5453.11 ccw(c4863.72,5443.72) 4863.72,5457 ccw(c4863.72,5470.28) v1@4873.11,5460.89
  Bottom Layer w4: v1@4867.5,5457.09 ccw(c4845.31,5457.31) 4861,5473 ccw(c4876.69,5488.69) v1@4876.91,5466.5 ; v1@4871.5,5457.05 ccw(c4858.65,5457.18) 4867.74,5466.26 ccw(c4876.82,5475.35) v1@4876.95,5462.5 ; v1(4877,5457) 4861,5473 4861,5511 4875,5525 4910,5525 4914.21,5520.79 U21.28@4977.68,5520.79 ; U21.28@4951.32,5517.96 ccw(c4944.49,5511.13) 4944.49,5520.79 ccw(c4944.49,5530.44) U21.28@4951.32,5523.62
VGA.GREEN7: U8.E5 U21.27 | length 3078.7
  Top Layer w4: v3(4996.3,4583.7) U8.E5@5015.98,4564.02 ; U8.E5@5008.64,4564.02 ccw(c4990.92,4564.02) 5003.45,4576.55 ccw(c5015.98,4589.08) U8.E5@5015.98,4571.36 ; 5009.1,4570.9 cw(c5021.91,4583.7) 5003.8,4583.7 ccw(c5021.91,4583.7) 5009.1,4570.9 ; 5009.1,4570.9 ccw(c4996.3,4558.09) 4996.3,4576.2 cw(c4996.3,4558.09) 5009.1,4570.9
  MidLayer1 w4: v1@4875.14,5273.43 ccw(c4858.92,5289.64) 4881.86,5289.64 ccw(c4904.79,5289.64) v1@4888.57,5273.43 ; v1@4877.97,5270.6 ccw(c4868.58,5279.99) 4881.86,5279.99 ccw(c4895.14,5279.99) v1@4885.75,5270.6 ; v1(4881.86,5266.71) 4881.86,5361.86 4940,5420 4940,5479.56 v1(4919.52,5500.04) ; v1@4919.52,5490.54 cw(c4919.52,5467.61) 4935.74,5483.82 cw(c4951.96,5500.04) v1@4929.02,5500.04 ; v1@4919.52,5494.54 cw(c4919.52,5481.26) 4928.91,5490.65 cw(c4938.3,5500.04) v1@4925.02,5500.04
  Bottom Layer w4: v1(4881.86,5266.71) 4918.29,5266.71 4925,5260 4925,5040 4903,5018 4767.19,5018 4729.19,5056 4272.19,5056 4240.19,5024 4240.19,4941.71 4256.86,4925.04 4673.54,4925.04 4679.31,4930.81 4717.75,4930.81 4759.55,4889.01 4781.06,4867.5 4920,4867.5 4964.4,4867.5 5031.44,4867.5 5049.44,4849.5 5110.5,4849.5 5115.19,4844.81 5115.19,4833.37 5115.19,4830 5115.19,4785.19 5102.19,4772.19 4982.19,4772.19 4972.53,4762.53 4972.53,4749.18 4972.53,4741.18 4972.53,4739.59 4972.53,4681.33 4972.53,4623.07 ccw(c4996.3,4623.07) 4979.49,4606.26 4985.91,4598.53 ; v1@4885.75,5262.82 cw(c4895.14,5253.43) 4895.14,5266.71 cw(c4895.14,5279.99) v1@4885.75,5270.6 ; v1@4888.57,5259.99 cw(c4904.79,5243.77) 4904.79,5266.71 cw(c4904.79,5289.64) v1@4888.57,5273.43 ; v1(4919.52,5500.04) U21.27@4977.68,5500.04 ; v1@4923.41,5496.15 cw(c4932.8,5486.76) 4932.8,5500.04 cw(c4932.8,5513.32) v1@4923.41,5503.93 ; v1@4926.24,5493.32 cw(c4942.46,5477.11) 4942.46,5500.04 cw(c4942.46,5522.98) v1@4926.24,5506.76 ; 4941.93,5500.04 ccw(c4941.93,5513.32) U21.27@4951.32,5503.93 ; 4947.06,5500.04 cw(c4947.06,5494.01) U21.27@4951.32,5498.27 ; v3@4988.91,4585 ccw(c4971.08,4588.15) 4985.91,4598.53 ; v3@4997.6,4591.09 cw(c5000.75,4608.92) 4985.91,4598.53
VGA.RED0: U8.A10 U21.15 | length 1155.3
  Top Layer w4: v2@5118.06,5453.06 cw(c5101.31,5436.31) 5125,5436.31 cw(c5148.69,5436.31) v2@5131.94,5453.06 ; v2@5120.89,5455.89 cw(c5110.97,5445.97) 5125,5445.97 cw(c5139.03,5445.97) v2@5129.11,5455.89 ; v2(5125,5460) 5125,5425.19 5140.19,5410 5140.19,5191.71 5198.52,5133.37 5209.7,5122.2 5209.7,5030 ; 5209.7,5050.79 5209.7,5030 ; 5209.7,5030 5209.7,4980.53 5215.19,4975.04 5232.86,4957.37 5232.86,4891.71 5221.02,4879.87 5221.02,4813.39 5211.5,4803.88 5211.5,4752.52 5212.83,4751.18 5212.83,4741.18 ; 5212.83,4739.22 cw(c5195.11,4739.22) 5207.64,4726.69 ccw(c5195.11,4739.22) 5212.83,4739.22 ; 5212.83,4739.22 ccw(c5230.56,4739.22) 5218.03,4726.69 cw(c5230.56,4739.22) 5212.83,4739.22 ; 5212.83,4741.18 U8.A10@5212.83,4721.5 5212.83,4741.18
  Bottom Layer w4: v2(5125,5460) 5123.37,5458.37 5198.52,5458.37 5213.9,5443 U21.15@5213.9,5402.68 ; v2@5129.11,5464.11 ccw(c5142.95,5477.95) 5142.95,5458.37 ; v2@5131.94,5453.06 cw(c5144.76,5440.24) 5144.76,5458.37 ; v2@5131.94,5466.94 ccw(c5152.61,5487.61) 5152.61,5458.37 ; U21.15@5211.07,5429.03 ccw(c5204.24,5435.86) 5213.9,5435.86 ccw(c5223.55,5435.86) U21.15@5216.73,5429.03
VGA.RED1: U8.B10 U21.16 | length 1234.9
  Top Layer w4: v1(5215.19,4908.37) 5215.19,4894.71 5212.19,4891.71 5212.19,4815.88 5203.5,4807.19 5203.5,4757.35 5197.33,4751.18 5197.33,4741.18 ; 5197.33,4701.84 ccw(c5207.48,4701.84) 5200.3,4694.66 ; 5197.33,4701.84 ccw(c5207.48,4701.84) 5200.3,4694.66 ; 5197.33,4701.84 5197.33,4741.18 ; 5197.33,4701.84 5197.33,4741.18 ; 5200.3,4694.66 ccw(c5212.83,4707.19) 5212.83,4689.47 cw(c5212.83,4707.19) 5200.3,4694.66 ; 5200.3,4694.66 cw(c5187.77,4682.13) 5205.49,4682.13 ccw(c5187.77,4682.13) 5200.3,4694.66
  MidLayer1 w4: v1@5283.47,5268.32 cw(c5267.26,5252.11) 5290.19,5252.11 cw(c5313.13,5252.11) v1@5296.91,5268.32 ; v1@5286.3,5271.15 cw(c5276.91,5261.76) 5290.19,5261.76 cw(c5303.47,5261.76) v1@5294.08,5271.15 ; v1(5290.19,5275.04) 5290.19,5251.71 5256.86,5218.37 5256.86,5167.64 5264.7,5159.81 5264.7,4982.88 5240.19,4958.37 ; 5224.58,4917.76 cw(c5215.19,4927.15) 5215.19,4913.87 ccw(c5215.19,4927.15) 5224.58,4917.76 ; 5224.58,4917.76 ccw(c5233.97,4908.37) 5220.69,4908.37 cw(c5233.97,4908.37) 5224.58,4917.76 ; 5231.41,4924.59 cw(c5215.19,4940.81) 5215.19,4917.87 ccw(c5215.19,4940.81) 5231.41,4924.59 ; 5231.41,4924.59 ccw(c5247.63,4908.37) 5224.69,4908.37 cw(c5247.63,4908.37) 5231.41,4924.59 ; 5240.19,4933.37 v1(5215.19,4908.37) 5240.19,4933.37 ; 5240.19,4933.37 5240.19,4958.37 ; 5240.19,4933.37 5240.19,4958.37
  Bottom Layer w4: U21.16@5191.38,5376.32 cw(c5184.56,5369.49) 5194.21,5369.49 cw(c5203.87,5369.49) U21.16@5197.04,5376.32 ; U21.16@5194.21,5402.68 5194.21,5310.79 5229.96,5275.04 v1(5290.19,5275.04) ; v1@5283.47,5268.32 ccw(c5267.26,5252.11) 5267.26,5275.04 ccw(c5267.26,5297.98) v1@5283.47,5281.76 ; v1@5286.3,5271.15 ccw(c5276.91,5261.76) 5276.91,5275.04 ccw(c5276.91,5288.32) v1@5286.3,5278.93
VGA.RED2: U8.F10 U21.17 | length 1170.5
  Top Layer w4: v3(5193.15,4544.33) U8.F10@5212.83,4524.65 ; U8.F10@5205.49,4524.65 ccw(c5187.77,4524.65) 5200.3,4537.18 ccw(c5212.83,4549.71) U8.F10@5212.83,4531.99 ; 5205.95,4531.53 cw(c5218.76,4544.33) 5200.65,4544.33 ccw(c5218.76,4544.33) 5205.95,4531.53 ; 5205.95,4531.53 ccw(c5193.15,4518.72) 5193.15,4536.83 cw(c5193.15,4518.72) 5205.95,4531.53
  MidLayer1 w4: 5169.29,4621.14 5169.29,4607.21 ; v3@5185.68,4544.98 ccw(c5167.64,4546.56) 5181.51,4558.2 ; v3@5193.8,4551.8 cw(c5195.38,4569.84) 5181.51,4558.2 ; v1@5205.69,5251.04 cw(c5182.76,5251.04) 5198.97,5234.82 cw(c5215.19,5218.61) v1@5215.19,5241.54 ; v1@5209.69,5251.04 cw(c5196.41,5251.04) 5205.8,5241.65 cw(c5215.19,5232.26) v1@5215.19,5245.54 ; v1(5215.19,5251.04) 5181.86,5217.71 5181.86,4950 5181.86,4925.33 5185.5,4921.69 5185.5,4896.56 5185.5,4890 5185.5,4840 5185.5,4827.85 5185.5,4825 5185.5,4821.25 5185.5,4806.75 5182.37,4803.63 5169.29,4790.54 5169.29,4749.18 5169.29,4741.18 5169.29,4700.75 5169.29,4681.33 5169.29,4607.21 ; 5169.29,4607.21 5169.29,4587.71 ccw(c5211.02,4587.71) 5181.51,4558.2
  Bottom Layer w4: U21.17@5171.7,5376.32 cw(c5164.87,5369.49) 5174.53,5369.49 cw(c5184.18,5369.49) U21.17@5177.36,5376.32 ; U21.17@5174.53,5402.68 5174.53,5291.7 v1(5215.19,5251.04) ; v1@5205.69,5251.04 ccw(c5182.76,5251.04) 5198.97,5267.26 ccw(c5215.19,5283.48) v1@5215.19,5260.54 ; v1@5209.69,5251.04 ccw(c5196.41,5251.04) 5205.8,5260.43 ccw(c5215.19,5269.82) v1@5215.19,5256.54
VGA.RED3: U8.H10 U21.18 | length 1771.5
  Top Layer w4: v3(5193.15,4465.59) U8.H10@5212.83,4445.91 ; U8.H10@5205.49,4445.91 ccw(c5187.77,4445.91) 5200.3,4458.44 ccw(c5212.83,4470.97) U8.H10@5212.83,4453.25 ; 5205.95,4452.79 cw(c5218.76,4465.59) 5200.65,4465.59 ccw(c5218.76,4465.59) 5205.95,4452.79 ; 5205.95,4452.79 ccw(c5193.15,4439.98) 5193.15,4458.09 cw(c5193.15,4439.98) 5205.95,4452.79
  MidLayer2 w4: v1(5085,5085) 5085,5083.48 5085.11,5083.37 5131.63,5083.37 5135,5080 5255,5080 5270,5065 5270,5030 5265,5025 5174.56,5025 5057.94,4908.37 5048.52,4908.37 5028.19,4888.04 5028.19,4866.81 5047,4848 5073,4848 5144.25,4848 5170.69,4848 5185.5,4833.19 5185.5,4829.5 5185.5,4806.75 5175.25,4796.5 5169.29,4790.54 5169.29,4680.27 ; v1@5088.89,5088.89 ccw(c5102.2,5102.2) 5102.2,5083.37 ; v1@5091.72,5078.28 cw(c5104.01,5065.99) 5104.01,5083.37 ; v1@5091.72,5091.72 ccw(c5111.86,5111.86) 5111.86,5083.37 ; 5169.29,4738.53 5169.29,4680.27 ; v3@5185.68,4466.24 ccw(c5167.64,4467.82) 5181.51,4479.46 ; v3@5193.8,4473.06 cw(c5195.38,4491.1) 5181.51,4479.46 ; 5169.29,4680.27 5169.29,4622.01 5169.29,4602.59 5169.29,4528.47 5169.29,4508.97 ccw(c5211.02,4508.97) 5181.51,4479.46
  Bottom Layer w4: v1@5078.28,5091.72 ccw(c5062.06,5107.93) 5085,5107.93 ccw(c5107.93,5107.93) v1@5091.72,5091.72 ; v1@5081.11,5088.89 ccw(c5071.72,5098.28) 5085,5098.28 ccw(c5098.28,5098.28) v1@5088.89,5088.89 ; U21.18@5152.01,5376.32 cw(c5145.19,5369.49) 5154.84,5369.49 cw(c5164.5,5369.49) U21.18@5157.67,5376.32 ; U21.18@5154.84,5402.68 5154.84,5326.31 5165.19,5315.96 5165.19,5218.88 5085,5138.69 v1@5085,5086.52 ; v1@5083.48,5085 5084.24,5085.76 v1@5085,5086.52 ; v1@5083.48,5085 5081.86,5083.37 v1@5083.48,5085 ; v1@5083.48,5085 v1(5085,5085) v1@5085,5086.52
VGA.RED4: U8.C10 U21.19 | length 1114.4
  Top Layer w4: v1(5123.52,5064.37) 5117.52,5058.37 5117.52,4977.34 5118.02,4976.84 5118.02,4965.24 5117.52,4964.75 5117.52,4927.35 5128.5,4916.37 5154.37,4916.37 5195.5,4875.25 5195.5,4785.49 5188.97,4778.96 5188.97,4750.03 5188.97,4741.18 ; 5188.97,4682.64 ccw(c5227.65,4682.64) 5200.3,4655.29 ; 5188.97,4682.64 ccw(c5227.65,4682.64) 5200.3,4655.29 ; 5188.97,4682.64 5188.97,4741.18 ; 5188.97,4682.64 5188.97,4741.18 ; 5200.3,4655.29 cw(c5187.77,4642.76) 5205.49,4642.76 ccw(c5187.77,4642.76) 5200.3,4655.29 ; 5200.3,4655.29 ccw(c5212.83,4667.82) 5212.83,4650.1 cw(c5212.83,4667.82) 5200.3,4655.29
  Bottom Layer w4: 5099.6,5064.79 cw(c5099.6,5040.45) v1@5116.81,5057.66 ; 5101.58,5064.79 ccw(c5101.58,5086.32) v1@5116.81,5071.09 ; 5109.25,5064.79 cw(c5109.25,5050.1) v1@5119.64,5060.49 ; 5111.24,5064.79 ccw(c5111.24,5076.66) v1@5119.64,5068.26 ; v1(5123.52,5064.37) 5123.11,5064.79 5080.47,5064.79 5067.5,5077.75 5067.5,5132.5 5156.86,5221.86 5156.86,5312.98 5135.16,5334.68 U21.19@5135.16,5402.68 ; U21.19@5132.33,5376.32 cw(c5125.5,5369.49) 5135.16,5369.49 cw(c5144.81,5369.49) U21.19@5137.99,5376.32
VGA.RED5: U8.G8 U21.20 | length 1964.4
  Top Layer w4: v3(5114.41,4504.96) U8.G8@5134.09,4485.28 ; U8.G8@5126.75,4485.28 ccw(c5109.03,4485.28) 5121.56,4497.81 ccw(c5134.09,4510.34) U8.G8@5134.09,4492.62 ; 5127.21,4492.16 cw(c5140.02,4504.96) 5121.91,4504.96 ccw(c5140.02,4504.96) 5127.21,4492.16 ; 5127.21,4492.16 ccw(c5114.41,4479.35) 5114.41,4497.46 cw(c5114.41,4479.35) 5127.21,4492.16
  MidLayer2 w4: v1@4900.14,4898.43 ccw(c4883.92,4914.64) 4906.86,4914.64 ccw(c4929.79,4914.64) v1@4913.57,4898.43 ; v1@4902.97,4895.6 ccw(c4893.58,4904.99) 4906.86,4904.99 ccw(c4920.14,4904.99) v1@4910.75,4895.6 ; v1(4906.86,4891.71) 4906.86,5108.37 4936.52,5138.04 v1(5040.19,5138.04) ; v1@5033.47,5131.32 ccw(c5017.26,5115.11) 5017.26,5138.04 ccw(c5017.26,5160.98) v1@5033.47,5144.76 ; v1@5036.3,5134.15 ccw(c5026.91,5124.76) 5026.91,5138.04 ccw(c5026.91,5151.32) v1@5036.3,5141.93
  Bottom Layer w4: v1@4906.86,4882.21 cw(c4906.87,4859.31) 4923.06,4875.5 ; v1@4906.86,4886.21 cw(c4906.87,4872.95) 4916.24,4882.32 cw(c4925.61,4891.7) v1@4912.36,4891.71 ; v1(4906.86,4891.71) 4923.06,4875.5 ; v1@4916.36,4891.7 ccw(c4939.26,4891.69) 4923.06,4875.5 ; v1(5040.19,5138.04) 5061.73,5138.04 ; v1@5044.25,5134.33 cw(c5052.66,5126.66) 5052.66,5138.04 cw(c5052.66,5149.42) v1@5044.25,5141.75 ; v1@5047.21,5131.64 cw(c5061.73,5118.38) 5061.73,5138.04 ; v1@5047.21,5144.45 ccw(c5061.73,5157.7) 5061.73,5138.04 ; v3@5107.02,4506.26 ccw(c5089.19,4509.41) 5104.02,4519.79 ; U21.20@5112.64,5376.32 cw(c5105.82,5369.49) 5115.47,5369.49 cw(c5125.13,5369.49) U21.20@5118.3,5376.32 ; U21.20@5115.47,5402.68 5115.47,5343.05 5148.52,5310 5148.52,5224.84 5061.73,5138.04 ; v3@5115.71,4512.35 cw(c5118.86,4530.18) 5104.02,4519.79 ; 4923.06,4875.5 5034.75,4875.5 5052.75,4857.5 5086.26,4857.5 5134.26,4905.5 5165.25,4905.5 5187.5,4883.25 5187.5,4864.35 5146.5,4823.35 5146.5,4808.72 5152,4803.22 5152,4800.22 5152,4778.48 5152,4775.48 5148.71,4772.19 5118,4772.19 5110,4764.19 5014.19,4764.19 5011.9,4761.9 5011.9,4749.18 5011.9,4741.18 5011.9,4739.59 5011.9,4681.33 5011.9,4623.07 ccw(c5035.67,4623.07) 5035.67,4599.3 cw(c5035.67,4583.7) 5051.27,4583.7 ccw(c5075.04,4583.7) 5075.04,4559.93 cw(c5075.04,4544.33) 5090.64,4544.33 ccw(c5114.41,4544.33) 5097.6,4527.52 5104.02,4519.79
VGA.RED6: U8.G9 U21.21 | length 1622.3
  Top Layer w4: v3(5153.78,4504.96) U8.G9@5173.46,4485.28 ; U8.G9@5166.12,4485.28 ccw(c5148.4,4485.28) 5160.93,4497.81 ccw(c5173.46,4510.34) U8.G9@5173.46,4492.62 ; 5166.58,4492.16 cw(c5179.39,4504.96) 5161.28,4504.96 ccw(c5179.39,4504.96) 5166.58,4492.16 ; 5166.58,4492.16 ccw(c5153.78,4479.35) 5153.78,4497.46 cw(c5153.78,4479.35) 5166.58,4492.16
  MidLayer1 w4: v1@5025.5,5000 ccw(c5002.56,5000) 5018.78,5016.22 ccw(c5035,5032.43) v1@5035,5009.5 ; v1@5029.5,5000 ccw(c5016.22,5000) 5025.61,5009.39 ccw(c5035,5018.78) v1@5035,5005.5 ; v1(5035,5000) 4973.52,5061.48 4973.52,5105 4973.52,5341.71 4990.19,5358.37 5056.86,5358.37 v1(5115.19,5300.04) ; v1@5105.69,5300.04 ccw(c5082.76,5300.04) 5098.97,5316.26 ccw(c5115.19,5332.48) v1@5115.19,5309.54 ; v1@5109.69,5300.04 ccw(c5096.41,5300.04) 5105.8,5309.43 ccw(c5115.19,5318.82) v1@5115.19,5305.54
  MidLayer2 w4: v1@5028.28,4993.28 cw(c5012.06,4977.06) 5035,4977.06 cw(c5057.93,4977.06) v1@5041.72,4993.28 ; v1@5031.11,4996.11 cw(c5021.72,4986.72) 5035,4986.72 cw(c5048.28,4986.72) v1@5038.89,4996.11 ; v1(5035,5000) 5035,4910 5020,4895 5020,4863.69 5043.81,4839.87 5130.13,4839.87 5138.27,4831.73 5138.27,4622.01 5138.27,4528.47 ; 5138.27,4542.4 5138.27,4528.47 ; 5142.39,4518.54 cw(c5152.32,4528.47) 5138.27,4528.47 ; v3@5146.31,4505.61 ccw(c5128.27,4507.19) 5142.14,4518.83 ccw(c5156.01,4530.47) v3@5154.43,4512.43
  Bottom Layer w4: U21.21@5092.96,5376.32 cw(c5086.13,5369.49) 5095.79,5369.49 cw(c5105.44,5369.49) U21.21@5098.62,5376.32 ; U21.21@5095.79,5402.68 5095.79,5362.74 5098.52,5360 5098.52,5325.04 5115.19,5308.37 v1(5115.19,5300.04) ; 5100.85,5322.71 cw(c5079.47,5301.32) v1@5109.69,5300.24 ; 5107.35,5316.21 cw(c5092.01,5300.87) v1@5113.69,5300.09
VGA.RED7: U8.C9 U21.22 | length 991.7
  Top Layer w4: v1(5098.52,5008.37) 5109.52,4997.37 5109.52,4974.02 5110.02,4973.53 5110.02,4968.56 5109.52,4968.06 5109.52,4911.73 5149.63,4871.63 5149.63,4741.2 ; 5149.6,4741.18 5149.6,4682.64 ccw(c5188.28,4682.64) 5160.93,4655.29 ; U8.C9@5166.12,4642.76 ccw(c5148.4,4642.76) 5160.93,4655.29 ; U8.C9@5173.46,4650.1 cw(c5173.46,4667.82) 5160.93,4655.29
  Bottom Layer w4: U21.22@5073.27,5376.32 cw(c5066.45,5369.49) 5076.1,5369.49 cw(c5085.76,5369.49) U21.22@5078.93,5376.32 ; U21.22@5076.1,5402.68 5076.1,5358.37 5062.52,5344.8 5062.52,5300.08 5065.36,5297.25 5065.36,5210.21 4998.52,5143.37 4998.52,5033.37 5011.9,5020 5060,5020 5071.63,5008.37 v1(5098.52,5008.37) ; v1@5091.81,5001.66 ccw(c5075.59,4985.44) 5075.59,5008.37 ccw(c5075.59,5031.31) v1@5091.81,5015.09 ; v1@5094.64,5004.49 ccw(c5085.25,4995.1) 5085.25,5008.37 ccw(c5085.25,5021.65) v1@5094.64,5012.26
VGA.VGA_CLK: U8.B6 U21.26 | length 1278
  Top Layer w4: v1@4887.19,5493.54 cw(c4887.19,5470.61) 4903.41,5486.82 cw(c4919.63,5503.04) v1@4896.69,5503.04 ; v1@4887.19,5497.54 cw(c4887.19,5484.26) 4896.58,5493.65 cw(c4905.97,5503.04) v1@4892.69,5503.04 ; v1(4887.19,5503.04) 4915.19,5475.04 4920.52,5475.04 4928.86,5466.71 4928.86,5440 4930,5440 4970,5400 4970,5303.56 4981.86,5291.71 4981.86,5200.04 4915.19,5133.37 4915.19,4959.71 5012.81,4862.09 ; 5023.52,4851.37 5012.81,4862.09 ; 5012.81,4862.09 5039.85,4835.05 5039.85,4749.18 5039.85,4741.18 ; 5039.85,4701.84 ccw(c5050,4701.84) 5042.82,4694.66 ; 5039.85,4701.84 ccw(c5050,4701.84) 5042.82,4694.66 ; 5039.85,4701.84 5039.85,4741.18 ; 5039.85,4701.84 5039.85,4741.18 ; 5042.82,4694.66 ccw(c5055.35,4707.19) 5055.35,4689.47 cw(c5055.35,4707.19) 5042.82,4694.66 ; 5042.82,4694.66 cw(c5030.29,4682.13) 5048.01,4682.13 ccw(c5030.29,4682.13) 5042.82,4694.66
  Bottom Layer w4: v1@4887.19,5493.54 cw(c4887.19,5470.61) 4903.41,5486.82 cw(c4919.63,5503.04) v1@4896.69,5503.04 ; v1@4887.19,5497.54 cw(c4887.19,5484.26) 4896.58,5493.65 cw(c4905.97,5503.04) v1@4892.69,5503.04 ; v1(4887.19,5503.04) 4907.69,5482.54 4976.55,5482.54 U21.26@4977.68,5481.42 ; 4941.78,5482.54 cw(c4941.78,5469.05) U21.26@4951.32,5478.59 ; 4947.21,5482.54 ccw(c4947.21,5488.36) U21.26@4951.32,5484.25
VINB: C142.2 NT43.1 U43.1 U43.3 | length 405.5
  MidLayer2 w12: v1(4515.19,2500.04) v1(4565.19,2500.04) ; v1@4519.08,2496.15 cw(c4528.47,2486.76) 4528.47,2500.04 cw(c4528.47,2513.32) v1@4519.08,2503.93 ; v1@4561.3,2496.15 ccw(c4551.91,2486.76) 4551.91,2500.04 ccw(c4551.91,2513.32) v1@4561.3,2503.93
  Bottom Layer w12: NT43.1@4513.34,2637.78 cw(c4496.7,2621.14) 4520.24,2621.14 cw(c4543.77,2621.14) NT43.1@4527.13,2637.78 ; 4514.41,2515.2 ccw(c4530.35,2515.2) v1@4519.08,2503.93 ; 4514.41,2556.71 cw(c4548.6,2556.71) C142.2@4524.42,2580.89 ; v1(4515.19,2500.04) 4514.41,2500.82 U43.1@4514.41,2537.4 4514.41,2579.25 4520.24,2585.08 NT43.1@4520.24,2654.92 ; C142.2@4516.21,2589.11 ccw(c4506.48,2598.84) 4520.24,2598.84 ; 4520.24,2599.22 ccw(c4534.53,2599.22) C142.2@4524.42,2589.11 ; v1@4561.3,2503.93 ccw(c4550.95,2514.29) 4565.59,2514.29 ; v1@4565.59,2500.44 U43.3@4565.59,2537.4 ; 4565.59,2512.35 ccw(c4577.5,2512.35) v1@4569.08,2503.93
VINC: C181.2 NT18.1 U58.1 U58.3 | length 636.3
  MidLayer1 w12: v1(1319.92,5150.04) 1435.04,5150.04 1452.19,5167.19 v1(1452.19,5275.04) ; v1@1323.81,5146.15 cw(c1333.2,5136.76) 1333.2,5150.04 cw(c1333.2,5163.32) v1@1323.81,5153.93 ; v1@1448.3,5271.15 cw(c1438.91,5261.76) 1452.19,5261.76 cw(c1465.47,5261.76) v1@1456.08,5271.15
  Bottom Layer w12: NT18.1@1313.03,5106.66 ccw(c1296.2,5123.49) 1320,5123.49 ; C181.2@1315.89,5180.22 cw(c1305.97,5170.3) 1320,5170.3 cw(c1334.03,5170.3) C181.2@1324.11,5180.22 ; v1@1316.03,5146.15 cw(c1306.45,5136.57) 1320,5136.57 ; v1@1316.03,5153.93 ccw(c1306.45,5163.51) 1320,5163.51 ; NT18.1@1319.92,5099.76 1320,5099.84 1320,5150.04 C181.2@1320,5184.33 ; 1320,5123.11 ccw(c1343.27,5123.11) NT18.1@1326.81,5106.66 ; 1320,5136.95 cw(c1333.01,5136.95) v1@1323.81,5146.15 ; 1320,5163.13 ccw(c1333.01,5163.13) v1@1323.81,5153.93 ; U58.1@1409.41,5242.4 1409.41,5269.41 1415.04,5275.04 v1(1452.19,5275.04) 1460.59,5266.64 U58.3@1460.59,5242.4 ; v1@1448.3,5278.93 cw(c1438.91,5288.32) 1438.91,5275.04 cw(c1438.91,5261.76) 1448.3,5271.15 cw(c1418.63,5241.48) U58.3@1460.59,5241.48
VOUTB: C143.1 C144.2 NT42.2 U43.5 | length 617.9
  Bottom Layer w12: C143.1@4453.41,2332.53 ccw(c4396.45,2389.5) 4477.01,2389.5 ccw(c4557.57,2389.5) C143.1@4500.6,2332.53 ; C143.1@4461.9,2324.05 ccw(c4425.42,2360.53) 4477.01,2360.53 ccw(c4528.6,2360.53) C143.1@4492.12,2324.05 ; NT42.2@4462.87,2416.75 cw(c4428.74,2382.62) 4477.01,2382.62 ; NT42.2@4468.17,2422.05 ccw(c4485.2,2439.08) NT42.2@4485.2,2415 ; NT42.2@4470,2433.37 4488.37,2415 ; NT42.2@4471.29,2453.78 ccw(c4476.23,2484.83) 4498.46,2462.6 ; NT42.2@4476.66,2430.54 ccw(c4514.17,2468.05) C144.2@4514.17,2415 ; C143.1@4477.01,2305 4477.01,2426.65 NT42.2@4469.76,2433.9 4498.46,2462.6 ; NT42.2@4479.51,2423.76 ccw(c4488.37,2423.86) 4488.37,2415 ; U43.5@4514.41,2462.6 4498.46,2462.6 ; C144.2@4516.21,2410.89 ccw(c4506.29,2400.97) 4506.29,2415 ccw(c4506.29,2429.03) C144.2@4516.21,2419.11 ; C144.2@4520.31,2415 4488.37,2415
VOUTC: C182.1 C183.2 NT17.2 U58.5 | length 1288.7
  MidLayer1 w12: v1(1440.19,5316.71) 1765.15,5316.71 1791.86,5290 v1(1791.86,5183.37) ; v1@1444.08,5312.82 cw(c1453.47,5303.43) 1453.47,5316.71 cw(c1453.47,5329.99) v1@1444.08,5320.6 ; v1@1787.97,5187.26 ccw(c1778.58,5196.65) 1791.86,5196.65 ccw(c1805.14,5196.65) v1@1795.75,5187.26
  Bottom Layer w12: U58.5@1409.41,5167.6 1409.41,5203.14 1392.52,5220.03 1392.52,5300.94 1408.29,5316.71 v1(1440.19,5316.71) ; v1@1436.3,5312.82 ccw(c1426.91,5303.43) 1426.91,5316.71 ccw(c1426.91,5329.99) v1@1436.3,5320.6 ; C182.1@1682.36,5175.23 cw(c1645.89,5130.65) 1703.48,5130.65 ; C182.1@1689.95,5184.52 cw(c1666.6,5155.97) 1703.48,5155.97 cw(c1740.37,5155.97) C182.1@1717.01,5184.52 ; 1698.36,5135.77 cw(c1672.38,5109.79) NT17.2@1708.94,5106.19 ; C182.1@1703.48,5183.37 1703.48,5130.65 ; C182.1@1703.48,5205 1724.15,5184.33 1791.86,5184.33 C183.2@1820,5184.33 ; C182.1@1711.52,5205.87 ccw(c1749.52,5228.61) 1749.52,5184.33 ; C182.1@1721.82,5212.04 ccw(c1770.69,5241.28) 1770.69,5184.33 ; C182.1@1724.61,5175.23 ccw(c1761.08,5130.65) 1703.48,5130.65 ; C182.1@1727.08,5177.47 cw(c1743.65,5160.9) 1743.65,5184.33 ; NT17.2@1728.9,5105.24 1703.48,5130.65 ; 1776.27,5184.33 cw(c1776.27,5167.79) v1@1787.97,5179.49 ; v1@1795.75,5179.49 cw(c1807.44,5167.79) 1807.44,5184.33
X1: C45.2 U5.46 Y2.1 | length 649.5
  Bottom Layer w12: U5.46@2528.19,5421.1 2566.1,5421.1 2575,5430 2575,5484.85 2580.15,5490 2685.85,5490 2707.5,5511.65 Y2.1@2707.5,5611.5 2707.5,5672 2699.5,5680 C45.2@2655.67,5680 ; C45.2@2659.78,5675.89 cw(c2669.7,5665.97) 2669.7,5680 cw(c2669.7,5694.03) C45.2@2659.78,5684.11 ; Y2.1@2692.3,5592.3 cw(c2655.59,5555.59) 2707.5,5555.59 cw(c2759.41,5555.59) Y2.1@2722.7,5592.3 ; Y2.1@2692.3,5630.7 ccw(c2655.59,5667.41) 2707.5,5667.41 ccw(c2759.41,5667.41) Y2.1@2722.7,5630.7
X2: C46.2 U5.47 Y2.3 | length 251.3
  Bottom Layer w12: U5.47@2528.19,5401.42 2610.17,5401.42 2612,5399.59 ; Y2.3@2597.3,5429.3 cw(c2560.59,5392.59) 2612.5,5392.59 cw(c2664.41,5392.59) Y2.3@2627.7,5429.3 ; 2612.5,5398.45 ccw(c2632.78,5398.45) C46.2@2618.44,5384.11 ; Y2.3@2612.5,5448.5 2612.5,5381.83 C46.2@2614.33,5380
pads on no net: D1.2 D2.2 D7.3 FD1.0 FD2.0 FD3.0 J4.12 J4.13 J5.10 J5.11 J5.12 J5.13 J6.10 J6.12 J6.13 J7.12 J7.13 J8.7 J8.MH3 J8.MH4 J9.4 J9.X J9.Y J10.4 J10.X J10.Y J20.1 J20.2 J20.3 J21.1 J21.3 J22.1 J22.3 J23.4 J23.5 J23.7 J23.8 J23.MH1 J23.MH2 J25.PEGA J25.PEGB J27.41 J27.42 J28.41 J28.42 J29.MH1 J29.MH2 J30.MH1 J30.MH2 J31.2 J31.6 J32.2 J32.6 PROTOTYPE1.7 PROTOTYPE1.8 PROTOTYPE1.9 PROTOTYPE1.10 PROTOTYPE1.11 PROTOTYPE1.12 PROTOTYPE1.13 PROTOTYPE1.14 PROTOTYPE1.15 PROTOTYPE1.16 PROTOTYPE1.17 PROTOTYPE1.18 PROTOTYPE1.19 PROTOTYPE1.20 PROTOTYPE1.21 PROTOTYPE1.22 PROTOTYPE1.23 PROTOTYPE1.24 PROTOTYPE1.25 PROTOTYPE1.26 PROTOTYPE1.A2 PROTOTYPE1.A3 PROTOTYPE1.A4 PROTOTYPE1.A5 PROTOTYPE1.A6 PROTOTYPE1.A7 PROTOTYPE1.A8 PROTOTYPE1.A9 PROTOTYPE1.A10 PROTOTYPE1.A11 PROTOTYPE1.A12 PROTOTYPE1.A13 PROTOTYPE1.A14 PROTOTYPE1.A15 PROTOTYPE1.A16 PROTOTYPE1.A17 PROTOTYPE1.A18 PROTOTYPE1.A19 PROTOTYPE1.A20 PROTOTYPE1.A21 PROTOTYPE1.A22 PROTOTYPE1.A23 PROTOTYPE1.A24 PROTOTYPE1.A25 PROTOTYPE1.A26 PROTOTYPE1.A27 PROTOTYPE1.A28 PROTOTYPE1.A29 PROTOTYPE1.A30 PROTOTYPE1.A31 PROTOTYPE1.B2 PROTOTYPE1.B3 PROTOTYPE1.B4 PROTOTYPE1.B5 PROTOTYPE1.B6 PROTOTYPE1.B7 PROTOTYPE1.B8 PROTOTYPE1.B9 PROTOTYPE1.B10 PROTOTYPE1.B11 PROTOTYPE1.B12 PROTOTYPE1.B13 PROTOTYPE1.B14 PROTOTYPE1.B15 PROTOTYPE1.B16 PROTOTYPE1.B17 PROTOTYPE1.B18 PROTOTYPE1.B19 PROTOTYPE1.B20 PROTOTYPE1.B21 PROTOTYPE1.B22 PROTOTYPE1.B23 PROTOTYPE1.B24 PROTOTYPE1.B25 PROTOTYPE1.B26 PROTOTYPE1.B27 PROTOTYPE1.B28 PROTOTYPE1.B29 PROTOTYPE1.B30 PROTOTYPE1.B31 PROTOTYPE1.C1 PROTOTYPE1.C2 PROTOTYPE1.C3 PROTOTYPE1.C4 PROTOTYPE1.C5 PROTOTYPE1.C6 PROTOTYPE1.C7 PROTOTYPE1.C8 PROTOTYPE1.C9 PROTOTYPE1.C10 PROTOTYPE1.C11 PROTOTYPE1.C12 PROTOTYPE1.C13 PROTOTYPE1.C14 PROTOTYPE1.C15 PROTOTYPE1.C16 PROTOTYPE1.C17 PROTOTYPE1.C18 PROTOTYPE1.C19 PROTOTYPE1.C20 PROTOTYPE1.C21 PROTOTYPE1.C22 PROTOTYPE1.C23 PROTOTYPE1.C24 PROTOTYPE1.C25 PROTOTYPE1.C26 PROTOTYPE1.C27 PROTOTYPE1.C28 PROTOTYPE1.C29 PROTOTYPE1.C30 PROTOTYPE1.C31 PROTOTYPE1.C32 PROTOTYPE1.D1 PROTOTYPE1.D2 PROTOTYPE1.D3 PROTOTYPE1.D4 PROTOTYPE1.D5 PROTOTYPE1.D6 PROTOTYPE1.D7 PROTOTYPE1.D8 PROTOTYPE1.D9 PROTOTYPE1.D10 PROTOTYPE1.D11 PROTOTYPE1.D12 PROTOTYPE1.D13 PROTOTYPE1.D14 PROTOTYPE1.D15 PROTOTYPE1.D16 PROTOTYPE1.D17 PROTOTYPE1.D18 PROTOTYPE1.D19 PROTOTYPE1.D20 PROTOTYPE1.D21 PROTOTYPE1.D22 PROTOTYPE1.D23 PROTOTYPE1.D24 PROTOTYPE1.D25 PROTOTYPE1.D26 PROTOTYPE1.D27 PROTOTYPE1.D28 PROTOTYPE1.D29 PROTOTYPE1.D30 PROTOTYPE1.D31 PROTOTYPE1.D32 PROTOTYPE1.E1 PROTOTYPE1.E2 PROTOTYPE1.E3 PROTOTYPE1.E4 PROTOTYPE1.E5 PROTOTYPE1.E6 PROTOTYPE1.E7 PROTOTYPE1.E8 PROTOTYPE1.E9 PROTOTYPE1.E10 PROTOTYPE1.E11 PROTOTYPE1.E12 PROTOTYPE1.E13 PROTOTYPE1.E14 PROTOTYPE1.E15 PROTOTYPE1.E16 PROTOTYPE1.E17 PROTOTYPE1.E18 PROTOTYPE1.E19 PROTOTYPE1.E20 PROTOTYPE1.E21 PROTOTYPE1.E22 PROTOTYPE1.E23 PROTOTYPE1.E24 PROTOTYPE1.E25 PROTOTYPE1.E26 PROTOTYPE1.E27 PROTOTYPE1.E28 PROTOTYPE1.E29 PROTOTYPE1.E30 PROTOTYPE1.E31 PROTOTYPE1.E32 PROTOTYPE1.F1 PROTOTYPE1.F2 PROTOTYPE1.F3 PROTOTYPE1.F4 PROTOTYPE1.F5 PROTOTYPE1.F6 PROTOTYPE1.F7 PROTOTYPE1.F8 PROTOTYPE1.F9 PROTOTYPE1.F10 PROTOTYPE1.F11 PROTOTYPE1.F12 PROTOTYPE1.F13 PROTOTYPE1.F14 PROTOTYPE1.F15 PROTOTYPE1.F16 PROTOTYPE1.F17 PROTOTYPE1.F18 PROTOTYPE1.F19 PROTOTYPE1.F20 PROTOTYPE1.F21 PROTOTYPE1.F22 PROTOTYPE1.F23 PROTOTYPE1.F24 PROTOTYPE1.F25 PROTOTYPE1.F26 PROTOTYPE1.F27 PROTOTYPE1.F28 PROTOTYPE1.F29 PROTOTYPE1.F30 PROTOTYPE1.F31 PROTOTYPE1.F32 PROTOTYPE1.G1 PROTOTYPE1.G2 PROTOTYPE1.G3 PROTOTYPE1.G4 PROTOTYPE1.G5 PROTOTYPE1.G6 PROTOTYPE1.G7 PROTOTYPE1.G8 PROTOTYPE1.G9 PROTOTYPE1.G10 PROTOTYPE1.G11 PROTOTYPE1.G12 PROTOTYPE1.G13 PROTOTYPE1.G14 PROTOTYPE1.G15 PROTOTYPE1.G16 PROTOTYPE1.G17 PROTOTYPE1.G18 PROTOTYPE1.G19 PROTOTYPE1.G20 PROTOTYPE1.G21 PROTOTYPE1.G22 PROTOTYPE1.G23 PROTOTYPE1.G24 PROTOTYPE1.G25 PROTOTYPE1.G26 PROTOTYPE1.G27 PROTOTYPE1.G28 PROTOTYPE1.G29 PROTOTYPE1.G30 PROTOTYPE1.G31 PROTOTYPE1.G32 R265.1 SW1.1 SW1.4 SW2.1 SW2.4 SW3.1 SW3.4 SW4.1 SW4.4 SW5.1 SW5.4 T1.2 T1.3 T1.6 T1.7 U2.2 U2.4 U2.7 U2.10 U2.14 U2.15 U3.6 U3.12 U4.1 U5.27 U6.3 U6.5 U6.7 U6.9 U6.16 U6.18 U7.A1 U7.A8 U7.B1 U7.B4 U7.C1 U7.D1 U7.E1 U7.F8 U7.G1 U7.G8 U7.H1 U7.H8 U8.A3 U8.A4 U8.A7 U8.A11 U8.A18 U8.A22 U8.A23 U8.AA4 U8.AA14 U8.AA19 U8.AB9 U8.AB21 U8.AC4 U8.AC5 U8.AC15 U8.AC17 U8.AD4 U8.AD15 U8.AE11 U8.AE16 U8.AE17 U8.AE21 U8.AE24 U8.B17 U8.B22 U8.B26 U8.C5 U8.C22 U8.C24 U8.D4 U8.D5 U8.D11 U8.D12 U8.D14 U8.D22 U8.D23 U8.D24 U8.E11 U8.E14 U8.E24 U8.F12 U8.F21 U8.F22 U8.F24 U8.F25 U8.G17 U8.G18 U8.G23 U8.G28 U8.H15 U8.H17 U8.H21 U8.H24 U8.J14 U8.J16 U8.J24 U8.K15 U8.L24 U8.N8 U8.T4 U8.T7 U8.T25 U8.U23 U8.U24 U8.V20 U8.V23 U8.W25 U8.Y5 U8.Y6 U8.Y15 U8.Y24 U8.Y25 U12.40 U13.40 U18.3 U18.4 U19.54 U21.9 U21.10 U21.13 U21.14 U21.35 U21.36 U23.3 U23.5 U23.6 U27.3 U27.4 U27.11 U30.E1 U30.E16 U30.L8 U30.L10 U30.L15 U30.M1 U30.M2 U30.M10 U30.M16 U30.N9 U30.P8 U30.T10 U30.T11 U36.3 U37.1 U38.1 U43.4 U44.4 U46.1 U46.8 U46.13 U54.1 U55.3 U55.4 U56.54 U58.4 U61.21 U61.28 U61.35 U61.111 U61.113 U62.3 U62.4 U63.3 U63.4 U64.3 U64.4 U65.1 U66.1 U67.1 U68.1 U70.3 U70.5 U70.8 U71.1 U72.1 VR1.4 VR1.5 VR1.6