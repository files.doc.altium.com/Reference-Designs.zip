# Altium PCB NB3000AL.PcbDoc (part 13 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
ATE.HOST_JTAG.HARD.TDI: J25.1 J33.B2 R267.1 | length 14393
  Top Layer w4: v2(85,6150) 110,6175 v2(110,6600) ; v2@85,6155.81 ccw(c85,6169.84) 94.92,6159.92 ccw(c104.84,6150) v2@90.81,6150 ; v2@85,6159.81 ccw(c85,6183.5) 101.75,6166.75 ccw(c118.5,6150) v2@94.81,6150 ; v2@103.06,6593.06 cw(c86.31,6576.31) 110,6576.31 cw(c133.69,6576.31) v2@116.94,6593.06 ; v2@105.89,6595.89 cw(c95.97,6585.97) 110,6585.97 cw(c124.03,6585.97) v2@114.11,6595.89 ; J25.1@7470.73,5403.99 ccw(c7431.47,5364.73) 7431.47,5420.25 ccw(c7431.47,5475.78) J25.1@7470.73,5436.52 ; J25.1@7473.56,5406.82 ccw(c7441.12,5374.38) 7441.12,5420.25 ccw(c7441.12,5466.12) J25.1@7473.56,5433.69 ; J25.1@7476.39,5409.65 ccw(c7450.78,5384.04) 7450.78,5420.25 ccw(c7450.78,5456.47) J25.1@7476.39,5430.86 ; J25.1@7479.21,5412.47 ccw(c7460.44,5393.7) 7460.44,5420.25 ccw(c7460.44,5446.81) J25.1@7479.21,5428.03 ; J25.1@7484.97,5480.66 ccw(c7484.77,5482.87) 7486.99,5482.87 ; J25.1@7489.02,5480.66 cw(c7489.21,5482.87) 7486.99,5482.87 ; v2@7528.06,5853.06 cw(c7511.31,5836.31) 7535,5836.31 cw(c7558.69,5836.31) v2@7541.94,5853.06 ; v2@7530.89,5855.89 cw(c7520.97,5845.97) 7535,5845.97 cw(c7549.03,5845.97) v2@7539.11,5855.89 ; v2(7535,5860) 7535,5771.92 7508.08,5745 7430,5745 7415,5730 7415,5430 7424.75,5420.25 J25.1@7486.99,5420.25 7486.99,5482.87 ; v2(7854,5997) R267.1@7905.81,5997 ; v2@7858.11,5992.89 cw(c7868.03,5982.97) 7868.03,5997 cw(c7868.03,6011.03) v2@7858.11,6001.11 ; v2@7860.94,5990.06 cw(c7877.69,5973.31) 7877.69,5997 cw(c7877.69,6020.69) v2@7860.94,6003.94 ; R267.1@7899.22,5990.41 ccw(c7883.31,5974.5) 7883.31,5997 ccw(c7883.31,6019.5) R267.1@7899.22,6003.59 ; R267.1@7902.05,5993.24 ccw(c7892.97,5984.16) 7892.97,5997 ccw(c7892.97,6009.84) R267.1@7902.05,6000.76
  MidLayer1 w4: v2(-510,4760) -524.14,4774.14 -524.14,5258.23 -454.81,5327.56 -329.09,5327.56 -311.52,5345.14 -311.52,5905.86 -184.56,6032.81 -47.62,6032.81 -35,6020.19 v2(-35,5990) ; v2@-41.94,5996.94 ccw(c-58.69,6013.69) -35,6013.69 ccw(c-11.31,6013.69) v2@-28.06,5996.94 ; v2@-39.11,5994.11 ccw(c-49.03,6004.03) -35,6004.03 ccw(c-20.97,6004.03) v2@-30.89,5994.11 ; v2@103.06,6606.94 ccw(c86.31,6623.69) 110,6623.69 ccw(c133.69,6623.69) v2@116.94,6606.94 ; v2@105.89,6604.11 ccw(c95.97,6614.03) 110,6614.03 ccw(c124.03,6614.03) v2@114.11,6604.11 ; v2(110,6600) 110,6770 218.28,6878.28 4865.41,6878.28 4996.69,6747 6144.63,6747 6266.63,6869 6926.37,6869 7048.37,6747 7375.37,6747 7408,6714.37 7408,6433 7446.85,6394.15 7446.85,6263.15 7600,6110 7600,5875 7585,5860 ; v2(7535,5860) 7585,5860 ; v2@7539.11,5855.89 cw(c7549.03,5845.97) 7549.03,5860 cw(c7549.03,5874.03) v2@7539.11,5864.11 ; v2@7541.94,5853.06 cw(c7558.69,5836.31) 7558.69,5860 cw(c7558.69,5883.69) v2@7541.94,5866.94 ; v2@7854,5987.19 cw(c7854,5963.5) 7870.75,5980.25 cw(c7887.5,5997) v2@7863.81,5997 ; v2@7854,5991.19 cw(c7854,5977.16) 7863.92,5987.08 cw(c7873.84,5997) v2@7859.81,5997 ; v2(7854,5997) 7889.81,5961.19 7906.62,5961.19 7942.81,5925 7942.81,5822.81 7929,5809 7823,5809 7796,5836 7751,5836 7737,5822 7623,5822 7585,5860
  MidLayer2 w4: v2(-595,4760) v2(-510,4760) ; v2@-590.89,4755.89 cw(c-580.97,4745.97) -580.97,4760 cw(c-580.97,4774.03) v2@-590.89,4764.11 ; v2@-588.06,4753.06 cw(c-571.31,4736.31) -571.31,4760 cw(c-571.31,4783.69) v2@-588.06,4766.94 ; v2@-516.94,4753.06 ccw(c-533.69,4736.31) -533.69,4760 ccw(c-533.69,4783.69) v2@-516.94,4766.94 ; v2@-514.11,4755.89 ccw(c-524.03,4745.97) -524.03,4760 ccw(c-524.03,4774.03) v2@-514.11,4764.11 ; v2@-41.94,5996.94 ccw(c-58.69,6013.69) -35,6013.69 ccw(c-11.31,6013.69) v2@-28.06,5996.94 ; v2@-39.11,5994.11 ccw(c-49.03,6004.03) -35,6004.03 ccw(c-20.97,6004.03) v2@-30.89,5994.11 ; v2(-35,5990) -35,6030 v2(85,6150) ; v2@75.19,6150 cw(c51.5,6150) 68.25,6133.25 cw(c85,6116.5) v2@85,6140.19 ; v2@79.19,6150 cw(c65.16,6150) 75.08,6140.08 cw(c85,6130.16) v2@85,6144.19
  Bottom Layer w4: J33.B2@-785.98,4227.66 -782.82,4224.5 -684.5,4224.5 -668.71,4208.71 -576.98,4208.71 -559.65,4226.04 -559.65,4724.65 v2(-595,4760) ; J33.B2@-714.22,4230.13 ccw(c-701.94,4240.7) -701.94,4224.5 ; J33.B2@-711.19,4232.74 ccw(c-693.22,4248.21) -693.22,4224.5 ; J33.B2@-708.76,4219.33 cw(c-696.29,4206.86) -696.29,4224.5 ; J33.B2@-708.16,4235.35 ccw(c-684.5,4255.71) -684.5,4224.5 ; v2@-595,4750.19 cw(c-595,4726.5) -578.25,4743.25 cw(c-561.5,4760) v2@-585.19,4760 ; v2@-595,4754.19 cw(c-595,4740.16) -585.08,4750.08 cw(c-575.16,4760) v2@-589.19,4760
ATE.HOST_JTAG.HARD.TDO: J25.2 J33.B3 R268.1 | length 13875.7
  Top Layer w4: v2@133.06,6623.06 cw(c116.31,6606.31) 140,6606.31 cw(c163.69,6606.31) v2@146.94,6623.06 ; v2@135.89,6625.89 cw(c125.97,6615.97) 140,6615.97 cw(c154.03,6615.97) v2@144.11,6625.89 ; v2@138.06,6176.94 ccw(c121.31,6193.69) 145,6193.69 ccw(c168.69,6193.69) v2@151.94,6176.94 ; v2(140,6630) 140,6220 145,6215 v2(145,6170) ; v2@140.89,6174.11 ccw(c130.97,6184.03) 145,6184.03 ccw(c159.03,6184.03) v2@149.11,6174.11 ; v2@7360,6350.19 cw(c7360,6326.5) 7376.75,6343.25 cw(c7393.5,6360) v2@7369.81,6360 ; v2@7360,6354.19 cw(c7360,6340.16) 7369.92,6350.08 cw(c7379.84,6360) v2@7365.81,6360 ; v2(7360,6360) 7518.05,6201.95 7518.05,5938.05 v2(7485,5905) 7524.05,5905 7555,5874.05 7555,5775 7486.99,5706.99 ; J25.2@7478.3,5694.04 ccw(c7473.01,5706.99) 7486.99,5706.99 ; J25.2@7479.81,5690.34 ccw(c7475.44,5701.04) 7486.99,5701.04 ccw(c7498.55,5701.04) J25.2@7494.18,5690.34 ; J25.2@7481.58,5695.1 ccw(c7479.91,5701.99) 7486.99,5701.99 ; J25.2@7484.89,5574.85 cw(c7484.68,5572.54) 7486.99,5572.54 ; v2@7485,5910.81 ccw(c7485,5924.84) 7494.92,5914.92 ccw(c7504.84,5905) v2@7490.81,5905 ; v2@7485,5914.81 ccw(c7485,5938.5) 7501.75,5921.75 ccw(c7518.5,5905) v2@7494.81,5905 ; J25.2@7489.1,5574.85 ccw(c7489.31,5572.54) 7486.99,5572.54 ; v2@7489.11,5900.89 cw(c7499.03,5890.97) 7499.03,5905 cw(c7499.03,5919.03) v2@7489.11,5909.11 ; v2@7491.94,5898.06 cw(c7508.69,5881.31) 7508.69,5905 cw(c7508.69,5928.69) v2@7491.94,5911.94 ; J25.2@7492.41,5695.1 cw(c7494.08,5701.99) 7486.99,5701.99 ; J25.2@7495.69,5694.04 cw(c7500.98,5706.99) 7486.99,5706.99 ; v2(7632,5997) R268.1@7673.82,5997 ; v2@7636.11,5992.89 cw(c7646.03,5982.97) 7646.03,5997 cw(c7646.03,6011.03) v2@7636.11,6001.11 ; v2@7638.94,5990.06 cw(c7655.69,5973.31) 7655.69,5997 cw(c7655.69,6020.69) v2@7638.94,6003.94 ; R268.1@7667.23,5990.41 ccw(c7651.32,5974.5) 7651.32,5997 ccw(c7651.32,6019.5) R268.1@7667.23,6003.59 ; R268.1@7670.06,5993.24 ccw(c7660.98,5984.16) 7660.98,5997 ccw(c7660.98,6009.84) R268.1@7670.06,6000.76 ; 7486.99,5572.54 J25.2@7486.99,5635.25 ; J25.2@7486.99,5635.25 J25.2@7486.99,5635.59 ; J25.2@7486.99,5635.25 J25.2@7486.99,5635.59 ; J25.2@7486.99,5635.59 7486.99,5706.99 ; J25.2@7486.99,5635.59 7486.99,5701.99
  MidLayer1 w4: v2@-406.94,4551.94 ccw(c-423.69,4568.69) -400,4568.69 ccw(c-376.31,4568.69) v2@-393.06,4551.94 ; v2@-404.11,4549.11 ccw(c-414.03,4559.03) -400,4559.03 ccw(c-385.97,4559.03) v2@-395.89,4549.11 ; v2(-400,4545) -400,4620 -407.83,4627.84 -482,4702 -482,5246.69 -417.12,5311.56 -322.46,5311.56 -295.52,5338.51 -295.52,5899.23 -234.74,5960 -36.47,5960 v2(-7.38,5989.09) ; v2@-17.19,5989.09 cw(c-40.87,5989.09) -24.13,5972.34 cw(c-7.38,5955.59) v2@-7.38,5979.28 ; v2@-13.19,5989.09 cw(c-27.22,5989.09) -17.3,5979.17 cw(c-7.38,5969.25) v2@-7.38,5983.28 ; v2@133.06,6636.94 ccw(c116.31,6653.69) 140,6653.69 ccw(c163.69,6653.69) v2@146.94,6636.94 ; v2@135.89,6634.11 ccw(c125.97,6644.03) 140,6644.03 ccw(c154.03,6644.03) v2@144.11,6634.11 ; v2(140,6630) 140,6788.69 221.59,6870.28 4862.1,6870.28 4993.37,6739 6147.94,6739 6171.94,6715 6942,6715 6966,6739 7372.06,6739 7400,6711.06 7400,6400 v2(7360,6360) ; v2@7360,6365.81 ccw(c7360,6379.84) 7369.92,6369.92 ccw(c7379.84,6360) v2@7365.81,6360 ; v2@7360,6369.81 ccw(c7360,6393.5) 7376.75,6376.75 ccw(c7393.5,6360) v2@7369.81,6360
  MidLayer2 w4: v2@-581.94,4168.06 cw(c-598.69,4151.31) -575,4151.31 cw(c-551.31,4151.31) v2@-568.06,4168.06 ; v2@-579.11,4170.89 cw(c-589.03,4160.97) -575,4160.97 cw(c-560.97,4160.97) v2@-570.89,4170.89 ; v2(-575,4175) -575,4131.31 -593.81,4112.5 -612.5,4112.5 -620,4105 -620,4090 -605.61,4075.61 -551.61,4075.61 -458.98,4168.24 -458.98,4541.21 -447.19,4553 -420,4553 -412,4545 v2(-400,4545) ; v2(-7.38,5989.09) 70.59,5989.09 75,5993.5 98.5,5993.5 145,6040 v2(145,6170) ; v2@-3.27,5984.98 cw(c6.65,5975.06) 6.65,5989.09 cw(c6.65,6003.12) v2@-3.27,5993.2 ; v2@-0.44,5982.15 cw(c16.31,5965.4) 16.31,5989.09 cw(c16.31,6012.77) v2@-0.44,5996.02 ; v2@138.06,6163.06 cw(c121.31,6146.31) 145,6146.31 cw(c168.69,6146.31) v2@151.94,6163.06 ; v2@140.89,6165.89 cw(c130.97,6155.97) 145,6155.97 cw(c159.03,6155.97) v2@149.11,6165.89 ; v2(7485,5905) 7600,5905 7632,5937 v2(7632,5997) ; v2@7489.11,5900.89 cw(c7499.03,5890.97) 7499.03,5905 cw(c7499.03,5919.03) v2@7489.11,5909.11 ; v2@7491.94,5898.06 cw(c7508.69,5881.31) 7508.69,5905 cw(c7508.69,5928.69) v2@7491.94,5911.94 ; v2@7625.06,5990.06 cw(c7608.31,5973.31) 7632,5973.31 cw(c7655.69,5973.31) v2@7638.94,5990.06 ; v2@7627.89,5992.89 cw(c7617.97,5982.97) 7632,5982.97 cw(c7646.03,5982.97) v2@7636.11,5992.89
  Bottom Layer w4: J33.B3@-785.98,4188.29 -705.14,4188.29 -691.06,4174.21 -676.56,4174.21 -664.89,4185.87 -580.87,4185.87 v2@-575,4180 ; J33.B3@-717.13,4188.51 cw(c-713.23,4170.99) -700.53,4183.68 ; J33.B3@-716.26,4184.61 cw(c-711.35,4162.57) -695.39,4178.53 ; J33.B3@-715.39,4180.7 cw(c-709.47,4154.15) -690.24,4173.39
ATE.HOST_JTAG.HARD.TMS: J25.4 J33.B4 R270.1 | length 13329.2
  Top Layer w4: v2(50,6290) 95,6335 95,6500 90,6505 v2(90,6575) ; v2@50,6295.81 ccw(c50,6309.84) 59.92,6299.92 ccw(c69.84,6290) v2@55.81,6290 ; v2@50,6299.81 ccw(c50,6323.5) 66.75,6306.75 ccw(c83.5,6290) v2@59.81,6290 ; v2@83.06,6568.06 cw(c66.31,6551.31) 90,6551.31 cw(c113.69,6551.31) v2@96.94,6568.06 ; v2@85.89,6570.89 cw(c75.97,6560.97) 90,6560.97 cw(c104.03,6560.97) v2@94.11,6570.89 ; v1@7583.47,5707.32 cw(c7567.26,5691.11) 7590.19,5691.11 cw(c7613.13,5691.11) v1@7596.91,5707.32 ; J25.4@7585,5630 J25.4@7590.19,5635.19 ; v1@7586.3,5710.15 cw(c7576.91,5700.76) 7590.19,5700.76 cw(c7603.47,5700.76) v1@7594.08,5710.15 ; J25.4@7590.19,5635.25 v1(7590.19,5714.04) ; v2(7640,5845) 7672.82,5845 R270.1@7673.82,5846 ; v2@7644.11,5840.89 cw(c7654.03,5830.97) 7654.03,5845 cw(c7654.03,5859.03) v2@7644.11,5849.11 ; v2@7646.94,5838.06 cw(c7663.69,5821.31) 7663.69,5845 cw(c7663.69,5868.69) v2@7646.94,5851.94 ; 7659.75,5845 ccw(c7659.75,5859.57) R270.1@7670.06,5849.27 ; 7662.2,5845 cw(c7662.2,5833.89) R270.1@7670.06,5841.75
  MidLayer1 w4: v2@-436.94,4541.94 ccw(c-453.69,4558.69) -430,4558.69 ccw(c-406.31,4558.69) v2@-423.06,4541.94 ; v2@-434.11,4539.11 ccw(c-444.03,4549.03) -430,4549.03 ccw(c-415.97,4549.03) v2@-425.89,4539.11 ; v2(-430,4535) -430,4570.19 -413.5,4586.69 -413.5,4622.19 -490,4698.69 -490,5250 -420.44,5319.56 -325.78,5319.56 -303.52,5341.82 -303.52,5902.54 -191.06,6015 v2(-55,6015) ; v2@-61.94,6008.06 ccw(c-78.69,5991.31) -78.69,6015 ccw(c-78.69,6038.69) v2@-61.94,6021.94 ; v2@-59.11,6010.89 ccw(c-69.03,6000.97) -69.03,6015 ccw(c-69.03,6029.03) v2@-59.11,6019.11 ; v2@83.06,6581.94 ccw(c66.31,6598.69) 90,6598.69 ccw(c113.69,6598.69) v2@96.94,6581.94 ; v2@85.89,6579.11 ccw(c75.97,6589.03) 90,6589.03 ccw(c104.03,6589.03) v2@94.11,6579.11 ; v2(90,6575) 90,6761.31 214.96,6886.28 4868.72,6886.28 5000,6755 6141.31,6755 6263.31,6877 6929.69,6877 7051.69,6755 7378.69,6755 7416,6717.69 7416,6436.31 7454.85,6397.46 7454.85,6266.46 7590.26,6131.06 7608,6113.31 7608,5877 v2(7640,5845) ; v2@7630.19,5845 ccw(c7606.5,5845) 7623.25,5861.75 ccw(c7640,5878.5) v2@7640,5854.81 ; v2@7634.19,5845 ccw(c7620.16,5845) 7630.08,5854.92 ccw(c7640,5864.84) v2@7640,5850.81
  MidLayer2 w4: v2@-614.81,4140 cw(c-638.5,4140) -621.75,4123.25 cw(c-605,4106.5) v2@-605,4130.19 ; v2@-610.81,4140 cw(c-624.84,4140) -614.92,4130.08 cw(c-605,4120.16) v2@-605,4134.19 ; v2(-605,4140) -630,4115 -630,4085 -610,4065 -550.9,4065 -450.98,4164.93 -450.98,4514.02 v2(-430,4535) ; v2@-439.81,4535 cw(c-463.5,4535) -446.75,4518.25 cw(c-430,4501.5) v2@-430,4525.19 ; v2@-435.81,4535 cw(c-449.84,4535) -439.92,4525.08 cw(c-430,4515.16) v2@-430,4529.19 ; v2@-61.94,6021.94 ccw(c-78.69,6038.69) -55,6038.69 ccw(c-31.31,6038.69) v2@-48.06,6021.94 ; v2@-59.11,6019.11 ccw(c-69.03,6029.03) -55,6029.03 ccw(c-40.97,6029.03) v2@-50.89,6019.11 ; v2(-55,6015) -55,6090 50,6195 v2(50,6290) ; v2@43.06,6283.06 cw(c26.31,6266.31) 50,6266.31 cw(c73.69,6266.31) v2@56.94,6283.06 ; v2@45.89,6285.89 cw(c35.97,6275.97) 50,6275.97 cw(c64.03,6275.97) v2@54.11,6285.89 ; v1@7590.19,5704.54 cw(c7590.19,5681.61) 7606.41,5697.82 cw(c7622.63,5714.04) v1@7599.69,5714.04 ; v1@7590.19,5708.54 cw(c7590.19,5695.26) 7599.58,5704.65 cw(c7608.97,5714.04) v1@7595.69,5714.04 ; v1(7590.19,5714.04) 7619.23,5685 7645,5685 7660,5700 7660,5735 7640,5755 v2(7640,5845) ; v2@7633.06,5838.06 cw(c7616.31,5821.31) 7640,5821.31 cw(c7663.69,5821.31) v2@7646.94,5838.06 ; v2@7635.89,5840.89 cw(c7625.97,5830.97) 7640,5830.97 cw(c7654.03,5830.97) v2@7644.11,5840.89
  Bottom Layer w4: J33.B4@-780,4148.92 -703.95,4148.92 -695,4139.98 -695,4131 -679,4115 -655,4115 -633.87,4136.13 -629.86,4136.13 -625.99,4140 ; J33.B4@-717.17,4149.13 cw(c-711.42,4135.58) -701.01,4145.99 ; J33.B4@-715.61,4145.45 cw(c-708.92,4129.69) -696.82,4141.79 ; v2@-612.53,4133.71 ccw(c-625.99,4122.46) -625.99,4140 ; v2@-612.53,4146.29 cw(c-625.99,4157.54) -625.99,4140 ; v2@-609.46,4136.27 ccw(c-617.43,4129.61) -617.43,4140 ccw(c-617.43,4150.39) v2@-609.46,4143.73 ; v2(-605,4140) -625.99,4140
ATE.HOST_JTAG.SOFT.TCK: J25.7 J33.A42 U30.E15 | length 21394.4
  Top Layer w4: J33.A42@-785.98,2574.12 -679.12,2574.12 -660,2555 -640,2555 -630,2565 -630,2640 -615,2655 -585,2655 -580,2650 v2(-545,2650) ; J33.A42@-711.58,2568.62 cw(c-698.3,2555.34) -698.3,2574.12 cw(c-698.3,2592.9) J33.A42@-711.58,2579.62 ; J33.A42@-708.76,2565.79 cw(c-688.65,2545.68) -688.65,2574.12 cw(c-688.65,2602.56) J33.A42@-708.76,2582.45 ; v2@-551.94,2643.06 ccw(c-568.69,2626.31) -568.69,2650 ccw(c-568.69,2673.69) v2@-551.94,2656.94 ; v2@-549.11,2645.89 ccw(c-559.03,2635.97) -559.03,2650 ccw(c-559.03,2664.03) v2@-549.11,2654.11 ; v2@6720,6485.19 cw(c6720,6461.5) 6736.75,6478.25 cw(c6753.5,6495) v2@6729.81,6495 ; v2@6720,6489.19 cw(c6720,6475.16) 6729.92,6485.08 cw(c6739.84,6495) v2@6725.81,6495 ; v2(6720,6495) 6780.79,6434.21 6885.79,6434.21 6897,6423 v2(6957,6423) ; v2@6950.06,6416.06 ccw(c6933.31,6399.31) 6933.31,6423 ccw(c6933.31,6446.69) v2@6950.06,6429.94 ; v2@6952.89,6418.89 ccw(c6942.97,6408.97) 6942.97,6423 ccw(c6942.97,6437.03) v2@6952.89,6427.11 ; v1@7396.5,2004 ccw(c7373.56,2004) 7389.78,2020.22 ccw(c7406,2036.43) v1@7406,2013.5 ; v1@7400.5,2004 ccw(c7387.22,2004) 7396.61,2013.39 ccw(c7406,2022.78) v1@7406,2009.5 ; v1(7406,2004) 7388.19,2021.81 7367.81,2021.81 7364.3,2018.3 7324.96,2018.3 7285.62,2018.3 ; J25.7@7781.58,5480.1 ccw(c7779.91,5486.99) 7786.99,5486.99 ; 7788.75,5488.75 7924.75,5488.75 7932.17,5481.32 7932.17,5385.19 8244,5073.36 8244,4581 v2(8290,4535) ; J25.7@7789.78,5458.88 ccw(c7810.35,5467.19) J25.7@7810.35,5445 ; J25.7@7792.41,5480.1 cw(c7794.08,5486.99) 7786.99,5486.99 ; J25.7@7793.48,5460.37 ccw(c7816.28,5469.58) 7816.28,5445 ; J25.7@7797.19,5461.87 ccw(c7822.21,5471.98) 7822.21,5445 ; J25.7@7803.26,5441.49 cw(c7811.73,5433.01) J25.7@7811.73,5445 ; v2@7833.06,5438.06 ccw(c7816.31,5421.31) 7816.31,5445 ccw(c7816.31,5468.69) v2@7833.06,5451.94 ; v2@7835.89,5440.89 ccw(c7825.97,5430.97) 7825.97,5445 ccw(c7825.97,5459.03) v2@7835.89,5449.11 ; v2(7840,5445) J25.7@7811.74,5445 ; v2@8280.19,4535 ccw(c8256.5,4535) 8273.25,4551.75 ccw(c8290,4568.5) v2@8290,4544.81 ; v2@8284.19,4535 ccw(c8270.16,4535) 8280.08,4544.92 ccw(c8290,4554.84) v2@8290,4540.81 ; 7278.44,2015.33 cw(c7285.62,2008.15) 7285.62,2018.3 ; 7278.44,2015.33 cw(c7285.62,2008.15) 7285.62,2018.3 ; 7278.44,2015.33 ccw(c7290.97,2002.79) 7273.25,2002.79 cw(c7290.97,2002.79) 7278.44,2015.33 ; 7278.44,2015.33 cw(c7265.91,2027.86) 7265.91,2010.14 ccw(c7265.91,2027.86) 7278.44,2015.33 ; 7786.99,5486.99 J25.7@7786.99,5420.25 J25.7@7811.74,5445
  MidLayer1 w4: -553,3211.14 -553,3103.31 -565.11,3091.21 -619.58,3091.21 -628.91,3100.54 -653.35,3100.54 -726.5,3027.39 -726.5,2852.79 -545,2671.29 ; -552.98,3211.16 -552.98,3422.93 -460.78,3515.13 -452.81,3523.1 -452.81,4103.31 -428,4128.12 -428,4221.88 -452.81,4246.69 -452.81,4558.69 -421.5,4590 -421.5,4618.88 -532.14,4729.52 -532.14,5261.54 -458.12,5335.56 -332.4,5335.56 -319.52,5348.45 -319.52,5909.17 -235,5993.69 -235,6045.19 -249.15,6059.34 ; v2@-551.37,2657.46 ccw(c-563.2,2671.29) -545,2671.29 ; v2@-548.78,2654.42 ccw(c-555.78,2662.61) -545,2662.61 ccw(c-534.22,2662.61) v2@-541.22,2654.42 ; v2(-545,2650) -545,2671.29 ; v2@-538.63,2657.46 cw(c-526.8,2671.29) -545,2671.29 ; v2(-275,6060) -249.15,6060 ; v2@-270.89,6055.89 cw(c-260.97,6045.97) -260.97,6060 cw(c-260.97,6074.03) v2@-270.89,6064.11 ; v2@-268.06,6053.06 cw(c-251.31,6036.31) -251.31,6060 cw(c-251.31,6083.69) v2@-268.06,6066.94 ; v2(5088.13,6632.81) 5122.19,6632.81 5132,6623 6562.91,6623 6672.5,6513.41 6672.5,6492.75 6685.92,6479.33 6704.33,6479.33 v2(6720,6495) ; v2@5092.23,6628.7 cw(c5102.15,6618.78) 5102.15,6632.81 cw(c5102.15,6646.84) v2@5092.23,6636.92 ; v2@5095.06,6625.87 cw(c5111.81,6609.13) 5111.81,6632.81 cw(c5111.81,6656.5) v2@5095.06,6639.75 ; v2(6957,6423) 6984,6450 7082.01,6450 7134.58,6397.42 7134.58,6359.84 7125,6350.25 v2(7125,6320) ; v2@6957,6428.81 ccw(c6957,6442.84) 6966.92,6432.92 ccw(c6976.84,6423) v2@6962.81,6423 ; v2@6957,6432.81 ccw(c6957,6456.5) 6973.75,6439.75 ccw(c6990.5,6423) v2@6966.81,6423 ; v2@7118.06,6326.94 ccw(c7101.31,6343.69) 7125,6343.69 ccw(c7148.69,6343.69) v2@7131.94,6326.94 ; v2@7120.89,6324.11 ccw(c7110.97,6334.03) 7125,6334.03 ccw(c7139.03,6334.03) v2@7129.11,6324.11
  MidLayer2 w4: v2(-275,6060) -285,6070 -285,6105 -181.05,6208.95 -112.36,6208.95 106,6427.31 106,6546.94 345.06,6786 2790.31,6786 2911.31,6665 2928.31,6648 5043.31,6648 5054.31,6637 ; 5063.98,6637 cw(c5063.98,6608.67) v2@5084.02,6628.7 ; 5073.64,6637 cw(c5073.64,6618.33) v2@5086.85,6631.53 ; 5074.55,6637 ccw(c5074.55,6646.38) v2@5081.19,6639.75 ; v2@5081.19,6625.87 ccw(c5054.33,6599.01) 5054.33,6637 ; v2(5088.13,6632.81) 5092.19,6632.81 5088,6637 5054.31,6637 ; v2(7125,6320) 7160,6355 7205,6355 7263.5,6296.5 7703.5,6296.5 7720,6280 7720,6090.19 7747.5,6062.69 7747.5,5939.75 7757.75,5929.5 7853.87,5929.5 7880.18,5955.81 7919.82,5955.81 7926.13,5949.5 7936.81,5949.5 7988,5898.31 7988,5483 7950,5445 v2(7840,5445) ; v2@7125,6325.81 ccw(c7125,6339.84) 7134.92,6329.92 ccw(c7144.84,6320) v2@7130.81,6320 ; v2@7125,6329.81 ccw(c7125,6353.5) 7141.75,6336.75 ccw(c7158.5,6320) v2@7134.81,6320 ; v2@7844.11,5440.89 cw(c7854.03,5430.97) 7854.03,5445 cw(c7854.03,5459.03) v2@7844.11,5449.11 ; v2@7846.94,5438.06 cw(c7863.69,5421.31) 7863.69,5445 cw(c7863.69,5468.69) v2@7846.94,5451.94 ; v2(8180,1795) 8220,1795 8225,1800 v2(8280,1800) v2@8275,1795 ; v2@8184.11,1790.89 cw(c8194.03,1780.97) 8194.03,1795 cw(c8194.03,1809.03) v2@8184.11,1799.11 ; v2@8186.94,1788.06 cw(c8203.69,1771.31) 8203.69,1795 cw(c8203.69,1818.69) v2@8186.94,1801.94 ; v2@8273.06,1793.06 ccw(c8256.31,1776.31) 8256.31,1800 ccw(c8256.31,1823.69) v2@8273.06,1806.94 ; v2@8275.89,1795.89 ccw(c8265.97,1785.97) 8265.97,1800 ccw(c8265.97,1814.03) v2@8275.89,1804.11
  Bottom Layer w4: v1@7396.5,2004 ccw(c7373.56,2004) 7389.78,2020.22 ccw(c7406,2036.43) v1@7406,2013.5 ; v1@7400.5,2004 ccw(c7387.22,2004) 7396.61,2013.39 ccw(c7406,2022.78) v1@7406,2009.5 ; v1(7406,2004) 7388.19,2021.81 7370.62,2021.81 7360.19,2011.38 7360.19,1962.62 7380.62,1942.19 7395.38,1942.19 7403,1949.81 7431.18,1949.81 7439.84,1958.47 7439.84,1988.97 7464.68,2013.81 7499.32,2013.81 7548.38,1964.75 7572.93,1964.75 7580.49,1957.19 7627.38,1957.19 7651.5,1957.19 7658.5,1950.19 7790,1950.19 7847.63,2007.81 7867.38,2007.81 7875.71,1999.48 7980.52,1999.48 8016,1964 8016,1817.57 8038.57,1795 v2(8180,1795) v2@8175,1790 ; v2@8173.06,1788.06 ccw(c8156.31,1771.31) 8156.31,1795 ccw(c8156.31,1818.69) v2@8173.06,1801.94 ; v2@8175.89,1790.89 ccw(c8165.97,1780.97) 8165.97,1795 ccw(c8165.97,1809.03) v2@8175.89,1799.11 ; v2@8270.19,1800 ccw(c8246.5,1800) 8263.25,1816.75 ccw(c8280,1833.5) v2@8280,1809.81 ; v2@8274.19,1800 ccw(c8260.16,1800) 8270.08,1809.92 ccw(c8280,1819.84) v2@8280,1805.81 ; v2(8280,1800) 8255.36,1824.64 8255.36,2293.36 8335,2373 8335,3570 8340.5,3575.5 8340.5,3663.76 8234,3770.26 8234,4479 v2(8290,4535) ; v2@8280.19,4535 cw(c8256.5,4535) 8273.25,4518.25 cw(c8290,4501.5) v2@8290,4525.19 ; v2@8284.19,4535 cw(c8270.16,4535) 8280.08,4525.08 cw(c8290,4515.16) v2@8290,4529.19
ATE.HOST_JTAG.SOFT.TDI: J25.5 J33.B45 U30.J14 | length 20377.9
  Top Layer w4: U30.J14@7226.54,1837.97 cw(c7226.54,1820.25) 7239.07,1832.78 cw(c7251.6,1845.31) U30.J14@7233.88,1845.31 ; U30.J14@7226.54,1845.31 v3(7246.22,1825.63) ; J25.5@7681.58,5480.1 ccw(c7679.91,5486.99) 7686.99,5486.99 ; J25.5@7686.99,5420.25 7686.99,5486.99 ; J25.5@7692.41,5480.1 cw(c7694.08,5486.99) 7686.99,5486.99 ; v2@7768.06,5528.06 ccw(c7751.31,5511.31) 7751.31,5535 ccw(c7751.31,5558.69) v2@7768.06,5541.94 ; v2@7770.89,5530.89 ccw(c7760.97,5520.97) 7760.97,5535 ccw(c7760.97,5549.03) v2@7770.89,5539.11 ; v2(7775,5535) 7735,5535 7686.99,5486.99 ; 7233.42,1838.43 cw(c7220.61,1825.63) 7238.72,1825.63 ccw(c7220.61,1825.63) 7233.42,1838.43 ; 7233.42,1838.43 ccw(c7246.22,1851.24) 7246.22,1833.13 cw(c7246.22,1851.24) 7233.42,1838.43
  MidLayer1 w4: v1@-591.53,2631.76 ccw(c-607.74,2647.98) -584.81,2647.98 ccw(c-561.87,2647.98) v1@-578.09,2631.76 ; v1@-588.7,2628.93 ccw(c-598.09,2638.32) -584.81,2638.32 ccw(c-571.53,2638.32) v1@-580.92,2628.93 ; v1(-584.81,2625.04) -584.81,2699.79 -734.5,2849.48 -734.5,3030.71 -656.67,3108.54 -625.6,3108.54 -616.27,3099.21 -568.42,3099.21 -561,3106.63 -561,3214.45 -560.98,3426.25 -460.81,3526.41 -460.81,4106.63 -436,4131.44 -436,4218.56 -460.81,4243.37 -460.81,4562.01 -429.5,4593.32 -429.5,4615.56 -540.14,4726.21 -540.14,5264.86 -461.44,5343.56 -335.72,5343.56 -327.52,5351.76 -327.52,5912.48 -245,5995 -245,6025 -255,6035 v2(-295,6035) ; v2@-290.89,6030.89 cw(c-280.97,6020.97) -280.97,6035 cw(c-280.97,6049.03) v2@-290.89,6039.11 ; v2@-288.06,6028.06 cw(c-271.31,6011.31) -271.31,6035 cw(c-271.31,6058.69) v2@-288.06,6041.94 ; v2@5105,6645.19 cw(c5105,6597.36) 5138.82,6631.18 ; v2@5105,6649.19 cw(c5105,6611.02) 5131.99,6638.01 ; v2@5105,6653.19 cw(c5105,6624.67) 5125.16,6644.84 ; v2(5105,6655) 5115,6655 5139,6631 6566.23,6631 6679.73,6517.5 6730,6517.5 6757.5,6490 6940,6490 v2(6985,6535) ; v2@5105,6657.19 cw(c5105,6638.33) 5118.33,6651.67 ; v2@6975.19,6535 cw(c6951.5,6535) 6968.25,6518.25 cw(c6985,6501.5) v2@6985,6525.19 ; v2@6979.19,6535 cw(c6965.16,6535) 6975.08,6525.08 cw(c6985,6515.16) v2@6985,6529.19 ; v2(6990,6480) 7063.32,6480 7068.32,6475 7142.58,6400.74 7142.58,6352.42 v2(7165,6330) ; v2@6994.11,6475.89 cw(c7004.03,6465.97) 7004.03,6480 cw(c7004.03,6494.03) v2@6994.11,6484.11 ; v2@6996.94,6473.06 cw(c7013.69,6456.31) 7013.69,6480 cw(c7013.69,6503.69) v2@6996.94,6486.94 ; v2@7155.19,6330 ccw(c7131.5,6330) 7148.25,6346.75 ccw(c7165,6363.5) v2@7165,6339.81 ; v2@7159.19,6330 ccw(c7145.16,6330) 7155.08,6339.92 ccw(c7165,6349.84) v2@7165,6335.81 ; v3@7247.52,1818.24 cw(c7250.67,1800.41) 7261.05,1815.24 ; v3@7253.61,1826.93 ccw(c7271.44,1830.08) 7261.05,1815.24 ; v2@7768.06,5528.06 cw(c7751.31,5511.31) 7775,5511.31 cw(c7798.69,5511.31) v2@7781.94,5528.06 ; v2@7770.89,5530.89 cw(c7760.97,5520.97) 7775,5520.97 cw(c7789.03,5520.97) v2@7779.11,5530.89 ; 7773.69,2911.38 7772.67,2912.4 ; v2(7775,5535) 7775,5457.18 8010,5222.18 8010,4872.37 8069.87,4812.5 8097.25,4812.5 8120,4789.75 8120,3988.5 8191.81,3916.69 8191.81,3883.46 8059.36,3751 8059.36,3698.3 8004.84,3643.78 7938.78,3643.78 7814.69,3519.69 7814.69,3373.2 7810.02,3368.54 7810.02,3303.37 7822.19,3291.21 7822.19,3177.29 7772.67,3127.77 7772.67,2912.4 ; 7261.08,1815.21 ccw(c7278.73,1843.25) 7278.9,1810.12 7385.37,1810.12 7392.75,1817.5 7447.5,1817.5 7480,1785 7620,1785 7670,1835 7670,1967.16 7661.99,1975.17 7661.99,2025.43 7737.81,2101.25 7737.81,2129.9 7766.61,2158.7 7766.61,2195.46 7766.61,2403.8 7750.19,2420.22 7750.19,2510.65 7746.81,2514.02 7746.81,2559.69 7735.31,2571.19 7706,2571.19 7686.19,2591 7686.19,2619 7706,2638.81 7750.31,2638.81 7790.5,2679 7790.5,2745.81 7775.81,2760.5 7775.81,2909.26 7772.67,2912.4
  MidLayer2 w4: v2@-301.94,6041.94 ccw(c-318.69,6058.69) -295,6058.69 ccw(c-271.31,6058.69) v2@-288.06,6041.94 ; v2@-299.11,6039.11 ccw(c-309.03,6049.03) -295,6049.03 ccw(c-280.97,6049.03) v2@-290.89,6039.11 ; v2(-295,6035) -295,6106.31 -184.36,6216.95 -115.68,6216.95 98,6430.63 98,6550.26 341.74,6794 2793.63,6794 2931.63,6656 5046.63,6656 5047.63,6655 v2(5105,6655) ; v2@5098.06,6648.06 ccw(c5081.31,6631.31) 5081.31,6655 ccw(c5081.31,6678.69) v2@5098.06,6661.94 ; v2@5100.89,6650.89 ccw(c5090.97,6640.97) 5090.97,6655 ccw(c5090.97,6669.03) v2@5100.89,6659.11 ; v2@6978.06,6528.06 cw(c6961.31,6511.31) 6985,6511.31 cw(c7008.69,6511.31) v2@6991.94,6528.06 ; v2@6980.89,6530.89 cw(c6970.97,6520.97) 6985,6520.97 cw(c6999.03,6520.97) v2@6989.11,6530.89 ; v2@6984,6487.76 ccw(c6974.52,6500) 6990,6500 ccw(c7005.48,6500) v2@6996,6487.76 ; v2(6985,6535) 6985,6505 6990,6500 v2(6990,6480) ; v2@6986.44,6484.6 ccw(c6980.83,6491.85) 6990,6491.85 ccw(c6999.17,6491.85) v2@6993.56,6484.6 ; v2(7165,6330) 7218.69,6330 7260.19,6288.5 7700.19,6288.5 7712,6276.69 7712,6086.87 7739.5,6059.37 7739.5,5936.44 7754.44,5921.5 7857.19,5921.5 7883.5,5947.81 7916.5,5947.81 7922.81,5941.5 7933.5,5941.5 7980,5895 7980,5505 7965,5490 7820,5490 v2(7775,5535) ; v2@7169.11,6325.89 cw(c7179.03,6315.97) 7179.03,6330 cw(c7179.03,6344.03) v2@7169.11,6334.11 ; v2@7171.94,6323.06 cw(c7188.69,6306.31) 7188.69,6330 cw(c7188.69,6353.69) v2@7171.94,6336.94 ; v2@7775,5525.19 cw(c7775,5501.5) 7791.75,5518.25 cw(c7808.5,5535) v2@7784.81,5535 ; v2@7775,5529.19 cw(c7775,5515.16) 7784.92,5525.08 cw(c7794.84,5535) v2@7780.81,5535
  Bottom Layer w4: J33.B45@-785.98,2456.01 -673.84,2456.01 -659.54,2441.71 -640.48,2441.71 -593.14,2489.04 -593.14,2583.37 -584.81,2591.71 v1(-584.81,2625.04) ; J33.B45@-711.58,2450.51 cw(c-698.3,2437.23) -698.3,2456.01 cw(c-698.3,2474.79) J33.B45@-711.58,2461.51 ; J33.B45@-708.76,2447.68 cw(c-688.65,2427.57) -688.65,2456.01 cw(c-688.65,2484.45) J33.B45@-708.76,2464.34 ; v1@-591.53,2618.32 cw(c-607.74,2602.11) -584.81,2602.11 cw(c-561.87,2602.11) v1@-578.09,2618.32 ; v1@-588.7,2621.15 cw(c-598.09,2611.76) -584.81,2611.76 cw(c-571.53,2611.76) v1@-580.92,2621.15
ATE.HOST_JTAG.SOFT.TDO: J25.6 J33.B39 U30.B11 | length 19464.8
  Top Layer w4: v1(-671.81,2650.04) -556.69,2765.16 -550.02,2765.16 -468.14,2847.04 -468.14,3144.08 -201.35,3410.87 -201.35,3568.4 6.86,3776.6 6.86,4063.14 2.29,4067.71 ; v1@-671.81,2655.54 ccw(c-671.81,2668.82) -662.42,2659.43 ccw(c-653.03,2650.04) v1@-666.31,2650.04 ; v1@-671.81,2659.54 ccw(c-671.81,2682.48) -655.59,2666.26 ccw(c-639.37,2650.04) v1@-662.31,2650.04 ; v1(-14.48,4067.71) 2.29,4067.71 ; v1@-6.33,4062.82 cw(c2.29,4057.66) 2.29,4067.71 ; v1@-6.33,4072.59 ccw(c2.29,4077.75) 2.29,4067.71 ; v2@7234.19,2322 cw(c7210.5,2322) 7227.25,2305.25 cw(c7244,2288.5) v2@7244,2312.19 ; v2@7238.19,2322 cw(c7224.16,2322) 7234.08,2312.08 cw(c7244,2302.16) v2@7244,2316.19 ; v2(7244,2322) 7220,2298 7155.07,2298 7124.27,2267.2 7124.27,2140.95 7123.93,2140.62 ; v2@7413.06,6353.06 cw(c7396.31,6336.31) 7420,6336.31 cw(c7443.69,6336.31) v2@7426.94,6353.06 ; v2@7415.89,6355.89 cw(c7405.97,6345.97) 7420,6345.97 cw(c7434.03,6345.97) v2@7424.11,6355.89 ; v2(7420,6360) 7420,6311.31 7526.05,6205.27 7526.05,5914.32 7559.25,5881.12 v2(7686.99,5753.37) J25.6@7686.99,5635.25 ; J25.6@7670.73,5689.02 ccw(c7631.46,5728.28) 7686.99,5728.28 ccw(c7742.52,5728.28) J25.6@7703.26,5689.02 ; J25.6@7673.56,5686.19 ccw(c7641.12,5718.62) 7686.99,5718.62 ccw(c7732.86,5718.62) J25.6@7700.43,5686.19 ; J25.6@7676.39,5683.36 ccw(c7650.78,5708.97) 7686.99,5708.97 ccw(c7723.2,5708.96) J25.6@7697.6,5683.36 ; v2@7677.18,5753.37 ccw(c7653.5,5753.37) 7670.25,5770.12 ccw(c7686.99,5786.87) v2@7686.99,5763.19 ; J25.6@7679.22,5680.53 ccw(c7660.44,5699.31) 7686.99,5699.31 ccw(c7713.55,5699.31) J25.6@7694.77,5680.53 ; v2@7680.06,5746.44 cw(c7663.31,5729.69) 7686.99,5729.69 cw(c7710.68,5729.69) v2@7693.93,5746.44 ; v2@7681.18,5753.37 ccw(c7667.15,5753.37) 7677.07,5763.29 ccw(c7686.99,5773.21) v2@7686.99,5759.19 ; v2@7682.89,5749.27 cw(c7672.97,5739.35) 7686.99,5739.35 cw(c7701.02,5739.35) v2@7691.1,5749.27 ; v1@7700.14,5334.99 ccw(c7683.92,5318.77) 7683.92,5341.71 ccw(c7683.92,5364.64) v1@7700.14,5348.43 ; v1@7702.97,5337.82 ccw(c7693.58,5328.43) 7693.58,5341.71 ccw(c7693.58,5354.99) v1@7702.97,5345.6 ; v1(7706.86,5341.71) 7658.29,5341.71 7640,5360 7640,5461.92 7742.41,5564.33 7742.41,5692.41 7805,5755 v2(7805,5785) ; v2@7798.06,5778.06 cw(c7781.31,5761.31) 7805,5761.31 cw(c7828.69,5761.31) v2@7811.94,5778.06 ; v2@7800.89,5780.89 cw(c7790.97,5770.97) 7805,5770.97 cw(c7819.03,5770.97) v2@7809.11,5780.89 ; 7120.96,2133.44 cw(c7108.42,2145.97) 7108.42,2128.25 ccw(c7108.42,2145.97) 7120.96,2133.44 ; 7120.96,2133.44 ccw(c7133.49,2120.91) 7115.77,2120.91 cw(c7133.49,2120.91) 7120.96,2133.44 ; 7120.96,2133.44 ccw(c7113.78,2140.62) 7123.93,2140.62 ; 7120.96,2133.44 ccw(c7113.78,2140.62) 7123.93,2140.62
  MidLayer1 w4: v2(-50,6230) 68.31,6230 120,6178.31 120,5965 75,5920 75,5136.9 116.9,5095 345,5095 445.5,4994.5 445.5,4635.5 376.04,4566.04 293.54,4566.04 267.5,4540 267.5,4417.5 140.19,4290.19 140.19,4245.44 -14.48,4090.78 v1(-14.48,4067.71) ; v2@-45.89,6225.89 cw(c-35.97,6215.97) -35.97,6230 cw(c-35.97,6244.03) v2@-45.89,6234.11 ; v2@-43.06,6223.06 cw(c-26.31,6206.31) -26.31,6230 cw(c-26.31,6253.69) v2@-43.06,6236.94 ; v1@-21.19,4074.43 ccw(c-37.41,4090.64) -14.48,4090.64 ccw(c8.46,4090.64) v1@-7.76,4074.43 ; v1@-18.36,4071.6 ccw(c-27.75,4080.99) -14.48,4080.99 ccw(c-1.2,4080.99) v1@-10.59,4071.6 ; v2(5065,6615) 6546.93,6615 6559.6,6615 6619.6,6555 6664.5,6510.1 6664.5,6489.44 6687.73,6466.21 6928.39,6466.21 6976,6513.81 7063.45,6513.81 7242.26,6335 7395,6335 v2(7420,6360) ; v2(7244,2322) 7244,2332 7250.81,2338.81 7250.81,2392.13 7451.19,2592.5 7451.19,2725 7458.19,2732 7458.19,2773.39 7530,2845.2 7531.86,2847.06 7531.86,3244.69 7562.17,3275 7664.55,3275 7727.5,3337.95 7727.5,3647.25 7705.1,3669.65 7608.97,3669.65 7580.89,3697.73 7580.89,4175.09 7602.52,4196.73 7602.52,4395.71 7640.19,4433.37 7640.19,4558.37 7665.19,4583.37 7743.19,4583.37 7751.52,4591.71 7751.52,4657.04 7706.86,4701.71 v1(7706.86,5341.71) ; v2@7410.19,6360 cw(c7386.5,6360) 7403.25,6343.25 cw(c7420,6326.5) v2@7420,6350.19 ; v2@7414.19,6360 cw(c7400.16,6360) 7410.08,6350.08 cw(c7420,6340.16) v2@7420,6354.19 ; v2(7686.99,5753.37) 7773.37,5753.37 v2(7805,5785) ; v2@7691.1,5749.27 cw(c7701.02,5739.35) 7701.02,5753.37 cw(c7701.02,5767.4) v2@7691.1,5757.48 ; v2@7693.93,5746.44 cw(c7710.68,5729.69) 7710.68,5753.37 cw(c7710.68,5777.06) v2@7693.93,5760.31 ; v1@7700.14,5334.99 cw(c7683.92,5318.77) 7706.86,5318.77 cw(c7729.79,5318.77) v1@7713.57,5334.99 ; v1@7702.97,5337.82 cw(c7693.58,5328.43) 7706.86,5328.43 cw(c7720.14,5328.43) v1@7710.75,5337.82 ; v2@7795.19,5785 cw(c7771.5,5785) 7788.25,5768.25 cw(c7805,5751.5) v2@7805,5775.19 ; v2@7799.19,5785 cw(c7785.16,5785) 7795.08,5775.08 cw(c7805,5765.16) v2@7805,5779.19
  MidLayer2 w4: v2@-56.94,6236.94 ccw(c-73.69,6253.69) -50,6253.69 ccw(c-26.31,6253.69) v2@-43.06,6236.94 ; v2@-54.11,6234.11 ccw(c-64.03,6244.03) -50,6244.03 ccw(c-35.97,6244.03) v2@-45.89,6234.11 ; v2(-50,6230) -50,6260 114,6424 114,6543.63 348.37,6778 2787,6778 2925,6640 5040,6640 v2(5065,6615)
  Bottom Layer w4: J33.B39@-711.58,2686.73 cw(c-698.3,2673.45) -698.3,2692.23 cw(c-698.3,2711.01) J33.B39@-711.58,2697.73 ; J33.B39@-708.76,2683.9 cw(c-688.65,2663.79) -688.65,2692.23 cw(c-688.65,2720.67) J33.B39@-708.76,2700.56 ; -703,2692.23 J33.B39@-785.98,2692.23 -687.23,2692.23 -671.81,2676.81 v1(-671.81,2650.04) ; v1@-678.53,2656.76 ccw(c-694.74,2672.98) -671.81,2672.98 ccw(c-648.87,2672.98) v1@-665.09,2656.76 ; v1@-675.7,2653.93 ccw(c-685.09,2663.32) -671.81,2663.32 ccw(c-658.53,2663.32) v1@-667.92,2653.93
ATE.HOST_JTAG.SOFT.TMS: J25.8 J33.A41 U30.G15 | length 21037.6
  Top Layer w4: J33.A41@-785.98,2613.49 -682.24,2613.49 -669.29,2600.54 -660.71,2600.54 -647.5,2613.75 -647.5,2647.5 -565,2730 ; J33.A41@-711.58,2607.99 cw(c-698.3,2594.71) -698.3,2613.49 cw(c-698.3,2632.27) J33.A41@-711.58,2618.99 ; J33.A41@-708.76,2605.16 cw(c-688.65,2585.05) -688.65,2613.49 cw(c-688.65,2641.93) J33.A41@-708.76,2621.82 ; v2@-552.76,2724 ccw(c-565,2714.52) -565,2730 ; v2@-552.76,2736 cw(c-565,2745.48) -565,2730 ; v2@-549.6,2726.44 ccw(c-556.85,2720.83) -556.85,2730 ccw(c-556.85,2739.17) v2@-549.6,2733.56 ; v2(-545,2730) -565,2730 ; v2@7404.7,1925.44 ccw(c7390,1912.24) 7390,1932 ; v2@7404.7,1938.56 cw(c7390,1951.76) 7390,1932 ; v2@7407.68,1928.12 ccw(c7398.97,1920.3) 7398.97,1932 ccw(c7398.97,1943.7) v2@7407.68,1935.88 ; v2(7412,1932) 7390,1932 ; J25.8@7786.99,5635.25 7844.75,5635.25 7850,5630 7850,5580 7872.91,5557.09 7892.91,5557.09 v2(7925,5525) ; v2@7915.19,5525 ccw(c7891.5,5525) 7908.25,5541.75 ccw(c7925,5558.5) v2@7925,5534.81 ; v2@7919.19,5525 ccw(c7905.16,5525) 7915.08,5534.92 ccw(c7925,5544.84) v2@7925,5530.81 ; 7278.44,1936.59 cw(c7285.62,1929.41) 7285.62,1939.56 ; 7278.44,1936.59 cw(c7285.62,1929.41) 7285.62,1939.56 ; 7278.44,1936.59 ccw(c7290.97,1924.05) 7273.25,1924.05 cw(c7290.97,1924.05) 7278.44,1936.59 ; 7278.44,1936.59 cw(c7265.91,1949.12) 7265.91,1931.4 ccw(c7265.91,1949.12) 7278.44,1936.59 ; 7285.62,1939.56 7285.95,1939.9 7382.1,1939.9 7390,1932
  MidLayer1 w4: v2@-551.94,2723.06 ccw(c-568.69,2706.31) -568.69,2730 ccw(c-568.69,2753.69) v2@-551.94,2736.94 ; v2@-549.11,2725.89 ccw(c-559.03,2715.97) -559.03,2730 ccw(c-559.03,2744.03) v2@-549.11,2734.11 ; v2(-545,2730) -592.39,2730 -718.5,2856.11 -718.5,3024.08 -650.04,3092.54 -632.23,3092.54 -622.89,3083.21 -561.79,3083.21 -545,3100 -545,3207.83 ; -544.98,3207.85 -544.98,3419.62 -444.81,3519.79 -444.81,4100 -420,4124.81 -420,4225.19 -444.81,4250 -444.81,4475 -382.19,4537.62 -382.19,4613.51 -474,4705.32 -474,5243.37 -413.81,5303.56 -319.15,5303.56 -287.52,5335.19 -287.52,5895.92 -231.43,5952 -13,5952 20,5985 20,6015 -10,6045 -220,6045 -275,6100 -275,6133.69 -207.73,6200.95 -80.95,6200.95 -67.95,6187.95 v2(-35,6187.95) ; v2@-41.94,6181.01 ccw(c-58.69,6164.27) -58.69,6187.95 ccw(c-58.69,6211.64) v2@-41.94,6194.89 ; v2@-39.11,6183.84 ccw(c-49.03,6173.92) -49.03,6187.95 ccw(c-49.03,6201.98) v2@-39.11,6192.06 ; v2(5100,6595) 5130,6595 5142,6607 6543.62,6607 6556.28,6607 6616.28,6547 6656.5,6506.78 6656.5,6486.12 6684.42,6458.21 6931.71,6458.21 6979.31,6505.81 7060.14,6505.81 7355.95,6210 ; v2@5104.11,6590.89 cw(c5114.03,6580.97) 5114.03,6595 cw(c5114.03,6609.03) v2@5104.11,6599.11 ; v2@5106.94,6588.06 cw(c5123.69,6571.31) 5123.69,6595 cw(c5123.69,6618.69) v2@5106.94,6601.94 ; v2@7563.06,6111.94 ccw(c7546.31,6128.69) 7570,6128.69 ; v2@7565.89,6109.11 ccw(c7555.97,6119.03) 7570,6119.03 ccw(c7584.03,6119.03) v2@7574.11,6109.11 ; v2(7570,6105) 7570,6128.69 ; v2@7576.94,6111.94 cw(c7593.69,6128.69) 7570,6128.69 ; v2(7860,1990) 7977.48,1990 8007.48,1960 8007.48,1808.03 8040,1775.51 v2(8040,1740) ; v2@7864.11,1985.89 cw(c7874.03,1975.97) 7874.03,1990 cw(c7874.03,2004.03) v2@7864.11,1994.11 ; v2@7866.94,1983.06 cw(c7883.69,1966.31) 7883.69,1990 cw(c7883.69,2013.69) v2@7866.94,1996.94 ; v2@8033.06,1746.94 ccw(c8016.31,1763.69) 8040,1763.69 ccw(c8063.69,1763.69) v2@8046.94,1746.94 ; v2@8035.89,1744.11 ccw(c8025.97,1754.03) 8040,1754.03 ccw(c8054.03,1754.03) v2@8044.11,1744.11 ; 7355.95,6210 7365,6210 ; 7355.95,6210 7365,6210 ; 7365,6210 7488.69,6210 7570,6128.69
  MidLayer2 w4: v2@-41.94,6194.89 ccw(c-58.69,6211.64) -35,6211.64 ccw(c-11.31,6211.64) v2@-28.06,6194.89 ; v2@-39.11,6192.06 ccw(c-49.03,6201.98) -35,6201.98 ccw(c-20.97,6201.98) v2@-30.89,6192.06 ; v2(-35,6187.95) -35,6217.19 -32.19,6220 -32.19,6265.18 122,6419.37 122,6540.31 351.69,6770 2783.69,6770 2921.69,6632 5008,6632 5045,6595 v2(5100,6595) ; v2@5093.06,6588.06 ccw(c5076.31,6571.31) 5076.31,6595 ccw(c5076.31,6618.69) v2@5093.06,6601.94 ; v2@5095.89,6590.89 ccw(c5085.97,6580.97) 5085.97,6595 ccw(c5085.97,6609.03) v2@5095.89,6599.11 ; v2@7570,6095.19 cw(c7570,6071.5) 7586.75,6088.25 cw(c7603.5,6105) v2@7579.81,6105 ; v2@7570,6099.19 cw(c7570,6085.16) 7579.92,6095.08 cw(c7589.84,6105) v2@7575.81,6105 ; v2@7580,6105 v2(7570,6105) 7609.13,6065.87 7719.13,6065.87 7731.5,6053.5 7731.5,5933.12 7751.12,5913.5 7860.5,5913.5 7886.81,5939.81 7913.19,5939.81 7923.62,5929.38 7923.62,5526.38 v2(7925,5525) ; v2@7918.06,5531.94 ccw(c7904.64,5545.36) 7923.62,5545.36 ; 7923.62,5542.35 ccw(c7942.35,5542.35) v2@7929.11,5529.11 ; 7923.62,5552.01 ccw(c7952.01,5552.01) v2@7931.94,5531.94 ; v2@8042.54,1742.54 v2(8040,1740) 8137.46,1740 8140,1742.54 8220.63,1742.54 8223.57,1739.6 v2(8270.21,1739.6) v2@8267.27,1742.54 ; v2@8044.11,1735.89 cw(c8054.03,1725.97) 8054.03,1740 cw(c8054.03,1754.03) v2@8044.11,1744.11 ; v2@8046.94,1733.06 cw(c8063.69,1716.31) 8063.69,1740 cw(c8063.69,1763.69) v2@8046.94,1746.94 ; v2@8263.28,1732.66 ccw(c8246.53,1715.91) 8246.53,1739.6 ccw(c8246.53,1763.28) v2@8263.28,1746.54 ; v2@8266.1,1735.49 ccw(c8256.18,1725.57) 8256.18,1739.6 ccw(c8256.18,1753.63) v2@8266.1,1743.71
  Bottom Layer w4: v2(7412,1932) 7435.19,1932 ; v2@7416.17,1927.95 cw(c7425.73,1918.68) 7425.73,1932 cw(c7425.73,1945.32) v2@7416.17,1936.05 ; v2@7419.04,1925.17 cw(c7435.19,1909.5) 7435.19,1932 ; v2@7419.04,1938.83 ccw(c7435.19,1954.5) 7435.19,1932 ; v2@7851.97,1984.36 ccw(c7841.13,1976.76) 7841.13,1990 ; v2@7851.97,1995.64 cw(c7841.13,2003.24) 7841.13,1990 ; v2(7860,1990) 7841.13,1990 ; v2@7925,5515.19 cw(c7925,5491.5) 7941.75,5508.25 cw(c7958.5,5525) v2@7934.81,5525 ; v2@7925,5519.19 cw(c7925,5505.16) 7934.92,5515.08 cw(c7944.84,5525) v2@7930.81,5525 ; v2(7925,5525) 7982.81,5467.19 7982.81,5255.88 8256.69,4982 8256.69,4524.31 8218,4485.63 8218,3763.64 8285.5,3696.14 8285.5,3654.44 8277.5,3646.44 8277.5,3622.75 8287.75,3612.5 8320.44,3612.5 8332.5,3600.44 8332.5,3578.81 8327,3573.31 8327,2376.31 8247.36,2296.67 8247.36,1762.45 v2(8270.21,1739.6) ; v2@8260.4,1739.6 ccw(c8236.72,1739.6) 8253.46,1756.35 ccw(c8270.21,1773.09) v2@8270.21,1749.41 ; v2@8264.4,1739.6 ccw(c8250.37,1739.6) 8260.29,1749.52 ccw(c8270.21,1759.44) v2@8270.21,1745.41 ; 7435.19,1932 7448.19,1945 7448.19,1986 7468,2005.81 7496,2005.81 7545.3,1956.51 7569.85,1956.51 7577.18,1949.19 7648.19,1949.19 7657.38,1940 7791.13,1940 7841.13,1990
ATE.KBD#.CLOCK: J31.5 J33.B47 R82.2 R85.2 | length 6454.6
  Top Layer w4: v1@2800.14,808.32 cw(c2783.92,792.11) 2806.86,792.11 cw(c2829.79,792.11) v1@2813.57,808.32 ; v1@2802.97,811.15 cw(c2793.58,801.76) 2806.86,801.76 cw(c2820.14,801.76) v1@2810.75,811.15 ; v1(2806.86,815.04) 2806.86,650.04 2892.05,564.85 J31.5@2892.05,421.1 ; J31.5@2871.19,441.96 ccw(c2820.84,492.31) 2892.05,492.31 ccw(c2963.26,492.31) J31.5@2912.9,441.96 ; J31.5@2874.02,439.13 ccw(c2830.49,482.66) 2892.05,482.66 ccw(c2953.6,482.66) J31.5@2910.08,439.13 ; J31.5@2876.85,436.3 ccw(c2840.15,473) 2892.05,473 ccw(c2943.94,473) J31.5@2907.25,436.3 ; J31.5@2879.68,433.47 ccw(c2849.81,463.34) 2892.05,463.34 ccw(c2934.29,463.34) J31.5@2904.42,433.47 ; J31.5@2882.5,430.65 ccw(c2859.47,453.68) 2892.05,453.68 ccw(c2924.63,453.68) J31.5@2901.59,430.65
  Bottom Layer w4: J33.B47@-785.98,2377.27 -702.73,2377.27 -671.36,2408.64 -614.95,2408.64 -551,2344.69 -551,2306.63 -571,2286.63 -571,1489.52 -551.48,1470 -510,1470 -496.29,1483.71 -191.1,1483.71 -66.44,1359.04 2780.96,1359.04 2800.87,1339.13 R85.2@2800.87,1005 R82.2@2800.87,950 2800.87,869.13 2806.86,863.14 v1(2806.86,815.04) ; J33.B47@-717.08,2373.05 ccw(c-717.08,2397.52) -699.78,2380.22 ; J33.B47@-717.08,2377.05 ccw(c-717.08,2411.17) -692.96,2387.04 ; J33.B47@-717.08,2381.05 ccw(c-717.08,2424.83) -686.13,2393.87 ; J33.B47@-717.08,2385.05 ccw(c-717.08,2438.49) -679.3,2400.7 ; J33.B47@-717.08,2389.05 ccw(c-717.08,2452.14) -672.47,2407.53 ; R82.2@2794.28,942.92 cw(c2778.37,927.01) 2800.87,927.01 cw(c2823.36,927.01) R82.2@2807.46,942.92 ; R82.2@2794.28,957.08 ccw(c2778.37,972.99) 2800.87,972.99 ccw(c2823.36,972.99) R82.2@2807.46,957.08 ; R85.2@2794.28,997.92 cw(c2778.37,982.01) 2800.87,982.01 cw(c2823.36,982.01) R85.2@2807.46,997.92 ; R85.2@2794.28,1012.08 ccw(c2778.37,1027.99) 2800.87,1027.99 ccw(c2823.36,1027.99) R85.2@2807.46,1012.08 ; R82.2@2797.11,945.75 cw(c2788.02,936.67) 2800.87,936.67 cw(c2813.71,936.67) R82.2@2804.63,945.75 ; R82.2@2797.11,954.25 ccw(c2788.02,963.33) 2800.87,963.33 ccw(c2813.71,963.33) R82.2@2804.63,954.25 ; R85.2@2797.11,1000.75 cw(c2788.02,991.67) 2800.87,991.67 cw(c2813.71,991.67) R85.2@2804.63,1000.75 ; R85.2@2797.11,1009.25 ccw(c2788.02,1018.33) 2800.87,1018.33 ccw(c2813.71,1018.33) R85.2@2804.63,1009.25 ; v1@2800.14,821.76 ccw(c2783.92,837.98) 2806.86,837.98 ccw(c2829.79,837.98) v1@2813.57,821.76 ; v1@2802.97,818.93 ccw(c2793.58,828.32) 2806.86,828.32 ccw(c2820.14,828.32) v1@2810.75,818.93
ATE.KBD#.DATA: J31.1 J33.B46 R83.2 R84.2 | length 6538.2
  MidLayer1 w4: J31.1@2949.93,343.53 ccw(c2899.58,393.89) 2970.79,393.89 ccw(c3042,393.89) J31.1@2991.64,343.53 ; J31.1@2952.76,340.71 ccw(c2909.23,384.23) 2970.79,384.23 ccw(c3032.34,384.23) J31.1@2988.82,340.71 ; J31.1@2955.59,337.88 ccw(c2918.89,374.57) 2970.79,374.57 ccw(c3022.68,374.57) J31.1@2985.99,337.88 ; J31.1@2958.42,335.05 ccw(c2928.55,364.92) 2970.79,364.92 ccw(c3013.03,364.92) J31.1@2983.16,335.05 ; J31.1@2961.24,332.22 ccw(c2938.21,355.26) 2970.79,355.26 ccw(c3003.37,355.26) J31.1@2980.33,332.22 ; J31.1@2970.79,322.68 2970.79,456.3 2981.52,467.04 3056.86,542.37 v1(3056.86,882.37) ; v1@3050.14,875.66 cw(c3033.92,859.44) 3056.86,859.44 cw(c3079.79,859.44) v1@3063.57,875.66 ; v1@3052.97,878.49 cw(c3043.58,869.1) 3056.86,869.1 cw(c3070.14,869.1) v1@3060.75,878.49
  MidLayer2 w4: v1@-531.81,1722.54 cw(c-531.81,1699.61) -515.59,1715.82 cw(c-499.37,1732.04) v1@-522.31,1732.04 ; v1@-531.81,1726.54 cw(c-531.81,1713.26) -522.42,1722.65 cw(c-513.03,1732.04) v1@-526.31,1732.04 ; v1(-531.81,1732.04) -493.14,1693.37 -493.14,1632.23 -460.01,1599.09 -392.73,1599.09 -301.13,1507.5 -114.87,1507.5 36.63,1356 2092.56,1356 2542.42,906.14 2569.57,879 2989,879 2992.37,882.37 v1(3056.86,882.37) ; v1@3050.14,875.66 ccw(c3033.92,859.44) 3033.92,882.37 ccw(c3033.92,905.31) v1@3050.14,889.09 ; v1@3052.97,878.49 ccw(c3043.58,869.1) 3043.58,882.37 ccw(c3043.58,895.65) v1@3052.97,886.26
  Bottom Layer w4: J33.B46@-785.98,2416.64 -611.64,2416.64 -543,2348 -543,2303.31 -563,2283.31 -563,1763.23 v1(-531.81,1732.04) ; J33.B46@-711.58,2411.14 cw(c-698.3,2397.86) -698.3,2416.64 cw(c-698.3,2435.42) J33.B46@-711.58,2422.14 ; J33.B46@-708.76,2408.31 cw(c-688.65,2388.2) -688.65,2416.64 cw(c-688.65,2445.08) J33.B46@-708.76,2424.97 ; v1@-541.31,1732.04 ccw(c-564.24,1732.04) -548.03,1748.26 ccw(c-531.81,1764.48) v1@-531.81,1741.54 ; v1@-537.31,1732.04 ccw(c-550.59,1732.04) -541.2,1741.43 ccw(c-531.81,1750.82) v1@-531.81,1737.54 ; v1@3050.14,889.09 ccw(c3034.13,905.1) 3056.77,905.1 ; R83.2@3050.18,942.92 cw(c3034.27,927.01) 3056.77,927.01 cw(c3079.27,927.01) R83.2@3063.36,942.92 ; R83.2@3050.18,957.08 ccw(c3034.27,972.99) 3056.77,972.99 ccw(c3079.27,972.99) R83.2@3063.36,957.08 ; R84.2@3050.18,997.92 cw(c3034.27,982.01) 3056.77,982.01 cw(c3079.27,982.01) R84.2@3063.36,997.92 ; v1@3052.97,886.26 ccw(c3043.78,895.45) 3056.77,895.45 ; R83.2@3053.01,945.75 cw(c3043.93,936.67) 3056.77,936.67 cw(c3069.61,936.67) R83.2@3060.53,945.75 ; R83.2@3053.01,954.25 ccw(c3043.93,963.33) 3056.77,963.33 ccw(c3069.61,963.33) R83.2@3060.53,954.25 ; R84.2@3053.01,1000.75 cw(c3043.93,991.67) 3056.77,991.67 cw(c3069.61,991.67) R84.2@3060.53,1000.75 ; v1@3056.77,882.62 R83.2@3056.77,950 R84.2@3056.77,1005 ; 3056.77,895.86 ccw(c3070.34,895.86) v1@3060.75,886.26 ; 3056.77,905.51 ccw(c3080,905.51) v1@3063.57,889.09
ATE.MIDI#.MIDI_OUT_PWR: J22.4 J33.B25 R199.2 | length 11701.6
  MidLayer1 w4: J22.4@4868.47,6356.32 ccw(c4787.87,6436.92) 4901.85,6436.92 ccw(c5015.83,6436.92) J22.4@4935.23,6356.32 ; J22.4@4871.29,6353.49 ccw(c4797.53,6427.26) 4901.85,6427.26 ccw(c5006.17,6427.26) J22.4@4932.41,6353.49 ; J22.4@4874.12,6350.66 ccw(c4807.18,6417.6) 4901.85,6417.6 ccw(c4996.52,6417.6) J22.4@4929.58,6350.66 ; J22.4@4876.95,6347.84 ccw(c4816.84,6407.95) 4901.85,6407.95 ccw(c4986.86,6407.95) J22.4@4926.75,6347.84 ; J22.4@4879.78,6345.01 ccw(c4826.5,6398.29) 4901.85,6398.29 ccw(c4977.2,6398.29) J22.4@4923.92,6345.01 ; J22.4@4882.61,6342.18 ccw(c4836.15,6388.63) 4901.85,6388.63 ccw(c4967.55,6388.63) J22.4@4921.09,6342.18 ; v2@4883.06,6673.06 cw(c4866.31,6656.31) 4890,6656.31 cw(c4913.69,6656.31) v2@4896.94,6673.06 ; J22.4@4885.44,6339.35 ccw(c4845.81,6378.98) 4901.85,6378.98 ccw(c4957.89,6378.98) J22.4@4918.26,6339.35 ; v2@4885.89,6675.89 cw(c4875.97,6665.97) 4890,6665.97 cw(c4904.03,6665.97) v2@4894.11,6675.89 ; v2(4890,6680) 4890,6486.85 4901.85,6475 J22.4@4901.85,6322.94
  MidLayer2 w4: v1@-679.64,3255.04 ccw(c-702.58,3255.04) -686.36,3271.26 ccw(c-670.14,3287.48) v1@-670.14,3264.54 ; v1@-675.64,3255.04 ccw(c-688.92,3255.04) -679.53,3264.43 ccw(c-670.14,3273.82) v1@-670.14,3260.54 ; v1(-670.14,3255.04) -705.5,3290.4 -705.5,3589.69 -692.38,3602.81 -676.65,3602.81 -505,3774.46 -505,3890 -561.54,3946.54 -661.16,3946.54 -670.62,3956 -704,3956 -712,3964 -712,4012 -700,4024 -649.42,4024 -635.42,4038 -635.42,4059.11 -709.81,4133.5 -709.81,4258.37 -693.14,4275.04 -593.14,4275.04 -576.48,4291.71 -576.48,4448.08 -628.81,4500.41 -628.81,4791.63 -576.48,4843.96 -576.48,6066.71 -509.81,6133.37 -279.25,6133.37 -187.59,6225.04 -118.9,6225.04 38.39,6382.33 38.39,6564.89 275.5,6802 2796.94,6802 2934.94,6664 4874,6664 ; v2@4880.19,6679.68 cw(c4859.02,6678.98) 4874,6664 ; v2@4884.19,6679.81 cw(c4871.65,6679.4) 4880.52,6670.52 cw(c4889.4,6661.65) v2@4889.81,6674.19 ; v2@4889.68,6670.19 ccw(c4888.98,6649.02) 4874,6664 ; v2(4890,6680) 4874,6664
  Bottom Layer w4: J33.B25@-785.98,3243.41 -681.77,3243.41 v1(-670.14,3255.04) ; J33.B25@-711.58,3237.91 cw(c-698.3,3224.63) -698.3,3243.41 cw(c-698.3,3262.19) J33.B25@-711.58,3248.91 ; J33.B25@-708.76,3235.08 cw(c-688.65,3214.98) -688.65,3243.41 cw(c-688.65,3271.85) J33.B25@-708.76,3251.74 ; J22.4@4875.66,6283.65 cw(c4843.03,6234.72) 4901.85,6234.72 ; J22.4@4877.88,6286.98 cw(c4848.02,6242.19) 4901.85,6242.19 cw(c4955.68,6242.19) J22.4@4925.82,6286.98 ; J22.4@4880.1,6290.31 cw(c4853,6249.66) 4901.85,6249.66 cw(c4950.7,6249.67) J22.4@4923.6,6290.31 ; J22.4@4882.32,6293.64 cw(c4857.98,6257.14) 4901.85,6257.14 cw(c4945.72,6257.14) J22.4@4921.38,6293.64 ; J22.4@4884.54,6296.97 cw(c4862.97,6264.61) 4901.85,6264.61 cw(c4940.73,6264.61) J22.4@4919.16,6296.97 ; J22.4@4886.75,6300.3 cw(c4867.95,6272.09) 4901.85,6272.09 cw(c4935.75,6272.09) J22.4@4916.95,6300.3 ; R199.2@4894.59,6167.08 ccw(c4878.68,6182.99) 4901.18,6182.99 ccw(c4923.68,6182.99) R199.2@4907.77,6167.08 ; R199.2@4897.42,6164.25 ccw(c4888.34,6173.33) 4901.18,6173.33 ccw(c4914.02,6173.33) R199.2@4904.94,6164.25 ; R199.2@4901.18,6160 4901.18,6234.04 4901.85,6234.71 ; J22.4@4901.85,6322.94 4901.85,6234.71 ; J22.4@4928.04,6283.65 ccw(c4960.67,6234.72) 4901.85,6234.72