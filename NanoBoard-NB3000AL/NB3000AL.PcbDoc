# Altium PCB NB3000AL.PcbDoc (part 52 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
HOST_SD.DAT1: J29.8 U30.R5 | length 2216
  Top Layer w4: v2@6926.19,1402 ccw(c6902.5,1402) 6919.25,1418.75 ccw(c6936,1435.5) v2@6936,1411.81 ; v2@6930.19,1402 ccw(c6916.16,1402) 6926.08,1411.92 ccw(c6936,1421.84) v2@6936,1407.81 ; v2(6936,1402) 6918,1420 6909.5,1420 6868.92,1460.58 6868.92,1476.14 6856.7,1488.37 6856.7,1589.38 ; 6856.7,1589.38 cw(c6866.85,1589.38) 6859.67,1596.56 ; 6856.7,1589.38 cw(c6866.85,1589.38) 6859.67,1596.56 ; 6859.67,1596.56 cw(c6872.2,1584.03) 6872.2,1601.75 ccw(c6872.2,1584.03) 6859.67,1596.56 ; 6859.67,1596.56 ccw(c6847.14,1609.09) 6864.86,1609.09 cw(c6847.14,1609.09) 6859.67,1596.56
  MidLayer1 w4: v2@6737.06,1441.06 cw(c6720.31,1424.31) 6744,1424.31 cw(c6767.69,1424.31) v2@6750.94,1441.06 ; v2@6739.89,1443.89 cw(c6729.97,1433.97) 6744,1433.97 cw(c6758.03,1433.97) v2@6748.11,1443.89 ; v2(6744,1448) 6744,1413.81 6740.19,1410 6740.19,1360.98 6760.19,1340.98 6760.19,1316.62 6770.81,1306 ; v2@6800.19,1286 ccw(c6776.5,1286) 6793.25,1302.75 ccw(c6810,1319.5) v2@6810,1295.81 ; v2@6804.19,1286 ccw(c6790.16,1286) 6800.08,1295.92 ccw(c6810,1305.84) v2@6810,1291.81 ; v2(6810,1286) 6790,1306 ; v2@6929.06,1395.06 cw(c6912.31,1378.31) 6936,1378.31 cw(c6959.69,1378.31) v2@6942.94,1395.06 ; v2@6930.42,1321.89 v2(6933.62,1318.69) ; v2@6931.89,1397.89 cw(c6921.97,1387.97) 6936,1387.97 cw(c6950.03,1387.97) v2@6940.11,1397.89 ; v2(6936,1402) 6936,1356 6933.62,1353.62 6933.62,1337.94 ; 6770.81,1306 6790,1306 ; 6770.81,1306 6790,1306 ; v2(6933.62,1318.69) 6933.62,1337.94 ; v2(6933.62,1318.69) 6933.62,1337.94 ; 6933.62,1337.94 cw(c6919.63,1337.94) 6927.85,1326.62 ccw(c6919.63,1337.94) 6933.62,1337.94 ; 6933.62,1337.94 ccw(c6947.62,1337.94) 6939.39,1326.62 cw(c6947.62,1337.94) 6933.62,1337.94
  MidLayer2 w4: v2(6744,1448) 6626,1448 6622,1452 ; v2(6810,1286) 6860,1286 6876,1302 6916.94,1302 ; v2@6814.11,1281.89 cw(c6824.03,1271.97) 6824.03,1286 cw(c6824.03,1300.03) v2@6814.11,1290.11 ; v2@6816.94,1279.06 cw(c6833.69,1262.31) 6833.69,1286 cw(c6833.69,1309.69) v2@6816.94,1292.94 ; v2@6923.81,1318.66 cw(c6900.34,1318.6) 6916.94,1302 ; v2@6927.81,1318.67 cw(c6913.91,1318.63) 6923.74,1308.8 cw(c6933.57,1298.97) v2@6933.61,1312.87 ; v2@6933.6,1308.87 ccw(c6933.53,1285.41) 6916.94,1302 ; v2(6933.62,1318.69) 6916.94,1302 ; 6614.92,1459.08 cw(c6624.84,1469) 6610.81,1469 ccw(c6624.84,1469) 6614.92,1459.08 ; 6614.92,1459.08 ccw(c6605,1449.16) 6605,1463.19 cw(c6605,1449.16) 6614.92,1459.08 ; 6621.75,1452.25 cw(c6638.5,1469) 6614.81,1469 ccw(c6638.5,1469) 6621.75,1452.25 ; 6621.75,1452.25 ccw(c6605,1435.5) 6605,1459.19 cw(c6605,1435.5) 6621.75,1452.25 ; 6622,1452 v2(6605,1469) 6622,1452
  Bottom Layer w4: J29.8@6142.69,1404.65 6142.69,1422.88 6188.31,1468.5 6247.69,1468.5 6281.81,1502.62 6281.81,1511 6302.62,1531.81 6317.38,1531.81 6343,1506.19 6437.62,1506.19 6459.62,1484.19 6589.81,1484.19 v2@6604,1470 ; J29.8@6143.01,1435.86 ccw(c6144.71,1462.12) J29.8@6163.32,1443.51 ; J29.8@6143.27,1439.85 ccw(c6145.47,1473.85) 6169.57,1449.76 ; J29.8@6143.52,1443.84 ccw(c6146.23,1485.58) 6175.81,1456 ; J29.8@6143.78,1447.83 ccw(c6147,1497.31) 6182.06,1462.25 ; J29.8@6144.04,1451.82 ccw(c6147.76,1509.05) 6188.31,1468.5 ; J29.8@6159.53,1431.03 cw(c6180.5,1431.03) 6165.67,1445.86 ; v2@6604,1470 6605,1470 v2(6605,1469) v2@6604,1470
HOST_SD.DAT2: J29.9 U30.T5 | length 469
  Top Layer w4: U30.T5@6867.01,1564.53 cw(c6854.48,1552) 6872.2,1552 ; U30.T5@6872.2,1569.72 U30.T5@6874,1567.93 ; U30.T5@6877.4,1564.53 ccw(c6889.93,1552) 6872.2,1552 ; v2@6927.06,1431.06 ccw(c6910.31,1414.31) 6910.31,1438 ccw(c6910.31,1461.69) v2@6927.06,1444.94 ; v2@6929.89,1433.89 ccw(c6919.97,1423.97) 6919.97,1438 ccw(c6919.97,1452.03) v2@6929.89,1442.11 ; v2(6934,1438) 6902.81,1438 6888.62,1452.19 6876.92,1463.89 6876.92,1479.46 6869.44,1486.93 6869.44,1508.31 6872.2,1511.07 6872.2,1552
  Bottom Layer w4: J29.9@6881.86,1441.96 6881.86,1418.64 J29.9@6895.84,1404.65 6895.84,1411.84 6922,1438 v2(6934,1438) ; J29.9@6896.77,1412.77 cw(c6934,1375.53) v2@6934,1428.19 ; J29.9@6903.59,1419.59 cw(c6934,1389.19) v2@6934,1432.19 ; J29.9@6910.42,1426.42 cw(c6934,1402.85) v2@6934,1436.19 ; J29.9@6917.25,1433.25 cw(c6934,1416.5) v2@6934,1440.19
HOST_SD.DAT3: J29.1 U30.T3 | length 280.9
  Top Layer w4: v2(6778,1470) 6793.46,1485.46 U30.T3@6793.46,1569.72 ; U30.T3@6788.27,1564.53 cw(c6775.74,1552) 6793.46,1552 cw(c6811.19,1552) U30.T3@6798.66,1564.53
  Bottom Layer w4: v2(6778,1470) 6795,1470 ; v2@6786.5,1465.09 cw(c6795,1460.18) 6795,1470 ; v2@6786.5,1474.91 ccw(c6795,1479.82) 6795,1470 ; J29.1@6797.42,1447.66 J29.1@6797.42,1404.65 6797.42,1467.58 6795,1470
HOST_SD.DETECT: U30.N8 U66.4 | length 4293.7
  Top Layer w4: v2@6258.19,790 ccw(c6234.5,790) 6251.25,806.75 ccw(c6268,823.5) v2@6268,799.81 ; v2@6262.19,790 ccw(c6248.16,790) 6258.08,799.92 ccw(c6268,809.84) v2@6268,795.81 ; v2(6268,790) 6235,823 6235,1108.54 6314.46,1188 v2(6490,1188) ; v2@6483.06,1181.06 ccw(c6466.31,1164.31) 6466.31,1188 ccw(c6466.31,1211.69) v2@6483.06,1194.94 ; v2@6485.89,1183.89 ccw(c6475.97,1173.97) 6475.97,1188 ccw(c6475.97,1202.03) v2@6485.89,1192.11 ; v3(6970.63,1668.15) U30.N8@6990.32,1687.83 ; U30.N8@6982.97,1687.83 cw(c6965.25,1687.83) 6977.78,1675.3 cw(c6990.31,1662.77) U30.N8@6990.31,1680.49 ; 6983.43,1680.95 cw(c6970.63,1693.76) 6970.63,1675.65 ccw(c6970.63,1693.76) 6983.43,1680.95 ; 6983.43,1680.95 ccw(c6996.24,1668.15) 6978.13,1668.15 cw(c6996.24,1668.15) 6983.43,1680.95
  MidLayer1 w4: v1@5160.5,1775 cw(c5137.56,1775) 5153.78,1758.78 cw(c5170,1742.56) v1@5170,1765.5 ; v1@5164.5,1775 cw(c5151.22,1775) 5160.61,1765.61 cw(c5170,1756.22) v1@5170,1769.5 ; v1(5170,1775) 5140.02,1745.02 5140.02,1453.89 5501.87,1092.04 5708.04,1092.04 5719.5,1103.5 5765.25,1103.5 5776.55,1092.2 5992.07,1092.2 6268,816.27 v2(6268,790) ; v2@6261.06,796.94 ccw(c6244.31,813.69) 6268,813.69 ccw(c6291.69,813.69) v2@6274.94,796.94 ; v2@6263.89,794.11 ccw(c6253.97,804.03) 6268,804.03 ccw(c6282.03,804.03) v2@6272.11,794.11 ; 6946.77,1591.34 6946.77,1605.27 ; v3@6963.24,1666.85 cw(c6945.41,1663.7) 6960.24,1653.32 ; v3@6971.93,1660.76 ccw(c6975.08,1642.93) 6960.24,1653.32 ; v2@6998.06,1168.06 ccw(c6981.31,1151.31) 6981.31,1175 ccw(c6981.31,1198.69) v2@6998.06,1181.94 ; v2@7000.89,1170.89 ccw(c6990.97,1160.97) 6990.97,1175 ccw(c6990.97,1189.03) v2@7000.89,1179.11 ; v2(7005,1175) 6957.34,1175 6925.72,1206.62 6925.72,1237.47 6948.5,1260.24 6948.5,1269.31 6969.81,1290.62 6969.81,1313.07 6949.48,1333.4 6949.48,1389.3 6953.81,1393.63 6953.81,1445.63 6957.81,1449.63 6957.81,1474.19 6954.19,1477.81 6954.19,1499.31 6946.77,1506.73 6946.77,1531.15 6946.77,1605.27 ; 6946.77,1605.27 6946.77,1628.52 cw(c6970.54,1628.52) 6953.16,1644.74 6960.24,1653.32
  MidLayer2 w4: v2@6490,1178.19 cw(c6490,1154.5) 6506.75,1171.25 cw(c6523.5,1188) v2@6499.81,1188 ; v2@6490,1182.19 cw(c6490,1168.16) 6499.92,1178.08 cw(c6509.84,1188) v2@6495.81,1188 ; v2(6490,1188) 6581,1097 6927,1097 v2@7002,1172 ; v2@6995.19,1175 cw(c6971.5,1175) 6988.25,1158.25 cw(c7005,1141.5) v2@7005,1165.19 ; v2@6999.19,1175 cw(c6985.16,1175) 6995.08,1165.08 cw(c7005,1155.16) v2@7005,1169.19
  Bottom Layer w4: v1(5170,1775) 5190,1775 ; v1@5174.26,1771.53 cw(c5181.58,1765.56) 5181.58,1775 cw(c5181.58,1784.44) v1@5174.26,1778.47 ; v1@5177.36,1769 cw(c5190,1758.7) 5190,1775 ; v1@5177.36,1781 ccw(c5190,1791.3) 5190,1775 ; U66.4@5235.46,1738.39 ccw(c5219.88,1723.73) 5219.88,1745.12 ; U66.4@5235.46,1751.84 cw(c5219.88,1766.51) 5219.88,1745.12 ; U66.4@5238.37,1741.13 ccw(c5229.14,1732.45) 5229.14,1745.12 ccw(c5229.14,1757.79) U66.4@5238.37,1749.1 ; U66.4@5242.6,1745.12 5219.88,1745.12 ; 5190,1775 5219.88,1745.12
HOST_SD.PROTECT: U30.R4 U65.4 | length 3206.3
  Top Layer w4: 6715.26,1325.16 ccw(c6733,1342.9) v2@6733,1317.81 ; 6716.66,1323.76 cw(c6700.9,1308) v2@6723.19,1308 ; 6722.09,1318.33 ccw(c6733,1329.24) v2@6733,1313.81 ; 6723.49,1316.93 cw(c6714.56,1308) v2@6727.19,1308 ; v2@6732.46,1307.96 6711.5,1328.92 6711.5,1400 6741.69,1430.19 6760,1430.19 ; 6816.8,1590.35 cw(c6824.67,1590.35) 6819.1,1595.91 ; 6819.38,1595.64 ccw(c6825.6,1589.41) 6816.8,1589.41 6816.8,1508.39 6840.7,1484.49 6840.7,1481.74 6847.81,1474.62 6847.81,1470 ; 6819.7,1596.6 ccw(c6807.17,1609.13) U30.R4@6824.89,1609.13 ; U30.R4@6825.49,1609.09 cw(c6807.77,1609.09) 6820.3,1596.56 ; 6760,1430.19 6774.69,1430.19 ; 6760,1430.19 6774.69,1430.19 ; 6774.69,1430.19 6818.69,1430.19 6834.73,1446.23 ; 6820.3,1596.56 cw(c6832.83,1584.03) 6832.83,1601.75 ccw(c6832.83,1584.03) 6820.3,1596.56 ; 6834.73,1446.23 6835.42,1446.23 6837.38,1448.19 ; 6834.73,1446.23 6836.69,1448.19 6837.38,1448.19 ; 6837.38,1448.19 6847.81,1458.62 ; 6837.38,1448.19 6847.81,1458.62 ; 6847.81,1458.62 6847.81,1470 ; 6847.81,1458.62 6847.81,1470
  MidLayer2 w4: v1(6614,1324) 6651.5,1324 6661.31,1333.81 6682.69,1333.81 ; v1@6617.89,1320.11 cw(c6627.28,1310.72) 6627.28,1324 cw(c6627.28,1337.28) v1@6617.89,1327.89 ; v1@6620.72,1317.28 cw(c6636.93,1301.06) 6636.93,1324 cw(c6636.93,1346.93) v1@6620.72,1330.72 ; v2@6726.06,1301.06 ccw(c6709.31,1284.31) 6709.31,1308 ccw(c6709.31,1331.69) v2@6726.06,1314.94 ; v2@6728.89,1303.89 ccw(c6718.97,1293.97) 6718.97,1308 ccw(c6718.97,1322.03) v2@6728.89,1312.11 ; v2@6732.42,1308 6708.5,1308 6694.6,1321.9 ; 6682.69,1333.81 6694.6,1321.9 ; 6682.69,1333.81 6694.6,1321.9
  Bottom Layer w4: U65.4@5235.66,1454.4 cw(c5218.91,1437.65) 5242.6,1437.65 cw(c5266.28,1437.65) U65.4@5249.54,1454.4 ; U65.4@5238.49,1457.23 cw(c5228.57,1447.31) 5242.6,1447.31 cw(c5256.63,1447.31) U65.4@5246.71,1457.23 ; U65.4@5242.6,1465.12 5242.6,1435.04 5244.26,1433.37 5511.86,1433.37 5528.52,1450.04 5528.52,1500.04 5535.48,1507 5538.23,1507 ; v1@6607.28,1317.28 cw(c6591.06,1301.06) 6614,1301.06 cw(c6636.93,1301.06) v1@6620.72,1317.28 ; v1@6610.11,1320.11 cw(c6600.72,1310.72) 6614,1310.72 cw(c6627.28,1310.72) v1@6617.89,1320.11 ; v1(6614,1324) 6614,1300.52 6547.61,1234.13 ; 5538.23,1507 5565,1507 ; 5538.23,1507 5565,1507 ; 5565,1507 5572,1500 5773.43,1500 ; 5773.43,1500 5812.25,1500 ; 5773.43,1500 5812.25,1500 ; 5812.25,1500 5901.13,1411.13 6006.86,1305.39 6006.86,1211.36 6018.5,1199.71 6391.34,1199.71 6420,1171.05 6420,1003.82 6432.94,990.87 6459.24,990.87 ; 6459.24,990.87 6476.07,1007.71 ; 6459.24,990.87 6476.07,1007.71 ; 6476.07,1007.71 6540,1007.71 6550,1017.71 6550,1185 6547.61,1187.39 ; 6547.61,1187.39 6547.61,1234.13 ; 6547.61,1187.39 6547.61,1234.13
  other v2: 6733,1308
HOST_SPARE1: R81.2 U8.AC22 | length 1489.6
  Top Layer w4: U8.AC22@5685.28,3848.01 cw(c5685.28,3830.29) 5697.81,3842.82 cw(c5710.34,3855.35) U8.AC22@5692.62,3855.35 ; U8.AC22@5685.28,3855.35 v3(5704.96,3835.67) ; 5692.16,3848.47 cw(c5679.35,3835.67) 5697.46,3835.67 ccw(c5679.35,3835.67) 5692.16,3848.47 ; 5692.16,3848.47 ccw(c5704.96,3861.28) 5704.96,3843.17 cw(c5704.96,3861.28) 5692.16,3848.47
  MidLayer1 w4: v3@5703.66,3828.28 cw(c5700.51,3810.45) 5715.35,3820.84 ; v3@5712.35,3834.37 ccw(c5730.18,3831.22) 5715.35,3820.84 ; 5728.82,3758.86 5728.82,3772.79 ; v1(5974,2914) 5992,2932 5992,3018 5992,3117.69 5955.88,3153.81 5955.88,3245.88 5965.36,3255.36 5965.36,3277.83 5978,3290.47 5978,3309.86 5924,3363.86 5924,3409.94 5912.5,3421.44 5912.5,3470 5912.5,3484.71 5912.5,3485.32 5876.86,3520.96 5812,3585.81 5746.19,3585.81 5728.82,3603.18 5728.82,3630.82 5728.82,3638.82 5728.82,3679.25 5728.82,3698.67 5728.82,3772.79 ; v1@5974,2919.5 ccw(c5974,2932.78) 5983.39,2923.39 ccw(c5992.78,2914) v1@5979.5,2914 ; v1@5974,2923.5 ccw(c5974,2946.43) 5990.22,2930.22 ccw(c6006.43,2914) v1@5983.5,2914 ; 5715.35,3820.84 5722.43,3812.26 cw(c5705.05,3796.04) 5728.82,3796.04 5728.82,3772.79
  Bottom Layer w4: R81.2@5884.68,2833.37 5885.82,2834.51 R81.2@5885.82,2835 5885.82,2850.57 5901.25,2866 5949.25,2914 5970,2914 5972,2912 v1@5974,2910 ; v1@5967.28,2907.28 ccw(c5951.06,2891.06) 5951.06,2914 ccw(c5951.06,2936.93) v1@5967.28,2920.72 ; v1@5970.11,2910.11 ccw(c5960.72,2900.72) 5960.72,2914 ccw(c5960.72,2927.28) v1@5970.11,2917.89 ; v1(5974,2914) v1@5975.92,2912.08
HOST_SRAM.A0: U30.D12 U47.1 | length 1756.3
  Top Layer w4: U30.D12@7147.8,2042.17 v3(7167.48,2061.85) ; U30.D12@7147.8,2049.51 ccw(c7147.8,2067.23) 7160.33,2054.7 ccw(c7172.86,2042.16) U30.D12@7155.14,2042.17 ; v1(7511.86,3366.71) 7512.86,3365.71 U47.1@7555.59,3365.71 ; v1@7515.75,3370.6 ccw(c7527.54,3382.4) 7527.54,3365.71 ; v1@7518.57,3359.99 cw(c7532.38,3346.18) U47.1@7532.38,3365.71 ; v1@7518.57,3373.43 ccw(c7537.2,3392.05) U47.1@7537.2,3365.71 ; 7154.68,2049.05 cw(c7167.48,2036.24) 7167.48,2054.35 ccw(c7167.48,2036.24) 7154.68,2049.05 ; 7154.68,2049.05 ccw(c7141.87,2061.85) 7159.98,2061.85 cw(c7141.87,2061.85) 7154.68,2049.05
  MidLayer1 w4: v3@7166.18,2069.24 ccw(c7163.03,2087.07) 7177.87,2076.68 ; v3@7174.87,2063.15 cw(c7192.7,2066.3) 7177.87,2076.68 ; 7191.34,2138.66 7191.34,2124.73 ; v1@7505.14,3359.99 cw(c7488.92,3343.77) 7511.86,3343.77 cw(c7534.79,3343.77) v1@7518.57,3359.99 ; v1@7507.97,3362.82 cw(c7498.58,3353.43) 7511.86,3353.43 cw(c7525.14,3353.43) v1@7515.75,3362.82 ; v1(7511.86,3366.71) 7511.86,3331.35 7523.52,3319.69 7523.52,2850.04 7450.19,2776.71 7450.19,2735.32 7443.19,2728.32 7443.19,2687.68 7443.19,2616.37 7443.19,2595.82 7242.81,2395.44 7242.81,2349.81 7190.19,2297.19 7190.19,2269 7207.81,2251.38 7207.81,2236.62 7191.34,2220.15 7191.34,2218.27 7191.34,2198.85 7191.34,2124.73 ; 7177.87,2076.68 7184.95,2085.26 ccw(c7167.57,2101.48) 7191.34,2101.48 7191.34,2124.73
HOST_SRAM.A1: U30.B14 U47.2 | length 1808.1
  Top Layer w4: v2(7271.56,2259.44) v2@7270,2261 ; U47.2@7555.59,3334.21 7590.86,3334.21 7591.7,3333.37 v1(7599.52,3333.37) ; U47.2@7574.56,3334.21 cw(c7574.56,3308.41) v1@7592.81,3326.66 ; U47.2@7578.61,3334.21 ccw(c7578.61,3354.28) v1@7592.81,3340.09 ; 7584.22,3334.21 cw(c7584.22,3318.07) v1@7595.64,3329.49 ; 7239.07,2133.44 cw(c7226.54,2145.97) 7226.54,2128.25 ccw(c7226.54,2145.97) 7239.07,2133.44 ; 7239.07,2133.44 ccw(c7251.6,2120.91) 7233.88,2120.91 cw(c7251.6,2120.91) 7239.07,2133.44 ; 7239.07,2133.44 ccw(c7231.89,2140.62) 7242.04,2140.62 ; 7239.07,2133.44 ccw(c7231.89,2140.62) 7242.04,2140.62 ; 7242.04,2140.62 7242.04,2179.96 7242.04,2227.96 7270,2255.91 7270,2259.44 v2@7270,2261 ; v2@7270,2261 7270,2262.53 v2@7270,2261
  MidLayer2 w4: v2@7264.62,2266.38 ccw(c7247.87,2283.13) 7271.56,2283.13 ccw(c7295.24,2283.13) v2@7278.49,2266.38 ; v2@7267.45,2263.55 ccw(c7257.53,2273.47) 7271.56,2273.47 ccw(c7285.59,2273.47) v2@7275.67,2263.55 ; v2@7273,2260.89 v2(7271.56,2259.44) 7271.56,2320.37 7273,2321.81 ; v1(7599.52,3333.37) 7653.52,3333.37 7706.86,3280.04 7706.86,2990.33 7697.05,2980.52 7697.05,2944.05 7539,2786 7479.94,2786 7440.19,2746.25 7440.19,2489 7289.39,2338.2 ; v1@7603.41,3329.49 cw(c7612.8,3320.1) 7612.8,3333.37 cw(c7612.8,3346.65) v1@7603.41,3337.26 ; v1@7606.24,3326.66 cw(c7622.46,3310.44) 7622.46,3333.37 cw(c7622.46,3356.31) v1@7606.24,3340.09 ; 7273,2321.81 7289.39,2338.2 ; 7273,2321.81 7289.39,2338.2
HOST_SRAM.A2: U30.A14 U47.3 | length 1711.7
  Top Layer w4: U30.A14@7221.34,2165.47 ccw(c7208.81,2178) 7226.54,2178 ccw(c7244.26,2178) U30.A14@7231.73,2165.47 ; U30.A14@7226.54,2160.28 7226.54,2224.03 7250,2247.5 v2@7250,2286.98 ; v2@7241.78,2280.04 cw(c7221.92,2260.19) 7250,2260.19 ; v2@7244.6,2282.87 cw(c7231.58,2269.84) 7250,2269.84 ; 7250,2266.4 cw(c7269.29,2266.4) v2@7255.65,2280.04 ; v1(7397.19,2633.37) 7433.37,2633.37 7443.27,2643.27 7451.19,2651.19 7451.19,2852.73 7423.03,2880.89 7423.03,2885.86 7423.52,2886.36 7423.52,3075.04 7440.19,3091.71 7465.19,3091.71 7475.87,3081.03 7496.18,3081.03 7506.86,3091.71 7506.86,3286.05 7523.52,3302.72 ; v1@7401.08,2629.49 cw(c7410.47,2620.1) 7410.47,2633.37 cw(c7410.47,2646.65) v1@7401.08,2637.26 ; v1@7403.91,2626.66 cw(c7420.13,2610.44) 7420.13,2633.37 cw(c7420.13,2656.31) v1@7403.91,2640.09 ; U47.3@7531.27,3298.45 ccw(c7523.52,3293.56) 7523.52,3302.72 ; U47.3@7531.27,3306.99 cw(c7523.52,3311.87) 7523.52,3302.72 ; U47.3@7555.59,3302.72 7523.52,3302.72
  MidLayer2 w4: 7226.19,2324 7226.19,2326 ; 7229.03,2300.97 ccw(c7241.47,2313.4) v2@7246.12,2296.44 ; 7233.9,2296.1 ccw(c7243.56,2305.76) v2@7247.18,2292.58 ; 7235.99,2294.01 cw(c7228.96,2286.98) v2@7238.9,2286.98 ; v2(7248.71,2286.98) 7243.02,2286.98 7226.19,2303.81 7226.19,2326 ; 7390.19,2593.54 cw(c7437.02,2593.54) v1@7403.91,2626.66 ; 7390.19,2603.2 cw(c7427.37,2603.2) v1@7401.08,2629.49 ; 7390.19,2612.85 cw(c7417.71,2612.85) v1@7398.25,2632.31 ; 7390.19,2622.51 cw(c7408.05,2622.51) v1@7395.42,2635.14 ; v1(7397.19,2633.37) 7390.19,2626.37 7390.19,2542.37 7226.19,2378.37 7226.19,2326
HOST_SRAM.A3: U30.H16 U47.4 | length 2098.9
  Top Layer w4: U30.H16@7305.28,1884.68 7324.96,1884.68 7361.32,1884.68 7380,1866 v2@7390,1866 ; U30.H16@7310.47,1879.49 cw(c7323,1866.96) 7323,1884.68 cw(c7323,1902.41) U30.H16@7310.47,1889.88 ; 7367.32,1878.68 ccw(c7377.61,1888.97) v2@7385.01,1876.45 ; 7370.96,1875.04 ccw(c7380.31,1884.39) v2@7387.04,1873 ; 7374.61,1871.39 ccw(c7383.02,1879.8) v2@7389.08,1869.56 ; U47.4@7555.59,3271.22 7608.38,3271.22 7673.52,3206.08 7673.52,3052.37 7631.86,3010.71 7631.86,2933.37 7740.19,2825.04 7747.36,2817.87 7747.36,2716.59 7738.19,2707.41 7738.19,2687 7752.81,2672.38 7752.81,2652.62 7750.19,2650 7750.19,2582.44 7756,2576.63 7756,2505.42 7750.19,2499.61 7750.19,2449.37 7766.61,2432.95 7766.61,2102.14 7781.5,2087.25 7781.5,2072.75 7752.56,2043.81 7721.31,2043.81 7705.12,2043.81 7679.12,2017.81 7623.38,2017.81 7615.38,2025.81 7600.62,2025.81 7590.19,2015.38 v1@7590.19,1980.19 ; U47.4@7578.81,3265.56 cw(c7592.46,3251.91) 7592.46,3271.22 cw(c7592.46,3290.53) U47.4@7578.81,3276.88
  MidLayer1 w4: v2@7390,1866.71 7436,1866.71 ; 7435,1866.71 7436,1866.71 ; v1@7579.96,1972.95 ccw(c7570.81,1967.2) 7570.81,1978 ; v1@7579.96,1983.05 cw(c7570.81,1988.8) 7570.81,1978 ; v1(7588,1978) 7570.81,1978 ; 7436,1866.71 7455,1866.71 7459.52,1866.71 7566.81,1974 7570.81,1978
  other v2: 7390,1868
HOST_SRAM.A4: U30.E10 U47.5 | length 1959.2
  Top Layer w4: U30.E10@7069.06,2002.8 v3(7088.74,2022.48) ; U30.E10@7069.06,2010.14 ccw(c7069.06,2027.86) 7081.59,2015.33 ccw(c7094.12,2002.79) U30.E10@7076.4,2002.79 ; U47.5@7555.59,3239.72 v1(7600.52,3239.71) ; U47.5@7577.55,3239.72 cw(c7577.55,3216.73) v1@7593.81,3232.99 ; U47.5@7577.63,3239.72 ccw(c7577.63,3262.6) v1@7593.81,3246.43 ; 7587.21,3239.72 cw(c7587.21,3226.39) v1@7596.64,3235.82 ; 7587.28,3239.72 ccw(c7587.28,3252.95) v1@7596.64,3243.6 ; 7075.94,2009.68 cw(c7088.74,1996.87) 7088.74,2014.98 ccw(c7088.74,1996.87) 7075.94,2009.68 ; 7075.94,2009.68 ccw(c7063.13,2022.48) 7081.24,2022.48 cw(c7063.13,2022.48) 7075.94,2009.68
  MidLayer1 w4: v2(7480,2620) 7472.19,2627.81 7467.19,2632.81 7467.19,2669 7467.19,2697.62 7467.19,2712.44 7507.5,2752.75 7507.5,2800.08 7548.52,2841.1 7548.52,3187.71 v1(7600.52,3239.71) ; v1@7591.02,3239.71 cw(c7568.09,3239.71) 7584.31,3223.49 cw(c7600.52,3207.27) v1@7600.52,3230.21 ; v1@7595.02,3239.71 cw(c7581.75,3239.71) 7591.14,3230.32 cw(c7600.52,3220.93) v1@7600.52,3234.21
  MidLayer2 w4: v2(7088,2344) 7104.25,2327.75 ; v3@7088.09,2029.95 ccw(c7086.51,2047.99) 7100.38,2036.35 ccw(c7114.25,2024.71) v3@7096.21,2023.13 ; v2@7088.13,2338.19 cw(c7088.41,2325.16) 7097.62,2334.38 cw(c7106.84,2343.59) v2@7093.81,2343.87 ; v2@7088.21,2334.19 cw(c7088.69,2312.2) 7104.25,2327.75 ; v2@7097.81,2343.79 ccw(c7119.8,2343.31) 7104.25,2327.75 ; 7100.13,2036.06 ccw(c7090.2,2045.99) 7104.25,2045.99 7104.25,2139.53 7104.25,2219.33 7104.25,2327.75
  Bottom Layer w4: v2@7082.36,2352.03 ccw(c7074.74,2362.88) 7088,2362.88 ; v2@7093.64,2352.03 cw(c7101.26,2362.88) 7088,2362.88 ; v2@7473.06,2613.06 ccw(c7456.31,2596.31) 7456.31,2620 ccw(c7456.31,2643.69) v2@7473.06,2626.94 ; v2@7475.89,2615.89 ccw(c7465.97,2605.97) 7465.97,2620 ccw(c7465.97,2634.03) v2@7475.89,2624.11 ; v2(7480,2620) 7439.87,2620 7207.69,2387.81 7187.81,2387.81 7168.62,2387.81 7155.69,2374.88 7135,2374.88 7118.13,2374.88 7100,2374.88 7093,2374.88 7088,2369.88 7088,2362.88 ; v2@7088,2344.75 7088,2362.88 ; v2@7088,2344.75 v2(7088,2344) v2@7088,2344.75
HOST_SRAM.A5: U30.T12 U47.18 | length 3069.1
  Top Layer w4: U30.T12@7142.6,1564.53 cw(c7130.07,1552) 7147.8,1552 cw(c7165.52,1552) U30.T12@7152.99,1564.53 ; v2@7147.06,1446.94 ccw(c7116.29,1477.71) 7159.81,1477.71 ; U30.T12@7147.8,1569.72 7147.8,1504.2 7159.81,1492.19 v2@7159.81,1440.81 ; v2@7149.89,1444.11 ccw(c7125.94,1468.06) 7159.81,1468.06 ; v2@7152.72,1441.28 ccw(c7135.6,1458.4) 7159.81,1458.4 ; U47.18@7555.59,2830.28 7591.15,2830.28 ; U47.18@7579.09,2824.92 cw(c7591.15,2814.03) 7591.15,2830.28 ; U47.18@7579.09,2835.64 ccw(c7591.15,2846.53) 7591.15,2830.28 ; v1(7685,2555) 7688,2552 7688,2554.5 7700.81,2567.31 7700.81,2720.61 7690.19,2731.23 7591.15,2830.28
  MidLayer1 w4: v2@7144.19,1439.9 cw(c7121.35,1439.65) 7137.5,1423.5 ; v2@7148.19,1439.94 cw(c7134.66,1439.79) 7144.23,1430.23 cw(c7153.79,1420.66) v2@7153.94,1434.19 ; v2@7153.9,1430.19 ccw(c7153.65,1407.35) 7137.5,1423.5 ; v2(7154,1440) 7137.5,1423.5 ; v2(7720,2605) 7780.19,2605 7787.38,2597.81 7800.5,2584.69 7800.5,2519.44 7790.69,2509.63 7782.19,2501.13 7782.19,2477.38 7782.19,2462.62 7782.19,2433.48 7798.61,2417.06 7798.61,2398.58 7857,2340.19 7857.36,2339.83 7857.36,2245.6 ; v2@7724.11,2600.89 cw(c7734.03,2590.97) 7734.03,2605 cw(c7734.03,2619.03) v2@7724.11,2609.11 ; v2@7726.94,2598.06 cw(c7743.69,2581.31) 7743.69,2605 cw(c7743.69,2628.69) v2@7726.94,2611.94 ; 7137.5,1423.5 7137.5,1418.5 7137.5,1384.38 7143.43,1378.44 7180.5,1341.38 7180.5,1310.75 7250.25,1241 7411.86,1241 7465.36,1294.5 7465.36,1423.51 7446,1442.87 7446,1476.63 7469.37,1500 7491.37,1500 7520,1528.63 7520,1544.06 7579.23,1603.29 7584.73,1603.29 7720.62,1739.18 7720.62,1782.09 7730.87,1792.34 7746.03,1792.34 7778.81,1825.12 7778.81,1950.31 7801.81,1973.31 7801.81,1980.81 7818.19,1997.19 7818.19,2009.5 7856.5,2047.81 7856.5,2205.34 7847.36,2214.48 7847.36,2235.6 ; 7847.36,2235.6 7857.36,2245.6 ; 7847.36,2235.6 7857.36,2245.6
  MidLayer2 w4: v1@7678.28,2561.72 ccw(c7654.82,2585.18) 7688,2585.18 ; v1@7681.11,2558.89 ccw(c7664.48,2575.52) 7688,2575.52 ; v1(7685,2555) 7688,2552 7688,2565 7688,2593 7700,2605 ; 7688,2570.69 ccw(c7700.69,2570.69) v1@7691.72,2561.72 ; v2@7712.24,2599 ccw(c7700,2589.52) 7700,2605 ; v2@7712.24,2611 cw(c7700,2620.48) 7700,2605 ; v2@7715.4,2601.44 ccw(c7708.15,2595.83) 7708.15,2605 ccw(c7708.15,2614.17) v2@7715.4,2608.56 ; v2(7720,2605) 7700,2605
HOST_SRAM.A6: U30.N13 U47.19 | length 3535.8
  Top Layer w4: U30.N13@7187.17,1680.49 cw(c7187.17,1662.77) 7199.7,1675.3 cw(c7212.23,1687.83) U30.N13@7194.51,1687.83 ; U30.N13@7187.17,1687.83 v3(7206.85,1668.15) ; U47.19@7555.59,2798.78 7609.97,2798.78 7692.81,2715.94 7692.81,2607.62 7667.5,2582.31 7667.5,2547.75 7677.75,2537.5 7692.25,2537.5 7702.5,2547.75 7702.5,2557.69 7710,2565.19 7729.81,2565.19 7740,2555 7740,2512.05 7725.81,2497.86 7725.81,2451.12 7750.61,2426.32 7750.61,2196.02 7750.61,2100.61 7675.81,2025.81 7626.69,2025.81 7618.69,2033.81 7597.31,2033.81 7582.19,2018.69 7582.19,1996.94 7570.5,1985.25 7570.5,1970.75 7616.5,1924.75 7616.5,1908.75 7627.75,1897.5 7642.25,1897.5 7678.25,1933.5 7810.19,1933.5 7856.3,1887.39 7856.3,1736.51 7865.81,1727 7865.81,1449.5 7670.31,1254 v2(7670,1254) ; U47.19@7578.81,2793.12 cw(c7592.46,2779.47) 7592.46,2798.78 cw(c7592.46,2818.09) U47.19@7578.81,2804.44 ; v2@7670,1259.81 ccw(c7670,1274.6) 7680.46,1264.14 ; v2@7670,1263.81 ccw(c7670,1288.25) 7687.28,1270.97 ; v2@7675.81,1254 cw(c7689.08,1254) 7679.7,1263.38 ; v2@7679.81,1254 cw(c7702.74,1254) 7686.53,1270.21 ; 7194.05,1680.95 cw(c7181.24,1668.15) 7199.35,1668.15 ccw(c7181.24,1668.15) 7194.05,1680.95 ; 7194.05,1680.95 ccw(c7206.85,1693.76) 7206.85,1675.65 cw(c7206.85,1693.76) 7194.05,1680.95
  MidLayer1 w4: v3@7205.55,1660.76 cw(c7202.4,1642.93) 7217.24,1653.32 ; v3@7214.24,1666.85 ccw(c7232.07,1663.7) 7217.24,1653.32 ; 7230.71,1591.34 7230.71,1605.27 ; v2(7280,1312) 7229.44,1362.56 7229.44,1414.94 7229.81,1415.31 7229.81,1444.82 7219.63,1455 7219.63,1491.82 7230.71,1502.9 7230.71,1531.15 7230.71,1605.27 ; 7217.24,1653.32 7224.32,1644.74 cw(c7206.94,1628.52) 7230.71,1628.52 7230.71,1605.27
  MidLayer2 w4: v2(7516,1314) 7582.13,1314 7590,1321.87 7646.13,1321.87 7670,1298 v2(7670,1254) ; v2@7520.11,1309.89 cw(c7530.03,1299.97) 7530.03,1314 cw(c7530.03,1328.03) v2@7520.11,1318.11 ; v2@7522.94,1307.06 cw(c7539.69,1290.31) 7539.69,1314 cw(c7539.69,1337.69) v2@7522.94,1320.94 ; v2@7663.06,1260.94 ccw(c7646.31,1277.69) 7670,1277.69 ccw(c7693.69,1277.69) v2@7676.94,1260.94 ; v2@7665.89,1258.11 ccw(c7655.97,1268.03) 7670,1268.03 ccw(c7684.03,1268.03) v2@7674.11,1258.11
  Bottom Layer w4: v2(7280,1312) 7280,1310 7292.31,1297.69 7295.5,1297.69 7317.51,1275.68 7355,1275.68 7370.2,1290.87 7475,1290.87 7492.87,1290.87 v2(7516,1314) ; v2@7506.19,1314 cw(c7482.5,1314) 7499.25,1297.25 cw(c7516,1280.5) v2@7516,1304.19 ; v2@7510.19,1314 cw(c7496.16,1314) 7506.08,1304.08 cw(c7516,1294.16) v2@7516,1308.19
HOST_SRAM.A7: U30.M11 U47.20 | length 3034.9
  Top Layer w4: U30.M11@7108.43,1719.86 cw(c7108.43,1702.14) 7120.96,1714.67 cw(c7133.49,1727.2) U30.M11@7115.77,1727.2 ; U30.M11@7108.43,1727.2 v3(7128.11,1707.52) ; v2(7136.62,1332.31) 7136.81,1332.5 7158.75,1332.5 ; v2@7140.87,1336.28 ccw(c7149.55,1344.37) 7149.55,1332.5 ; v2@7140.98,1328.47 cw(c7149.9,1320.62) 7149.9,1332.5 ; v2@7143.8,1339 ccw(c7158.75,1352.94) 7158.75,1332.5 ; v2@7143.98,1325.83 cw(c7158.75,1312.82) 7158.75,1332.5 ; v2(7529.28,1838.29) 7543.71,1823.86 7558.19,1809.38 7558.19,1757.76 7573.81,1742.14 7573.81,1692.62 7567.81,1686.62 7567.81,1601.9 7460.12,1494.21 7460.12,1300.57 7416.04,1256.5 7236.75,1256.5 7226.5,1266.75 7226.5,1274 7200.5,1300 7191.25,1300 7158.75,1332.5 ; U47.20@7555.59,2767.28 7622.95,2767.28 7663,2727.23 7663,2721 7663,2651.38 7665,2649.38 v2(7665,2620) ; U47.20@7578.81,2761.63 cw(c7592.46,2747.97) 7592.46,2767.28 cw(c7592.46,2786.6) U47.20@7578.81,2772.94 ; v2@7658.06,2626.94 ccw(c7641.31,2643.69) 7665,2643.69 ccw(c7688.69,2643.69) v2@7671.94,2626.94 ; v2@7660.89,2624.11 ccw(c7650.97,2634.03) 7665,2634.03 ccw(c7679.03,2634.03) v2@7669.11,2624.11 ; 7115.31,1720.32 cw(c7102.5,1707.52) 7120.61,1707.52 ccw(c7102.5,1707.52) 7115.31,1720.32 ; 7115.31,1720.32 ccw(c7128.11,1733.13) 7128.11,1715.02 cw(c7128.11,1733.13) 7115.31,1720.32
  MidLayer1 w4: v2(7529.28,1838.29) 7545.48,1838.29 ; v2@7537.98,1833.75 cw(c7545.48,1829.83) 7545.48,1838.29 ; v2@7537.98,1842.84 ccw(c7545.48,1846.76) 7545.48,1838.29 ; v2(7665,2620) 7665,2600.87 7702.68,2563.19 7722.76,2563.19 7737.81,2548.13 7737.81,2532.62 7737.81,2511.71 7742.19,2507.33 7742.19,2416.91 7758.61,2400.49 7758.61,2192.15 7758.61,2162.01 7729.81,2133.22 7729.81,2104.57 7653.99,2028.75 7653.99,1960.74 7635.44,1942.19 ; 7545.48,1838.29 7616.5,1909.31 7616.5,1923.25 7619.67,1926.42 ; 7619.67,1926.42 7635.44,1942.19 ; 7619.67,1926.42 7635.44,1942.19
  MidLayer2 w4: v13@7106,1495.81 ccw(c7106,1514.67) 7119.33,1501.33 ; v13@7106,1499.81 ccw(c7106,1528.33) 7126.16,1508.16 ; v13@7108,1490 7143.62,1525.62 7143.62,1590.47 7143.62,1684.01 ccw(c7129.57,1684.01) 7139.5,1693.94 ; v13@7115.81,1490 cw(c7134.67,1490) 7121.33,1503.33 ; v3@7127.46,1700.05 cw(c7125.88,1682.01) 7139.75,1693.65 cw(c7153.62,1705.29) v3@7135.58,1706.87
  Bottom Layer w4: v13@7099.06,1483.06 cw(c7082.31,1466.31) 7106,1466.31 cw(c7129.69,1466.31) v13@7112.94,1483.06 ; v13@7101.89,1485.89 cw(c7091.97,1475.97) 7106,1475.97 cw(c7120.03,1475.97) v13@7110.11,1485.89 ; v13(7106,1490) 7106,1462.19 7128.19,1440 7128.19,1375.75 7136.62,1367.32 v2(7136.62,1332.31) ; v2@7129.68,1339.25 ccw(c7112.94,1356) 7136.62,1356 ccw(c7160.31,1356) v2@7143.56,1339.25 ; v2@7132.51,1336.42 ccw(c7122.59,1346.34) 7136.62,1346.34 ccw(c7150.65,1346.34) v2@7140.73,1336.42
HOST_SRAM.A8: U30.N14 U47.21 | length 2171.3
  Top Layer w4: U30.N14@7226.54,1680.49 cw(c7226.54,1662.77) 7239.07,1675.3 cw(c7251.6,1687.83) U30.N14@7233.88,1687.83 ; U30.N14@7226.54,1687.83 v3(7246.22,1668.15) ; v2(7420,1610) 7422,1612 7447.19,1612 ; v2@7424.25,1606.03 cw(c7437.98,1593.21) 7437.98,1612 ; v2@7426.94,1616.94 ccw(c7438.86,1628.86) 7438.86,1612 ; v2@7427.17,1603.3 cw(c7447.19,1584.62) 7447.19,1612 ; v2@7429.06,2163.06 cw(c7412.31,2146.31) 7436,2146.31 cw(c7459.69,2146.31) v2@7442.94,2163.06 ; v2@7431.89,2165.89 cw(c7421.97,2155.97) 7436,2155.97 cw(c7450.03,2155.97) v2@7440.11,2165.89 ; v2(7436,2170) 7436,2141 7430.19,2135.19 7430.19,2089.37 7438.18,2081.38 7438.18,1998.62 7432.19,1992.63 7432.19,1932.05 7454,1910.24 7454,1895.13 7446.19,1887.32 7446.19,1809 7471.81,1783.38 7471.81,1768.62 7463.93,1760.75 7463.93,1665 ; 7463.93,1673.56 7463.93,1628.77 7453.11,1617.95 7447.19,1612 ; U47.21@7555.59,2735.79 7610.21,2735.79 7615.19,2730.81 v1(7615.19,2706.71) ; U47.21@7578.81,2730.13 cw(c7592.46,2716.47) 7592.46,2735.79 cw(c7592.46,2755.1) U47.21@7578.81,2741.44 ; v1@7608.47,2713.43 ccw(c7592.26,2729.64) 7615.19,2729.64 ccw(c7638.13,2729.64) v1@7621.91,2713.43 ; v1@7611.3,2710.6 ccw(c7601.91,2719.99) 7615.19,2719.99 ccw(c7628.47,2719.99) v1@7619.08,2710.6 ; 7233.42,1680.95 cw(c7220.61,1668.15) 7238.72,1668.15 ccw(c7220.61,1668.15) 7233.42,1680.95 ; 7233.42,1680.95 ccw(c7246.22,1693.76) 7246.22,1675.65 cw(c7246.22,1693.76) 7233.42,1680.95
  MidLayer1 w4: v3@7247.52,1660.76 cw(c7250.67,1642.93) 7261.05,1657.76 ; v3@7253.61,1669.45 ccw(c7271.44,1672.6) 7261.05,1657.76 ; 7323.03,1644.29 7309.1,1644.29 ; 7390.98,1631.83 ccw(c7420,1660.85) v2@7420,1619.81 ; 7397.81,1625 ccw(c7420,1647.19) v2@7420,1615.81 ; 7404.64,1618.17 ccw(c7420,1633.54) v2@7420,1611.81 ; 7408.33,1614.48 cw(c7403.86,1610) v2@7410.19,1610 ; v2(7420,1610) 7412.81,1610 7378.52,1644.29 7354.33,1644.29 7309.1,1644.29 ; v2@7436,2175.81 ccw(c7436,2189.84) 7445.92,2179.92 ccw(c7455.84,2170) v2@7441.81,2170 ; v2@7436,2179.81 ccw(c7436,2203.5) 7452.75,2186.75 ccw(c7469.5,2170) v2@7445.81,2170 ; v2@7438,2172 7453.81,2187.81 7453.81,2211.38 7448.52,2216.66 7448.52,2296.52 7474.81,2322.81 7532.81,2322.81 7536,2326 ; v1@7530.64,2336.16 cw(c7523.7,2326) 7536,2326 ; v1(7536,2344) 7536,2326 ; v1@7541.36,2336.16 ccw(c7548.3,2326) 7536,2326 ; 7261.05,1657.76 7269.63,1650.68 ccw(c7285.85,1668.06) 7285.85,1644.29 7309.1,1644.29
  MidLayer2 w4: v1@7530.83,2351.97 ccw(c7524.67,2361.48) 7536,2361.48 ; v1(7536,2344) 7536,2361.48 ; v1@7541.17,2351.97 cw(c7547.33,2361.48) 7536,2361.48 ; v1@7615.19,2697.21 cw(c7615.19,2674.27) 7631.41,2690.49 cw(c7647.63,2706.71) v1@7624.69,2706.71 ; v1@7615.19,2701.21 cw(c7615.19,2687.93) 7624.58,2697.32 cw(c7633.97,2706.71) v1@7620.69,2706.71 ; v1(7615.19,2706.71) 7640.19,2681.71 7640.19,2590 7640.19,2537.06 7522.5,2419.37 7522.5,2400.68 7522.5,2390 7522.5,2376.75 7522.69,2376.56 7522.69,2374.79 7536,2361.48
HOST_SRAM.A9: U30.N11 U47.22 | length 3196.3
  Top Layer w4: U30.N11@7108.43,1680.49 cw(c7108.43,1662.77) 7120.96,1675.3 cw(c7133.49,1687.83) U30.N11@7115.77,1687.83 ; U30.N11@7108.43,1687.83 v3(7128.11,1668.15) ; v2(7156,1290) 7158,1292 7197.19,1292 7218.5,1270.69 7218.5,1263.44 7233.44,1248.5 7419.36,1248.5 7468.12,1297.26 7468.12,1490.89 7575.81,1598.59 7575.81,1683.31 7581.81,1689.31 7581.81,1745.46 7566.19,1761.08 7566.19,1826.62 7524,1868.81 v2(7524,1882) ; v2@7160.11,1285.89 cw(c7174.86,1271.14) 7174.86,1292 cw(c7174.86,1308.86) v2@7162.94,1296.94 ; v2@7162.94,1283.06 cw(c7184.51,1261.49) 7184.51,1292 ; 7506.97,2650.6 cw(c7486.37,2630) v1@7515.5,2630 ; 7513.16,2644.4 ccw(c7525,2656.24) v1@7525,2639.5 ; 7513.8,2643.77 cw(c7500.03,2630) v1@7519.5,2630 ; v1(7525,2630) 7525,2632.56 7507.81,2649.75 7507.81,2693.81 7518.29,2704.29 U47.22@7555.59,2704.29 ; v1@7530,2498.5 cw(c7530,2475.56) 7546.22,2491.78 cw(c7562.44,2508) v1@7539.5,2508 ; v1@7530,2502.5 cw(c7530,2489.22) 7539.39,2498.61 cw(c7548.78,2508) v1@7535.5,2508 ; v1(7530,2508) 7598,2440 7704.81,2440 7742.61,2402.2 7742.61,2192.71 7742.61,2103.92 7686.69,2048 v2(7642,2048) ; U47.22@7532.37,2698.64 ccw(c7518.72,2684.98) 7518.72,2704.29 ccw(c7518.72,2723.61) U47.22@7532.37,2709.95 ; v2@7646.11,2043.89 cw(c7656.03,2033.97) 7656.03,2048 cw(c7656.03,2062.03) v2@7646.11,2052.11 ; v2@7648.94,2041.06 cw(c7665.69,2024.31) 7665.69,2048 cw(c7665.69,2071.69) v2@7648.94,2054.94 ; 7115.31,1680.95 cw(c7102.5,1668.15) 7120.61,1668.15 ccw(c7102.5,1668.15) 7115.31,1680.95 ; 7115.31,1680.95 ccw(c7128.11,1693.76) 7128.11,1675.65 cw(c7128.11,1693.76) 7115.31,1680.95
  MidLayer1 w4: v3@7126.81,1660.76 cw(c7123.66,1642.93) 7138.5,1653.32 ; v3@7135.5,1666.85 ccw(c7153.33,1663.7) 7138.5,1653.32 ; 7151.97,1591.34 7151.97,1605.27 ; v2(7156,1290) 7172.5,1306.5 7172.5,1338.06 7137.89,1372.67 7129.5,1381.06 7129.5,1440.69 7147,1458.19 7152.69,1458.19 7167.81,1473.31 7167.81,1495.89 7151.97,1511.73 7151.97,1531.15 7151.97,1605.27 ; v2@7156.06,1295.81 ccw(c7156.21,1309.34) 7165.77,1299.77 ccw(c7175.34,1290.21) v2@7161.81,1290.06 ; v2@7156.1,1299.81 ccw(c7156.35,1322.65) 7172.5,1306.5 ccw(c7188.65,1290.35) v2@7165.81,1290.1 ; v2(7524,1882) 7528.38,1886.38 7567.88,1886.38 7633.68,1952.18 7645.99,1964.49 7645.99,2006.75 7645.99,2020 7645.99,2029.14 7642,2033.13 v2(7642,2048) ; 7138.5,1653.32 7145.58,1644.74 cw(c7128.2,1628.52) 7151.97,1628.52 7151.97,1605.27
  MidLayer2 w4: v1@7518.28,2623.28 cw(c7502.06,2607.06) 7525,2607.06 cw(c7547.94,2607.06) v1@7531.72,2623.28 ; v1@7521.11,2626.11 cw(c7511.72,2616.72) 7525,2616.72 cw(c7538.28,2616.72) v1@7528.89,2626.11 ; v1@7523.28,2514.72 ccw(c7519.14,2518.86) 7525,2518.86 ; 7525,2523.69 ccw(c7545.69,2523.69) v1@7531.06,2509.06 ; 7525,2533.35 ccw(c7555.35,2533.35) v1@7533.89,2511.89 ; 7525,2543.01 ccw(c7565.01,2543.01) v1@7536.72,2514.72 ; v1(7530,2508) 7525,2513 v1(7525,2630) ; v1(7525,2630) 7525,2631.52 v1(7525,2630)
HOST_SRAM.A10: U30.K12 U47.23 | length 2026.7
  Top Layer w4: U30.K12@7147.8,1798.6 cw(c7147.8,1780.88) 7160.33,1793.41 cw(c7172.86,1805.94) U30.K12@7155.14,1805.94 ; U30.K12@7147.8,1805.94 v3(7167.48,1786.26) ; v1(7924.52,1800.04) 7934.94,1800.04 7950.04,1800.04 8008.19,1858.19 8008.19,1873.29 8008.19,1880 8008.19,2544.39 8024.02,2560.23 8024.02,2644.15 8004.41,2663.76 U47.23@8004.41,2704.29 ; v1@7928.41,1796.15 cw(c7937.8,1786.76) 7937.8,1800.04 cw(c7937.8,1813.32) v1@7928.41,1803.93 ; v1@7931.24,1793.32 cw(c7947.46,1777.11) 7947.46,1800.04 cw(c7947.46,1822.98) v1@7931.24,1806.76 ; U47.23@7998.75,2698.64 cw(c7985.1,2684.98) 8004.41,2684.98 cw(c8023.72,2684.98) U47.23@8010.07,2698.64 ; 7154.68,1799.06 cw(c7141.87,1786.26) 7159.98,1786.26 ccw(c7141.87,1786.26) 7154.68,1799.06 ; 7154.68,1799.06 ccw(c7167.48,1811.87) 7167.48,1793.76 cw(c7167.48,1811.87) 7154.68,1799.06
  MidLayer2 w4: v3@7168.13,1778.79 cw(c7169.71,1760.75) 7181.35,1774.62 cw(c7192.99,1788.49) v3@7174.95,1786.91 ; 7181.06,1774.87 ccw(c7190.99,1784.8) 7190.99,1770.75 7284.53,1770.75 7434.06,1770.75 7446.62,1758.19 7492.63,1758.19 7499.78,1765.34 7590.21,1765.34 7650,1765.34 7703.87,1765.34 7724.6,1786.06 7730.87,1792.34 7745.37,1792.34 7753.71,1784 7865,1784 7908.48,1784 ; v1@7915.02,1799.97 cw(c7892.69,1799.79) 7908.48,1784 ; v1@7919.02,1800 cw(c7906.1,1799.9) 7915.24,1790.75 cw(c7924.38,1781.61) v1@7924.48,1794.54 ; v1@7924.45,1790.54 ccw(c7924.28,1768.21) 7908.48,1784 ; v1(7924.52,1800.04) 7908.48,1784
HOST_SRAM.A11: U30.L12 U47.24 | length 2488.3
  Top Layer w4: U30.L12@7147.8,1759.23 cw(c7147.8,1741.51) 7160.33,1754.04 cw(c7172.86,1766.57) U30.L12@7155.14,1766.57 ; U30.L12@7147.8,1766.57 v3(7167.48,1746.89) ; U47.24@8004.41,2735.79 8038.52,2735.79 ; U47.24@8028.24,2730.82 cw(c8038.52,2722.66) 8038.52,2735.79 ; U47.24@8028.24,2740.76 ccw(c8038.52,2748.92) 8038.52,2735.79 ; v1(8213.86,1725.04) 8231.86,1743.04 8231.86,2280.52 8123.52,2388.85 8123.52,2458.37 8073.52,2508.37 8073.52,2700.79 8038.52,2735.79 ; v1@8213.86,1730.54 ccw(c8213.86,1743.82) 8223.25,1734.43 ccw(c8232.64,1725.04) v1@8219.36,1725.04 ; v1@8213.86,1734.54 ccw(c8213.86,1757.48) 8230.07,1741.26 ccw(c8246.29,1725.04) v1@8223.36,1725.04 ; 7154.68,1759.69 cw(c7141.87,1746.89) 7159.98,1746.89 ccw(c7141.87,1746.89) 7154.68,1759.69 ; 7154.68,1759.69 ccw(c7167.48,1772.5) 7167.48,1754.39 cw(c7167.48,1772.5) 7154.68,1759.69
  MidLayer2 w4: v3@7168.13,1739.42 cw(c7169.71,1721.38) 7181.35,1735.25 cw(c7192.99,1749.12) v3@7174.95,1747.54 ; 7181.06,1735.5 ccw(c7190.99,1745.43) 7190.99,1731.38 7284.53,1731.38 7357.3,1731.38 7380.5,1708.19 7402.69,1708.19 7412.42,1717.91 7437.91,1717.91 7438,1718 ; 7435,1718 7438,1718 ; v1@8207.14,1718.32 ccw(c8190.92,1702.11) 8190.92,1725.04 ccw(c8190.92,1747.98) v1@8207.14,1731.76 ; v1@8209.97,1721.15 ccw(c8200.58,1711.76) 8200.58,1725.04 ccw(c8200.58,1738.32) v1@8209.97,1728.93 ; v1(8213.86,1725.04) 8160.04,1725.04 8150,1715 7777.5,1715 7770.69,1708.19 7749.31,1708.19 7741.31,1716.19 7663.69,1716.19 7655.69,1708.19 7607.76,1708.19 7586.84,1729.11 7512.11,1729.11 7501,1718 7438,1718
HOST_SRAM.A12: U30.J11 U47.25 | length 2766.1
  Top Layer w4: U30.J11@7108.43,1837.97 cw(c7108.42,1820.25) 7120.96,1832.78 cw(c7133.49,1845.31) U30.J11@7115.77,1845.31 ; U30.J11@7108.43,1845.31 v3(7128.11,1825.63) ; v1@7892.1,1801 8001.39,1691.71 8221.86,1691.71 8239.9,1709.75 8239.9,2482.75 8265.19,2508.04 8265.19,2709.81 8207.72,2767.28 U47.25@8004.41,2767.28 ; v1@7893.9,1793.3 cw(c7893.9,1779.06) 7903.97,1789.13 ; v1@7899.4,1802.8 ccw(c7921.37,1802.8) 7905.83,1787.27 ; v1@7903.4,1802.8 ccw(c7935.03,1802.8) 7912.66,1780.44 ; U47.25@8027.63,2761.63 cw(c8041.28,2747.97) 8041.28,2767.28 cw(c8041.28,2786.6) U47.25@8027.63,2772.94 ; 7115.31,1838.43 cw(c7102.5,1825.63) 7120.61,1825.63 ccw(c7102.5,1825.63) 7115.31,1838.43 ; 7115.31,1838.43 ccw(c7128.11,1851.24) 7128.11,1833.13 cw(c7128.11,1851.24) 7115.31,1838.43
  MidLayer2 w4: v3@7128.76,1818.16 cw(c7130.34,1800.12) 7141.98,1813.99 ; v3@7135.58,1826.28 ccw(c7153.62,1827.86) 7141.98,1813.99 ; v1@7887.18,1796.08 ccw(c7870.97,1779.86) 7870.97,1802.8 ccw(c7870.97,1825.73) v1@7887.18,1809.52 ; v1@7890.01,1798.91 ccw(c7880.62,1789.52) 7880.62,1802.8 ccw(c7880.62,1816.08) v1@7890.01,1806.69 ; v1(7893.9,1802.8) 7730.02,1802.8 7721.28,1794.06 7700.56,1773.34 7593.53,1773.34 7481.85,1773.34 7471,1784.19 7461.38,1793.81 7446.62,1793.81 7434.81,1782 7386,1782 7366.23,1801.77 7284.53,1801.77 7265.11,1801.77 7190.99,1801.77 7171.49,1801.77 cw(c7171.49,1843.5) 7141.98,1813.99
HOST_SRAM.A13: U30.N16 U47.26 | length 2132.3
  Top Layer w4: U30.N16@7305.28,1687.83 7324.96,1687.83 7352,1687.83 ; U30.N16@7310.47,1682.64 cw(c7323,1670.11) 7323,1687.83 cw(c7323,1705.56) U30.N16@7310.47,1693.03 ; 7354.33,1687.83 7352,1687.83 ; v2@7439.19,1659.25 ccw(c7422.44,1642.5) 7422.44,1666.19 ccw(c7422.44,1689.87) v2@7439.19,1673.12 ; v2@7442.01,1662.08 ccw(c7432.09,1652.16) 7432.09,1666.19 ccw(c7432.09,1680.21) v2@7442.01,1670.29 ; v2@7446,1666.19 v2(7446.12,1666.19) 7420.32,1666.19 7414.31,1672.19 7394.62,1672.19 7378.98,1687.83 7352,1687.83 ; U47.26@8004.41,2798.78 8041.12,2798.78 v1(8048.52,2791.37) ; U47.26@8007.71,2798.78 cw(c8007.71,2750.56) v1@8041.81,2784.66 ; U47.26@8017.37,2798.78 cw(c8017.37,2760.22) v1@8044.64,2787.49 ; U47.26@8027.03,2798.78 cw(c8027.03,2769.88) v1@8047.46,2790.31 ; 8036.68,2798.78 cw(c8036.68,2779.53) v1@8050.29,2793.14
  MidLayer1 w4: v2(7446.12,1666.19) 7471.81,1691.87 7488.06,1691.87 7490,1693.81 7513.38,1693.81 7515,1692.19 7562.84,1692.19 7694,1823.35 7694,1977.1 7685.99,1985.11 7685.99,2015.49 7716.21,2045.71 7722.31,2051.81 7724.44,2051.81 7749.5,2051.81 7755.81,2045.5 7825.56,2045.5 7840.5,2060.44 7840.5,2198.71 7831.36,2207.85 7831.36,2242.23 7834,2244.87 7834,2289.56 v1(7831.86,2291.71) ; v2@7446.12,1672 ccw(c7446.12,1686.03) 7456.04,1676.11 ccw(c7465.96,1666.19) v2@7451.93,1666.19 ; v2@7446.12,1676 ccw(c7446.12,1699.68) 7462.87,1682.93 ccw(c7479.62,1666.19) v2@7455.93,1666.19 ; v1@7825.14,2284.99 cw(c7803.75,2263.6) 7834,2263.6 ; v1@7827.97,2287.82 cw(c7813.41,2273.26) 7834,2273.26 ; 7834,2273.95 cw(c7849.62,2273.95) v1@7838.57,2284.99
  MidLayer2 w4: v1(7831.86,2291.71) 8048.52,2508.37 v1(8048.52,2791.37) ; v1@7831.86,2297.21 ccw(c7831.86,2310.49) 7841.25,2301.1 ccw(c7850.64,2291.71) v1@7837.36,2291.71 ; v1@7831.86,2301.21 ccw(c7831.86,2324.14) 7848.07,2307.93 ccw(c7864.29,2291.71) v1@7841.36,2291.71 ; v1@8041.81,2784.66 cw(c8025.59,2768.44) 8048.52,2768.44 cw(c8071.46,2768.44) v1@8055.24,2784.66 ; v1@8044.64,2787.49 cw(c8035.25,2778.1) 8048.52,2778.1 cw(c8061.8,2778.1) v1@8052.41,2787.49
HOST_SRAM.A14: U30.J12 U47.27 | length 2182.5
  Top Layer w4: U30.J12@7147.8,1837.97 cw(c7147.8,1820.25) 7160.33,1832.78 cw(c7172.86,1845.31) U30.J12@7155.14,1845.31 ; U30.J12@7147.8,1845.31 v3(7167.48,1825.63) ; v1(7951.86,1841.71) 7980.39,1841.71 7999.6,1860.91 7999.6,1889.45 7999.6,2030 7999.6,2547.12 8016.02,2563.54 8016.02,2640.83 7970.85,2686.01 7970.85,2808.34 7992.79,2830.28 U47.27@8004.41,2830.28 ; v1@7955.75,1837.82 cw(c7965.14,1828.43) 7965.14,1841.71 cw(c7965.14,1854.99) v1@7955.75,1845.6 ; v1@7958.57,1834.99 cw(c7974.79,1818.77) 7974.79,1841.71 cw(c7974.79,1864.64) v1@7958.57,1848.43 ; 7973.82,2811.31 ccw(c7960.33,2824.8) U47.27@7979.02,2828.66 ; 7979.07,2816.55 ccw(c7969.02,2826.6) U47.27@7982.93,2829.47 ; U47.27@7983.33,2820.82 cw(c7986.85,2817.3) U47.27@7986.85,2822.28 ; 7154.68,1838.43 cw(c7141.87,1825.63) 7159.98,1825.63 ccw(c7141.87,1825.63) 7154.68,1838.43 ; 7154.68,1838.43 ccw(c7167.48,1851.24) 7167.48,1833.13 cw(c7167.48,1851.24) 7154.68,1838.43
  MidLayer2 w4: v3@7168.13,1818.16 cw(c7169.71,1800.12) 7181.35,1813.99 cw(c7192.99,1827.86) v3@7174.95,1826.28 ; 7181.06,1814.24 ccw(c7190.99,1824.17) 7190.99,1810.12 7284.53,1810.12 7385.37,1810.12 7392.75,1817.5 7415,1817.5 7422.69,1809.81 7468,1809.81 7488.48,1789.34 7600.15,1789.34 7693.93,1789.34 7742.78,1838.19 7780,1838.19 7948.34,1838.19 v1(7951.86,1841.71) ; 7920.43,1838.19 ccw(c7920.43,1873.14) v1@7945.14,1848.43 ; 7930.08,1838.19 ccw(c7930.08,1863.48) v1@7947.97,1845.6 ; 7937.42,1838.19 cw(c7937.42,1827.27) v1@7945.14,1834.99 ; 7939.74,1838.19 ccw(c7939.74,1853.82) v1@7950.8,1842.77
HOST_SRAM.A15: U30.R16 U47.42 | length 2870.7
  Top Layer w4: U30.R16@7305.28,1609.09 7324.96,1609.09 7354,1609.09 ; U30.R16@7310.47,1603.9 cw(c7323,1591.37) 7323,1609.09 cw(c7323,1626.82) U30.R16@7310.47,1614.29 ; 7354.33,1609.09 7354,1609.09 ; v2@7417.06,1557.06 ccw(c7400.31,1540.31) 7400.31,1564 ccw(c7400.31,1587.69) v2@7417.06,1570.94 ; v2@7419.89,1559.89 ccw(c7409.97,1549.97) 7409.97,1564 ccw(c7409.97,1578.03) v2@7419.89,1568.11 ; v2(7424,1564) 7384,1564 7375,1573 7375,1601 7366.91,1609.09 7354,1609.09 ; v2@7463.06,1556.94 ccw(c7446.26,1573.74) 7470.02,1573.74 ; v2@7465.89,1554.11 ccw(c7455.91,1564.09) 7470.02,1564.09 ; v2(7470,1550) 7470.02,1600.89 7487.93,1618.8 7487.93,1747.93 7496.31,1756.31 7496.31,1792.82 7470.19,1818.94 7470.19,1877.38 7478,1885.19 7478,1920.18 7456.19,1942 7456.19,1982.69 7462.18,1988.68 7462.18,2091.32 7454.19,2099.31 7454.19,2120.69 7480,2146.5 v2(7480,2174.81) ; 7470.02,1563.97 ccw(c7483.97,1563.97) v2@7474.11,1554.11 ; 7470.02,1573.63 ccw(c7493.63,1573.63) v2@7476.94,1556.94 ; v2@7473.06,2167.87 cw(c7456.31,2151.12) 7480,2151.12 cw(c7503.69,2151.12) v2@7486.94,2167.87 ; v2@7475.89,2170.7 cw(c7465.97,2160.78) 7480,2160.78 cw(c7494.03,2160.78) v2@7484.11,2170.7 ; v1@7865.14,2556.76 ccw(c7844.9,2577) 7873.52,2577 ; v1@7867.97,2553.93 ccw(c7854.55,2567.34) 7873.52,2567.34 ; v1@7873.52,2550.04 7873.52,2605.39 7882.12,2613.99 7882.12,2897.7 7873.52,2906.29 7873.52,3298.52 7877.72,3302.72 U47.42@8004.41,3302.72 ; 7873.52,2568.95 ccw(c7890.77,2568.95) v1@7878.57,2556.76 ; U47.42@7981.19,3297.06 ccw(c7967.54,3283.4) 7967.54,3302.72 ccw(c7967.54,3322.03) U47.42@7981.19,3308.37
  MidLayer1 w4: v2(7424,1564) 7438,1550 v2(7470,1550) ; v2@7463.06,1543.06 ccw(c7446.31,1526.31) 7446.31,1550 ccw(c7446.31,1573.69) v2@7463.06,1556.94 ; v2@7465.89,1545.89 ccw(c7455.97,1535.97) 7455.97,1550 ccw(c7455.97,1564.03) v2@7465.89,1554.11
  Bottom Layer w4: v2@7473.06,2181.74 ccw(c7456.31,2198.49) 7480,2198.49 ccw(c7503.69,2198.49) v2@7486.94,2181.74 ; v2@7475.89,2178.92 ccw(c7465.97,2188.84) 7480,2188.84 ccw(c7494.03,2188.84) v2@7484.11,2178.92 ; v2(7480,2174.81) 7480,2236.44 7496,2252.44 7565.19,2321.63 7565.19,2416.71 7573.52,2425.04 7646.6,2425.04 7727.75,2506.19 7798.8,2506.19 7806.82,2514.21 7842.66,2550.04 v1(7871.86,2550.04) ; v1@7865.14,2543.32 ccw(c7848.92,2527.11) 7848.92,2550.04 ccw(c7848.92,2572.98) v1@7865.14,2556.76 ; v1@7867.97,2546.15 ccw(c7858.58,2536.76) 7858.58,2550.04 ccw(c7858.58,2563.32) v1@7867.97,2553.93
HOST_SRAM.A16: U30.H15 U47.43 | length 2505.9
  Top Layer w4: v2(7434,1902) 7418.19,1886.19 7380.62,1886.19 7366.28,1900.53 7362,1900.53 7285.95,1900.53 7285.62,1900.19 ; v1(7959.86,3328.04) 7966.03,3334.21 U47.43@8004.41,3334.21 ; v1@7960.92,3326.98 cw(c7978.38,3309.52) U47.43@7978.38,3334.21 ; v1@7963.75,3324.15 cw(c7988.04,3299.86) U47.43@7988.04,3334.21 ; v1@7966.57,3321.32 cw(c7997.69,3290.21) U47.43@7997.69,3334.21 ; 7278.44,1897.22 cw(c7285.62,1890.04) 7285.62,1900.19 ; 7278.44,1897.22 cw(c7285.62,1890.04) 7285.62,1900.19 ; 7278.44,1897.22 ccw(c7290.97,1884.68) 7273.25,1884.68 cw(c7290.97,1884.68) 7278.44,1897.22 ; 7278.44,1897.22 cw(c7265.91,1909.75) 7265.91,1892.03 ccw(c7265.91,1909.75) 7278.44,1897.22
  MidLayer1 w4: v2@7437.81,1905.99 7437.81,1966.7 7471.11,2000 ; v1@7660.28,2089.28 ccw(c7644.06,2073.06) 7644.06,2096 ccw(c7644.06,2118.93) v1@7660.28,2102.72 ; v1@7663.11,2092.11 ccw(c7653.72,2082.72) 7653.72,2096 ccw(c7653.72,2109.28) v1@7663.11,2099.89 ; v1(7667,2096) 7642.18,2096 7584.26,2038.08 ; 7471.11,2000 7479.31,2000 ; 7471.11,2000 7479.31,2000 ; 7479.31,2000 7484.81,2000 7510.81,2000 ; 7479.31,2000 7510.81,2000 ; 7510.81,2000 7515.81,2005 7526.19,2015.38 ; 7526.19,2015.38 7538.62,2027.81 ; 7526.19,2015.38 7538.62,2027.81 ; 7538.62,2027.81 7545,2027.81 ; 7545,2027.81 7553.38,2027.81 ; 7545,2027.81 7553.38,2027.81 ; 7553.38,2027.81 7574,2027.81 ; 7574,2027.81 7584.26,2038.08 ; 7574,2027.81 7584.26,2038.08
  MidLayer2 w4: v1(7667,2096) 7750.96,2096 7751.15,2096.19 ; v1@7670.89,2092.11 cw(c7680.28,2082.72) 7680.28,2096 cw(c7680.28,2109.28) v1@7670.89,2099.89 ; v1@7673.72,2089.28 cw(c7689.94,2073.06) 7689.94,2096 cw(c7689.94,2118.93) v1@7673.72,2102.72 ; 7685.71,2096.19 7751.15,2096.19 ; v1@7959.86,3318.54 cw(c7959.86,3295.61) 7976.07,3311.82 cw(c7992.29,3328.04) v1@7969.36,3328.04 ; v1@7959.86,3322.54 cw(c7959.86,3309.26) 7969.25,3318.65 cw(c7978.64,3328.04) v1@7965.36,3328.04 ; v1(7959.86,3328.04) 8015.19,3272.71 8015.19,2973.19 7830.5,2788.5 7830.5,2526.81 7792.19,2488.5 7782,2488.5 7773.19,2479.69 7773.19,2118.23 ; 7751.15,2096.19 7773.19,2118.23 ; 7751.15,2096.19 7773.19,2118.23