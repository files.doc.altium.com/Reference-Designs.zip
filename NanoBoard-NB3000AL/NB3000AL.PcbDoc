# Altium PCB NB3000AL.PcbDoc (part 79 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Other copper (continued)
Multi-Layer:
  pour cut-out: -701.84,4350 -1000,4350 -1000,2240 -701.84,2240
  lines w5 net 1V8: 2099.63,2046.36 ccw(c2084.27,2061.73) 2106,2061.73 ccw(c2127.72,2061.73) 2112.36,2046.36 ccw(c2127.72,2061.73) 2127.72,2040 ccw(c2127.72,2018.27) 2112.36,2033.64 ; 2099.63,2058.64 cw(c2084.27,2043.27) 2106,2043.27 cw(c2127.72,2043.27) 2112.36,2058.64 ; 2099.63,2071.36 ccw(c2084.27,2086.73) 2106,2086.73 ccw(c2127.72,2086.73) 2112.36,2071.36 ; 2099.63,2083.64 cw(c2084.27,2068.27) 2106,2068.27 cw(c2127.72,2068.27) 2112.36,2083.64 ; 2099.63,2096.36 ccw(c2084.27,2111.73) 2106,2111.73 ccw(c2127.72,2111.73) 2112.36,2096.36 ; 2099.63,2108.64 cw(c2084.27,2093.27) 2106,2093.27 cw(c2127.72,2093.27) 2112.36,2108.64 ; 2099.63,2121.36 ccw(c2084.27,2136.73) 2106,2136.73 ccw(c2127.72,2136.73) 2112.36,2121.36 ; 2099.63,2133.64 cw(c2084.27,2118.27) 2106,2118.27 cw(c2127.72,2118.27) 2112.36,2133.64 ; 2099.63,2146.36 ccw(c2084.27,2161.73) 2106,2161.73 ccw(c2127.72,2161.73) 2112.36,2146.36 ; 2099.63,2158.64 cw(c2084.27,2143.27) 2106,2143.27 cw(c2127.72,2143.27) 2112.36,2158.64 ; 2099.63,2171.36 ccw(c2084.27,2186.73) 2106,2186.73 ccw(c2127.72,2186.73) 2112.36,2171.36 ; 2099.63,2183.64 cw(c2084.27,2168.27) 2106,2168.27 cw(c2127.72,2168.27) 2112.36,2183.64 ; 2106,2190 2106,2165 2106,2140 2106,2115 2106,2090 2106,2065 2106,2040 2131.99,2040 2131.99,2065 2131.99,2090 2131.99,2115 ; 2125.63,2033.64 ccw(c2110.26,2018.27) 2110.26,2040 ccw(c2110.26,2061.73) 2125.63,2046.37 ccw(c2110.26,2061.73) 2131.99,2061.73 ccw(c2153.72,2061.73) 2138.36,2046.37 ; 2125.63,2058.64 cw(c2110.26,2043.27) 2131.99,2043.27 cw(c2153.72,2043.27) 2138.36,2058.64 ; 2125.63,2071.37 ccw(c2110.26,2086.73) 2131.99,2086.73 ccw(c2153.72,2086.73) 2138.36,2071.37 ; 2125.63,2083.64 cw(c2110.26,2068.27) 2131.99,2068.27 cw(c2153.72,2068.27) 2138.36,2083.64 ; 2125.63,2096.37 ccw(c2110.26,2111.73) 2131.99,2111.73 ccw(c2153.72,2111.73) 2138.36,2096.37 ; 2125.63,2108.64 cw(c2110.26,2093.27) 2131.99,2093.27 cw(c2153.72,2093.27) 2138.36,2108.64 cw(c2153.72,2093.27) 2153.72,2115 cw(c2153.72,2136.73) 2138.36,2121.37 cw(c2153.72,2136.73) 2131.99,2136.73 cw(c2110.26,2136.73) 2125.63,2121.37 ; 2125.63,2133.64 cw(c2110.26,2118.27) 2131.99,2118.27 cw(c2153.72,2118.27) 2138.36,2133.64 ; 2125.63,2146.37 ccw(c2110.26,2161.73) 2131.99,2161.73 ccw(c2153.72,2161.73) 2138.36,2146.37 ; 2125.63,2158.64 cw(c2110.26,2143.27) 2131.99,2143.27 cw(c2153.72,2143.27) 2138.36,2158.64 ; 2125.63,2171.37 ccw(c2110.26,2186.73) 2131.99,2186.73 ccw(c2153.72,2186.73) 2138.36,2171.37 ; 2125.63,2183.64 cw(c2110.26,2168.27) 2131.99,2168.27 cw(c2153.72,2168.27) 2138.36,2183.64 ; 2131.99,2190 2131.99,2165 2131.99,2140 ; 2138.1,2146.61 ccw(c2152.84,2162.58) 2153.7,2140.87 ccw(c2154.57,2119.16) 2138.6,2133.9 ; 2150.38,2147.1 cw(c2134.42,2161.84) 2135.28,2140.13 cw(c2136.15,2118.42) 2150.89,2134.39 ; 2150.63,2108.64 ccw(c2135.26,2093.27) 2135.26,2115 ccw(c2135.26,2136.73) 2150.63,2121.37 ; 2163.36,2108.64 cw(c2178.72,2093.27) 2178.72,2115 cw(c2178.72,2136.73) 2163.36,2121.37 ; 2163.36,2134.63 cw(c2178.72,2119.27) 2178.72,2141 cw(c2178.72,2162.73) 2163.36,2147.36 ; 2175.63,2108.64 ccw(c2160.26,2093.27) 2160.26,2115 ccw(c2160.26,2136.73) 2175.63,2121.37 ; 2175.63,2134.63 ccw(c2160.26,2119.27) 2160.26,2141 ccw(c2160.26,2162.73) 2175.63,2147.36 ; 2181.99,2141 2156.99,2141 2131.99,2140 ; 2188.22,2108.51 cw(c2203.27,2092.83) 2203.72,2114.56 cw(c2204.16,2136.28) 2188.49,2121.23 ; 2206.02,1670.99 2232.01,1670.99 ; 2206.02,1770 2232.01,1770 ; 2212.38,1664.63 cw(c2227.74,1649.27) 2227.74,1670.99 cw(c2227.74,1692.72) 2212.38,1677.36 ; 2212.38,1763.63 cw(c2227.74,1748.27) 2227.74,1770 cw(c2227.74,1791.73) 2212.38,1776.36 ; 2224.52,2107.76 ccw(c2208.85,2092.72) 2209.29,2114.44 ccw(c2209.74,2136.17) 2224.78,2120.49 ; 2224.65,2094.36 ccw(c2209.29,2109.73) 2231.02,2109.73 ccw(c2252.74,2109.73) 2237.38,2094.36 ccw(c2252.74,2109.73) 2252.74,2088 ccw(c2252.75,2066.27) 2237.38,2081.64 ; 2224.65,2107.63 cw(c2209.29,2092.27) 2231.02,2092.27 cw(c2252.74,2092.27) 2237.38,2107.63 cw(c2252.74,2092.27) 2252.74,2114 cw(c2252.74,2135.73) 2237.38,2120.36 ; 2225.65,1664.63 ccw(c2210.28,1649.26) 2210.28,1670.99 ccw(c2210.28,1692.72) 2225.65,1677.36 ccw(c2210.28,1692.72) 2232.01,1692.72 ccw(c2253.74,1692.72) 2238.38,1677.36 ccw(c2253.74,1692.72) 2253.74,1670.99 ccw(c2253.74,1649.27) 2238.38,1664.63 ; 2225.65,1689.63 cw(c2210.28,1674.27) 2232.01,1674.27 cw(c2253.74,1674.27) 2238.38,1689.63 ; 2225.65,1763.63 ccw(c2210.28,1748.27) 2210.28,1770 ccw(c2210.28,1791.72) 2225.65,1776.36 ccw(c2210.28,1791.73) 2232.01,1791.73 ccw(c2253.74,1791.73) 2238.38,1776.36 ccw(c2253.74,1791.73) 2253.74,1770 ccw(c2253.74,1748.27) 2238.38,1763.63 ; 2225.65,1788.63 cw(c2210.28,1773.27) 2232.01,1773.27 cw(c2253.74,1773.27) 2238.38,1788.63 ; 2232.01,1695.99 2232.01,1670.99 ; 2232.01,1795 2232.01,1770 ; 2250.65,2107.63 ccw(c2235.28,2092.27) 2235.28,2114 ccw(c2235.28,2135.72) 2250.65,2120.36 ; 2250.65,2081.64 ccw(c2235.29,2066.27) 2235.28,2088 ccw(c2235.28,2109.73) 2250.65,2094.37 ; 2251.64,1664.63 ccw(c2236.28,1649.27) 2236.28,1670.99 ccw(c2236.28,1692.72) 2251.64,1677.36 ccw(c2236.28,1692.72) 2258.01,1692.72 ccw(c2279.74,1692.72) 2264.37,1677.36 ccw(c2279.73,1692.72) 2279.74,1671 ccw(c2279.74,1649.27) 2264.37,1664.63 ; 2251.64,1689.63 cw(c2236.28,1674.27) 2258.01,1674.27 cw(c2279.74,1674.27) 2264.37,1689.63 ; 2251.64,1763.63 ccw(c2236.28,1748.27) 2236.28,1770 ccw(c2236.28,1791.73) 2251.64,1776.36 ccw(c2236.28,1791.73) 2258.01,1791.73 ccw(c2279.74,1791.73) 2264.37,1776.36 ccw(c2279.74,1791.73) 2279.74,1770 ccw(c2279.74,1748.27) 2264.37,1763.63 ; 2251.64,1788.63 cw(c2236.28,1773.27) 2258.01,1773.27 cw(c2279.74,1773.27) 2264.37,1788.63 ; 2251.64,1801.36 ccw(c2236.28,1816.73) 2258.01,1816.73 ccw(c2279.74,1816.73) 2264.37,1801.36 ; 2251.64,1813.63 cw(c2236.28,1798.27) 2258.01,1798.27 cw(c2279.74,1798.27) 2264.37,1813.63 ; 2258.01,1695.99 2258.01,1670.99 ; 2258.01,1820 2258.01,1795 2258.01,1770 ; 2263.38,2081.64 cw(c2278.74,2066.27) 2278.74,2088 cw(c2278.74,2109.73) 2263.38,2094.37 ; 2263.38,2107.63 cw(c2278.74,2092.27) 2278.74,2114 cw(c2278.74,2135.73) 2263.38,2120.36 ; 2276.65,2081.64 ccw(c2261.28,2066.27) 2261.28,2088 ccw(c2261.28,2109.73) 2276.64,2094.37 ; 2276.64,2107.63 ccw(c2261.28,2092.27) 2261.28,2114 ccw(c2261.28,2135.73) 2276.64,2120.36 ; 2277.64,1664.63 ccw(c2262.28,1649.27) 2262.28,1670.99 ccw(c2262.27,1692.72) 2277.64,1677.36 ccw(c2262.28,1692.72) 2284,1692.72 ccw(c2305.73,1692.72) 2290.37,1677.36 ccw(c2305.73,1692.72) 2305.73,1671 ccw(c2305.73,1649.27) 2290.37,1664.63 ; 2277.64,1689.63 cw(c2262.28,1674.27) 2284,1674.27 cw(c2305.73,1674.27) 2290.37,1689.63 ; 2277.64,1763.64 ccw(c2262.28,1748.27) 2262.28,1770 ccw(c2262.28,1791.73) 2277.64,1776.36 ccw(c2262.28,1791.73) 2284,1791.73 ccw(c2305.73,1791.73) 2290.37,1776.36 ccw(c2305.73,1791.73) 2305.73,1770 ccw(c2305.73,1748.27) 2290.37,1763.64 ; 2277.64,1788.64 cw(c2262.28,1773.27) 2284,1773.27 cw(c2305.73,1773.27) 2290.37,1788.64 ; 2277.64,1801.36 ccw(c2262.28,1816.73) 2284,1816.73 ccw(c2305.73,1816.73) 2290.37,1801.36 ; 2277.64,1813.64 cw(c2262.28,1798.27) 2284,1798.27 cw(c2305.73,1798.27) 2290.37,1813.64 ; 2283.01,2114 2257.01,2114 2231.02,2114 ; 2284,1696 2284,1671 ; 2284,1820 2284,1795 2284,1770 ; 2289.37,2081.64 cw(c2304.74,2066.28) 2304.74,2088 cw(c2304.74,2109.73) 2289.37,2094.37 ; 2302.64,2081.64 ccw(c2287.28,2066.27) 2287.28,2088 ccw(c2287.28,2109.73) 2302.64,2094.37 ; 2303.64,1664.63 ccw(c2288.27,1649.27) 2288.27,1671 ccw(c2288.27,1692.72) 2303.64,1677.36 ccw(c2288.27,1692.72) 2310,1692.72 ccw(c2331.73,1692.72) 2316.36,1677.36 ; 2303.64,1689.63 cw(c2288.27,1674.27) 2310,1674.27 cw(c2331.73,1674.27) 2316.36,1689.63 ; 2303.64,1763.64 ccw(c2288.27,1748.27) 2288.27,1770 ccw(c2288.27,1791.73) 2303.64,1776.36 ccw(c2288.27,1791.73) 2310,1791.73 ccw(c2331.73,1791.73) 2316.36,1776.36 ; 2303.64,1788.64 cw(c2288.27,1773.27) 2310,1773.27 cw(c2331.73,1773.27) 2316.36,1788.64 ; 2303.64,1801.36 ccw(c2288.27,1816.73) 2310,1816.73 ccw(c2331.73,1816.73) 2316.36,1801.36 ; 2303.64,1813.64 cw(c2288.27,1798.27) 2310,1798.27 cw(c2331.73,1798.27) 2316.36,1813.64 cw(c2331.73,1798.27) 2331.73,1820 cw(c2331.73,1841.73) 2316.36,1826.36 ; 2309,2114 2335,2114 ; 2315.37,2081.64 cw(c2330.73,2066.28) 2330.73,2088 cw(c2330.73,2109.73) 2315.37,2094.37 ; 2315.37,2107.64 cw(c2330.73,2092.27) 2330.73,2114 cw(c2330.73,2135.73) 2315.37,2120.36 ; 2316.1,1689.38 cw(c2330.84,1673.42) 2331.71,1695.13 cw(c2332.57,1716.84) 2316.61,1702.1 ; 2328.39,1688.89 ccw(c2312.42,1674.15) 2313.29,1695.86 ccw(c2314.15,1717.58) 2328.89,1701.61 ; 2328.64,1813.64 ccw(c2313.27,1798.27) 2313.27,1820 ccw(c2313.27,1841.73) 2328.64,1826.36 ; 2328.64,2081.64 ccw(c2313.27,2066.28) 2313.27,2088 ccw(c2313.27,2109.73) 2328.64,2094.37 ; 2328.64,2107.64 ccw(c2313.27,2092.27) 2313.27,2114 ccw(c2313.27,2135.73) 2328.64,2120.36 ; 2335,1695 2310,1696 2310,1671 2284,1671 ; 2335,1820 2310,1820 2310,1795 2310,1770 2284,1770 ; 2335,2088 2309,2088 2283.01,2088 2257.01,2088 2231.02,2088 2231.02,2114 ; 2351.64,1444.38 ccw(c2336.27,1459.74) 2358,1459.74 ccw(c2379.73,1459.74) 2364.37,1444.38 ccw(c2379.73,1459.74) 2379.73,1438.01 ccw(c2379.73,1416.28) 2364.37,1431.65 ; 2351.64,1457.64 cw(c2336.27,1442.28) 2358,1442.28 cw(c2379.73,1442.28) 2364.37,1457.64 cw(c2379.73,1442.28) 2379.73,1464.01 cw(c2379.73,1485.74) 2364.37,1470.37 cw(c2379.73,1485.74) 2358,1485.74 cw(c2336.27,1485.74) 2351.64,1470.37 ; 2351.64,1483.64 cw(c2336.27,1468.28) 2358,1468.28 cw(c2379.73,1468.28) 2364.36,1483.64 cw(c2379.73,1468.28) 2379.73,1490 cw(c2379.73,1511.73) 2364.36,1496.37 cw(c2379.73,1511.73) 2358,1511.73 cw(c2336.27,1511.73) 2351.64,1496.37 ; 2351.64,1509.64 cw(c2336.27,1494.27) 2358,1494.27 cw(c2379.73,1494.27) 2364.36,1509.64 cw(c2379.73,1494.27) 2379.73,1516 cw(c2379.73,1537.73) 2364.36,1522.36 cw(c2379.73,1537.73) 2358,1537.73 cw(c2336.27,1537.73) 2351.64,1522.36 ; 2351.64,1535.63 cw(c2336.27,1520.27) 2358,1520.27 cw(c2379.73,1520.27) 2364.36,1535.63 cw(c2379.73,1520.27) 2379.73,1542 cw(c2379.73,1563.72) 2364.36,1548.36 ; 2376.64,1431.65 ccw(c2361.27,1416.28) 2361.27,1438.01 ccw(c2361.27,1459.74) 2376.64,1444.38 ; 2376.64,1457.64 ccw(c2361.27,1442.28) 2361.27,1464.01 ccw(c2361.27,1485.74) 2376.64,1470.37 ; 2376.64,1483.64 ccw(c2361.27,1468.28) 2361.27,1490 ccw(c2361.27,1511.73) 2376.64,1496.37 ; 2376.64,1509.64 ccw(c2361.27,1494.27) 2361.27,1516 ccw(c2361.27,1537.73) 2376.64,1522.36 ; 2376.64,1535.63 ccw(c2361.27,1520.27) 2361.27,1542 ccw(c2361.27,1563.72) 2376.64,1548.36 ; 2389.37,1431.65 cw(c2404.73,1416.28) 2404.73,1438.01 cw(c2404.73,1459.74) 2389.37,1444.38 ; 2389.37,1457.64 cw(c2404.73,1442.28) 2404.73,1464.01 cw(c2404.73,1485.74) 2389.37,1470.37 ; 2389.36,1483.64 cw(c2404.73,1468.28) 2404.73,1490 cw(c2404.73,1511.73) 2389.36,1496.37 ; 2389.36,1509.64 cw(c2404.73,1494.27) 2404.73,1516 cw(c2404.73,1537.73) 2389.36,1522.36 ; 2389.36,1535.63 cw(c2404.73,1520.27) 2404.73,1542 cw(c2404.73,1563.72) 2389.36,1548.36 ; 2401.64,1431.65 ccw(c2386.27,1416.28) 2386.27,1438.01 ccw(c2386.27,1459.74) 2401.64,1444.38 ; 2401.64,1457.64 ccw(c2386.27,1442.28) 2386.27,1464.01 ccw(c2386.27,1485.74) 2401.64,1470.37 ; 2401.64,1483.64 ccw(c2386.27,1468.28) 2386.27,1490 ccw(c2386.27,1511.73) 2401.64,1496.37 ; 2401.64,1509.64 ccw(c2386.27,1494.27) 2386.27,1516 ccw(c2386.27,1537.73) 2401.64,1522.36 ; 2401.64,1535.63 ccw(c2386.27,1520.27) 2386.27,1542 ccw(c2386.27,1563.72) 2401.64,1548.36 ccw(c2386.27,1563.72) 2408,1563.72 ccw(c2429.73,1563.72) 2414.36,1548.36 ; 2401.63,1578.5 cw(c2386.27,1563.14) 2408,1563.14 cw(c2429.73,1563.14) 2414.36,1578.5 ; 2408,1584.87 2408,1542 2383,1542 2358,1542 2358,1516 ; 2408,1438.01 2383,1438.01 2358,1438.01 2358,1464.01 ; 2408,1464.01 2383,1464.01 2358,1464.01 ; 2408,1490 2383,1490 2358,1490 ; 2408,1516 2383,1516 2358,1516 ; 2820,1871.99 2845,1871.99 2870,1871.99 ; 2820,1897.99 2845,1897.99 ; 2826.36,1865.63 cw(c2841.73,1850.26) 2841.73,1871.99 cw(c2841.73,1893.72) 2826.36,1878.36 ; 2826.36,1891.62 cw(c2841.73,1876.26) 2841.73,1897.99 cw(c2841.73,1919.72) 2826.36,1904.35 ; 2838.63,1865.63 ccw(c2823.27,1850.26) 2823.27,1871.99 ccw(c2823.27,1893.72) 2838.63,1878.36 ; 2838.63,1891.62 ccw(c2823.27,1876.26) 2823.27,1897.99 ccw(c2823.27,1919.72) 2838.63,1904.35 ; 2851.36,1865.63 cw(c2866.73,1850.26) 2866.73,1871.99 cw(c2866.73,1893.72) 2851.36,1878.36 ; 2863.63,1865.63 ccw(c2848.27,1850.26) 2848.27,1871.99 ccw(c2848.27,1893.72) 2863.63,1878.36 ; 2967.99,1937 2993.99,1937 2993.99,1912 3019.98,1912 ; 2974.36,1930.64 cw(c2989.72,1915.27) 2989.72,1937 cw(c2989.72,1958.73) 2974.36,1943.37 ; 2987.62,1918.37 ccw(c2972.26,1933.73) 2993.99,1933.73 ccw(c3015.72,1933.73) 3000.35,1918.37 ccw(c3015.72,1933.73) 3015.72,1912 ccw(c3015.72,1890.28) 3000.35,1905.64 ; 2987.62,1943.37 cw(c2972.26,1958.73) 2972.26,1937 cw(c2972.26,1915.27) 2987.62,1930.64 cw(c2972.26,1915.27) 2993.99,1915.27 cw(c3015.72,1915.27) 3000.35,1930.64 ; 2996.64,1717.36 ccw(c2981.28,1732.73) 3003,1732.73 ccw(c3024.73,1732.73) 3009.37,1717.36 ccw(c3024.73,1732.73) 3024.73,1711 ccw(c3024.73,1689.27) 3009.37,1704.64 ; 2996.64,1729.64 cw(c2981.28,1714.27) 3003,1714.27 cw(c3024.73,1714.27) 3009.37,1729.64 ; 2996.64,1742.36 ccw(c2981.28,1757.73) 3003,1757.73 ccw(c3024.73,1757.73) 3009.37,1742.36 ; 2996.64,1754.64 cw(c2981.28,1739.27) 3003,1739.27 cw(c3024.73,1739.27) 3009.37,1754.64 ; 3003,1761 3003,1736 3003,1711 3029,1711 3029,1736 ; 3013.62,1893.37 ccw(c2998.26,1908.73) 3019.98,1908.73 ccw(c3041.71,1908.73) 3026.35,1893.37 ; 3013.62,1930.64 cw(c2998.26,1915.28) 3019.98,1915.28 cw(c3041.71,1915.28) 3026.35,1930.64 ; 3019.98,1887 3019.98,1912 ; 3019.98,1937 3019.98,1912 ; 3022.64,1704.64 ccw(c3007.27,1689.27) 3007.27,1711 ccw(c3007.27,1732.73) 3022.64,1717.36 ccw(c3007.27,1732.73) 3029,1732.73 ccw(c3050.73,1732.73) 3035.36,1717.36 ; 3022.64,1729.64 cw(c3007.27,1714.27) 3029,1714.27 cw(c3050.73,1714.27) 3035.36,1729.64 cw(c3050.73,1714.27) 3050.73,1736 cw(c3050.73,1757.73) 3035.36,1742.36 cw(c3050.73,1757.73) 3029,1757.73 cw(c3007.27,1757.73) 3022.64,1742.36 ; 3022.64,1754.64 cw(c3007.27,1739.27) 3029,1739.27 cw(c3050.73,1739.27) 3035.36,1754.64 ; 3029,1761 3029,1736 ; 3039.62,1893.37 ccw(c3024.25,1908.73) 3045.98,1908.73 ccw(c3067.71,1908.73) 3052.34,1893.37 ccw(c3067.71,1908.73) 3067.71,1887 ccw(c3067.71,1865.28) 3052.34,1880.64 ; 3039.62,1930.64 cw(c3024.25,1915.28) 3045.98,1915.28 cw(c3067.71,1915.28) 3052.34,1930.64 ; 3045.98,1937 3045.98,1912 ; 3048.63,1717.36 ccw(c3033.27,1732.73) 3055,1732.73 ccw(c3076.72,1732.73) 3061.36,1717.36 ; 3048.63,1754.64 cw(c3033.27,1739.27) 3055,1739.27 cw(c3076.72,1739.27) 3061.36,1754.64 ; 3052.34,1905.64 ccw(c3067.71,1890.28) 3045.98,1890.28 ccw(c3024.25,1890.28) 3039.62,1905.64 ccw(c3024.25,1890.28) 3024.25,1912 ccw(c3024.25,1933.73) 3039.62,1918.37 ccw(c3024.25,1933.73) 3045.98,1933.73 ccw(c3067.71,1933.73) 3052.34,1918.37 ; 3055,1711 3055,1736 ; 3055,1761 3055,1736 ; 3065.61,1880.64 ccw(c3050.25,1865.28) 3050.25,1887 ccw(c3050.25,1908.73) 3065.61,1893.37 ccw(c3050.25,1908.73) 3071.98,1908.73 ccw(c3093.7,1908.73) 3078.34,1893.37 ccw(c3093.7,1908.73) 3093.7,1887.01 ccw(c3093.7,1865.28) 3078.34,1880.64 ; 3065.61,1905.64 cw(c3050.25,1890.28) 3071.98,1890.28 cw(c3093.7,1890.28) 3078.34,1905.64 ; 3065.61,1918.37 ccw(c3050.25,1933.73) 3071.98,1933.73 ccw(c3093.7,1933.73) 3078.34,1918.37 ; 3065.61,1930.64 cw(c3050.25,1915.28) 3071.98,1915.28 cw(c3093.7,1915.28) 3078.34,1930.64 ; 3071.98,1937 3071.98,1912 3071.98,1887 ; 3074.63,1717.37 ccw(c3059.26,1732.73) 3080.99,1732.73 ccw(c3102.72,1732.73) 3087.36,1717.37 ccw(c3102.72,1732.73) 3102.72,1711 ccw(c3102.72,1689.27) 3087.36,1704.64 ; 3074.63,1754.64 cw(c3059.26,1739.27) 3080.99,1739.27 cw(c3102.72,1739.27) 3087.36,1754.64 ; 3080.99,1761 3080.99,1736 ; 3087.36,1729.64 ccw(c3102.72,1714.27) 3080.99,1714.27 ccw(c3059.26,1714.27) 3074.63,1729.64 ccw(c3059.26,1714.27) 3059.26,1736 ccw(c3059.26,1757.73) 3074.63,1742.37 ccw(c3059.26,1757.73) 3080.99,1757.73 ccw(c3102.72,1757.73) 3087.36,1742.37 ; 3091.61,1880.64 ccw(c3076.24,1865.28) 3076.24,1887 ccw(c3076.24,1908.73) 3091.61,1893.37 ccw(c3076.24,1908.73) 3097.97,1908.73 ccw(c3119.7,1908.73) 3104.34,1893.37 ; 3091.61,1905.64 cw(c3076.24,1890.28) 3097.97,1890.28 cw(c3119.7,1890.28) 3104.34,1905.64 ; 3091.61,1918.37 ccw(c3076.24,1933.73) 3097.97,1933.73 ccw(c3119.7,1933.73) 3104.34,1918.37 ; 3091.61,1930.64 cw(c3076.24,1915.28) 3097.97,1915.28 cw(c3119.7,1915.28) 3104.34,1930.64 ; 3097.97,1937.01 3097.97,1912.01 3097.97,1887.01 3071.98,1887 ; 3100.62,1704.64 ccw(c3085.26,1689.27) 3085.26,1711 ccw(c3085.26,1732.73) 3100.62,1717.37 ccw(c3085.26,1732.73) 3106.99,1732.73 ccw(c3128.72,1732.73) 3113.35,1717.37 ; 3100.62,1729.64 cw(c3085.26,1714.27) 3106.99,1714.27 cw(c3128.72,1714.27) 3113.35,1729.64 ; 3100.62,1742.37 ccw(c3085.26,1757.73) 3106.99,1757.73 ccw(c3128.72,1757.73) 3113.35,1742.37 ; 3100.62,1754.64 cw(c3085.26,1739.27) 3106.99,1739.27 cw(c3128.72,1739.27) 3113.35,1754.64 ; 3106.99,1761 3106.99,1736 3106.99,1711 3080.99,1711 3080.99,1736 ; 2131.99,2115 2131.99,2140 ; 2131.99,2115 2156.99,2115 2181.99,2115 2231.02,2114 ; 2232.01,1670.99 2258.01,1670.99 ; 2232.01,1770 2258.01,1770 ; 2258.01,1670.99 2284,1671 ; 2258.01,1770 2284,1770 ; 2358,1464.01 2358,1490 ; 2358,1490 2358,1516 ; 3019.98,1912 3045.98,1912 ; 3029,1736 3055,1736 ; 3045.98,1912 3045.98,1887 3071.98,1887 ; 3055,1736 3080.99,1736 ; 2998.26,1912 cw(c2998.26,1890.27) 3013.62,1905.64 cw(c2998.26,1890.28) 3019.98,1890.28 cw(c3041.71,1890.28) 3026.35,1905.64 cw(c3041.71,1890.28) 3041.71,1912 cw(c3041.71,1933.73) 3026.35,1918.37 cw(c3041.71,1933.73) 3019.98,1933.73 cw(c2998.26,1933.73) 3013.62,1918.37 cw(c2998.26,1933.73) 2998.26,1912 ; 3033.27,1736 cw(c3033.27,1714.27) 3048.63,1729.64 cw(c3033.27,1714.27) 3055,1714.27 cw(c3076.72,1714.27) 3061.36,1729.64 cw(c3076.72,1714.27) 3076.72,1736 cw(c3076.72,1757.73) 3061.36,1742.36 cw(c3076.72,1757.73) 3055,1757.73 cw(c3033.27,1757.73) 3048.63,1742.36 cw(c3033.27,1757.73) 3033.27,1736
  lines w5 net 2V5: 1099.65,1706.36 ccw(c1084.29,1721.72) 1106.02,1721.72 ccw(c1127.74,1721.72) 1112.38,1706.36 ccw(c1127.74,1721.73) 1127.74,1700 ccw(c1127.74,1678.27) 1112.38,1693.63 ; 1099.65,1718.63 cw(c1084.29,1703.27) 1106.02,1703.27 cw(c1127.74,1703.27) 1112.38,1718.63 ; 1099.65,1731.36 ccw(c1084.29,1746.72) 1106.02,1746.72 ccw(c1127.74,1746.72) 1112.38,1731.36 ; 1099.65,1743.63 cw(c1084.29,1728.27) 1106.02,1728.27 cw(c1127.74,1728.27) 1112.38,1743.63 ; 1099.65,1756.36 ccw(c1084.29,1771.72) 1106.02,1771.72 ccw(c1127.74,1771.72) 1112.38,1756.36 ; 1099.65,1768.63 cw(c1084.29,1753.27) 1106.02,1753.27 cw(c1127.74,1753.27) 1112.38,1768.63 ; 1106.02,1775 1106.02,1750 1106.02,1725 1106.02,1700 1132.01,1700 ; 1125.65,1693.63 ccw(c1110.28,1678.27) 1110.28,1700 ccw(c1110.28,1721.72) 1125.65,1706.36 ccw(c1110.28,1721.73) 1132.01,1721.73 ccw(c1153.74,1721.73) 1138.38,1706.36 ccw(c1153.74,1721.73) 1153.74,1700 ccw(c1153.74,1678.27) 1138.38,1693.63 ; 1125.65,1718.63 cw(c1110.28,1703.27) 1132.01,1703.27 cw(c1153.74,1703.27) 1138.38,1718.63 ; 1125.65,1731.36 ccw(c1110.28,1746.73) 1132.01,1746.73 ccw(c1153.74,1746.73) 1138.38,1731.36 ; 1125.65,1743.63 cw(c1110.28,1728.27) 1132.01,1728.27 cw(c1153.74,1728.27) 1138.38,1743.63 ; 1125.65,1756.36 ccw(c1110.28,1771.73) 1132.01,1771.73 ccw(c1153.74,1771.73) 1138.38,1756.36 ; 1125.65,1768.63 cw(c1110.28,1753.27) 1132.01,1753.27 cw(c1153.74,1753.27) 1138.38,1768.63 ; 1132.01,1775 1132.01,1750 1132.01,1725 1132.01,1700 ; 1151.64,1693.63 ccw(c1136.28,1678.27) 1136.28,1700 ccw(c1136.28,1721.73) 1151.64,1706.36 ccw(c1136.28,1721.73) 1158.01,1721.73 ccw(c1179.74,1721.73) 1164.37,1706.36 ccw(c1179.74,1721.73) 1179.74,1700 ccw(c1179.74,1678.27) 1164.37,1693.63 ; 1151.64,1718.63 cw(c1136.28,1703.27) 1158.01,1703.27 cw(c1179.74,1703.27) 1164.37,1718.63 ; 1151.64,1731.36 ccw(c1136.28,1746.73) 1158.01,1746.73 ccw(c1179.74,1746.73) 1164.37,1731.36 ; 1151.64,1743.63 cw(c1136.28,1728.27) 1158.01,1728.27 cw(c1179.74,1728.27) 1164.37,1743.63 ; 1151.64,1756.36 ccw(c1136.28,1771.73) 1158.01,1771.73 ccw(c1179.74,1771.73) 1164.37,1756.36 ; 1151.64,1768.63 cw(c1136.28,1753.27) 1158.01,1753.27 cw(c1179.74,1753.27) 1164.37,1768.63 ; 1158.01,1775 1158.01,1750 1158.01,1725 1158.01,1700 ; 1177.64,1693.64 ccw(c1162.28,1678.27) 1162.28,1700 ccw(c1162.28,1721.73) 1177.64,1706.36 ccw(c1162.28,1721.73) 1184,1721.73 ccw(c1205.73,1721.73) 1190.37,1706.36 ccw(c1205.73,1721.73) 1205.73,1700 ccw(c1205.73,1678.27) 1190.37,1693.64 ; 1177.64,1718.64 cw(c1162.28,1703.27) 1184,1703.27 cw(c1205.73,1703.27) 1190.37,1718.64 ; 1177.64,1731.36 ccw(c1162.28,1746.73) 1184,1746.73 ccw(c1205.73,1746.73) 1190.37,1731.36 ; 1177.64,1743.64 cw(c1162.28,1728.27) 1184,1728.27 cw(c1205.73,1728.27) 1190.37,1743.64 ; 1177.64,1756.36 ccw(c1162.28,1771.73) 1184,1771.73 ccw(c1205.73,1771.73) 1190.37,1756.36 ; 1177.64,1768.64 cw(c1162.28,1753.27) 1184,1753.27 cw(c1205.73,1753.27) 1190.37,1768.64 ; 1184,1775 1184,1750 1184,1725 1184,1700 ; 1203.64,1693.64 ccw(c1188.27,1678.27) 1188.27,1700 ccw(c1188.27,1721.73) 1203.64,1706.36 ccw(c1188.27,1721.73) 1210,1721.73 ccw(c1231.73,1721.73) 1216.36,1706.36 ; 1203.64,1718.64 cw(c1188.27,1703.27) 1210,1703.27 cw(c1231.73,1703.27) 1216.36,1718.64 ; 1203.64,1731.36 ccw(c1188.27,1746.73) 1210,1746.73 ccw(c1231.73,1746.73) 1216.36,1731.36 ; 1203.64,1743.64 cw(c1188.27,1728.27) 1210,1728.27 cw(c1231.73,1728.27) 1216.36,1743.64 ; 1203.64,1756.36 ccw(c1188.27,1771.73) 1210,1771.73 ccw(c1231.73,1771.73) 1216.36,1756.36 ; 1203.64,1768.64 cw(c1188.27,1753.27) 1210,1753.27 cw(c1231.73,1753.27) 1216.36,1768.64 ; 1214.83,1767.4 cw(c1226.49,1749.07) 1231.21,1770.28 cw(c1235.93,1791.49) 1217.6,1779.83 ; 1247.4,1760.15 ccw(c1229.06,1748.49) 1233.79,1769.7 ccw(c1238.51,1790.91) 1250.17,1772.58 ; 1255,1764.98 1210,1775 1210,1750 1210,1725 1210,1700 1184,1700 ; 1266.64,1444.38 ccw(c1251.27,1459.74) 1273,1459.74 ccw(c1294.73,1459.74) 1279.37,1444.38 ccw(c1294.73,1459.74) 1294.73,1438.01 ccw(c1294.73,1416.28) 1279.37,1431.65 ; 1266.64,1457.64 cw(c1251.27,1442.28) 1273,1442.28 cw(c1294.73,1442.28) 1279.37,1457.64 cw(c1294.73,1442.28) 1294.73,1464.01 cw(c1294.73,1485.74) 1279.37,1470.37 cw(c1294.73,1485.74) 1273,1485.74 cw(c1251.27,1485.74) 1266.64,1470.37 ; 1266.64,1483.64 cw(c1251.27,1468.28) 1273,1468.28 cw(c1294.73,1468.28) 1279.36,1483.64 cw(c1294.73,1468.28) 1294.73,1490 cw(c1294.73,1511.73) 1279.36,1496.37 cw(c1294.73,1511.73) 1273,1511.73 cw(c1251.27,1511.73) 1266.64,1496.37 ; 1266.64,1509.64 cw(c1251.27,1494.27) 1273,1494.27 cw(c1294.73,1494.27) 1279.36,1509.64 cw(c1294.73,1494.27) 1294.73,1516 cw(c1294.73,1537.73) 1279.36,1522.36 cw(c1294.73,1537.73) 1273,1537.73 cw(c1251.27,1537.73) 1266.64,1522.36 ; 1266.64,1535.63 cw(c1251.27,1520.27) 1273,1520.27 cw(c1294.73,1520.27) 1279.36,1535.63 cw(c1294.73,1520.27) 1294.73,1542 cw(c1294.73,1563.72) 1279.36,1548.36 ; 1291.64,1431.65 ccw(c1276.27,1416.28) 1276.27,1438.01 ccw(c1276.27,1459.74) 1291.64,1444.38 ; 1291.64,1457.64 ccw(c1276.27,1442.28) 1276.27,1464.01 ccw(c1276.27,1485.74) 1291.64,1470.37 ; 1291.64,1483.64 ccw(c1276.27,1468.28) 1276.27,1490 ccw(c1276.27,1511.73) 1291.64,1496.37 ; 1291.64,1509.64 ccw(c1276.27,1494.27) 1276.27,1516 ccw(c1276.27,1537.73) 1291.64,1522.36 ; 1291.64,1535.63 ccw(c1276.27,1520.27) 1276.27,1542 ccw(c1276.27,1563.72) 1291.64,1548.36 ; 1304.37,1431.65 cw(c1319.73,1416.28) 1319.73,1438.01 cw(c1319.73,1459.74) 1304.37,1444.38 ; 1304.37,1457.64 cw(c1319.73,1442.28) 1319.73,1464.01 cw(c1319.73,1485.74) 1304.37,1470.37 ; 1304.36,1483.64 cw(c1319.73,1468.28) 1319.73,1490 cw(c1319.73,1511.73) 1304.36,1496.37 ; 1304.36,1509.64 cw(c1319.73,1494.27) 1319.73,1516 cw(c1319.73,1537.73) 1304.36,1522.36 ; 1304.36,1535.63 cw(c1319.73,1520.27) 1319.73,1542 cw(c1319.73,1563.72) 1304.36,1548.36 ; 1316.64,1431.65 ccw(c1301.27,1416.28) 1301.27,1438.01 ccw(c1301.27,1459.74) 1316.64,1444.38 ; 1316.64,1457.64 ccw(c1301.27,1442.28) 1301.27,1464.01 ccw(c1301.27,1485.74) 1316.64,1470.37 ; 1316.64,1483.64 ccw(c1301.27,1468.28) 1301.27,1490 ccw(c1301.27,1511.73) 1316.64,1496.37 ; 1316.64,1509.64 ccw(c1301.27,1494.27) 1301.27,1516 ccw(c1301.27,1537.73) 1316.64,1522.36 ; 1316.64,1535.63 ccw(c1301.27,1520.27) 1301.27,1542 ccw(c1301.27,1563.72) 1316.64,1548.36 ccw(c1301.27,1563.72) 1323,1563.72 ccw(c1344.72,1563.73) 1329.36,1548.36 ; 1316.63,1578.63 cw(c1301.27,1563.27) 1323,1563.27 cw(c1344.72,1563.27) 1329.36,1578.64 ; 1322.99,1585 1323,1542 1298,1542 1273,1542 1273,1516 ; 1323,1438.01 1298,1438.01 1273,1438.01 1273,1464.01 ; 1323,1464.01 1298,1464.01 1273,1464.01 ; 1323,1490 1298,1490 1273,1490 ; 1323,1516 1298,1516 1273,1516 ; 1734.99,1978.96 1760,1980 1760,1954 1760,1928.01 ; 1741.09,1985.59 ccw(c1755.8,2001.57) 1756.7,1979.86 ccw(c1757.6,1958.15) 1741.61,1972.87 ; 1753.38,1986.1 cw(c1737.39,2000.81) 1738.29,1979.1 cw(c1739.19,1957.39) 1753.9,1973.38 ; 1753.65,1614.41 ccw(c1738.28,1629.78) 1760.01,1629.78 ccw(c1781.74,1629.78) 1766.37,1614.41 ; 1753.65,1627.68 cw(c1738.28,1612.32) 1760.01,1612.32 cw(c1781.74,1612.32) 1766.37,1627.68 ; 1753.64,1934.37 ccw(c1738.27,1949.74) 1760,1949.74 ccw(c1781.73,1949.74) 1766.37,1934.37 ; 1753.64,1947.64 cw(c1738.27,1932.28) 1760,1932.28 cw(c1781.73,1932.28) 1766.36,1947.64 ; 1753.64,1960.37 ccw(c1738.27,1975.73) 1760,1975.73 ccw(c1781.73,1975.73) 1766.36,1960.37 ; 1753.64,1973.64 cw(c1738.27,1958.27) 1760,1958.27 cw(c1781.73,1958.27) 1766.36,1973.64 ; 1760.01,1608.05 1760.01,1634.04 ; 1796.64,2203.36 ccw(c1781.28,2218.73) 1803,2218.73 ccw(c1824.73,2218.73) 1809.37,2203.36 ; 1796.64,2215.64 cw(c1781.28,2200.27) 1803,2200.27 cw(c1824.73,2200.27) 1809.37,2215.64 cw(c1824.73,2200.27) 1824.73,2222 cw(c1824.73,2243.73) 1809.37,2228.36 cw(c1824.73,2243.73) 1803,2243.73 cw(c1781.28,2243.73) 1796.64,2228.36 ; 1796.64,2240.64 cw(c1781.28,2225.27) 1803,2225.27 cw(c1824.73,2225.27) 1809.37,2240.64 ; 1803,2197 1803,2222 ; 1803,2247 1803,2222 ; 1822.64,2178.36 ccw(c1807.27,2193.73) 1829,2193.73 ccw(c1850.73,2193.73) 1835.36,2178.36 ccw(c1850.73,2193.73) 1850.73,2172 ccw(c1850.73,2150.27) 1835.36,2165.64 ; 1822.64,2190.64 cw(c1807.27,2175.27) 1829,2175.27 cw(c1850.73,2175.27) 1835.36,2190.64 ; 1822.64,2203.36 ccw(c1807.27,2218.73) 1829,2218.73 ccw(c1850.73,2218.73) 1835.36,2203.36 ; 1822.64,2240.64 cw(c1807.27,2225.27) 1829,2225.27 cw(c1850.73,2225.27) 1835.36,2240.64 ; 1829,2247 1829,2222 ; 1835.36,2215.64 ccw(c1850.73,2200.27) 1829,2200.27 ccw(c1807.27,2200.27) 1822.64,2215.64 ccw(c1807.27,2200.27) 1807.27,2222 ccw(c1807.27,2243.73) 1822.64,2228.36 ccw(c1807.27,2243.73) 1829,2243.73 ccw(c1850.73,2243.73) 1835.36,2228.36 ; 1848.63,2165.64 ccw(c1833.27,2150.27) 1833.27,2172 ccw(c1833.27,2193.73) 1848.63,2178.36 ccw(c1833.27,2193.73) 1855,2193.73 ccw(c1876.72,2193.73) 1861.36,2178.36 ccw(c1876.72,2193.73) 1876.72,2172 ccw(c1876.72,2150.27) 1861.36,2165.64 ; 1848.63,2190.64 cw(c1833.27,2175.27) 1855,2175.27 cw(c1876.72,2175.27) 1861.36,2190.64 ; 1848.63,2203.36 ccw(c1833.27,2218.73) 1855,2218.73 ccw(c1876.72,2218.73) 1861.36,2203.36 ; 1848.63,2215.64 cw(c1833.27,2200.27) 1855,2200.27 cw(c1876.72,2200.27) 1861.36,2215.64 ; 1848.63,2228.36 ccw(c1833.27,2243.73) 1855,2243.73 ccw(c1876.72,2243.73) 1861.36,2228.36 ; 1848.63,2240.64 cw(c1833.27,2225.27) 1855,2225.27 cw(c1876.72,2225.27) 1861.36,2240.64 ; 1855,2247 1855,2222 1855,2197 1855,2172 ; 1874.63,2165.64 ccw(c1859.26,2150.27) 1859.26,2172 ccw(c1859.26,2193.73) 1874.63,2178.37 ccw(c1859.26,2193.73) 1880.99,2193.73 ccw(c1902.72,2193.73) 1887.36,2178.37 ccw(c1902.72,2193.73) 1902.72,2172 ccw(c1902.72,2150.27) 1887.36,2165.64 ; 1874.63,2190.64 cw(c1859.26,2175.27) 1880.99,2175.27 cw(c1902.72,2175.27) 1887.36,2190.64 ; 1874.63,2203.37 ccw(c1859.26,2218.73) 1880.99,2218.73 ccw(c1902.72,2218.73) 1887.36,2203.37 ; 1874.63,2215.64 cw(c1859.26,2200.27) 1880.99,2200.27 cw(c1902.72,2200.27) 1887.36,2215.64 ; 1874.63,2228.37 ccw(c1859.26,2243.73) 1880.99,2243.73 ccw(c1902.72,2243.73) 1887.36,2228.37 ; 1874.63,2240.64 cw(c1859.26,2225.27) 1880.99,2225.27 cw(c1902.72,2225.27) 1887.36,2240.64 ; 1880.99,2247 1880.99,2222 1880.99,2197 1880.99,2172 ; 1900.62,2165.64 ccw(c1885.26,2150.27) 1885.26,2172 ccw(c1885.26,2193.73) 1900.62,2178.37 ccw(c1885.26,2193.73) 1906.99,2193.73 ccw(c1928.72,2193.73) 1913.35,2178.37 ; 1900.62,2190.64 cw(c1885.26,2175.27) 1906.99,2175.27 cw(c1928.72,2175.27) 1913.35,2190.64 ; 1900.62,2203.37 ccw(c1885.26,2218.73) 1906.99,2218.73 ccw(c1928.72,2218.73) 1913.35,2203.37 ; 1900.62,2215.64 cw(c1885.26,2200.27) 1906.99,2200.27 cw(c1928.72,2200.27) 1913.35,2215.64 ; 1900.62,2228.37 ccw(c1885.26,2243.73) 1906.99,2243.73 ccw(c1928.72,2243.73) 1913.35,2228.37 ; 1900.62,2240.64 cw(c1885.26,2225.27) 1906.99,2225.27 cw(c1928.72,2225.27) 1913.35,2240.64 ; 1906.99,2247 1906.99,2222 1906.99,2197 1906.99,2172 1880.99,2172 ; 1916.64,1674.38 ccw(c1901.27,1689.74) 1923,1689.74 ccw(c1944.73,1689.74) 1929.37,1674.38 ccw(c1944.73,1689.74) 1944.73,1668.01 ccw(c1944.73,1646.28) 1929.37,1661.65 ; 1916.64,1687.64 cw(c1901.27,1672.28) 1923,1672.28 cw(c1944.73,1672.28) 1929.37,1687.64 cw(c1944.73,1672.28) 1944.73,1694.01 cw(c1944.73,1715.74) 1929.37,1700.37 cw(c1944.73,1715.74) 1923,1715.74 cw(c1901.27,1715.74) 1916.64,1700.37 ; 1916.64,1713.64 cw(c1901.27,1698.28) 1923,1698.28 cw(c1944.73,1698.28) 1929.36,1713.64 cw(c1944.73,1698.28) 1944.73,1720 cw(c1944.73,1741.73) 1929.36,1726.37 cw(c1944.73,1741.73) 1923,1741.73 cw(c1901.27,1741.73) 1916.64,1726.37 ; 1916.64,1739.64 cw(c1901.27,1724.27) 1923,1724.27 cw(c1944.73,1724.27) 1929.36,1739.64 cw(c1944.73,1724.27) 1944.73,1746 cw(c1944.73,1767.73) 1929.36,1752.36 cw(c1944.73,1767.73) 1923,1767.73 cw(c1901.27,1767.73) 1916.64,1752.36 ; 1916.64,1765.63 cw(c1901.27,1750.27) 1923,1750.27 cw(c1944.73,1750.27) 1929.36,1765.63 cw(c1944.73,1750.27) 1944.73,1772 cw(c1944.73,1793.72) 1929.36,1778.36 ; 1941.64,1661.65 ccw(c1926.27,1646.28) 1926.27,1668.01 ccw(c1926.27,1689.74) 1941.64,1674.38 ; 1941.64,1687.64 ccw(c1926.27,1672.28) 1926.27,1694.01 ccw(c1926.27,1715.74) 1941.64,1700.37 ; 1941.64,1713.64 ccw(c1926.27,1698.28) 1926.27,1720 ccw(c1926.27,1741.73) 1941.64,1726.37 ; 1941.64,1739.64 ccw(c1926.27,1724.27) 1926.27,1746 ccw(c1926.27,1767.73) 1941.64,1752.36 ; 1941.64,1765.63 ccw(c1926.27,1750.27) 1926.27,1772 ccw(c1926.27,1793.72) 1941.64,1778.36 ; 1954.37,1661.65 cw(c1969.73,1646.28) 1969.73,1668.01 cw(c1969.73,1689.74) 1954.37,1674.38 ; 1954.37,1687.64 cw(c1969.73,1672.28) 1969.73,1694.01 cw(c1969.73,1715.74) 1954.37,1700.37 ; 1954.36,1713.64 cw(c1969.73,1698.28) 1969.73,1720 cw(c1969.73,1741.73) 1954.36,1726.37 ; 1954.36,1739.64 cw(c1969.73,1724.27) 1969.73,1746 cw(c1969.73,1767.73) 1954.36,1752.36 ; 1954.36,1765.63 cw(c1969.73,1750.27) 1969.73,1772 cw(c1969.73,1793.72) 1954.36,1778.36 ; 1966.64,1661.65 ccw(c1951.27,1646.28) 1951.27,1668.01 ccw(c1951.27,1689.74) 1966.64,1674.38 ; 1966.64,1687.64 ccw(c1951.27,1672.28) 1951.27,1694.01 ccw(c1951.27,1715.74) 1966.64,1700.37 ; 1966.64,1713.64 ccw(c1951.27,1698.28) 1951.27,1720 ccw(c1951.27,1741.73) 1966.64,1726.37 ; 1966.64,1739.64 ccw(c1951.27,1724.27) 1951.27,1746 ccw(c1951.27,1767.73) 1966.64,1752.36 ; 1966.64,1765.63 ccw(c1951.27,1750.27) 1951.27,1772 ccw(c1951.27,1793.72) 1966.64,1778.36 ; 1979.37,1661.65 cw(c1994.73,1646.28) 1994.73,1668.01 cw(c1994.73,1689.74) 1979.37,1674.38 ; 1979.37,1687.64 cw(c1994.73,1672.28) 1994.73,1694.01 cw(c1994.73,1715.74) 1979.37,1700.37 ; 1979.36,1713.64 cw(c1994.73,1698.28) 1994.73,1720 cw(c1994.73,1741.73) 1979.36,1726.37 ; 1979.36,1739.64 cw(c1994.73,1724.27) 1994.73,1746 cw(c1994.73,1767.73) 1979.36,1752.36 ; 1979.36,1765.63 cw(c1994.73,1750.27) 1994.73,1772 cw(c1994.73,1793.72) 1979.36,1778.36 ; 1991.64,1661.65 ccw(c1976.27,1646.28) 1976.27,1668.01 ccw(c1976.27,1689.74) 1991.64,1674.38 ; 1991.64,1687.64 ccw(c1976.27,1672.28) 1976.27,1694.01 ccw(c1976.27,1715.74) 1991.64,1700.37 ; 1991.64,1713.64 ccw(c1976.27,1698.28) 1976.27,1720 ccw(c1976.27,1741.73) 1991.64,1726.37 ; 1991.64,1739.64 ccw(c1976.27,1724.27) 1976.27,1746 ccw(c1976.27,1767.73) 1991.64,1752.36 ; 1991.64,1765.63 ccw(c1976.27,1750.27) 1976.27,1772 ccw(c1976.27,1793.72) 1991.64,1778.36 ; 1998,1772 1973,1772 1948,1772 1923,1772 1923,1746 ; 2004.37,1661.65 cw(c2019.73,1646.28) 2019.73,1668.01 cw(c2019.73,1689.74) 2004.37,1674.38 ; 2004.37,1687.64 cw(c2019.73,1672.28) 2019.73,1694.01 cw(c2019.73,1715.74) 2004.37,1700.37 ; 2004.36,1713.64 cw(c2019.73,1698.28) 2019.73,1720 cw(c2019.73,1741.73) 2004.36,1726.37 ; 2004.36,1739.64 cw(c2019.73,1724.27) 2019.73,1746 cw(c2019.73,1767.73) 2004.36,1752.36 ; 2016.64,1661.65 ccw(c2001.27,1646.28) 2001.27,1668.01 ccw(c2001.27,1689.74) 2016.64,1674.38 ; 2016.64,1687.64 ccw(c2001.27,1672.28) 2001.27,1694.01 ccw(c2001.27,1715.74) 2016.64,1700.37 ; 2016.64,1713.64 ccw(c2001.27,1698.28) 2001.27,1720 ccw(c2001.27,1741.73) 2016.64,1726.37 ; 2016.64,1739.64 ccw(c2001.27,1724.27) 2001.27,1746 ccw(c2001.27,1767.73) 2016.64,1752.36 ; 2023,1668.01 1998,1668.01 1973,1668.01 1948,1668.01 1923,1668.01 1923,1694.01 ; 2023,1694.01 1998,1694.01 1973,1694.01 1948,1694.01 1923,1694.01 ; 2023,1720 1998,1720 1973,1720 1948,1720 1923,1720 ; 2023,1746 1998,1746 1973,1746 1948,1746 1923,1746 ; 1132.01,1700 1158.01,1700 ; 1158.01,1700 1184,1700 ; 1273,1464.01 1273,1490 ; 1273,1490 1273,1516 ; 1803,2222 1829,2222 ; 1829,2222 1829,2197 1829,2172 1855,2172 ; 1855,2172 1880.99,2172 ; 1923,1694.01 1923,1720 ; 1923,1720 1923,1746
  lines w15 net SHIELD: -923.8,4404.41 -923.8,5803 -923.31,5807.38 -921.85,5811.54 -919.5,5815.27 -916.39,5818.39 -912.66,5820.74 -908.49,5822.19 -904.11,5822.69 -612.78,5822.69 -608.4,5823.18 -604.24,5824.64 -600.5,5826.98 -597.39,5830.1 -595.04,5833.83 -593.59,5837.99 -593.09,5842.37 -593.09,5899.47 -593.59,5903.85 -595.04,5908.01 -597.39,5911.74 -600.5,5914.86 -604.24,5917.2 -608.4,5918.66 -612.78,5919.15 -854.9,5919.15 -859.28,5919.65 -863.44,5921.1 -867.17,5923.45 -870.29,5926.57 -872.64,5930.3 -874.09,5934.46 -874.59,5938.84 -874.59,6185.98 -430.77,6185.98 -388.41,6188.06 -346.46,6194.28 -305.32,6204.59 -265.39,6218.88 -227.05,6237.01 -190.67,6258.82 -156.61,6284.09 -125.18,6312.57 -96.7,6344 -71.43,6378.07 -49.63,6414.45 -31.5,6452.79 -17.21,6492.73 -6.91,6533.87 -0.68,6575.83 1.4,6618.2 1.4,6835.47 99.82,6835.47 108.58,6836.46 116.9,6839.37 124.37,6844.06 130.6,6850.3 135.29,6857.76 138.21,6866.09 139.19,6874.85 139.19,6914.22 7540.77,6914.22 7540.77,6874.85 7541.76,6866.09 7544.67,6857.77 7549.36,6850.3 7555.59,6844.07 7563.05,6839.37 7571.38,6836.46 7580.14,6835.48 7678.56,6835.48 7678.56,6618.2 7680.65,6575.83 7686.87,6533.88 7697.17,6492.73 7711.46,6452.79 7729.59,6414.45 7751.4,6378.07 7776.66,6344 7805.14,6312.57 7836.57,6284.09 7870.63,6258.82 7907.01,6237.01 7945.35,6218.88 7985.28,6204.59 8026.42,6194.28 8068.37,6188.06 8110.73,6185.98 8554.55,6185.98 8554.55,5938.84 8554.05,5934.46 8552.6,5930.3 8550.25,5926.57 8547.13,5923.45 8543.4,5921.1 8539.24,5919.65 8534.86,5919.16 8292.74,5919.16 8288.36,5918.66 8284.2,5917.2 8280.47,5914.86 8277.35,5911.74 8275,5908.01 8273.55,5903.85 8273.05,5899.47 8273.05,5842.37 8273.55,5837.99 8275,5833.83 8277.35,5830.1 8280.47,5826.98 8284.2,5824.64 8288.36,5823.18 8292.74,5822.69 8584.08,5822.69 8588.46,5822.19 8592.62,5820.74 8596.35,5818.39 8599.46,5815.28 8601.81,5811.54 8603.27,5807.38 8603.76,5803 8603.76,4404.41 8603.27,4400.03 8601.81,4395.87 8599.46,4392.13 8596.35,4389.02 8592.62,4386.67 8588.46,4385.21 8584.08,4384.72 8292.74,4384.72 8288.36,4384.23 8284.2,4382.77 8280.47,4380.43 8277.35,4377.31 8275,4373.58 8273.55,4369.41 8273.05,4365.03 8273.05,4307.94 8273.55,4303.56 8275,4299.4 8277.35,4295.67 8280.47,4292.55 8284.2,4290.2 8288.36,4288.75 8292.74,4288.25 8584.08,4288.25 8588.46,4287.76 8592.62,4286.3 8596.35,4283.96 8599.46,4280.84 8601.81,4277.11 8603.27,4272.95 8603.76,4268.57 8603.76,3870.29 8603.27,3865.91 8601.81,3861.75 8599.46,3858.02 8596.35,3854.9 8592.62,3852.55 8588.46,3851.1 8584.08,3850.6 8296.67,3850.6 8288.9,3849.79 8281.46,3847.37 8274.69,3843.46 8268.88,3838.23 8264.28,3831.9 8261.1,3824.76 8259.48,3817.11 8259.48,3809.29 8261.1,3801.64 8264.28,3794.49 8268.88,3788.17 8274.69,3782.93 8281.46,3779.03 8288.9,3776.61 8296.67,3775.79 8584.08,3775.79 8588.46,3775.3 8592.62,3773.84 8596.35,3771.5 8599.46,3768.38 8601.81,3764.64 8603.27,3760.48 8603.76,3756.1 8603.76,2295.89 8603.27,2291.51 8601.81,2287.35 8599.46,2283.62 8596.35,2280.5 8592.62,2278.15 8588.46,2276.7 8584.08,2276.2 8292.74,2276.2 8288.36,2275.71 8284.2,2274.25 8280.47,2271.91 8277.35,2268.79 8275,2265.06 8273.55,2260.9 8273.05,2256.52 8273.05,2199.42 8273.55,2195.04 8275,2190.88 8277.35,2187.15 8280.47,2184.03 8284.2,2181.68 8288.36,2180.23 8292.74,2179.74 8534.86,2179.74 8539.24,2179.24 8543.4,2177.79 8547.13,2175.44 8550.25,2172.32 8552.6,2168.59 8554.05,2164.43 8554.55,2160.05 8554.55,1441.32 8111.63,1441.32 8069.19,1439.23 8027.15,1433 7985.92,1422.67 7945.91,1408.35 7907.49,1390.18 7871.03,1368.33 7836.9,1343.01 7805.41,1314.46 7776.87,1282.97 7751.55,1248.83 7729.7,1212.37 7711.53,1173.95 7697.21,1133.93 7686.89,1092.7 7680.65,1050.65 7678.56,1008.2 7678.56,63.2 7580.14,63.2 7571.38,62.22 7563.06,59.31 7555.59,54.61 7549.36,48.38 7544.67,40.91 7541.76,32.59 7540.77,23.83 7540.77,-15.55 139.19,-15.55 139.19,23.83 138.21,32.59 135.29,40.91 130.6,48.38 124.37,54.61 116.9,59.3 108.58,62.22 99.82,63.2 1.4,63.2 1.4,1008.2 -0.69,1050.65 -6.92,1092.7 -17.25,1133.93 -31.57,1173.95 -49.74,1212.37 -71.59,1248.83 -96.9,1282.97 -125.45,1314.46 -156.94,1343.01 -191.07,1368.33 -227.52,1390.18 -265.94,1408.35 -305.96,1422.67 -347.19,1433 -389.22,1439.23 -431.67,1441.32 -874.59,1441.32 -874.59,2160.05 -874.09,2164.43

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  drawing of 4403 lines, arcs and shapes, not listed
  text "RS232" at 604.45,6800 h90
  text "RS485" at 1610,6800 h90
  text "ETHERNET" at 2067.99,6800 h90
  text "SVGA VIDEO" at 5516.2,6800 h90
  text "HOST USB" at 6393.5,6800 h90
  text "5VDC" at 6937.6,6800 h90
  text "POWER" at 7217.89,6800 h90
  text "EIA-574" at 641.44,6725 h50
  text "10Mbps/FULL DUPLEX" at 1480,6725 h50
  text "10/100Mbps" at 2157.21,6725 h50
  text "24BIT/80MHZ" at 5623.41,6725 h50
  text "UNIVERSAL SERIAL BUS" at 6327.56,6725 h50
  text "6A MAX" at 6954.67,6725 h50
  text "ON/OFF" at 7282.58,6725 h50
  text "MIDI IN" at 2917.86,6640.83 h90
  text "MIDI THRU" at 3673.03,6640.83 h90
  text "MIDI OUT" at 4524.27,6640.83 h90
  text "MUSICAL INSTRUMENT" at 2792.21,6565.83 h50
  text "MUSICAL INSTRUMENT" at 3618.98,6565.83 h50
  text "MUSICAL INSTRUMENT" at 4445.75,6565.83 h50
  text "DIGITAL INTERFACE" at 2824.29,6520.83 h50
  text "DIGITAL INTERFACE" at 3651.07,6520.83 h50
  text "DIGITAL INTERFACE" at 4477.84,6520.83 h50
  text "5VDC" at 7170,6225 h80
  text "ADC2" at 2180.43,6180 h55
  text "ADC3" at 2377.28,6180 h55
  text "5V" at 193.92,6160 h60
  text "DAC0" at 342.27,6160 h55
  text "DAC1" at 539.12,6160 h55
  text "DAC2" at 735.97,6160 h55
  text "DAC3" at 932.82,6160 h55
  text "5V" at 1640,6160 h60
  text "ADC0" at 1786.73,6160 h55
  text "ADC1" at 1983.58,6160 h55
  text "5V" at 3319.7,6160.01 h60
  text "PWM0" at 3459.84,6160.01 h55
  text "PWM1" at 3656.69,6160.01 h55
  text "PWM2" at 3853.54,6160.01 h55
  text "PWM3" at 4050.39,6160.01 h55
  text "NC0" at 4756.79,6160 h55
  text "COM0" at 4934.36,6160 h55
  text "N00" at 5151.85,6160 h55
  text "NC1" at 5347.34,6160 h55
  text "COM1" at 5524.92,6160 h55
  text "NO1" at 5742.4,6160 h55
  text "NC2" at 5937.89,6160 h55
  text "COM2" at 6115.47,6160 h55
  text "NO2" at 6332.95,6160 h55
  text "NC3" at 6528.44,6160 h55
  text "COM3" at 6706.02,6160 h55
  text "NO3" at 6923.5,6160 h55
  text "PWM" at 4515,6040 h45
  text "RELAYS" at 7135.94,6039.99 h45
  text "RS485" at 1365,6035 h45
  text "ETHERNET STATUS" at 2797.74,6035 h45
  text "ACTIVE" at 4481.63,5980 h50
  text "ACTIVE" at 7133.34,5979.99 h50
  text "CHANNELS" at 4465.81,5940 h40
  text "CHANNELS" at 7117.52,5939.99 h40
  text "FULL DUPLEX" at 2797.74,5840 h60
  text "0" at 4640.05,5780 h50
  text "0" at 7291.76,5779.99 h50
  text "LINK" at 2797.66,5690.13 h60
  text "1" at 4644.59,5609.61 h50
  text "1" at 7296.3,5609.61 h50
  text "4x DIGITAL TO ANALOG CONVERTER" at 310,5585 h60
  text "4x ANALOG TO DIGITAL CONVERTER" at 1755,5585 h60
  text "4x PULSE WIDTH MODULATOR" at 3605,5585 h60
  text "4x ISOLATED COMMON/NORMALLY OPEN/NORMALLY CLOSED RELAYS" at 5490,5585 h50
  text "10Mbps" at 2800.53,5543.43 h60
  text "120R" at 1370,5500 h60
  text "TERM" at 1355,5445 h60
  text "2" at 4639.86,5439.23 h50
  text "2" at 7291.57,5439.22 h50
  text "100Mbps" at 2800.53,5393.64 h60
  text "ON" at 1390,5390 h60
  text "F05C" at 3776.17,5379.18 h20 r90
  text "F05C" at 3931.17,5379.18 h20 r90
  text "F05C" at 846.17,5323 h20 r90
  text "F05C" at 2286.17,5313 h20 r90
  text "84S08" at 605,5310 h24 r90
  text "84S02" at 1920,5295 h24 r90
  text "3" at 4640,5268.84 h50
  text "3" at 7291.71,5268.83 h50
  text "COLLISION" at 2800.53,5243.84 h60
  text "F05C" at 3776.17,5243 h20 r90
  text "F05C" at 3931.17,5243 h20 r90
  text "SYSTEM JTAG" at 7535,5215.53 h50
  text "PLATFORM" at 167.98,5055 h50
  text "STATUS" at 167.98,5005 h50
  text "PLATFORM" at 7621.98,4966 h50
  text "STATUS 1" at 192.18,4930 h50
  text "UPGRADE ENABLE" at 7609,4924 h35
  text "PT2300-S" at -160,4850 h50 r90
  text "2" at 583.66,4794.72 h39.37
  text "4" at 838.66,4794.72 h39.37
  text "2" at 1983.66,4794.72 h39.37
  text "4" at 2238.66,4794.72 h39.37
  text "3" at 2238.66,4694.72 h39.37
  text "1" at 593.66,4689.72 h39.37
  text "3" at 838.66,4689.72 h39.37
  text "1" at 1993.66,4689.72 h39.37
  text "STATUS 2" at 190,4640 h50
  text "32K768" at 3610,4536 h28 r90
  text "5V" at 698.66,4524.72 h70.87 r90
  text "5V" at 2098.66,4524.72 h70.87 r90
  text "3V3" at 2198.66,4509.72 h70.87 r90
  text "3V3" at 798.66,4499.72 h70.87 r90
  text "User Header A" at 1334.98,4485.26 h94.49
  text "User Header B" at 2735.98,4485.26 h94.49
  text "+" at 3783.68,4436.46 h80
  text "SRAM-256Kx16" at 6491.32,4375 h50 r90
  text "SRAM-256Kx16" at 7166.32,4375 h50 r90
  text "PCF2123" at 3735,4230 h28 r90
  text "S" at 4405.65,4118.23 h59.05
  text "GND" at -60,4095 h50
  text "32K" at 3624.39,4092.39 h50
  text "W" at 4398,4062 h53
  text "I" at 4417.2,4002.06 h59.05
  text "5V0" at -60,3995 h50
  text "GND" at 3620,3992.23 h50
  text "T" at 4406.01,3944.33 h59.05
  text "3V3" at -60,3895 h50
  text "+B" at 3640,3892.24 h50
  text "C" at 4404.55,3887.23 h59.05
  text "VHC04" at 4060,3876 h28 r90
  text "H" at 4405.9,3828.89 h59.05
  text "2V5" at -60,3795 h50
  text "&" at 4403.51,3771.12 h59.05
  text "L" at 4407.7,3713.44 h59.05
  text "1V8" at -60,3695 h50
  text "E" at 4406.66,3655.72 h59.05
  text "ICS307-02" at 8010,3625 h34 r90
  text "D" at 4405.2,3598 h59.05
  text "1V2" at -60,3595 h50
  text "DRAM-16Mx16" at 6491.32,3517.31 h50 r90
  text "DRAM-16Mx16" at 7166.32,3517.31 h50 r90
  text "I" at 4417.2,3512.21 h59.05
  text "AUL" at -60,3490 h50
  text "O" at 4402.7,3457 h59.05
  text "AUR" at -65,3395 h50
  text "BAT" at 3619.39,3392.39 h50
  text "VHC04" at 4060,3330 h28 r90
  text "GND" at 228.12,3300.23 h35
  text "1V2" at 328.12,3300.23 h35
  text "GND" at 428.12,3300.23 h35
  text "1V8" at 528.12,3300.23 h35
  text "GND" at 628.12,3300.23 h35
  text "2V5" at 728.12,3300.23 h35
  text "GND" at 2828.12,3300.23 h35
  text "3V3" at 2928.12,3300.23 h35
  text "GND" at 3028.12,3300.23 h35
  text "5V0" at 3128.12,3300.23 h35
  text "GND" at 3228.12,3300.23 h35
  text "+B" at 3328.12,3300.23 h35
  text "VHC04" at 6960,3026 h28 r90
  text "VHC04" at 7270,3026 h28 r90
  text "VHC04" at 5265,3020 h28 r90
  text "ATE" at -682.26,2995 h60
  text "XPT2406" at 6640,2992.16 h30 r90
  text "NANOCONNECT" at 1133.2,2945.23 h59.05
  text "NB3000AL.02" at 2710.45,2940 h120
  text "TOUCH SCREEN LCD IO" at 5602,2932 h59.05
  text "Altera Cyclone III" at 2710.45,2801.44 h100
  text "NB3000AL.02" at 3540,2801.44 h60
  text "SRAM-256Kx16" at 7876.32,2770 h50 r90
  text "CS4270" at -161.51,2573.97 h45 r90
  text "ISP1760" at 5808.3,2513.65 h50
  text "DS2502" at 8034,2468.01 h26
  text "PWR" at 7825,2365 h50
  text "PERIPHERAL BOARD" at 889.66,2310.23 h102.36
  text "PGM" at 7824.95,2080 h50
  text "25P80" at 5820,1775 h36 r90
  text "25P80" at 6295,1775 h36 r90
  text "25P80" at 5820,1435 h36 r90
  text "25P80" at 6295,1435 h36 r90
  text "USB2" at 5264.86,555.83 h90
  text "USB2" at 5589.86,555.04 h90
  text "USB2" at 5914.86,550.83 h90
  text "7" at 6778.45,540.42 h60
  text "6" at 6877.17,540.1 h60
  text "5" at 6978.15,540.1 h60
  text "4" at 7078,540.42 h60
  text "3" at 7177.86,540.1 h60
  text "2" at 7277.71,540.76 h60
  text "1" at 7381.56,540.42 h60
  text "0" at 7477.41,540.44 h60
  text "PORT 1" at 5288.55,490 h50
  text "PORT 2" at 5613.55,489.21 h50
  text "PORT 3" at 5938.55,485 h50
  text "HEADPHONES" at 735,480 h55
  text "LINE IN" at 1115.13,456 h60
  text "LINE OUT" at 1520.13,456 h60
  text "AMP TEST" at 1925.13,456 h60
  text "RGB USER LEDS" at 6170,424.03 h50
  text "PS2" at 2965,405 h60
  text "PS2" at 3555,405 h60
  text "L" at 816.84,404.14 h34
  text "R" at 974.84,404.14 h34
  text "L" at 1221.84,404.14 h34
  text "R" at 1379.84,404.14 h34
  text "L" at 1626.84,404.14 h34
  text "R" at 1784.84,404.14 h34
  text "L" at 2031.84,404.14 h34
  text "R" at 2189.84,404.14 h34
  text "USER DIP SWITCH" at 6853.16,219.61 h50
  text "SPDIF IN" at 4054.94,120.83 h75
  text "SPDIF OUT" at 4412.69,120.83 h75
  text "2" at 6334.69,91.1 h60
  text "7" at 5778.45,90.76 h60
  text "6" at 5890.29,90.44 h60
  text "5" at 6000.95,90.44 h60
  text "4" at 6112.19,90.76 h60
  text "3" at 6223.44,90.44 h60
  text "1" at 6450.92,90.76 h60
  text "0" at 6557.18,90.79 h60
  text "TEST/RESET" at 5320,35 h60
  text "VOLUME" at 448.47,25 h55
  text "KEYBOARD" at 2822.86,25.83 h80
  text "MOUSE" at 3474.94,25.83 h80
Bottom Overlay:
  drawing of 5203 lines, arcs and shapes, not listed
  text "2201" at 6591,6385 h28 r270
  text "F05C" at 5741,6113 h20 r270
  text "+" at -23.11,6080.76 h80 r270
  text "1G04" at 4128,6078 h28
  text "1G04" at 4333,6078 h28
  text "1G04" at 4538,6078 h28
  text "1G04" at 6212.16,6023 h28
  text "1G04" at 3663.57,5974.94 h28 r270
  text "+" at 7798.68,5943.06 h80
  text "FUSE" at 4474.37,5567.87 h80
  text "LVC244" at 3442,5503 h28 r270
  text "COMPLIANCE:" at 7334.41,5495.57 h45
  text "ISL8491IB" at 1615.05,5488.08 h28 r270
  text "RTL8201" at 2455,5470 h35
  text "CLASS 2" at 6584.41,5405.58 h40
  text "IPC-A-600G" at 7244.41,5405.57 h40
  text "HIN232ACBNZ" at 790,5380 h34 r270
  text "CLASS 2" at 6584.41,5325.58 h40
  text "TYPE 3" at 6834.41,5325.57 h40
  text "IPC-6012D" at 7244.41,5325.57 h40
  text ".Application_BuildNumber" at 4096.21,5237.03 h60
  text "AD BUILD No:" at 4460.98,5236.81 h34
  text "4157" at 8108.92,4782.65 h23
  text "SRAM-256Kx16" at 6298.68,4375 h50 r270
  text "SRAM-256Kx16" at 6973.68,4375 h50 r270
  text "CY2305" at 8007.11,3879 h30 r90
  text "SD CARD" at 6794.22,3703.75 h120
  text "SDIO" at 6693.38,3510 h130
  text "SDHC" at 6717.02,3380 h130
  text "DESIGNED IN SYDNEY" at 5421,3126 h40
  text "AUSTRALIA" at 5315.43,3037 h50
  text "MANUFACTURE" at 7806.31,2995.59 h40
  text "DATE" at 7807.41,2928.79 h40
  text "1G04" at 7975.06,2393.57 h28
  text "3V3" at 266.21,2173.09 h32
  text "2V5" at 1351.21,2173 h32
  text "1V8" at 2436.14,2171 h32
  text "1V2" at 3626.14,2171 h32
  text "1G04" at 5325.06,1683.57 h28
  text "1G04" at 5560.06,1683.57 h28
  text "1G04" at 5325.06,1413.57 h28
  text "1G04" at 5560.06,1413.57 h28
  text "FUSE" at 2439.37,1097.87 h80
  text "HCU04" at 4155,1055 h28 r270
  text "2201" at 5355,975 h28 r90
  text "2201" at 5605,975 h28 r90
  text "2201" at 5855,975 h28 r90
  text "2201" at 7390,455 h28 r270
Bottom Paste:
  rectangle: 3618.53,1758.03 3918.53,2074
Top Solder:
  drawing of 369 lines, arcs and shapes, not listed
Bottom Solder:
  drawing of 373 lines, arcs and shapes, not listed
1. Boundary:
  lines w5: 4870,3670 5910,3670 5910,4710 4870,4710 4870,3670
16. Template Layer:
  drawing of 246 lines, arcs and shapes, not listed