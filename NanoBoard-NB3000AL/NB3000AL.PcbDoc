# Altium PCB NB3000AL.PcbDoc (part 36 of 79)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 9527.56 x 6929.77 mil, 6 copper layers (Top Layer, GND+SHIELD, MidLayer1, MidLayer2, P2 - 3V3+5V0, Bottom Layer), stack 62.375 mil thick; 894 components, 1037 nets, 4749 pads, 5320 vias.

## Via types
v1: diameter 23, hole 11.81, Top Layer to Bottom Layer, 3722 vias
v2: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, 731 vias
v3: diameter 19, hole 11.81, Top Layer to Bottom Layer, tented both sides, 628 vias
v4: diameter 20, hole 11.81, Top Layer to Bottom Layer, 91 vias
v5: diameter 26, hole 11.81, Top Layer to Bottom Layer, 64 vias
v6: diameter 23, hole 11.81, Top Layer to Bottom Layer, tented both sides, 52 vias
v7: diameter 31, hole 11.81, Top Layer to Bottom Layer, 14 vias
v8: diameter 27, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v9: diameter 27.56, hole 11.81, Top Layer to Bottom Layer, tented both sides, 4 vias
v10: diameter 29, hole 11.81, Top Layer to Bottom Layer, 3 vias
v11: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 3 vias
v12: diameter 19, hole 11.81, Top Layer to Bottom Layer, 2 vias
v13: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented top, 1 vias
v14: diameter 21, hole 11.81, Top Layer to Bottom Layer, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DB_SPI.DOUT: U8.AG23 U30.A3 | length 2743.7
  Top Layer w4: v1@5843.28,3265.28 ccw(c5827.06,3249.06) 5827.06,3272 ccw(c5827.06,3294.93) v1@5843.28,3278.72 ; v1@5846.11,3268.11 ccw(c5836.72,3258.72) 5836.72,3272 ccw(c5836.72,3285.28) v1@5846.11,3275.89 ; v1(5850,3272) 5821.25,3272 5811.06,3282.19 5771.64,3321.61 5771.64,3430.45 5773.81,3432.62 5773.81,3447.38 5763.38,3457.81 5752.34,3457.81 5709.02,3501.13 5709.02,3531.02 5718.19,3540.19 5718.19,3558.39 5740,3580.2 5740,3630 5740.15,3638.82 5740.15,3678.16 ; U30.A3@6788.27,2165.47 ccw(c6775.74,2178) 6793.46,2178 ccw(c6811.19,2178) U30.A3@6798.66,2165.47 ; v2@6791.09,2244.5 cw(c6786.18,2236) 6796,2236 ; U30.A3@6793.46,2160.28 6793.46,2233.46 6796,2236 ; v2(6796,2253) 6796,2236 ; v2@6800.91,2244.5 ccw(c6805.82,2236) 6796,2236 ; 5737.18,3685.34 ccw(c5724.65,3672.8) 5724.65,3690.53 cw(c5724.65,3672.8) 5737.18,3685.34 ; 5737.18,3685.34 cw(c5749.71,3697.87) 5731.99,3697.87 ccw(c5749.71,3697.87) 5737.18,3685.34 ; 5737.18,3685.34 cw(c5730,3678.16) 5740.15,3678.16 ; 5737.18,3685.34 cw(c5730,3678.16) 5740.15,3678.16
  MidLayer2 w4: v1(5850,3272) 5894.63,3272 5905,3282.37 5930.86,3282.37 5965.19,3248.04 6010.65,3248.04 6065.19,3193.5 6065.19,3108.37 6081.86,3091.71 6300,3091.71 ; v1@5853.89,3268.11 cw(c5863.28,3258.72) 5863.28,3272 cw(c5863.28,3285.28) v1@5853.89,3275.89 ; v1@5856.72,3265.28 cw(c5872.93,3249.06) 5872.93,3272 cw(c5872.93,3294.93) v1@5856.72,3278.72 ; v2(6796,2253) 6784.77,2264.23 6774.96,2264.23 ; 6300,3091.71 6316.23,3091.71 ; 6300,3091.71 6316.23,3091.71 ; 6316.23,3091.71 6320,3091.71 ; 6320,3091.71 6328.17,3091.71 ; 6320,3091.71 6328.17,3091.71 ; 6328.17,3091.71 6360.45,3091.71 6489.94,2962.21 6622.66,2962.21 6622.82,2962.37 6723.52,2962.37 6782.86,2903.04 6782.86,2551.36 6770.19,2538.69 6770.19,2517.31 6782.03,2505.47 6782.03,2451.16 6801.81,2431.38 6801.81,2415 ; 6755.08,2325 6755.08,2341.16 ; 6755.08,2325 6755.08,2284.11 6771.92,2267.27 ; 6755.08,2325 6755.08,2341.16 ; 6755.08,2341.16 6801.81,2387.89 6801.81,2400.97 ; 6771.92,2267.27 6774.96,2264.23 ; 6771.92,2267.27 6774.96,2264.23 ; 6801.81,2400.97 6801.81,2415 ; 6801.81,2400.97 6801.81,2415
DB_SPI.MODE: U8.AF27 U30.B10 | length 2786.8
  Top Layer w4: 5894.66,3724.71 ccw(c5901.84,3731.89) 5901.84,3721.74 ; 5894.66,3724.71 ccw(c5901.84,3731.89) 5901.84,3721.74 ; 5894.66,3724.71 cw(c5907.19,3737.24) 5889.47,3737.24 ccw(c5907.19,3737.24) 5894.66,3724.71 ; 5894.66,3724.71 ccw(c5882.13,3712.18) 5882.13,3729.9 cw(c5882.13,3712.18) 5894.66,3724.71 ; 5901.84,3721.74 5941.18,3721.74 5951.95,3721.74 5977.12,3696.57 5977.12,3601.57 6048.52,3530.16 6048.52,3400.04 6115.19,3333.37 6148.52,3333.37 6198.52,3283.37 6231.86,3283.37 6256.86,3308.37 6323.52,3308.37 6331.86,3300.04 6331.86,3275.04 6313.19,3256.37 6313.19,3118.71 6323.52,3108.37 6323.52,3026.71 6358.52,2991.71 6373.23,2977 6438,2977 6464.46,2950.54 6734.46,2950.54 6820.3,2864.7 7043.2,2864.7 7102,2805.9 7102,2730.18 7060,2688.18 7060,2558.75 7065.5,2553.25 7065.5,2538.75 7052.19,2525.44 7052.19,2507.62 7067,2492.81 7082.62,2492.81 7086.14,2489.3 7086.14,2460.7 7082.62,2457.19 7078.44,2457.19 7067.81,2446.56 7067.81,2294.19 7084.9,2277.1 7084.9,2140.95 7084.56,2140.62 ; 7081.59,2133.44 cw(c7069.05,2145.97) 7069.05,2128.25 ccw(c7069.05,2145.97) 7081.59,2133.44 ; 7081.59,2133.44 ccw(c7094.12,2120.91) 7076.4,2120.91 cw(c7094.12,2120.91) 7081.59,2133.44 ; 7081.59,2133.44 ccw(c7074.41,2140.62) 7084.56,2140.62 ; 7081.59,2133.44 ccw(c7074.41,2140.62) 7084.56,2140.62
DB_SPI.SEL: U8.AE25 U30.D5 | length 3058.7
  Top Layer w4: 5892.88,3597.12 cw(c5870.8,3575.04) v1@5902.02,3575.04 ; 5899.71,3590.29 cw(c5884.45,3575.04) v1@5906.02,3575.04 ; 5901.17,3588.83 ccw(c5911.52,3599.18) v1@5911.52,3584.54 ; v1(5911.52,3575.04) 5911.52,3578.48 5867,3623 5867,3630 5866.62,3638.82 5866.62,3697.36 ccw(c5856.47,3697.36) 5863.64,3704.54 5863.64,3704.76 5855.73,3712.68 ccw(c5842.76,3697.87) 5842.76,3717.56 cw(c5842.76,3737.25) 5823.07,3737.24 5823.07,3748.69 ccw(c5803.39,3748.69) 5817.31,3762.6 5817.31,3762.69 5815.92,3764.08 ; v3(6852.52,2061.85) U30.D5@6872.2,2042.17 ; U30.D5@6864.86,2042.17 ccw(c6847.14,2042.16) 6859.67,2054.7 ccw(c6872.2,2067.23) U30.D5@6872.2,2049.51 ; 5815.92,3764.08 cw(c5828.45,3776.61) 5810.73,3776.61 ccw(c5828.45,3776.61) 5815.92,3764.08 ; 5815.92,3764.08 ccw(c5803.39,3751.55) 5803.39,3769.27 cw(c5803.39,3751.55) 5815.92,3764.08 ; 6865.32,2049.05 cw(c6878.13,2061.85) 6860.02,2061.85 ccw(c6878.13,2061.85) 6865.32,2049.05 ; 6865.32,2049.05 ccw(c6852.52,2036.24) 6852.52,2054.35 cw(c6852.52,2036.24) 6865.32,2049.05
  MidLayer1 w4: v1@6827.47,2309.99 cw(c6811.26,2293.77) 6834.19,2293.77 cw(c6857.13,2293.77) v1@6840.91,2309.99 ; 6828.66,2138.66 6828.66,2124.73 ; v1@6830.3,2312.82 cw(c6820.91,2303.43) 6834.19,2303.43 cw(c6847.47,2303.43) v1@6838.08,2312.82 ; v1(6834.19,2316.71) 6834.19,2269.38 6832.52,2267.71 6821.19,2256.38 6821.19,2240.81 6828.66,2233.34 6828.66,2218.27 6828.66,2198.85 6828.66,2124.73 ; v3@6845.13,2063.15 ccw(c6827.3,2066.3) 6842.13,2076.68 ; v3@6853.82,2069.24 cw(c6856.97,2087.07) 6842.13,2076.68 ; 6828.66,2124.73 6828.66,2101.48 ccw(c6852.43,2101.48) 6835.05,2085.26 6842.13,2076.68
  MidLayer2 w4: v1@5904.81,3568.32 cw(c5888.59,3552.11) 5911.52,3552.11 cw(c5934.46,3552.11) v1@5918.24,3568.32 ; v1@5907.64,3571.15 cw(c5898.25,3561.76) 5911.52,3561.76 cw(c5924.8,3561.76) v1@5915.41,3571.15 ; v1(5911.52,3575.04) 5911.52,3521.19 5928.9,3503.81 6019,3503.81 6073.31,3449.5 6091.31,3449.5 ; v1@6827.47,2323.43 ccw(c6811.26,2339.64) 6834.19,2339.64 ccw(c6857.13,2339.64) v1@6840.91,2323.43 ; v1@6830.3,2320.6 ccw(c6820.91,2329.99) 6834.19,2329.99 ccw(c6847.47,2329.99) v1@6838.08,2320.6 ; v1(6834.19,2316.71) 6834.19,2346.06 6817.5,2362.75 6817.5,2382.37 6826.19,2391.06 6826.19,2494.62 6846,2514.44 6846,2597.52 6886.32,2637.84 ; 6091.31,3449.5 6107.62,3433.19 ; 6091.31,3449.5 6107.62,3433.19 ; 6107.62,3433.19 6132.04,3433.19 6206.86,3358.37 6273.52,3358.37 6289.86,3342.04 6665.19,3342.04 6700,3307.23 6700,3115.23 6765.19,3050.04 6827.59,3050.04 6897.5,2980.13 6897.5,2725 ; 6886.32,2637.84 6897.5,2649.02 ; 6886.32,2637.84 6897.5,2649.02 ; 6897.5,2649.02 6897.5,2706.15 ; 6897.5,2706.15 6897.5,2725 ; 6897.5,2706.15 6897.5,2725
DB_SRAM1.A0: U8.G13 U14.1 | length 2321.5
  Top Layer w4: v3(5311.26,4504.96) U8.G13@5330.94,4485.28 ; U8.G13@5323.6,4485.28 ccw(c5305.88,4485.28) 5318.41,4497.81 ccw(c5330.94,4510.34) U8.G13@5330.95,4492.62 ; 5324.06,4492.16 cw(c5336.87,4504.96) 5318.76,4504.96 ccw(c5336.87,4504.96) 5324.06,4492.16 ; 5324.06,4492.16 ccw(c5311.26,4479.35) 5311.26,4497.46 cw(c5311.26,4479.35) 5324.06,4492.16
  MidLayer2 w4: 5299.87,4518.54 cw(c5309.8,4528.47) 5295.75,4528.47 5295.75,4622.01 5295.75,4789.06 5287.19,4797.62 5287.19,4813.33 5348.86,4875 5348.86,5029.05 5402.69,5082.88 5469.92,5082.88 5487.24,5100.2 5508.36,5100.2 5536.56,5072 5646.15,5072 5703.52,5129.37 5731.52,5129.37 5760.86,5100.04 5761.35,5099.55 5892.68,5099.55 5893.17,5100.04 5909.44,5100.04 5935.28,5074.21 5980.48,5074.21 5997.98,5091.71 6218.29,5091.71 6290.19,5019.81 6290.19,4967.29 6324.61,4932.87 6339.11,4932.87 6347.94,4941.71 v1(6455.52,4941.71) ; v3@5303.79,4505.61 ccw(c5285.75,4507.19) 5299.62,4518.83 ccw(c5313.49,4530.47) v3@5311.91,4512.43 ; v1@6448.81,4934.99 ccw(c6432.59,4918.77) 6432.59,4941.71 ccw(c6432.59,4964.64) v1@6448.81,4948.43 ; v1@6451.64,4937.82 ccw(c6442.25,4928.43) 6442.25,4941.71 ccw(c6442.25,4954.99) v1@6451.64,4945.6
  Bottom Layer w4: v1(6455.52,4941.71) 6505.68,4991.87 6541.36,4991.87 6562.52,4970.71 U14.1@6619.41,4970.71 ; v1@6455.52,4947.21 ccw(c6455.52,4960.49) 6464.91,4951.1 ccw(c6474.3,4941.71) v1@6461.02,4941.71 ; v1@6455.52,4951.21 ccw(c6455.52,4974.14) 6471.74,4957.93 ccw(c6487.96,4941.71) v1@6465.02,4941.71 ; U14.1@6596.19,4965.05 ccw(c6582.54,4951.39) 6582.54,4970.71 ccw(c6582.54,4990.02) U14.1@6596.19,4976.37
DB_SRAM1.A1: U8.F15 U14.2 | length 2477.5
  Top Layer w4: U8.F15@5409.68,4524.65 v3(5429.37,4544.33) ; U8.F15@5409.69,4531.99 ccw(c5409.69,4549.71) 5422.22,4537.18 ccw(c5434.75,4524.65) U8.F15@5417.03,4524.65 ; 5416.57,4531.53 cw(c5429.37,4518.72) 5429.37,4536.83 ccw(c5429.37,4518.72) 5416.57,4531.53 ; 5416.57,4531.53 ccw(c5403.76,4544.33) 5421.87,4544.33 cw(c5403.76,4544.33) 5416.57,4531.53
  MidLayer1 w4: v3@5428.72,4551.8 ccw(c5427.14,4569.84) 5441.01,4558.2 ; v3@5436.84,4544.98 cw(c5454.88,4546.56) 5441.01,4558.2 ; 6560.14,5269.99 ccw(c6535.13,5295) v1@6570.5,5295 ; 6566.97,5276.82 ccw(c6548.79,5295) v1@6574.5,5295 ; 6572.57,5282.42 cw(c6580,5275) v1@6580,5285.5 ; 6573.8,5283.65 ccw(c6562.45,5295) v1@6578.5,5295 ; v1(6580,5295) 6580,5289.85 6500.86,5210.71 5792.52,5210.71 5533.81,4952 5533.81,4924.62 5531.86,4922.67 5531.86,4867.32 5483.5,4818.96 5483.5,4794.31 5453.23,4764.04 5453.23,4751.18 5453.23,4741.18 5453.23,4700.75 5453.23,4681.33 5453.23,4607.21 5453.23,4587.71 cw(c5411.5,4587.71) 5441.01,4558.2
  MidLayer2 w4: v1@6573.28,5288.28 cw(c6557.06,5272.06) 6580,5272.06 cw(c6602.93,5272.06) v1@6586.72,5288.28 ; v1@6576.11,5291.11 cw(c6566.72,5281.72) 6580,5281.72 cw(c6593.28,5281.72) v1@6583.89,5291.11 ; v1(6580,5295) 6580,5247.02 6662.02,5165 6662.02,5003.21 v1(6679.52,4985.71) ; v1@6670.02,4985.71 ccw(c6647.09,4985.71) 6663.31,5001.93 ccw(c6679.52,5018.14) v1@6679.52,4995.21 ; v1@6674.02,4985.71 ccw(c6660.75,4985.71) 6670.14,4995.1 ccw(c6679.52,5004.49) v1@6679.52,4991.21
  Bottom Layer w4: U14.2@6619.41,4939.21 6633.03,4939.21 v1(6679.52,4985.71) ; U14.2@6636.97,4947.21 ccw(c6636.97,4957.02) 6643.9,4950.08 ; U14.2@6640.97,4939.21 cw(c6660.14,4939.21) 6646.58,4952.77 ; U14.2@6644.97,4939.21 cw(c6673.79,4939.21) 6653.41,4959.59 ; v1@6670.02,4985.71 cw(c6647.09,4985.71) 6663.31,4969.49 cw(c6679.52,4953.27) v1@6679.52,4976.21 ; v1@6674.02,4985.71 cw(c6660.75,4985.71) 6670.14,4976.32 cw(c6679.52,4966.93) v1@6679.52,4980.21
DB_SRAM1.A2: U8.D17 U14.3 | length 2125.4
  Top Layer w4: U8.D17@5488.43,4603.39 v3(5508.11,4623.07) ; U8.D17@5488.42,4610.73 ccw(c5488.42,4628.45) 5500.96,4615.92 ccw(c5513.49,4603.39) U8.D17@5495.77,4603.39 ; v1(6381.86,5152.37) 6487.86,5152.37 6581.86,5058.37 6581.86,5030 6573.52,5021.67 v1(6573.52,4941.71) ; v1@6385.75,5148.49 cw(c6395.14,5139.1) 6395.14,5152.37 cw(c6395.14,5165.65) v1@6385.75,5156.26 ; v1@6388.57,5145.66 cw(c6404.79,5129.44) 6404.79,5152.37 cw(c6404.79,5175.31) v1@6388.57,5159.09 ; v1@6566.81,4948.43 ccw(c6550.59,4964.64) 6573.52,4964.64 ccw(c6596.46,4964.64) v1@6580.24,4948.43 ; v1@6569.64,4945.6 ccw(c6560.25,4954.99) 6573.52,4954.99 ccw(c6586.8,4954.99) v1@6577.41,4945.6 ; 5495.31,4610.27 cw(c5508.11,4597.46) 5508.11,4615.57 ccw(c5508.11,4597.46) 5495.31,4610.27 ; 5495.31,4610.27 ccw(c5482.5,4623.07) 5500.61,4623.07 cw(c5482.5,4623.07) 5495.31,4610.27
  MidLayer1 w4: v3@5502.81,4628.37 ccw(c5490,4641.18) 5508.11,4641.18 ccw(c5526.22,4641.18) v3@5513.41,4628.37 ; v3@5502.92,4628.26 ccw(c5490.38,4640.8) 5508.11,4640.8 ccw(c5525.84,4640.8) v3@5513.3,4628.26 ; v3(5508.11,4623.07) 5508.11,4741.18 5508.11,4749.18 5508.11,4771.89 5499.52,4780.48 5499.52,4812.35 5502.89,4815.72 5548.52,4861.35 5548.52,4916.71 5549.81,4918 5549.81,4945.37 5613.32,5008.88 5637.82,5033.37 5755.82,5033.37 5855.15,5132.71 6362.19,5132.71 v1(6381.86,5152.37) ; v1@6372.36,5152.37 cw(c6349.42,5152.37) 6365.64,5136.16 cw(c6381.86,5119.94) v1@6381.86,5142.87 ; v1@6376.36,5152.37 cw(c6363.08,5152.37) 6372.47,5142.99 cw(c6381.86,5133.6) v1@6381.86,5146.87
  Bottom Layer w4: v1@6566.81,4934.99 cw(c6550.59,4918.77) 6573.52,4918.77 cw(c6596.46,4918.77) v1@6580.24,4934.99 ; v1@6569.64,4937.82 cw(c6560.25,4928.43) 6573.52,4928.43 cw(c6586.8,4928.43) v1@6577.41,4937.82 ; v1(6573.52,4941.71) 6573.52,4915.72 6581.52,4907.72 U14.3@6619.41,4907.72 ; U14.3@6596.19,4902.06 ccw(c6582.54,4888.4) 6582.54,4907.72 ccw(c6582.54,4927.03) U14.3@6596.19,4913.37
DB_SRAM1.A3: U8.G19 U14.4 | length 1785.9
  Top Layer w4: U8.G19@5567.17,4485.28 v3(5586.85,4504.96) ; U8.G19@5567.17,4492.62 ccw(c5567.17,4510.34) 5579.7,4497.81 ccw(c5592.23,4485.28) U8.G19@5574.51,4485.28 ; 5574.05,4492.16 cw(c5586.85,4479.35) 5586.85,4497.46 ccw(c5586.85,4479.35) 5574.05,4492.16 ; 5574.05,4492.16 ccw(c5561.24,4504.96) 5579.35,4504.96 cw(c5561.24,4504.96) 5574.05,4492.16
  MidLayer2 w4: v3@5586.2,4512.43 ccw(c5584.62,4530.47) 5598.49,4518.83 ccw(c5612.36,4507.19) v3@5594.32,4505.61 ; 5598.24,4518.54 ccw(c5588.31,4528.47) 5602.36,4528.47 ; 5602.36,4542.4 5602.36,4528.47 ; 5602.36,4738.53 5602.36,4680.27 ; v1@6564.02,4866.71 cw(c6541.09,4866.71) 6557.31,4850.49 cw(c6573.52,4834.27) v1@6573.52,4857.21 ; v1@6568.02,4866.71 cw(c6554.75,4866.71) 6564.14,4857.32 cw(c6573.52,4847.93) v1@6573.52,4861.21 ; v1(6573.52,4866.71) 6531.86,4825.04 6418.19,4825.04 6367.7,4774.55 6362.7,4774.55 6306.36,4774.55 6273.52,4741.71 6178.29,4741.71 6140,4780 6105,4780 6093.37,4768.37 6062.84,4768.37 5947.84,4883.37 5854.86,4883.37 5838.19,4900.04 5711.5,4900.04 5676.19,4864.73 5676.19,4825.97 5632.37,4782.15 5612.15,4782.15 5602.36,4772.36 5602.36,4749.18 5602.36,4741.18 5602.36,4680.27 ; 5602.36,4528.47 5602.36,4622.01 5602.36,4680.27
  Bottom Layer w4: v1(6573.52,4866.71) 6581.19,4866.71 6590.7,4876.22 ; v1@6576.41,4871.39 ccw(c6580.98,4878.79) 6587.12,4872.64 ; v1@6578.51,4874.79 ccw(c6583.7,4883.21) 6590.7,4876.22 ; 6591.22,4876.74 cw(c6600.07,4867.89) U14.4@6602.69,4880.13 ; U14.4@6619.41,4876.22 6590.7,4876.22
DB_SRAM1.A4: U8.A21 U14.5 | length 1874.7
  Top Layer w4: U8.A21@5640.71,4726.69 ccw(c5628.18,4739.22) 5645.91,4739.22 ccw(c5663.63,4739.22) U8.A21@5651.1,4726.69 ; U8.A21@5645.91,4721.5 5645.91,4775.91 5653.41,4783.41 5681.78,4811.78 5681.78,4827.09 5681.78,5100.12 v1(5665.19,5116.71) ; v1@5665.19,5107.21 cw(c5665.19,5084.27) 5681.41,5100.49 cw(c5697.63,5116.71) v1@5674.69,5116.71 ; v1@5665.19,5111.21 cw(c5665.19,5097.93) 5674.58,5107.32 cw(c5683.97,5116.71) v1@5670.69,5116.71
  MidLayer2 w4: v1(5665.19,5116.71) 5665.19,5125.04 5681.86,5141.71 ; v1@5666.67,5116.97 cw(c5682.16,5119.75) 5671.03,5130.88 ; v1@5670.6,5117.68 cw(c5691.34,5121.4) 5676.44,5136.29 ; v1@5674.54,5118.39 cw(c5700.52,5123.05) 5681.86,5141.71 ; v1@6516.81,4959.99 ccw(c6500.59,4943.77) 6500.59,4966.71 ccw(c6500.59,4989.64) v1@6516.81,4973.43 ; v1@6519.64,4962.82 ccw(c6510.25,4953.43) 6510.25,4966.71 ccw(c6510.25,4979.99) v1@6519.64,4970.6 ; v1(6523.52,4966.71) 6415.19,4966.71 6265.19,5116.71 5898.52,5116.71 5890.19,5108.37 5763.86,5108.37 5730.52,5141.71 5681.86,5141.71
  Bottom Layer w4: v1@6523.52,4957.21 cw(c6523.52,4934.27) 6539.74,4950.49 cw(c6555.96,4966.71) v1@6533.02,4966.71 ; v1@6523.52,4961.21 cw(c6523.52,4947.93) 6532.91,4957.32 cw(c6542.3,4966.71) v1@6529.02,4966.71 ; v1(6523.52,4966.71) 6548.52,4941.71 6548.52,4858.37 6565.19,4841.71 6601.84,4841.71 6601.84,4844.72 U14.5@6619.41,4844.72 ; 6575.26,4841.71 ccw(c6575.26,4871.31) U14.5@6596.19,4850.38 ; 6584.91,4841.71 ccw(c6584.91,4861.66) U14.5@6599.02,4847.55 ; 6589.82,4841.71 cw(c6589.82,4832.69) U14.5@6596.19,4839.07
DB_SRAM1.A5: U8.K25 U14.18 | length 1341.1
  Top Layer w4: U8.K25@5803.39,4367.17 v3(5823.07,4386.85) ; U8.K25@5803.39,4374.51 ccw(c5803.39,4392.23) 5815.92,4379.7 ccw(c5828.45,4367.17) U8.K25@5810.73,4367.17 ; 5810.27,4374.05 cw(c5823.07,4361.24) 5823.07,4379.35 ccw(c5823.07,4361.24) 5810.27,4374.05 ; 5810.27,4374.05 ccw(c5797.46,4386.85) 5815.57,4386.85 cw(c5797.46,4386.85) 5810.27,4374.05
  MidLayer1 w4: v3(5823.07,4386.85) 5881.33,4386.85 5900.75,4386.85 5941.18,4386.85 5949.18,4386.85 5998.47,4386.85 6007.12,4395.5 6040,4395.5 6094.44,4395.5 6099.34,4395.5 6219.38,4515.54 6315,4515.54 6633.02,4515.54 v1(6665.19,4483.37) ; v3@5828.26,4381.66 cw(c5840.8,4369.12) 5840.8,4386.85 cw(c5840.8,4404.58) v3@5828.26,4392.04 ; v1@6655.69,4483.37 ccw(c6632.76,4483.37) 6648.97,4499.59 ccw(c6665.19,4515.81) v1@6665.19,4492.87 ; v1@6659.69,4483.37 ccw(c6646.41,4483.37) 6655.8,4492.76 ccw(c6665.19,4502.15) v1@6665.19,4488.87 ; 5841.18,4386.85 cw(c5841.18,4404.96) 5828.37,4392.15 ccw(c5841.18,4404.96) 5841.18,4386.85 ; 5841.18,4386.85 ccw(c5841.18,4368.74) 5828.37,4381.55 cw(c5841.18,4368.74) 5841.18,4386.85
  Bottom Layer w4: U14.18@6619.41,4435.27 6660.27,4435.27 6665.19,4440.19 v1(6665.19,4483.37) ; U14.18@6642.63,4429.62 cw(c6656.28,4415.96) 6656.28,4435.27 cw(c6656.28,4454.59) U14.18@6642.63,4440.93 ; v1@6658.47,4476.66 cw(c6642.26,4460.44) 6665.19,4460.44 cw(c6688.13,4460.44) v1@6671.91,4476.66 ; v1@6661.3,4479.49 cw(c6651.91,4470.1) 6665.19,4470.1 cw(c6678.47,4470.1) v1@6669.08,4479.49
DB_SRAM1.A6: U8.L25 U14.19 | length 1235.4
  Top Layer w4: U8.L25@5803.39,4327.8 v3(5823.07,4347.48) ; U8.L25@5803.39,4335.14 ccw(c5803.39,4352.86) 5815.92,4340.33 ccw(c5828.45,4327.8) U8.L25@5810.73,4327.8 ; 5810.27,4334.68 cw(c5823.07,4321.87) 5823.07,4339.98 ccw(c5823.07,4321.87) 5810.27,4334.68 ; 5810.27,4334.68 ccw(c5797.46,4347.48) 5815.57,4347.48 cw(c5797.46,4347.48) 5810.27,4334.68
  MidLayer1 w4: v3(5823.07,4347.48) 5881.33,4347.48 5900.75,4347.48 5941.18,4347.48 5951.18,4347.48 5987.67,4347.48 5995.5,4355.31 5995.5,4361.25 6005.75,4371.5 6022.25,4371.5 6031.19,4362.56 6031.19,4356.62 6046.1,4341.71 6137.21,4341.71 6235.93,4440.43 6245.5,4450 6296.81,4450 ; v3@5828.26,4342.29 cw(c5840.8,4329.75) 5840.8,4347.48 cw(c5840.8,4365.21) v3@5828.26,4352.67 ; v3@5828.37,4342.18 cw(c5841.18,4329.37) 5841.18,4347.48 cw(c5841.18,4365.59) v3@5828.37,4352.78 ; v1@6566.81,4418.32 ccw(c6550.59,4402.11) 6550.59,4425.04 ccw(c6550.59,4447.98) v1@6566.81,4431.76 ; v1@6569.64,4421.15 ccw(c6560.25,4411.76) 6560.25,4425.04 ccw(c6560.25,4438.32) v1@6569.64,4428.93 ; v1(6573.52,4425.04) 6527.72,4425.04 6511.95,4440.81 6480,4440.81 6461.41,4440.81 6459.79,4439.19 6307.62,4439.19 ; 6296.81,4450 6307.62,4439.19 ; 6296.81,4450 6307.62,4439.19
  Bottom Layer w4: v1@6573.52,4415.54 cw(c6573.52,4392.61) 6589.74,4408.82 cw(c6605.96,4425.04) v1@6583.02,4425.04 ; v1@6573.52,4419.54 cw(c6573.52,4406.26) 6582.91,4415.65 cw(c6592.3,4425.04) v1@6579.02,4425.04 ; v1(6573.52,4425.04) 6598.52,4400.04 6619.41,4400.04 6623.52,4400.04 6623.52,4403.78 U14.19@6619.41,4403.78 ; 6583.6,4414.96 ccw(c6600.98,4432.34) U14.19@6601.73,4407.78 ; 6590.15,4408.42 ccw(c6601.37,4419.64) U14.19@6601.85,4403.78
DB_SRAM1.A7: U8.H7 U14.20 | length 4894.4
  Top Layer w4: v3(5075.04,4465.59) U8.H7@5094.72,4445.91 ; U8.H7@5087.38,4445.91 ccw(c5069.66,4445.91) 5082.19,4458.44 ccw(c5094.72,4470.97) U8.H7@5094.72,4453.25 ; 5087.84,4452.79 cw(c5100.65,4465.59) 5082.54,4465.59 ccw(c5100.65,4465.59) 5087.84,4452.79 ; 5087.84,4452.79 ccw(c5075.04,4439.98) 5075.04,4458.09 cw(c5075.04,4439.98) 5087.84,4452.79
  MidLayer2 w4: v1@4603.49,4364.92 ccw(c4589.28,4380) 4610,4380 ccw(c4630.72,4380) v1@4616.51,4364.92 ; v1@4606.23,4362 ccw(c4598,4370.74) 4610,4370.74 ccw(c4622,4370.74) v1@4613.77,4362 ; v1@4610,4366.38 4610,4380 4627.28,4397.28 4640.9,4397.28 4653.5,4409.88 4653.5,4536.12 4661.5,4544.12 4661.5,4571.88 4640.69,4592.69 4640.69,4684.31 4640.19,4684.81 4628.52,4696.48 ; 4640,4685 4628.52,4696.48 ; v1@6677.14,4795.32 ccw(c6660.92,4779.11) 6660.92,4802.04 ccw(c6660.92,4824.98) v1@6677.14,4808.76 ; v1@6679.97,4798.15 ccw(c6670.58,4788.76) 6670.58,4802.04 ccw(c6670.58,4815.32) v1@6679.97,4805.93 ; v1(6683.86,4802.04) 6647.96,4802.04 6638.02,4811.98 6638.02,4935.44 6638.02,5155.06 6593.71,5199.37 6580.08,5213 6455.52,5213 6441.9,5199.37 5762.23,5199.37 5753.85,5191 5622.69,5191 5586.69,5227 5363.31,5227 5293.39,5157.08 5292.08,5157.08 ; 4628.52,4696.48 4628.52,4720 ; 4628.52,4720 4628.52,4736.51 ; 4628.52,4720 4628.52,4736.51 ; 4628.52,4736.51 4621.36,4743.68 4621.36,4781.52 4621.36,4786.27 4620,4787.63 4620,4787.88 4617.36,4790.52 4617.36,4792.33 4617.36,4807.09 4628.52,4818.25 4628.52,5010 4628.52,5022.21 4822.85,5216.54 5104.98,5216.54 5199.59,5216.54 5210.92,5205.2 5259.05,5157.08 5267.76,5157.08 ; 5267.76,5157.08 5292.08,5157.08 ; 5267.76,5157.08 5292.08,5157.08
  Bottom Layer w4: v1@4603.28,4364.72 ccw(c4587.06,4380.93) 4610,4380.93 ccw(c4632.93,4380.93) v1@4616.72,4364.72 ; v1@4606.11,4361.89 ccw(c4596.72,4371.28) 4610,4371.28 ccw(c4623.28,4371.28) v1@4613.89,4361.89 ; v1(4610,4358) 4610,4395 4610,4405 4610,4435 4653.5,4478.5 4653.5,4568.5 4670,4585 4700,4585 4730,4585 4805,4585 4821.9,4568.1 4830.82,4568.1 4838.82,4568.1 4840.41,4568.1 4898.67,4568.1 4956.93,4568.1 cw(c4956.93,4544.33) 4980.7,4544.33 ccw(c4996.3,4544.33) 4996.3,4528.73 cw(c4996.3,4504.96) 5020.07,4504.96 ccw(c5035.67,4504.96) 5035.67,4489.36 cw(c5035.67,4465.59) 5052.48,4482.4 5060.21,4475.98 ; v3@5067.65,4464.29 ccw(c5049.82,4461.14) 5060.21,4475.98 ; v3@5073.74,4472.98 cw(c5070.59,4490.81) 5060.21,4475.98 ; U14.20@6619.41,4372.28 6648.98,4372.28 ; U14.20@6644.35,4369.2 cw(c6648.98,4367.27) 6648.98,4372.28 ; U14.20@6644.35,4375.36 ccw(c6648.98,4377.29) 6648.98,4372.28 ; v1(6683.86,4802.04) 6683.86,4793.71 6652.97,4762.82 6652.97,4704.18 6714.5,4642.65 6714.5,4613.17 6695,4593.67 6695,4415.25 6669.93,4390.18 6666.88,4390.18 6648.98,4372.28
DB_SRAM1.A8: U8.M26 U14.21 | length 1019
  Top Layer w4: U8.M26@5842.76,4295.77 ccw(c5842.76,4313.49) 5855.29,4300.96 ; U8.M26@5850.1,4288.42 cw(c5867.82,4288.42) 5855.29,4300.96 ; v1@6005.56,4289 5982.28,4312.29 5949.18,4312.29 5941.18,4312.29 5882.64,4312.29 ccw(c5882.64,4273.61) 5855.29,4300.96
  MidLayer1 w4: v1@6009.91,4288.09 6027.86,4306.04 6029.32,4307.5 6041.75,4307.5 ; v1@6475.1,4334.28 v1@6480.72,4334.28 ; v1@6478.28,4328.28 ccw(c6462.06,4312.06) 6462.06,4335 ccw(c6462.06,4357.93) v1@6478.28,4341.72 ; v1@6481.11,4331.11 ccw(c6471.72,4321.72) 6471.72,4335 ccw(c6471.72,4348.28) v1@6481.11,4338.89 ; v1(6485,4335) 6436.46,4335 6426.5,4325.04 6315.19,4325.04 6298.52,4308.37 6256.86,4308.37 6240.73,4324.5 6208.75,4324.5 6198.5,4314.25 6198.5,4291.73 6165.19,4258.37 6090.19,4258.37 6073.52,4275.04 6073.86,4275.37 6073.86,4301.39 6067.75,4307.5 6055,4307.5 ; 6041.75,4307.5 6055,4307.5 ; 6041.75,4307.5 6055,4307.5
  Bottom Layer w4: v1(6485,4335) 6500,4350 6570,4350 6579.21,4340.79 U14.21@6619.41,4340.79 ; U14.21@6596.19,4335.13 ccw(c6582.54,4321.47) 6582.54,4340.79 ccw(c6582.54,4360.1) U14.21@6596.19,4346.44
  other v1: 6009,4289
DB_SRAM1.A9: U8.V1 U14.22 | length 6323.7
  Top Layer w4: v1@4225.14,4365.09 ccw(c4208.92,4381.31) 4231.86,4381.31 ccw(c4254.79,4381.31) v1@4238.57,4365.09 ; v1@4227.97,4362.26 ccw(c4218.58,4371.65) 4231.86,4371.65 ccw(c4245.14,4371.65) v1@4235.75,4362.26 ; v1(4231.86,4358.37) 4231.86,4632.29 4218.02,4646.13 4218.02,4861.21 4286.4,4929.58 4298.52,4941.71 4298.52,4991.71 v1(4398.52,5091.71) ; v1@4389.02,5091.71 cw(c4366.09,5091.71) 4382.31,5075.49 cw(c4398.52,5059.27) v1@4398.52,5082.21 ; v1@4393.02,5091.71 cw(c4379.75,5091.71) 4389.14,5082.32 cw(c4398.52,5072.93) v1@4398.52,5086.21 ; v1@4809.6,4058.02 ccw(c4820.38,4065.11) 4820.38,4052.2 ; v1@4809.65,4052.2 4827.8,4052.2 ; v1@4811.72,4048.28 cw(c4821.19,4038.81) 4821.19,4052.2 ; v1@4812.94,4060.22 ccw(c4827.79,4069.98) 4827.79,4052.2 ; U8.V1@4853.31,4047.01 ccw(c4840.78,4034.48) 4840.78,4052.2 ccw(c4840.78,4069.93) U8.V1@4853.31,4057.4 ; U8.V1@4858.5,4052.2 4838.82,4052.2 4827.8,4052.2
  MidLayer2 w4: v1(4398.52,5091.71) 4515,5091.71 4531.33,5075.37 4560.17,5075.37 4649.19,5164.39 4649.19,5170.69 4667.71,5189.21 4674.11,5189.21 4706.86,5221.96 4706.86,5235 4776.86,5305 5025,5305 5060,5340 5322.07,5340 5357.94,5375.87 5903,5375.87 6063.5,5215.37 6425,5215.37 6435.27,5215.37 6448.89,5229 6586.71,5229 6654.02,5161.69 6654.02,4943.98 6675,4923 6684,4923 6754.29,4923 6796.42,4880.87 6806.09,4880.87 6841.75,4845.21 6955.02,4845.21 v1(6974.19,4826.04) ; v1@4402.41,5087.82 cw(c4411.8,5078.43) 4411.8,5091.71 cw(c4411.8,5104.99) v1@4402.41,5095.6 ; v1@4405.24,5084.99 cw(c4421.46,5068.77) 4421.46,5091.71 cw(c4421.46,5114.64) v1@4405.24,5098.43 ; v1@6964.69,4826.04 ccw(c6941.76,4826.04) 6957.97,4842.26 ccw(c6974.19,4858.48) v1@6974.19,4835.54 ; v1@6968.69,4826.04 ccw(c6955.41,4826.04) 6964.8,4835.43 ccw(c6974.19,4844.82) v1@6974.19,4831.54
  Bottom Layer w4: v1@4225.14,4351.66 cw(c4208.92,4335.44) 4231.86,4335.44 cw(c4254.79,4335.44) v1@4238.57,4351.66 ; v1@4227.97,4354.49 cw(c4218.58,4345.1) 4231.86,4345.1 cw(c4245.14,4345.1) v1@4235.75,4354.49 ; v1(4231.86,4358.37) 4231.86,4307.29 4249.61,4289.54 4294.04,4289.54 4304.54,4300.04 4314.31,4309.81 4335.69,4309.81 4345.46,4300.04 4430,4300.04 4452.11,4300.04 4490.34,4261.81 4517.32,4261.81 4530.13,4249 4545.24,4249 4625,4249 4636.5,4237.5 4691.69,4237.5 4696.69,4242.5 4717.56,4242.5 4734.5,4225.56 4734.5,4204.44 4729.5,4199.44 4729.5,4149.19 4741.69,4137 4763.75,4137 4773.75,4137 4779.5,4131.25 4779.5,4121.25 4779.5,4099.19 4790.93,4087.75 4802.25,4087.75 4805,4085 v1@4805,4060.63 ; v1@4798.28,4061.72 ccw(c4782.06,4077.93) 4805,4077.93 ccw(c4827.93,4077.93) v1@4811.72,4061.72 ; v1@4801.11,4058.89 ccw(c4791.72,4068.28) 4805,4068.28 ccw(c4818.28,4068.28) v1@4808.89,4058.89 ; U14.22@6619.41,4309.29 U14.22@6626.99,4301.71 ; U14.22@6632.82,4302.45 cw(c6622.93,4286.16) 6641.99,4286.16 ; U14.22@6634.89,4305.87 cw(c6627.24,4293.26) 6641.99,4293.26 ; U14.22@6636.97,4309.29 cw(c6631.55,4300.37) U14.22@6641.99,4300.37 ; U14.22@6641.99,4301.71 6641.99,4286.71 6677.99,4250.71 6771.58,4250.71 6771.74,4250.87 6789.97,4250.87 6790.13,4250.71 6958.71,4250.71 6989.36,4281.36 6989.36,4316.62 6999.61,4326.87 7013.04,4326.87 7076.36,4390.19 7076.36,4632.21 6974.19,4734.37 v1(6974.19,4826.04) ; v1@6967.47,4819.32 cw(c6951.26,4803.11) 6974.19,4803.11 cw(c6997.13,4803.11) v1@6980.91,4819.32 ; v1@6970.3,4822.15 cw(c6960.91,4812.76) 6974.19,4812.76 cw(c6987.47,4812.76) v1@6978.08,4822.15
  other v1: 4805,4055
DB_SRAM1.A10: U8.R22 U14.23 | length 956.6
  Top Layer w4: U8.R22@5685.28,4162.97 cw(c5685.28,4145.25) 5697.81,4157.78 cw(c5710.34,4170.31) U8.R22@5692.62,4170.31 ; U8.R22@5685.28,4170.31 v3(5704.96,4150.63) ; 5692.16,4163.43 cw(c5679.35,4150.63) 5697.46,4150.63 ccw(c5679.35,4150.63) 5692.16,4163.43 ; 5692.16,4163.43 ccw(c5704.96,4176.24) 5704.96,4158.13 cw(c5704.96,4176.24) 5692.16,4163.43
  MidLayer2 w4: v3@5705.61,4143.16 cw(c5707.19,4125.12) 5718.83,4138.99 cw(c5730.47,4152.86) v3@5712.43,4151.28 ; 5718.54,4139.24 ccw(c5728.47,4149.17) 5728.47,4135.12 5742.4,4135.12 5802.59,4135.12 5822.01,4135.12 5880.27,4135.12 5938.53,4135.12 5941.18,4135.12 5945.12,4135.12 5945.81,4135.12 6007,4196.31 6007,4197 6007,4235.25 6034.5,4262.75 6034.5,4297.25 6044.75,4307.5 6064.32,4307.5 6111.82,4260 6135,4260 6182,4307 v1(6216,4307) ; v1@6209.28,4300.28 ccw(c6193.06,4284.06) 6193.06,4307 ccw(c6193.06,4329.93) v1@6209.28,4313.72 ; v1@6212.11,4303.11 ccw(c6202.72,4293.72) 6202.72,4307 ccw(c6202.72,4320.28) v1@6212.11,4310.89
  Bottom Layer w4: U14.23@6170.59,4309.29 6171.51,4308.37 6214.63,4308.37 v1(6216,4307) ; U14.23@6189.75,4308.37 cw(c6189.75,4280.75) v1@6209.28,4300.28 ; U14.23@6190.98,4312.12 ccw(c6200.02,4321.16) 6200.02,4308.37 ; U14.23@6196.38,4308.37 ccw(c6196.38,4326.62) v1@6209.28,4313.72 ; 6199.4,4308.37 cw(c6199.4,4290.4) v1@6212.11,4303.11
DB_SRAM1.A11: U8.L20 U14.24 | length 726.7
  Top Layer w4: U8.L20@5606.54,4327.8 v3(5626.22,4347.48) ; U8.L20@5606.54,4335.14 ccw(c5606.54,4352.86) 5619.07,4340.33 ccw(c5631.6,4327.8) U8.L20@5613.88,4327.8 ; 5613.42,4334.68 cw(c5626.22,4321.87) 5626.22,4339.98 ccw(c5626.22,4321.87) 5613.42,4334.68 ; 5613.42,4334.68 ccw(c5600.61,4347.48) 5618.72,4347.48 cw(c5600.61,4347.48) 5613.42,4334.68
  Bottom Layer w4: v3@5626.87,4354.95 ccw(c5628.45,4372.99) 5640.09,4359.12 ccw(c5651.73,4345.25) v3@5633.69,4346.83 ; 5639.8,4358.87 cw(c5649.73,4348.94) 5649.73,4362.99 5663.66,4362.99 5723.85,4362.99 5743.27,4362.99 5801.53,4362.99 5859.79,4362.99 5918.05,4362.99 5941.18,4362.99 5949.18,4362.99 5965.7,4362.99 6005.07,4323.62 6100.08,4323.62 6117.25,4340.79 U14.24@6170.59,4340.79 ; U14.24@6147.37,4335.13 ccw(c6133.72,4321.47) 6133.72,4340.79 ccw(c6133.72,4360.1) U14.24@6147.37,4346.44
DB_SRAM1.A12: U8.H22 U14.25 | length 878.5
  Top Layer w4: U8.H22@5685.28,4445.91 v3(5704.96,4465.59) ; U8.H22@5685.28,4453.25 ccw(c5685.28,4470.97) 5697.81,4458.44 ccw(c5710.34,4445.91) U8.H22@5692.62,4445.91 ; 5692.16,4452.79 cw(c5704.96,4439.98) 5704.96,4458.09 ccw(c5704.96,4439.98) 5692.16,4452.79 ; 5692.16,4452.79 ccw(c5679.35,4465.59) 5697.46,4465.59 cw(c5679.35,4465.59) 5692.16,4452.79
  Bottom Layer w4: v3@5706.26,4472.98 ccw(c5709.41,4490.81) 5719.79,4475.98 ; v3@5712.35,4464.29 cw(c5730.18,4461.14) 5719.79,4475.98 ; U14.25@6145.65,4369.21 ccw(c6141.03,4367.28) 6141.03,4372.28 ; U14.25@6145.65,4375.36 cw(c6141.03,4377.28) 6141.03,4372.28 ; U14.25@6170.59,4372.28 6141.03,4372.28 ; 5719.79,4475.98 5727.52,4482.4 cw(c5744.33,4465.59) 5744.33,4489.36 ccw(c5744.33,4504.96) 5759.93,4504.96 cw(c5783.7,4504.96) 5783.7,4528.73 ccw(c5783.7,4544.33) 5799.3,4544.33 cw(c5823.07,4544.33) 5823.07,4568.1 5881.33,4568.1 5939.59,4568.1 5941.18,4568.1 5949.18,4568.1 5961.9,4568.1 5964.19,4565.81 5964.19,4375.81 6008.03,4331.97 6097.12,4331.97 6108.17,4343.02 6118.65,4353.5 6122.25,4353.5 6141.03,4372.28
DB_SRAM1.A13: U8.J25 U14.26 | length 749.5
  Top Layer w4: U8.J25@5803.39,4406.54 v3(5823.07,4426.22) ; U8.J25@5803.39,4413.88 ccw(c5803.39,4431.6) 5815.92,4419.07 ccw(c5828.45,4406.54) U8.J25@5810.73,4406.54 ; 5810.27,4413.42 cw(c5823.07,4400.61) 5823.07,4418.72 ccw(c5823.07,4400.61) 5810.27,4413.42 ; 5810.27,4413.42 ccw(c5797.46,4426.22) 5815.57,4426.22 cw(c5797.46,4426.22) 5810.27,4413.42
  MidLayer1 w4: v3(5823.07,4426.22) 5881.33,4426.22 5900.75,4426.22 5941.18,4426.22 5946.22,4426.22 6015.03,4426.22 6037.75,4403.5 6080.25,4403.5 6097,4420.25 v1(6097,4447) ; v3@5828.26,4421.03 cw(c5840.8,4408.49) 5840.8,4426.22 cw(c5840.8,4443.95) v3@5828.26,4431.41 ; v3@5828.37,4420.92 cw(c5841.18,4408.11) 5841.18,4426.22 cw(c5841.18,4444.33) v3@5828.37,4431.52 ; v1@6090.28,4440.28 cw(c6074.06,4424.06) 6097,4424.06 cw(c6119.93,4424.06) v1@6103.72,4440.28 ; v1@6093.11,4443.11 cw(c6083.72,4433.72) 6097,4433.72 cw(c6110.28,4433.72) v1@6100.89,4443.11
  Bottom Layer w4: v1@6090.28,4440.28 cw(c6074.06,4424.06) 6097,4424.06 cw(c6119.93,4424.06) v1@6103.72,4440.28 ; v1@6093.11,4443.11 cw(c6083.72,4433.72) 6097,4433.72 cw(c6110.28,4433.72) v1@6100.89,4443.11 ; v1@6095,4445 v1(6097,4447) 6097,4414 6107.22,4403.78 U14.26@6170.59,4403.78 ; U14.26@6147.37,4398.12 ccw(c6133.72,4384.46) 6133.72,4403.78 ccw(c6133.72,4423.09) U14.26@6147.37,4409.44 ; U14.26@6170.59,4403.78 6173.52,4403.78 U14.26@6170.59,4403.78
DB_SRAM1.A14: U8.J22 U14.27 | length 680.5
  Top Layer w4: U8.J22@5685.28,4406.54 v3(5704.96,4426.22) ; U8.J22@5685.28,4413.88 ccw(c5685.28,4431.6) 5697.81,4419.07 ccw(c5710.34,4406.54) U8.J22@5692.62,4406.54 ; 5692.16,4413.42 cw(c5704.96,4400.61) 5704.96,4418.72 ccw(c5704.96,4400.61) 5692.16,4413.42 ; 5692.16,4413.42 ccw(c5679.35,4426.22) 5697.46,4426.22 cw(c5679.35,4426.22) 5692.16,4413.42
  MidLayer2 w4: v3@5705.61,4433.69 ccw(c5707.19,4451.73) 5718.83,4437.86 ccw(c5730.47,4423.99) v3@5712.43,4425.57 ; 5718.54,4437.61 cw(c5728.47,4427.68) 5728.47,4441.73 5742.4,4441.73 5802.59,4441.73 5822.01,4441.73 5880.27,4441.73 5938.53,4441.73 5941.18,4441.73 5951.18,4441.71 5999.54,4441.71 6037.75,4403.5 6080.25,4403.5 6124,4447.25 v1(6124,4451)
  Bottom Layer w4: v1(6124,4451) 6126.45,4453.45 6126.45,4453.66 6126.26,4453.85 6126.03,4453.62 6126.03,4439.2 6129.96,4435.27 U14.27@6170.59,4435.27 ; U14.27@6147.37,4429.62 ccw(c6133.72,4415.96) 6133.72,4435.27 ccw(c6133.72,4454.59) U14.27@6147.37,4440.93
DB_SRAM1.A15: U8.C16 U14.42 | length 1404.6
  Top Layer w4: U8.C16@5449.05,4650.1 ccw(c5449.05,4667.82) 5461.59,4655.29 ; v1@5455.5,4935 cw(c5432.56,4935) 5448.78,4918.78 cw(c5465,4902.56) v1@5465,4925.5 ; U8.C16@5456.4,4642.76 cw(c5474.12,4642.76) 5461.59,4655.29 ; v1@5459.5,4935 cw(c5446.22,4935) 5455.61,4925.61 cw(c5465,4916.22) v1@5465,4929.5 ; v1(5465,4935) 5434.19,4904.19 5434.19,4855.62 5456.85,4832.97 5461.11,4832.97 5471.36,4822.71 5472.92,4821.16 5472.92,4773 5472.92,4741.18 5472.92,4682.64 cw(c5434.24,4682.64) 5461.59,4655.29
  Bottom Layer w4: v1(5465,4935) 5465,4934.85 5513.86,4983.71 5703,4983.71 5795,4891.71 5838.86,4891.71 5921.75,4808.81 5982.42,4808.81 5982.86,4808.37 6023.52,4849.04 6023.52,4872.46 6068.61,4917.54 6096.83,4917.54 6106.66,4907.72 U14.42@6170.59,4907.72 6136.7,4907.72 ; v1@5465,4940.5 ccw(c5465,4954.14) 5474.64,4944.49 ; v1@5465,4944.5 ccw(c5465,4967.8) 5481.47,4951.32 ; v1@5470.5,4935 cw(c5483.42,4935) 5474.28,4944.13 ; v1@5474.5,4935 cw(c5497.07,4935) 5481.11,4950.96 ; U14.42@6146.71,4902.81 ccw(c6136.7,4895.04) 6136.7,4907.72 ccw(c6136.7,4920.39) U14.42@6146.71,4912.62 ; U14.42@6147.37,4902.06 ccw(c6133.72,4888.4) 6133.72,4907.72 ccw(c6133.72,4927.03) U14.42@6147.37,4913.37
DB_SRAM1.A16: U8.H14 U14.43 | length 1678
  Top Layer w4: v3(5350.63,4465.59) U8.H14@5370.31,4445.91 ; U8.H14@5362.97,4445.91 ccw(c5345.25,4445.91) 5357.78,4458.44 ccw(c5370.31,4470.97) U8.H14@5370.31,4453.25 ; 5363.43,4452.79 cw(c5376.24,4465.59) 5358.13,4465.59 ccw(c5376.24,4465.59) 5363.43,4452.79 ; 5363.43,4452.79 ccw(c5350.63,4439.98) 5350.63,4458.09 cw(c5350.63,4439.98) 5363.43,4452.79
  MidLayer2 w4: v3@5343.16,4466.24 ccw(c5325.12,4467.82) 5338.99,4479.46 ; v3@5351.28,4473.06 cw(c5352.86,4491.1) 5338.99,4479.46 ; v1@6206.51,4944.45 ccw(c6195.52,4936.45) 6195.52,4950.04 ; v1@6206.51,4955.63 cw(c6195.52,4963.63) 6195.52,4950.04 ; v1(6214.19,4950.04) 6195.52,4950.04 ; 5338.99,4479.46 cw(c5368.5,4508.97) 5326.77,4508.97 5326.77,4528.47 5326.77,4602.59 5326.77,4622.01 5326.77,4790.58 5326.77,4796.77 5356.86,4826.86 5356.86,4868.04 ; 5356.86,4868.04 5356.86,4880 ; 5356.86,4868.04 5356.86,4880 ; 5356.86,4880 5356.86,4993.04 5365.94,5002.12 5374.44,5002.12 5394.94,5002.12 5399.19,5006.37 5409.52,5016.71 5625.29,5016.71 5633.79,5025.21 6120.36,5025.21 6195.52,4950.04
  Bottom Layer w4: U14.43@6170.59,4939.21 6203.36,4939.21 ; U14.43@6194.74,4934.68 cw(c6203.36,4928.75) 6203.36,4939.21 ; U14.43@6194.74,4943.74 ccw(c6203.36,4949.67) 6203.36,4939.21 ; v1(6214.19,4950.04) 6203.36,4939.21
DB_SRAM1.A17: U8.E12 U14.44 | length 1937.9
  Top Layer w4: v3(5271.89,4583.7) U8.E12@5291.57,4564.02 ; U8.E12@5284.23,4564.02 ccw(c5266.51,4564.02) 5279.04,4576.55 ccw(c5291.57,4589.08) U8.E12@5291.57,4571.36 ; 5284.69,4570.9 cw(c5297.5,4583.7) 5279.39,4583.7 ccw(c5297.5,4583.7) 5284.69,4570.9 ; 5284.69,4570.9 ccw(c5271.89,4558.09) 5271.89,4576.2 cw(c5271.89,4558.09) 5284.69,4570.9
  MidLayer1 w4: 5256.38,4621.14 5256.38,4607.21 ; 5260.5,4597.28 cw(c5270.43,4607.21) 5256.38,4607.21 ; v3@5264.42,4584.35 ccw(c5246.38,4585.93) 5260.25,4597.57 ccw(c5274.12,4609.21) v3@5272.54,4591.17 ; 5468.1,5077.5 cw(c5468.1,5045) v1@5491.08,5067.98 ; 5477.76,5077.5 cw(c5477.76,5054.66) v1@5493.91,5070.81 ; 5481.63,5077.5 ccw(c5481.63,5090.87) v1@5491.08,5081.42 ; v1(5497.8,5074.7) 5495,5077.5 5407.31,5077.5 5353.63,5023.81 5353.63,4886.81 5297.63,4830.81 5279.19,4812.37 5279.19,4810 5279.19,4800 5279.19,4794.31 5279.19,4779.19 5273.99,4773.99 5256.38,4756.38 5256.38,4749.18 5256.38,4741.18 5256.38,4700.75 5256.38,4607.21
  MidLayer2 w4: v1@5497.8,5065.2 cw(c5497.8,5042.26) 5514.02,5058.48 cw(c5530.23,5074.7) v1@5507.3,5074.7 ; v1@5497.8,5069.2 cw(c5497.8,5055.92) 5507.19,5065.31 cw(c5516.58,5074.7) v1@5503.3,5074.7 ; v1(5497.8,5074.7) 5539.29,5033.21 6123.69,5033.21 6165.19,4991.71 6180,4991.71 ; v1@6239,4942.36 ccw(c6228.7,4955) 6245,4955 ccw(c6261.3,4955) v1@6251,4942.36 ; v1@6241.53,4939.26 ccw(c6235.56,4946.58) 6245,4946.58 ccw(c6254.44,4946.58) v1@6248.47,4939.26 ; v1(6245,4935) 6245,4955 6208.29,4991.71 6198.52,4991.71 ; 6180,4991.71 6198.52,4991.71 ; 6180,4991.71 6198.52,4991.71
  Bottom Layer w4: U14.44@6170.59,4970.71 6218.27,4970.71 6237.77,4951.21 6239.02,4951.21 6245,4945.23 v1(6245,4935) ; U14.44@6193.81,4965.05 cw(c6207.46,4951.4) 6207.46,4970.71 cw(c6207.47,4990.02) U14.44@6193.81,4976.36 ; 6237.78,4952.45 cw(c6228.72,4943.39) v1@6240.11,4937.52 ; 6241.66,4948.58 cw(c6233.84,4940.75) v1@6243.67,4935.69
DB_SRAM1.A18: U8.G27 U14.28 | length 499
  Top Layer w4: v1@6013.66,4450.45 ccw(c6006,4446.28) 6006,4455 ; v1@6013.66,4459.55 cw(c6006,4463.72) 6006,4455 ; v1(6022,4455) 6006,4455 ; 5894.66,4497.81 cw(c5901.84,4490.63) 5901.84,4500.78 ; 5894.66,4497.81 cw(c5901.84,4490.63) 5901.84,4500.78 ; 5894.66,4497.81 ccw(c5907.19,4485.28) 5889.47,4485.28 cw(c5907.19,4485.28) 5894.66,4497.81 ; 5894.66,4497.81 cw(c5882.13,4510.34) 5882.13,4492.62 ccw(c5882.13,4510.34) 5894.66,4497.81 ; 5901.84,4500.78 5941.18,4500.78 5949.18,4500.78 5960.22,4500.78 5970.28,4500.78 5996.78,4474.28 5996.78,4464.22 6006,4455
  Bottom Layer w4: v1(6022,4455) 6039,4472 6052.25,4472 6059.75,4479.5 6078.93,4479.5 6089.93,4468.5 6163.73,4468.5 6164.52,4467.71 6165.19,4467.04 6165.19,4466.77 U14.28@6170.59,4466.77 ; v1@6022,4460.5 ccw(c6022,4473.78) 6031.39,4464.39 ccw(c6040.78,4455) v1@6027.5,4455 ; v1@6022,4464.5 ccw(c6022,4487.43) 6038.22,4471.22 ccw(c6054.43,4455) v1@6031.5,4455 ; 6129.54,4468.5 cw(c6129.54,4443.28) U14.28@6147.37,4461.11 ; 6137.89,4468.5 ccw(c6137.89,4481.91) U14.28@6147.37,4472.43 ; 6139.2,4468.5 cw(c6139.2,4452.94) U14.28@6150.2,4463.94
DB_SRAM1.D0: U8.D20 U14.7 | length 1851.2
  Top Layer w4: U8.D20@5606.54,4603.39 v3(5626.22,4623.07) ; U8.D20@5606.54,4610.73 ccw(c5606.54,4628.45) 5619.07,4615.92 ccw(c5631.6,4603.39) U8.D20@5613.88,4603.39 ; 5613.42,4610.27 cw(c5626.22,4597.46) 5626.22,4615.57 ccw(c5626.22,4597.46) 5613.42,4610.27 ; 5613.42,4610.27 ccw(c5600.61,4623.07) 5618.72,4623.07 cw(c5600.61,4623.07) 5613.42,4610.27
  MidLayer1 w4: v3@5620.92,4628.37 ccw(c5608.11,4641.18) 5626.22,4641.18 ccw(c5644.33,4641.18) v3@5631.52,4628.37 ; v3@5621.03,4628.26 ccw(c5608.49,4640.8) 5626.22,4640.8 ccw(c5643.95,4640.8) v3@5631.41,4628.26 ; v3(5626.22,4623.07) 5626.22,4700.75 5626.22,4749.18 5627.25,4750.21 5639.9,4750.21 5669.08,4779.39 5669.08,4788.64 5689.81,4809.37 5689.81,4841.72 5745.09,4897 5846.71,4897 5854.71,4889 5902.62,4889 5906.12,4892.5 5947.73,4892.5 6066.19,4774.04 6096.86,4774.04 6162.82,4840 6232.88,4840 6243.75,4850.87 6290.36,4850.87 6319.52,4821.71 v1(6665.19,4821.71) ; v1@6658.47,4814.99 ccw(c6642.26,4798.77) 6642.26,4821.71 ccw(c6642.26,4844.64) v1@6658.47,4828.43 ; v1@6661.3,4817.82 ccw(c6651.91,4808.43) 6651.91,4821.71 ccw(c6651.91,4834.99) v1@6661.3,4825.6
  Bottom Layer w4: U14.7@6619.41,4781.73 U14.7@6636.96,4781.73 ; 6630.88,4771.39 ccw(c6637.58,4782.77) 6646.92,4773.43 ; U14.7@6632.91,4774.84 ccw(c6640.29,4787.37) 6650.57,4777.09 ; U14.7@6634.94,4778.28 ccw(c6642.99,4791.97) 6654.23,4780.74 ; U14.7@6639,4785.18 ccw(c6648.41,4801.18) 6661.54,4788.05 ; U14.7@6641.02,4788.63 ccw(c6651.12,4805.78) 6665.19,4791.71 ; 6657.88,4784.4 cw(c6645.7,4796.58) U14.7@6636.97,4781.73 ; v1@6658.47,4814.99 cw(c6642.26,4798.77) 6665.19,4798.77 cw(c6688.13,4798.77) v1@6671.91,4814.99 ; v1@6661.3,4817.82 cw(c6651.91,4808.43) 6665.19,4808.43 cw(c6678.47,4808.43) v1@6669.08,4817.82 ; v1(6665.19,4821.71) 6665.19,4791.71 ; U14.7@6636.96,4781.73 6636.96,4775.04 6648.52,4775.04 6665.19,4791.71
DB_SRAM1.D1: U8.E22 U14.8 | length 1834.3
  Top Layer w4: U8.E22@5685.28,4564.02 v3(5704.96,4583.7) ; U8.E22@5685.28,4571.36 ccw(c5685.28,4589.08) 5697.81,4576.55 ccw(c5710.34,4564.02) U8.E22@5692.62,4564.02 ; 5692.16,4570.9 cw(c5704.96,4558.09) 5704.96,4576.2 ccw(c5704.96,4558.09) 5692.16,4570.9 ; 5692.16,4570.9 ccw(c5679.35,4583.7) 5697.46,4583.7 cw(c5679.35,4583.7) 5692.16,4570.9
  MidLayer1 w4: v3@5704.31,4591.17 ccw(c5702.73,4609.21) 5716.6,4597.57 ccw(c5730.47,4585.93) v3@5712.43,4584.35 ; 5716.35,4597.28 ccw(c5706.42,4607.21) 5720.47,4607.21 5720.47,4700.75 5720.47,4741.18 5720.47,4749.18 5720.47,4762.08 5721.5,4763.11 5721.5,4770 5721.5,4775.25 5721.5,4839.47 5755.03,4873 5836.77,4873 5844.77,4865 5875,4865 5905,4835 v1(5955,4835) ; v1@5948.28,4828.28 ccw(c5932.06,4812.06) 5932.06,4835 ccw(c5932.06,4857.93) v1@5948.28,4841.72 ; v1@5951.11,4831.11 ccw(c5941.72,4821.72) 5941.72,4835 ccw(c5941.72,4848.28) v1@5951.11,4838.89
  Bottom Layer w4: v1@5948.28,4841.72 ccw(c5932.06,4857.93) 5955,4857.93 ccw(c5977.93,4857.93) v1@5961.72,4841.72 ; v1@5951.11,4838.89 ccw(c5941.72,4848.28) 5955,4848.28 ccw(c5968.28,4848.28) v1@5958.89,4838.89 ; v1(5955,4835) 5955,4923.18 5990.85,4959.03 6030.22,4959.03 6036.38,4965.19 6046.23,4975.04 6070.59,4999.41 6079,5007.81 6079,5054.19 6079,5062.69 6100.31,5084 6155,5084 6176.69,5084 6208.86,5084 6301.15,4991.71 6340,4991.71 ; 6340.52,4991.71 6340,4991.71 ; 6506.52,4750.37 6506.52,4750.23 ; U14.8@6596.19,4744.58 ccw(c6582.54,4730.92) 6582.54,4750.23 ccw(c6582.54,4769.55) U14.8@6596.19,4755.89 ; U14.8@6619.41,4750.23 6506.52,4750.23 ; 6340,4991.71 6367.19,4964.52 6367.19,4875.67 6492.62,4750.23 6506.52,4750.23
DB_SRAM1.D2: U8.C23 U14.9 | length 2458.4
  Top Layer w4: 6386.52,5038.04 6387.35,5038.87 ; 5737.18,4655.29 ccw(c5749.71,4642.76) 5731.99,4642.76 cw(c5749.71,4642.76) 5737.18,4655.29 ; 5737.18,4655.29 cw(c5724.65,4667.82) 5724.65,4650.1 ccw(c5724.65,4667.82) 5737.18,4655.29 ; 5737.18,4655.29 ccw(c5709.83,4682.64) 5748.51,4682.64 ; 5737.18,4655.29 ccw(c5709.83,4682.64) 5748.51,4682.64 ; 5748.51,4682.64 5748.51,4741.18 ; 5748.51,4682.64 5748.51,4741.18 ; 5748.51,4741.18 5748.51,4749.49 5748.51,4777.81 5743.52,4782.79 5743.52,5016.77 5769,5042.24 5769,5055.85 5829.86,5116.71 6423.52,5116.71 ; 6331.86,4963.65 cw(c6318.58,4963.65) 6327.97,4954.26 ccw(c6318.58,4963.65) 6331.86,4963.65 ; 6331.86,4963.65 ccw(c6345.14,4963.65) 6335.75,4954.26 cw(c6345.14,4963.65) 6331.86,4963.65 ; 6331.86,4973.31 cw(c6308.92,4973.31) 6325.14,4957.09 ccw(c6308.92,4973.31) 6331.86,4973.31 ; 6331.86,4973.31 ccw(c6354.79,4973.31) 6338.57,4957.09 cw(c6354.79,4973.31) 6331.86,4973.31 ; 6331.86,4983.37 v1(6331.86,4950.37) 6331.86,4983.37 ; 6331.86,4983.37 6331.86,5026.86 6343.87,5038.87 6387.35,5038.87 ; 6387.35,5038.87 6400,5038.87 ; 6387.35,5038.87 6400,5038.87 ; 6400,5038.87 6433.87,5038.87 6440,5045 6440,5100.23 ; 6423.52,5116.71 6440,5100.23 ; 6423.52,5116.71 6440,5100.23
  Bottom Layer w4: 6331.86,4907.64 v1(6331.86,4950.37) 6331.86,4899.69 6512.81,4718.74 U14.9@6619.41,4718.74 6555,4718.74 ; 6331.86,4927.44 cw(c6354.79,4927.44) 6338.57,4943.66 ccw(c6354.79,4927.44) 6331.86,4927.44 ; 6331.86,4927.44 ccw(c6308.92,4927.44) 6325.14,4943.66 cw(c6308.92,4927.44) 6331.86,4927.44 ; 6331.86,4937.1 cw(c6345.14,4937.1) 6335.75,4946.49 ccw(c6345.14,4937.1) 6331.86,4937.1 ; 6331.86,4937.1 ccw(c6318.58,4937.1) 6327.97,4946.49 cw(c6318.58,4937.1) 6331.86,4937.1 ; 6555,4718.74 6520.76,4718.74 6555,4718.74 ; 6582.54,4718.74 ccw(c6582.54,4738.05) 6596.19,4724.4 cw(c6582.54,4738.05) 6582.54,4718.74 ; 6582.54,4718.74 cw(c6582.54,4699.42) 6596.19,4713.08 ccw(c6582.54,4699.42) 6582.54,4718.74
DB_SRAM1.D3: U8.F17 U14.10 | length 1943.1
  Top Layer w4: U8.F17@5488.43,4524.65 v3(5508.11,4544.33) ; U8.F17@5488.42,4531.99 ccw(c5488.42,4549.71) 5500.96,4537.18 ccw(c5513.49,4524.65) U8.F17@5495.77,4524.65 ; 5495.31,4531.53 cw(c5508.11,4518.72) 5508.11,4536.83 ccw(c5508.11,4518.72) 5495.31,4531.53 ; 5495.31,4531.53 ccw(c5482.5,4544.33) 5500.61,4544.33 cw(c5482.5,4544.33) 5495.31,4531.53
  MidLayer1 w4: v3@5507.46,4551.8 ccw(c5505.88,4569.84) 5519.75,4558.2 ; v3@5515.58,4544.98 cw(c5533.62,4546.56) 5519.75,4558.2 ; 5531.97,4621.14 5531.97,4607.21 ; v1@6030.5,5055 cw(c6007.56,5055) 6023.78,5038.78 cw(c6040,5022.56) v1@6040,5045.5 ; v1@6034.5,5055 cw(c6021.22,5055) 6030.61,5045.61 cw(c6040,5036.22) v1@6040,5049.5 ; v1(6040,5055) 5985.04,5000.04 5649.74,5000.04 5612,4962.3 5612,4902.2 5550,4840.2 5550,4790 5531.97,4771.97 5531.97,4749.18 5531.97,4741.18 5531.97,4700.75 5531.97,4681.33 5531.97,4607.21 ; 5519.75,4558.2 ccw(c5490.24,4587.71) 5531.97,4587.71 5531.97,4607.21
  MidLayer2 w4: v1(6040,5055) 6084.37,5055 6095,5044.37 6180.67,5044.37 v1(6237.2,4987.85) v1@6237.2,4985.29 ; v1@6227.7,4987.85 ccw(c6204.76,4987.85) 6220.98,5004.06 ccw(c6237.2,5020.28) v1@6237.2,4997.35 ; v1@6231.7,4987.85 ccw(c6218.42,4987.85) 6227.81,4997.24 ccw(c6237.2,5006.62) v1@6237.2,4993.35
  Bottom Layer w4: v1(6237.2,4987.85) 6237.2,4985.29 6247.7,4974.79 6247.7,4972.54 6248.52,4971.71 6465.19,4755.04 6532.99,4687.24 U14.10@6619.41,4687.24 ; U14.10@6596.19,4681.59 ccw(c6582.54,4667.93) 6582.54,4687.24 ccw(c6582.54,4706.56) U14.10@6596.19,4692.9
DB_SRAM1.D4: U8.C26 U14.13 | length 1872.5
  Top Layer w4: U8.C26@5842.76,4650.1 ccw(c5842.76,4667.82) 5855.29,4655.29 ; U8.C26@5850.1,4642.76 cw(c5867.82,4642.76) 5855.29,4655.29 ; v1@6393.28,4756.72 ccw(c6377.06,4772.93) 6400,4772.93 ccw(c6422.93,4772.93) v1@6406.72,4756.72 ; v1@6396.11,4753.89 ccw(c6386.72,4763.28) 6400,4763.28 ccw(c6413.28,4763.28) v1@6403.89,4753.89 ; v1(6400,4750) 6400,4845 6410.72,4855.72 6410.72,4880.72 6410.72,4913 ; 6410.72,4924.72 6410.72,4913 ; 5855.29,4655.29 cw(c5882.64,4627.94) 5882.64,4666.62 ; 5855.29,4655.29 cw(c5882.64,4627.94) 5882.64,4666.62 ; 5882.64,4666.62 5941.18,4666.62 5980.62,4666.62 6011.19,4697.19 6011.19,4725 6035,4748.81 6035,4952.93 ; 6035,4952.93 6096.28,5014.21 ; 6035,4952.93 6096.28,5014.21 ; 6096.28,5014.21 6142.5,5014.21 6149.17,5007.54 6250.46,5007.54 6314.36,4943.64 6314.36,4943.13 6325.44,4932.04 6340.19,4932.04 6390.19,4982.04 6390.19,5021.71 6398.52,5030.04 6431.86,5030.04 6448.52,5013.37 6448.52,4989 6448.52,4976.21 6448.52,4970.77 6410.72,4932.97 6410.72,4913
  Bottom Layer w4: v1@6400.04,4750.04 6431.86,4750.04 6498.52,4683.37 6498.52,4644.69 6550.46,4592.75 U14.13@6619.41,4592.75 ; v1@6403.89,4746.11 cw(c6413.38,4736.62) 6413.38,4750.04 ; v1@6403.89,4753.89 ccw(c6413.18,4763.18) 6413.18,4750.04 ; v1@6406.72,4743.28 cw(c6423.03,4726.97) 6423.03,4750.04 ; v1@6406.72,4756.72 ccw(c6422.84,4772.84) 6422.84,4750.04 ; U14.13@6596.19,4587.1 ccw(c6582.54,4573.44) 6582.54,4592.75 ccw(c6582.54,4612.07) U14.13@6596.19,4598.41
DB_SRAM1.D5: U8.G22 U14.14 | length 1615.2
  Top Layer w4: U8.G22@5685.28,4485.28 v3(5704.96,4504.96) ; U8.G22@5685.28,4492.62 ccw(c5685.28,4510.34) 5697.81,4497.81 ccw(c5710.34,4485.28) U8.G22@5692.62,4485.28 ; 5692.16,4492.16 cw(c5704.96,4479.35) 5704.96,4497.46 ccw(c5704.96,4479.35) 5692.16,4492.16 ; 5692.16,4492.16 ccw(c5679.35,4504.96) 5697.46,4504.96 cw(c5679.35,4504.96) 5692.16,4492.16
  MidLayer2 w4: v1@6115.19,4748.87 cw(c6115.19,4725.94) 6131.41,4742.16 cw(c6147.63,4758.37) v1@6124.69,4758.37 ; v1@6115.19,4752.87 cw(c6115.19,4739.6) 6124.58,4748.99 cw(c6133.97,4758.37) v1@6120.69,4758.37 ; v1(6115.19,4758.37) 6140.19,4733.37 6285,4733.37 6293.33,4741.71 v1(6325.19,4741.71) ; v1@6318.47,4734.99 ccw(c6302.26,4718.77) 6302.26,4741.71 ccw(c6302.26,4764.64) v1@6318.47,4748.43 ; v1@6321.3,4737.82 ccw(c6311.91,4728.43) 6311.91,4741.71 ccw(c6311.91,4754.99) v1@6321.3,4745.6
  Bottom Layer w4: v3@5706.26,4512.35 ccw(c5709.41,4530.18) 5719.79,4515.35 ; v3@5712.35,4503.66 cw(c5730.18,4500.51) 5719.79,4515.35 ; v1@6108.47,4751.66 ccw(c6092.26,4735.44) 6092.26,4758.37 ccw(c6092.26,4781.31) v1@6108.47,4765.09 ; v1@6111.3,4754.49 ccw(c6101.91,4745.1) 6101.91,4758.37 ccw(c6101.91,4771.65) v1@6111.3,4762.26 ; v1(6115.19,4758.37) 6081.63,4758.37 6065,4775 6010,4775 5993.37,4758.37 5947.71,4712.71 5947.71,4687.29 5965,4670 5965,4612.47 5960,4607.47 5952.47,4607.47 5941.18,4607.47 5939.59,4607.47 5881.33,4607.47 5823.07,4607.47 ccw(c5823.07,4583.7) 5799.3,4583.7 cw(c5783.7,4583.7) 5783.7,4568.1 ccw(c5783.7,4544.33) 5759.93,4544.33 cw(c5744.33,4544.33) 5744.33,4528.73 ccw(c5744.33,4504.96) 5727.52,4521.77 5719.79,4515.35 ; v1(6325.19,4741.71) 6363.29,4741.71 6375,4730 6435.23,4730 6456.52,4708.71 6490.19,4675.04 6490.19,4641.71 6570.64,4561.26 U14.14@6619.41,4561.26 ; v1@6329.08,4737.82 cw(c6338.47,4728.43) 6338.47,4741.71 cw(c6338.47,4754.99) v1@6329.08,4745.6 ; v1@6331.91,4734.99 cw(c6348.13,4718.77) 6348.13,4741.71 cw(c6348.13,4764.64) v1@6331.91,4748.43 ; U14.14@6596.19,4555.6 ccw(c6582.54,4541.94) 6582.54,4561.26 ccw(c6582.54,4580.57) U14.14@6596.19,4566.92